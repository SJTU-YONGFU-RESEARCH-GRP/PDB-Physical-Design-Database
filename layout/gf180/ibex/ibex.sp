* cell ibex_core
* pin instr_addr_o[0]
* pin alert_minor_o
* pin instr_rdata_i[22]
* pin data_addr_o[1]
* pin instr_rdata_i[20]
* pin instr_rdata_i[19]
* pin instr_rdata_i[18]
* pin instr_rdata_i[9]
* pin instr_rdata_i[8]
* pin instr_rdata_i[0]
* pin instr_rdata_i[11]
* pin instr_rdata_i[15]
* pin clk_i
* pin instr_rdata_i[10]
* pin instr_rdata_i[13]
* pin instr_rdata_i[14]
* pin instr_rdata_i[12]
* pin instr_rdata_i[7]
* pin instr_rdata_i[2]
* pin instr_rdata_i[3]
* pin instr_rdata_i[4]
* pin instr_rdata_i[5]
* pin instr_rdata_i[6]
* pin data_we_o
* pin data_req_o
* pin data_rvalid_i
* pin data_gnt_i
* pin data_err_i
* pin rst_ni
* pin instr_addr_o[1]
* pin alert_major_o
* pin data_addr_o[0]
* pin instr_rdata_i[21]
* pin instr_rdata_i[23]
* pin instr_rdata_i[24]
* pin instr_rdata_i[25]
* pin instr_rdata_i[26]
* pin instr_rdata_i[28]
* pin instr_rdata_i[27]
* pin instr_rdata_i[16]
* pin instr_rdata_i[17]
* pin instr_rdata_i[29]
* pin instr_rdata_i[1]
* pin instr_rdata_i[30]
* pin instr_rdata_i[31]
* pin instr_addr_o[30]
* pin instr_err_i
* pin instr_addr_o[29]
* pin instr_addr_o[6]
* pin instr_addr_o[3]
* pin instr_addr_o[21]
* pin instr_addr_o[27]
* pin instr_addr_o[2]
* pin instr_addr_o[31]
* pin instr_addr_o[4]
* pin instr_addr_o[28]
* pin instr_addr_o[24]
* pin instr_addr_o[5]
* pin instr_addr_o[22]
* pin instr_addr_o[7]
* pin instr_addr_o[9]
* pin instr_addr_o[17]
* pin instr_addr_o[18]
* pin instr_addr_o[19]
* pin instr_addr_o[12]
* pin instr_addr_o[20]
* pin instr_addr_o[14]
* pin instr_addr_o[26]
* pin instr_addr_o[15]
* pin instr_addr_o[25]
* pin instr_addr_o[16]
* pin instr_addr_o[11]
* pin instr_addr_o[10]
* pin instr_addr_o[13]
* pin instr_addr_o[23]
* pin instr_addr_o[8]
* pin instr_gnt_i
* pin instr_rvalid_i
* pin instr_req_o
* pin test_en_i
* pin fetch_enable_i
* pin core_sleep_o
* pin debug_req_i
* pin data_addr_o[4]
* pin data_addr_o[2]
* pin data_addr_o[6]
* pin data_addr_o[7]
* pin data_rdata_i[17]
* pin data_rdata_i[25]
* pin data_rdata_i[9]
* pin data_rdata_i[14]
* pin data_rdata_i[23]
* pin data_rdata_i[1]
* pin data_rdata_i[22]
* pin data_rdata_i[6]
* pin data_rdata_i[31]
* pin data_rdata_i[30]
* pin data_rdata_i[15]
* pin data_rdata_i[7]
* pin data_rdata_i[8]
* pin data_rdata_i[16]
* pin data_rdata_i[24]
* pin data_rdata_i[0]
* pin data_rdata_i[27]
* pin data_rdata_i[19]
* pin data_rdata_i[11]
* pin data_rdata_i[3]
* pin boot_addr_i[30]
* pin boot_addr_i[29]
* pin boot_addr_i[25]
* pin boot_addr_i[9]
* pin data_rdata_i[29]
* pin data_rdata_i[21]
* pin boot_addr_i[28]
* pin boot_addr_i[31]
* pin data_rdata_i[13]
* pin data_rdata_i[5]
* pin boot_addr_i[8]
* pin boot_addr_i[27]
* pin data_rdata_i[4]
* pin data_rdata_i[28]
* pin boot_addr_i[26]
* pin boot_addr_i[24]
* pin boot_addr_i[14]
* pin data_rdata_i[10]
* pin data_rdata_i[18]
* pin data_rdata_i[26]
* pin data_rdata_i[12]
* pin data_rdata_i[20]
* pin data_rdata_i[2]
* pin boot_addr_i[10]
* pin boot_addr_i[11]
* pin boot_addr_i[15]
* pin boot_addr_i[17]
* pin boot_addr_i[12]
* pin boot_addr_i[13]
* pin boot_addr_i[19]
* pin boot_addr_i[21]
* pin data_addr_o[12]
* pin data_addr_o[10]
* pin boot_addr_i[22]
* pin boot_addr_i[20]
* pin data_be_o[2]
* pin data_be_o[3]
* pin boot_addr_i[18]
* pin data_be_o[1]
* pin data_wdata_o[8]
* pin data_wdata_o[9]
* pin data_be_o[0]
* pin boot_addr_i[16]
* pin data_wdata_o[16]
* pin boot_addr_i[23]
* pin data_wdata_o[15]
* pin data_wdata_o[22]
* pin data_wdata_o[17]
* pin data_wdata_o[14]
* pin data_wdata_o[19]
* pin data_wdata_o[18]
* pin data_wdata_o[23]
* pin irq_fast_i[14]
* pin irq_nm_i
* pin data_wdata_o[11]
* pin data_wdata_o[21]
* pin data_wdata_o[13]
* pin data_wdata_o[0]
* pin data_wdata_o[10]
* pin data_wdata_o[20]
* pin irq_fast_i[13]
* pin irq_fast_i[12]
* pin data_wdata_o[12]
* pin irq_fast_i[11]
* pin data_addr_o[9]
* pin data_wdata_o[4]
* pin data_addr_o[8]
* pin irq_fast_i[10]
* pin data_addr_o[5]
* pin data_wdata_o[24]
* pin data_wdata_o[28]
* pin data_addr_o[21]
* pin irq_timer_i
* pin irq_software_i
* pin data_addr_o[14]
* pin data_addr_o[3]
* pin data_addr_o[15]
* pin data_wdata_o[26]
* pin data_wdata_o[1]
* pin data_wdata_o[6]
* pin data_wdata_o[31]
* pin data_wdata_o[25]
* pin irq_fast_i[9]
* pin irq_external_i
* pin data_wdata_o[2]
* pin data_wdata_o[30]
* pin data_wdata_o[5]
* pin data_wdata_o[7]
* pin irq_fast_i[8]
* pin data_wdata_o[29]
* pin data_wdata_o[3]
* pin data_wdata_o[27]
* pin irq_fast_i[6]
* pin irq_fast_i[7]
* pin data_addr_o[11]
* pin data_addr_o[13]
* pin irq_fast_i[1]
* pin irq_fast_i[0]
* pin irq_fast_i[5]
* pin irq_fast_i[2]
* pin irq_fast_i[3]
* pin irq_fast_i[4]
* pin hart_id_i[4]
* pin hart_id_i[5]
* pin hart_id_i[2]
* pin hart_id_i[10]
* pin hart_id_i[6]
* pin hart_id_i[31]
* pin hart_id_i[14]
* pin hart_id_i[9]
* pin hart_id_i[24]
* pin hart_id_i[1]
* pin hart_id_i[11]
* pin hart_id_i[20]
* pin hart_id_i[18]
* pin hart_id_i[17]
* pin hart_id_i[16]
* pin hart_id_i[27]
* pin hart_id_i[12]
* pin hart_id_i[26]
* pin hart_id_i[30]
* pin hart_id_i[0]
* pin hart_id_i[15]
* pin hart_id_i[25]
* pin hart_id_i[3]
* pin hart_id_i[8]
* pin hart_id_i[19]
* pin hart_id_i[7]
* pin hart_id_i[13]
* pin hart_id_i[28]
* pin hart_id_i[21]
* pin hart_id_i[23]
* pin hart_id_i[29]
* pin hart_id_i[22]
* pin data_addr_o[18]
* pin data_addr_o[27]
* pin data_addr_o[24]
* pin data_addr_o[26]
* pin data_addr_o[30]
* pin data_addr_o[17]
* pin data_addr_o[20]
* pin data_addr_o[22]
* pin data_addr_o[31]
* pin data_addr_o[28]
* pin data_addr_o[25]
* pin data_addr_o[19]
* pin data_addr_o[29]
* pin data_addr_o[16]
* pin data_addr_o[23]
* pin VDD
* pin VSS,gf180mcu_gnd
.SUBCKT ibex_core 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23
+ 24 25 26 27 28 74 143 326 327 826 916 1083 1245 1292 1452 1501 1609 1610 1685
+ 1754 1860 1929 2140 2141 2194 2195 2196 2197 2198 2199 2200 2270 2271 2337
+ 2338 2339 2398 2399 2400 2460 2461 2525 2526 2592 2593 2594 2595 2596 2661
+ 2662 2663 2664 2739 2740 2846 3093 3159 3160 3198 4251 4587 4638 4642 4643
+ 4713 4771 4772 4855 4947 4948 4949 5087 5088 5167 5238 5239 5491 5492 5564
+ 5632 5772 5773 5774 5775 5881 5882 5969 6048 6096 6097 6116 6117 6182 6183
+ 6215 6216 6275 6368 6478 6479 6480 6539 6541 6542 6543 6634 6635 6757 6758
+ 6759 6760 6849 6850 6927 7102 7179 7264 7304 7305 7361 7362 7412 7469 7470
+ 7471 7559 7671 7728 7761 7819 7896 7897 7984 7985 8067 8068 8105 8106 8160
+ 8161 8273 8274 8275 8276 8334 8335 8403 8437 8497 8498 8499 8537 8580 8583
+ 8584 8585 8623 8624 8677 8679 8779 8786 8787 8788 8789 8790 8834 8835 8881
+ 8882 8883 8884 8923 8975 8976 8977 9033 9034 9072 9086 9124 9231 9310 9311
+ 9312 9419 9633 9634 9635 9740 9741 9742 9743 9820 9821 9822 9823 9824 9825
+ 9826 9926 9927 9928 10016 10017 10018 10105 10106 10254 10255 10256 10257
+ 10258 10259 10366 10367 10368 10369 11267 14019 14042 14045 14048 14049 14050
+ 14051 14059 14060 14061 14062 14063 14064 14065 14073 14074
* net 1 instr_addr_o[0]
* net 2 alert_minor_o
* net 3 instr_rdata_i[22]
* net 4 data_addr_o[1]
* net 5 instr_rdata_i[20]
* net 6 instr_rdata_i[19]
* net 7 instr_rdata_i[18]
* net 8 instr_rdata_i[9]
* net 9 instr_rdata_i[8]
* net 10 instr_rdata_i[0]
* net 11 instr_rdata_i[11]
* net 12 instr_rdata_i[15]
* net 13 clk_i
* net 14 instr_rdata_i[10]
* net 15 instr_rdata_i[13]
* net 16 instr_rdata_i[14]
* net 17 instr_rdata_i[12]
* net 18 instr_rdata_i[7]
* net 19 instr_rdata_i[2]
* net 20 instr_rdata_i[3]
* net 21 instr_rdata_i[4]
* net 22 instr_rdata_i[5]
* net 23 instr_rdata_i[6]
* net 24 data_we_o
* net 25 data_req_o
* net 26 data_rvalid_i
* net 27 data_gnt_i
* net 28 data_err_i
* net 74 rst_ni
* net 143 instr_addr_o[1]
* net 326 alert_major_o
* net 327 data_addr_o[0]
* net 826 instr_rdata_i[21]
* net 916 instr_rdata_i[23]
* net 1083 instr_rdata_i[24]
* net 1245 instr_rdata_i[25]
* net 1292 instr_rdata_i[26]
* net 1452 instr_rdata_i[28]
* net 1501 instr_rdata_i[27]
* net 1609 instr_rdata_i[16]
* net 1610 instr_rdata_i[17]
* net 1685 instr_rdata_i[29]
* net 1754 instr_rdata_i[1]
* net 1860 instr_rdata_i[30]
* net 1929 instr_rdata_i[31]
* net 2140 instr_addr_o[30]
* net 2141 instr_err_i
* net 2194 instr_addr_o[29]
* net 2195 instr_addr_o[6]
* net 2196 instr_addr_o[3]
* net 2197 instr_addr_o[21]
* net 2198 instr_addr_o[27]
* net 2199 instr_addr_o[2]
* net 2200 instr_addr_o[31]
* net 2270 instr_addr_o[4]
* net 2271 instr_addr_o[28]
* net 2337 instr_addr_o[24]
* net 2338 instr_addr_o[5]
* net 2339 instr_addr_o[22]
* net 2398 instr_addr_o[7]
* net 2399 instr_addr_o[9]
* net 2400 instr_addr_o[17]
* net 2460 instr_addr_o[18]
* net 2461 instr_addr_o[19]
* net 2525 instr_addr_o[12]
* net 2526 instr_addr_o[20]
* net 2592 instr_addr_o[14]
* net 2593 instr_addr_o[26]
* net 2594 instr_addr_o[15]
* net 2595 instr_addr_o[25]
* net 2596 instr_addr_o[16]
* net 2661 instr_addr_o[11]
* net 2662 instr_addr_o[10]
* net 2663 instr_addr_o[13]
* net 2664 instr_addr_o[23]
* net 2739 instr_addr_o[8]
* net 2740 instr_gnt_i
* net 2846 instr_rvalid_i
* net 3093 instr_req_o
* net 3159 test_en_i
* net 3160 fetch_enable_i
* net 3198 core_sleep_o
* net 4251 debug_req_i
* net 4587 data_addr_o[4]
* net 4638 data_addr_o[2]
* net 4642 data_addr_o[6]
* net 4643 data_addr_o[7]
* net 4713 data_rdata_i[17]
* net 4771 data_rdata_i[25]
* net 4772 data_rdata_i[9]
* net 4855 data_rdata_i[14]
* net 4947 data_rdata_i[23]
* net 4948 data_rdata_i[1]
* net 4949 data_rdata_i[22]
* net 5087 data_rdata_i[6]
* net 5088 data_rdata_i[31]
* net 5167 data_rdata_i[30]
* net 5238 data_rdata_i[15]
* net 5239 data_rdata_i[7]
* net 5491 data_rdata_i[8]
* net 5492 data_rdata_i[16]
* net 5564 data_rdata_i[24]
* net 5632 data_rdata_i[0]
* net 5772 data_rdata_i[27]
* net 5773 data_rdata_i[19]
* net 5774 data_rdata_i[11]
* net 5775 data_rdata_i[3]
* net 5881 boot_addr_i[30]
* net 5882 boot_addr_i[29]
* net 5969 boot_addr_i[25]
* net 6048 boot_addr_i[9]
* net 6096 data_rdata_i[29]
* net 6097 data_rdata_i[21]
* net 6116 boot_addr_i[28]
* net 6117 boot_addr_i[31]
* net 6182 data_rdata_i[13]
* net 6183 data_rdata_i[5]
* net 6215 boot_addr_i[8]
* net 6216 boot_addr_i[27]
* net 6275 data_rdata_i[4]
* net 6368 data_rdata_i[28]
* net 6478 boot_addr_i[26]
* net 6479 boot_addr_i[24]
* net 6480 boot_addr_i[14]
* net 6539 data_rdata_i[10]
* net 6541 data_rdata_i[18]
* net 6542 data_rdata_i[26]
* net 6543 data_rdata_i[12]
* net 6634 data_rdata_i[20]
* net 6635 data_rdata_i[2]
* net 6757 boot_addr_i[10]
* net 6758 boot_addr_i[11]
* net 6759 boot_addr_i[15]
* net 6760 boot_addr_i[17]
* net 6849 boot_addr_i[12]
* net 6850 boot_addr_i[13]
* net 6927 boot_addr_i[19]
* net 7102 boot_addr_i[21]
* net 7179 data_addr_o[12]
* net 7264 data_addr_o[10]
* net 7304 boot_addr_i[22]
* net 7305 boot_addr_i[20]
* net 7361 data_be_o[2]
* net 7362 data_be_o[3]
* net 7412 boot_addr_i[18]
* net 7469 data_be_o[1]
* net 7470 data_wdata_o[8]
* net 7471 data_wdata_o[9]
* net 7559 data_be_o[0]
* net 7671 boot_addr_i[16]
* net 7728 data_wdata_o[16]
* net 7761 boot_addr_i[23]
* net 7819 data_wdata_o[15]
* net 7896 data_wdata_o[22]
* net 7897 data_wdata_o[17]
* net 7984 data_wdata_o[14]
* net 7985 data_wdata_o[19]
* net 8067 data_wdata_o[18]
* net 8068 data_wdata_o[23]
* net 8105 irq_fast_i[14]
* net 8106 irq_nm_i
* net 8160 data_wdata_o[11]
* net 8161 data_wdata_o[21]
* net 8273 data_wdata_o[13]
* net 8274 data_wdata_o[0]
* net 8275 data_wdata_o[10]
* net 8276 data_wdata_o[20]
* net 8334 irq_fast_i[13]
* net 8335 irq_fast_i[12]
* net 8403 data_wdata_o[12]
* net 8437 irq_fast_i[11]
* net 8497 data_addr_o[9]
* net 8498 data_wdata_o[4]
* net 8499 data_addr_o[8]
* net 8537 irq_fast_i[10]
* net 8580 data_addr_o[5]
* net 8583 data_wdata_o[24]
* net 8584 data_wdata_o[28]
* net 8585 data_addr_o[21]
* net 8623 irq_timer_i
* net 8624 irq_software_i
* net 8677 data_addr_o[14]
* net 8679 data_addr_o[3]
* net 8779 data_addr_o[15]
* net 8786 data_wdata_o[26]
* net 8787 data_wdata_o[1]
* net 8788 data_wdata_o[6]
* net 8789 data_wdata_o[31]
* net 8790 data_wdata_o[25]
* net 8834 irq_fast_i[9]
* net 8835 irq_external_i
* net 8881 data_wdata_o[2]
* net 8882 data_wdata_o[30]
* net 8883 data_wdata_o[5]
* net 8884 data_wdata_o[7]
* net 8923 irq_fast_i[8]
* net 8975 data_wdata_o[29]
* net 8976 data_wdata_o[3]
* net 8977 data_wdata_o[27]
* net 9033 irq_fast_i[6]
* net 9034 irq_fast_i[7]
* net 9072 data_addr_o[11]
* net 9086 data_addr_o[13]
* net 9124 irq_fast_i[1]
* net 9231 irq_fast_i[0]
* net 9310 irq_fast_i[5]
* net 9311 irq_fast_i[2]
* net 9312 irq_fast_i[3]
* net 9419 irq_fast_i[4]
* net 9633 hart_id_i[4]
* net 9634 hart_id_i[5]
* net 9635 hart_id_i[2]
* net 9740 hart_id_i[10]
* net 9741 hart_id_i[6]
* net 9742 hart_id_i[31]
* net 9743 hart_id_i[14]
* net 9820 hart_id_i[9]
* net 9821 hart_id_i[24]
* net 9822 hart_id_i[1]
* net 9823 hart_id_i[11]
* net 9824 hart_id_i[20]
* net 9825 hart_id_i[18]
* net 9826 hart_id_i[17]
* net 9926 hart_id_i[16]
* net 9927 hart_id_i[27]
* net 9928 hart_id_i[12]
* net 10016 hart_id_i[26]
* net 10017 hart_id_i[30]
* net 10018 hart_id_i[0]
* net 10105 hart_id_i[15]
* net 10106 hart_id_i[25]
* net 10254 hart_id_i[3]
* net 10255 hart_id_i[8]
* net 10256 hart_id_i[19]
* net 10257 hart_id_i[7]
* net 10258 hart_id_i[13]
* net 10259 hart_id_i[28]
* net 10366 hart_id_i[21]
* net 10367 hart_id_i[23]
* net 10368 hart_id_i[29]
* net 10369 hart_id_i[22]
* net 11267 data_addr_o[18]
* net 14019 data_addr_o[27]
* net 14042 data_addr_o[24]
* net 14045 data_addr_o[26]
* net 14048 data_addr_o[30]
* net 14049 data_addr_o[17]
* net 14050 data_addr_o[20]
* net 14051 data_addr_o[22]
* net 14059 data_addr_o[31]
* net 14060 data_addr_o[28]
* net 14061 data_addr_o[25]
* net 14062 data_addr_o[19]
* net 14063 data_addr_o[29]
* net 14064 data_addr_o[16]
* net 14065 data_addr_o[23]
* net 14073 VDD
* net 14074 VSS,gf180mcu_gnd
* cell instance $4 m0 *1 95.2,15.12
X$4 14074 14073 1 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $8 m0 *1 97.44,15.12
X$8 14074 14073 2 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $10 r0 *1 156.24,126
X$10 3 14073 14074 719 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16 m0 *1 138.88,15.12
X$16 14074 14073 4 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $18 r0 *1 181.44,206.64
X$18 5 14073 14074 1559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $25 m0 *1 180.32,166.32
X$25 6 14073 14074 978 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32 r0 *1 206.64,156.24
X$32 7 14073 14074 865 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $38 r0 *1 236.88,156.24
X$38 8 14073 14074 1030 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $44 r0 *1 247.52,146.16
X$44 9 14073 14074 922 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49 r0 *1 250.32,15.12
X$49 10 14073 14074 919 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52 m0 *1 249.2,226.8
X$52 11 14073 14074 1622 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61 r0 *1 258.72,15.12
X$61 12 14073 14074 482 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69 r0 *1 134.96,378
X$69 14074 13 3100 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $72 r0 *1 333.76,55.44
X$72 14074 13 473 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $75 r0 *1 277.2,85.68
X$75 14 14073 14074 417 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $80 r0 *1 272.16,55.44
X$80 15 14073 14074 1695 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83 m0 *1 295.68,25.2
X$83 16 14073 14074 175 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88 m0 *1 299.6,95.76
X$88 17 14073 14074 925 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94 r0 *1 306.88,156.24
X$94 18 14073 14074 986 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $98 r0 *1 304.08,146.16
X$98 19 14073 14074 957 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101 r0 *1 339.92,146.16
X$101 20 14073 14074 987 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $107 r0 *1 351.68,156.24
X$107 21 14073 14074 958 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $115 r0 *1 363.44,216.72
X$115 22 14073 14074 1564 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $124 r0 *1 352.24,246.96
X$124 23 14073 14074 1868 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $132 m0 *1 568.4,25.2
X$132 102 14073 14074 24 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $135 m0 *1 571.76,15.12
X$135 35 14073 14074 25 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $143 r0 *1 617.12,448.56
X$143 26 14073 14074 4209 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $147 r0 *1 579.04,458.64
X$147 27 14073 14074 4214 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $153 m0 *1 518,25.2
X$153 28 14073 14074 85 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $159 m0 *1 464.8,15.12
X$159 14074 29 83 31 30 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $161 r0 *1 806.96,65.52
X$161 14074 29 302 37 321 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $163 r0 *1 595.28,206.64
X$163 14074 29 1412 1137 1500 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $165 m0 *1 626.08,176.4
X$165 14074 29 936 1137 972 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $168 r0 *1 592.48,176.4
X$168 14074 29 1100 1137 1134 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $170 r0 *1 624.4,166.32
X$170 14074 29 935 548 1136 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $172 r0 *1 641.2,236.88
X$172 14074 29 1707 1137 1753 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $175 r0 *1 409.92,75.6
X$175 14074 29 281 31 317 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $178 m0 *1 617.68,196.56
X$178 14074 29 1264 1137 1290 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $180 m0 *1 618.8,206.64
X$180 14074 29 1366 1137 1365 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $182 m0 *1 654.08,216.72
X$182 14074 29 1472 1137 1495 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $184 r0 *1 591.36,166.32
X$184 14074 29 998 548 1025 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $186 r0 *1 593.04,196.56
X$186 14074 29 1312 1137 1311 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $188 m0 *1 624.4,166.32
X$188 14074 29 880 548 912 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $190 r0 *1 623.84,156.24
X$190 14074 29 879 548 910 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $192 r0 *1 650.16,226.8
X$192 14074 29 1570 1137 1569 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $194 m0 *1 401.52,75.6
X$194 14074 29 328 31 352 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $196 r0 *1 599.2,216.72
X$196 14074 29 1515 1137 1608 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $198 m0 *1 425.6,65.52
X$198 14074 29 260 31 259 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $200 r0 *1 854.56,65.52
X$200 14074 29 306 233 305 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $202 r0 *1 637.28,216.72
X$202 14074 29 1469 1137 1471 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $204 m0 *1 641.2,186.48
X$204 14074 29 1160 1137 1244 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $206 r0 *1 432.32,45.36
X$206 14074 29 215 31 247 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $208 m0 *1 722.4,267.12
X$208 14074 29 2013 1046 1953 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $210 r0 *1 385.84,166.32
X$210 14074 29 1039 514 988 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $213 m0 *1 379.68,206.64
X$213 14074 29 1360 1357 1358 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $215 r0 *1 359.52,206.64
X$215 14074 29 1409 1357 1390 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $217 m0 *1 702.24,267.12
X$217 14074 29 1574 1046 1952 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $220 m0 *1 380.8,166.32
X$220 14074 29 927 514 960 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $222 m0 *1 358.4,156.24
X$222 14074 29 791 514 901 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $224 m0 *1 431.76,186.48
X$224 14074 29 1042 867 1183 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $226 m0 *1 670.32,257.04
X$226 14074 29 1708 1046 1829 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $228 r0 *1 672,267.12
X$228 14074 29 1772 1137 2090 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $230 m0 *1 677.6,267.12
X$230 14074 29 1639 1046 1927 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $233 r0 *1 366.8,166.32
X$233 14074 29 1038 514 1071 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $236 r0 *1 395.36,196.56
X$236 14074 29 1306 1357 1392 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $238 r0 *1 836.64,196.56
X$238 14074 29 1317 591 1316 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $241 r0 *1 817.6,196.56
X$241 14074 29 1344 591 1441 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $244 m0 *1 364.56,216.72
X$244 14074 29 1305 1357 1541 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $246 m0 *1 412.16,216.72
X$246 14074 29 1462 1357 1461 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $248 r0 *1 416.08,216.72
X$248 14074 29 1510 1357 1509 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $250 m0 *1 614.88,267.12
X$250 14074 29 1768 1137 1809 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $252 r0 *1 375.2,126
X$252 14074 29 651 514 723 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $254 m0 *1 379.12,115.92
X$254 14074 29 574 514 606 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $256 r0 *1 590.8,257.04
X$256 14074 29 1881 1137 1880 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $258 r0 *1 367.36,146.16
X$258 14074 29 789 514 827 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $260 m0 *1 600.32,297.36
X$260 14074 29 2167 1943 2293 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $262 m0 *1 359.52,146.16
X$262 14074 29 790 514 854 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $264 r0 *1 649.04,246.96
X$264 14074 29 1771 1137 1828 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $266 m0 *1 622.72,226.8
X$266 14074 29 1470 1137 1451 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $268 m0 *1 627.76,257.04
X$268 14074 29 1949 1137 1984 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $270 r0 *1 392,85.68
X$270 14074 29 418 31 445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $272 r0 *1 390.88,75.6
X$272 14074 29 282 31 361 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $274 r0 *1 413.84,85.68
X$274 14074 29 386 31 419 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $276 m0 *1 380.8,126
X$276 14074 29 648 514 647 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $278 r0 *1 599.76,246.96
X$278 14074 29 1827 1137 1859 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $281 r0 *1 423.36,105.84
X$281 14074 29 543 514 608 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $283 m0 *1 415.52,105.84
X$283 14074 29 515 514 483 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $286 m0 *1 403.76,166.32
X$286 14074 29 962 867 961 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $288 r0 *1 704.48,236.88
X$288 14074 29 1573 1046 1641 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $290 m0 *1 725.76,226.8
X$290 14074 29 1575 1046 1682 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $292 m0 *1 421.12,156.24
X$292 14074 29 869 867 868 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $294 m0 *1 702.8,246.96
X$294 14074 29 1710 1046 1858 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $296 r0 *1 404.88,166.32
X$296 14074 29 1040 867 989 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $298 r0 *1 399.84,115.92
X$298 14074 29 614 514 690 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $300 r0 *1 602,287.28
X$300 14074 29 2217 1137 2335 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $303 m0 *1 420,136.08
X$303 14074 29 616 514 615 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $305 r0 *1 417.76,146.16
X$305 14074 29 928 514 903 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $307 r0 *1 451.36,15.12
X$307 14074 29 51 31 50 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $309 r0 *1 836.08,126
X$309 14074 29 665 591 664 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $311 m0 *1 809.76,95.76
X$311 14074 29 377 233 477 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $314 m0 *1 828.8,95.76
X$314 14074 29 387 233 465 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $316 r0 *1 843.36,95.76
X$316 14074 29 379 233 499 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $318 r0 *1 815.92,126
X$318 14074 29 663 591 688 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $320 r0 *1 480.48,25.2
X$320 14074 29 105 31 136 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $322 r0 *1 590.8,65.52
X$322 14074 29 291 86 290 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $324 r0 *1 470.4,15.12
X$324 14074 29 53 31 77 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $326 m0 *1 442.96,35.28
X$326 14074 29 144 31 171 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $328 r0 *1 826.56,115.92
X$328 14074 29 593 591 610 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $331 m0 *1 604.24,75.6
X$331 14074 29 339 86 340 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $334 m0 *1 488.88,25.2
X$334 14074 29 32 31 101 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $336 r0 *1 602,95.76
X$336 14074 29 489 86 513 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $338 r0 *1 602.56,105.84
X$338 14074 29 572 86 550 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $341 r0 *1 471.52,65.52
X$341 14074 29 331 31 356 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $343 r0 *1 501.76,85.68
X$343 14074 29 365 31 423 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $345 m0 *1 471.52,85.68
X$345 14074 29 363 31 450 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $347 r0 *1 587.44,146.16
X$347 14074 29 744 548 835 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $349 r0 *1 477.12,75.6
X$349 14074 29 364 31 397 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $352 m0 *1 494.48,65.52
X$352 14074 29 284 31 283 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $354 r0 *1 582.4,126
X$354 14074 29 583 548 687 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $357 r0 *1 640.64,95.76
X$357 14074 29 491 86 490 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $360 m0 *1 654.08,95.76
X$360 14074 29 459 86 458 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $362 r0 *1 829.36,85.68
X$362 14074 29 405 233 428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $364 m0 *1 445.2,45.36
X$364 14074 29 147 31 249 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $366 m0 *1 468.16,65.52
X$366 14074 29 227 31 226 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $368 m0 *1 636.72,105.84
X$368 14074 29 552 86 542 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $370 r0 *1 451.36,45.36
X$370 14074 29 146 31 248 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $372 r0 *1 501.2,35.28
X$372 14074 29 151 31 200 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $374 r0 *1 599.76,75.6
X$374 14074 29 369 86 414 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $376 r0 *1 570.08,25.2
X$376 14074 29 87 86 103 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $379 r0 *1 530.88,15.12
X$379 14074 29 81 86 56 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $381 r0 *1 507.92,25.2
X$381 14074 29 107 31 138 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $383 m0 *1 521.36,15.12
X$383 14074 29 49 31 33 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $385 r0 *1 507.92,15.12
X$385 14074 29 34 31 78 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $387 m0 *1 580.16,15.12
X$387 14074 29 36 86 82 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $389 m0 *1 556.08,65.52
X$389 14074 29 264 86 278 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $391 m0 *1 566.72,45.36
X$391 14074 29 178 86 177 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $393 r0 *1 576.24,35.28
X$393 14074 29 109 86 220 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $395 r0 *1 591.92,15.12
X$395 14074 29 59 86 80 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $397 r0 *1 810.88,136.08
X$397 14074 29 754 591 785 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $399 m0 *1 601.44,35.28
X$399 14074 29 112 86 111 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $402 r0 *1 614.32,35.28
X$402 14074 29 156 86 174 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $404 m0 *1 615.44,45.36
X$404 14074 29 155 86 182 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $406 r0 *1 552.72,65.52
X$406 14074 29 285 86 337 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $408 r0 *1 571.76,65.52
X$408 14074 29 287 86 286 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $410 r0 *1 539.28,35.28
X$410 14074 29 152 86 196 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $412 r0 *1 540.4,25.2
X$412 14074 29 108 86 139 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $414 m0 *1 513.52,65.52
X$414 14074 29 263 31 262 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $416 m0 *1 539.84,75.6
X$416 14074 29 338 86 336 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $418 r0 *1 515.2,45.36
X$418 14074 29 176 31 202 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $420 r0 *1 525.84,105.84
X$420 14074 29 522 548 521 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $422 m0 *1 509.6,105.84
X$422 14074 29 520 548 487 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $424 r0 *1 529.2,115.92
X$424 14074 29 579 548 624 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $426 r0 *1 580.72,105.84
X$426 14074 29 528 86 582 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $429 r0 *1 516.32,75.6
X$429 14074 29 366 31 398 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $432 r0 *1 540.96,75.6
X$432 14074 29 368 86 412 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $434 r0 *1 657.44,166.32
X$434 14074 29 1000 142 999 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $437 m0 *1 670.32,176.4
X$437 14074 29 1102 1046 1047 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $440 r0 *1 514.64,126
X$440 14074 29 577 548 653 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $442 r0 *1 670.88,176.4
X$442 14074 29 1103 1046 1191 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $444 r0 *1 801.36,75.6
X$444 14074 29 375 37 411 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $446 m0 *1 712.88,136.08
X$446 14074 29 703 591 746 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $448 m0 *1 800.24,75.6
X$448 14074 29 376 37 389 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $450 r0 *1 724.64,136.08
X$450 14074 29 706 142 747 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $452 m0 *1 711.76,156.24
X$452 14074 29 705 142 837 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $454 r0 *1 546.56,105.84
X$454 14074 29 524 548 569 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $456 r0 *1 702.24,166.32
X$456 14074 29 1002 142 1080 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $459 m0 *1 698.32,176.4
X$459 14074 29 1001 1046 1048 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $462 r0 *1 712.32,176.4
X$462 14074 29 1004 1046 1138 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $464 m0 *1 551.6,105.84
X$464 14074 29 525 86 541 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $466 r0 *1 706.16,196.56
X$466 14074 29 1265 1046 1313 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $468 r0 *1 549.36,146.16
X$468 14074 29 733 548 732 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $470 r0 *1 731.36,186.48
X$470 14074 29 1242 1046 1285 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $473 r0 *1 551.04,136.08
X$473 14074 29 696 548 734 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $475 m0 *1 703.92,206.64
X$475 14074 29 1368 1046 1447 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $478 r0 *1 670.88,206.64
X$478 14074 29 1473 1046 1415 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $480 m0 *1 684.32,206.64
X$480 14074 29 1367 1046 1395 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $482 m0 *1 560,126
X$482 14074 29 581 548 686 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $485 m0 *1 688.24,216.72
X$485 14074 29 1449 1046 1416 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $487 m0 *1 728,196.56
X$487 14074 29 1267 1046 1266 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $490 m0 *1 552.72,115.92
X$490 14074 29 580 548 570 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $492 r0 *1 444.08,95.76
X$492 14074 29 485 514 484 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $494 r0 *1 435.12,75.6
X$494 14074 29 395 31 410 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $497 r0 *1 722.4,105.84
X$497 14074 29 555 142 556 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $500 r0 *1 757.12,146.16
X$500 14074 29 840 591 839 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $502 r0 *1 738.08,146.16
X$502 14074 29 750 142 864 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $504 m0 *1 740.88,146.16
X$504 14074 29 751 142 749 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $507 m0 *1 779.52,115.92
X$507 14074 29 589 591 632 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $509 r0 *1 706.16,95.76
X$509 14074 29 495 142 494 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $512 m0 *1 460.88,105.84
X$512 14074 29 518 31 516 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $514 r0 *1 700,105.84
X$514 14074 29 554 142 553 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $517 r0 *1 726.32,95.76
X$517 14074 29 462 142 461 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $519 r0 *1 798,115.92
X$519 14074 29 590 591 592 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $521 m0 *1 799.68,126
X$521 14074 29 633 591 634 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $523 r0 *1 624.4,126
X$523 14074 29 657 548 655 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $525 m0 *1 635.04,126
X$525 14074 29 658 548 627 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $527 m0 *1 632.24,115.92
X$527 14074 29 585 548 613 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $530 m0 *1 624.4,136.08
X$530 14074 29 698 548 788 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $532 r0 *1 480.48,115.92
X$532 14074 29 611 548 621 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $534 m0 *1 682.08,146.16
X$534 14074 29 701 142 823 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $537 r0 *1 672.56,126
X$537 14074 29 661 142 736 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $539 m0 *1 662.48,146.16
X$539 14074 29 628 142 660 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $542 m0 *1 488.88,136.08
X$542 14074 29 623 548 730 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $544 m0 *1 483.84,115.92
X$544 14074 29 566 31 546 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $546 m0 *1 487.76,146.16
X$546 14074 29 622 548 740 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $548 r0 *1 663.04,95.76
X$548 14074 29 493 142 492 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $550 r0 *1 437.36,115.92
X$550 14074 29 617 514 575 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $552 r0 *1 451.92,126
X$552 14074 29 620 514 683 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $554 r0 *1 679.84,85.68
X$554 14074 29 427 142 425 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $556 m0 *1 763.28,126
X$556 14074 29 630 591 629 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $558 m0 *1 684.32,95.76
X$558 14074 29 480 142 479 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $560 m0 *1 456.4,136.08
X$560 14074 29 618 548 693 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $562 m0 *1 955.92,146.16
X$562 14074 29 769 233 768 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $564 r0 *1 959.84,146.16
X$564 14074 29 805 472 856 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $566 r0 *1 969.92,136.08
X$566 14074 29 771 71 668 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $568 m0 *1 941.92,156.24
X$568 14074 29 893 233 905 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $570 m0 *1 969.92,15.12
X$570 14074 29 40 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $572 m0 *1 555.52,297.36
X$572 14074 29 2111 1943 2329 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $574 r0 *1 577.36,277.2
X$574 14074 29 2113 1137 2193 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $577 r0 *1 580.72,287.28
X$577 14074 29 2112 1943 2334 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $580 r0 *1 926.8,176.4
X$580 14074 29 1110 1225 1179 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $583 r0 *1 963.2,186.48
X$583 14074 29 1227 472 1226 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $585 r0 *1 958.72,176.4
X$585 14074 29 1111 472 1177 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $588 m0 *1 967.12,176.4
X$588 14074 29 1061 472 1124 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $590 r0 *1 967.68,166.32
X$590 14074 29 1011 472 1018 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $592 r0 *1 966,156.24
X$592 14074 29 712 472 711 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $594 r0 *1 918.4,146.16
X$594 14074 29 763 233 762 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $597 m0 *1 916.16,146.16
X$597 14074 29 764 233 709 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $599 m0 *1 935.2,146.16
X$599 14074 29 804 233 817 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $601 m0 *1 543.2,196.56
X$601 14074 29 1263 867 1291 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $604 r0 *1 777.28,257.04
X$604 14074 29 1956 2060 2034 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $606 r0 *1 527.52,166.32
X$606 14074 29 995 548 994 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $608 r0 *1 537.04,176.4
X$608 14074 29 996 867 1098 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $610 m0 *1 513.52,176.4
X$610 14074 29 876 867 1045 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $613 m0 *1 531.44,216.72
X$613 14074 29 1466 867 1442 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $615 r0 *1 531.44,216.72
X$615 14074 29 1514 867 1679 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $618 r0 *1 540.4,186.48
X$618 14074 29 1217 867 1216 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $621 r0 *1 509.6,196.56
X$621 14074 29 1309 867 1440 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $623 r0 *1 508.48,186.48
X$623 14074 29 1189 867 1188 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $625 m0 *1 422.24,297.36
X$625 14074 29 2161 1357 2323 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $627 r0 *1 422.24,277.2
X$627 14074 29 2160 1357 2158 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $629 m0 *1 563.92,156.24
X$629 14074 29 743 548 909 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $631 m0 *1 739.2,257.04
X$631 14074 29 1888 1046 1830 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $633 r0 *1 423.92,287.28
X$633 14074 29 2159 1357 2322 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $636 r0 *1 738.08,257.04
X$636 14074 29 1886 1046 1885 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $638 m0 *1 579.04,176.4
X$638 14074 29 1099 867 1133 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $641 r0 *1 533.68,156.24
X$641 14074 29 877 548 906 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $643 r0 *1 798.56,257.04
X$643 14074 29 1957 1225 2033 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $645 r0 *1 357.28,186.48
X$645 14074 29 1210 514 1284 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $647 m0 *1 481.04,156.24
X$647 14074 29 833 548 858 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $650 r0 *1 927.36,186.48
X$650 14074 29 1058 1225 1240 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $652 m0 *1 925.68,196.56
X$652 14074 29 1059 1225 1342 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $654 r0 *1 480.48,156.24
X$654 14074 29 929 548 965 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $656 m0 *1 490.56,176.4
X$656 14074 29 993 867 1021 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $659 m0 *1 488.88,186.48
X$659 14074 29 1157 867 1186 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $661 r0 *1 460.88,156.24
X$661 14074 29 871 548 904 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $663 m0 *1 464.8,166.32
X$663 14074 29 992 548 1077 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $665 m0 *1 565.6,196.56
X$665 14074 29 1310 1137 1346 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $667 r0 *1 561.12,186.48
X$667 14074 29 1158 867 1192 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $670 m0 *1 580.16,206.64
X$670 14074 29 1364 867 1448 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $673 m0 *1 551.6,216.72
X$673 14074 29 1468 867 1445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $675 r0 *1 426.16,327.6
X$675 14074 29 2215 2762 2729 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $677 r0 *1 428.4,226.8
X$677 14074 29 1511 1357 1631 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $680 m0 *1 400.96,236.88
X$680 14074 29 1700 1357 1744 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $683 m0 *1 374.08,287.28
X$683 14074 29 2103 1357 2263 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $686 r0 *1 788.48,267.12
X$686 14074 29 2018 2060 2087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $689 m0 *1 380.8,297.36
X$689 14074 29 2157 1357 2386 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $691 r0 *1 393.12,287.28
X$691 14074 29 2104 1357 2265 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $694 m0 *1 360.64,267.12
X$694 14074 29 2002 1357 2001 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $696 r0 *1 367.92,277.2
X$696 14074 29 2156 1357 2155 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $699 r0 *1 747.6,267.12
X$699 14074 29 2016 1046 2058 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $702 r0 *1 402.08,267.12
X$702 14074 29 1870 1357 2031 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $704 m0 *1 418.32,267.12
X$704 14074 29 1871 1357 2032 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $706 r0 *1 392,226.8
X$706 14074 29 1566 1357 1630 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $708 m0 *1 369.04,236.88
X$708 14074 29 1697 1357 1743 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $710 r0 *1 366.24,226.8
X$710 14074 29 1629 1357 1565 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $712 r0 *1 404.88,257.04
X$712 14074 29 1819 1357 1919 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $715 m0 *1 418.88,246.96
X$715 14074 29 1763 1357 1762 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $717 r0 *1 769.44,267.12
X$717 14074 29 2017 2060 2059 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $720 m0 *1 361.76,257.04
X$720 14074 29 1939 1357 1869 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $722 r0 *1 362.32,257.04
X$722 14074 29 1940 1357 1978 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $724 m0 *1 448.56,277.2
X$724 14074 29 2052 1357 2089 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $727 m0 *1 478.24,267.12
X$727 14074 29 1874 1357 2035 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $729 m0 *1 446.88,327.6
X$729 14074 29 2163 1943 2685 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $731 m0 *1 462,287.28
X$731 14074 29 2107 1943 2192 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $733 m0 *1 469.28,327.6
X$733 14074 29 2486 1943 2653 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $735 m0 *1 884.24,186.48
X$735 14074 29 1165 591 1164 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $737 r0 *1 463.68,287.28
X$737 14074 29 2164 1943 2393 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $740 r0 *1 505.12,257.04
X$740 14074 29 1823 1943 1876 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $742 r0 *1 473.2,257.04
X$742 14074 29 1875 1357 1942 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $744 r0 *1 467.6,246.96
X$744 14074 29 1821 1357 1873 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $746 m0 *1 436.24,226.8
X$746 14074 29 1513 1357 1674 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $748 m0 *1 779.52,176.4
X$748 14074 29 1006 1046 1050 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $750 r0 *1 784.56,156.24
X$750 14074 29 862 591 971 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $752 m0 *1 779.52,166.32
X$752 14074 29 885 591 884 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $754 m0 *1 515.76,257.04
X$754 14074 29 1824 1943 1877 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $756 m0 *1 563.92,337.68
X$756 14074 29 2292 1943 2765 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $758 m0 *1 542.08,236.88
X$758 14074 29 1467 867 1443 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $760 r0 *1 512.96,236.88
X$760 14074 29 1766 867 1807 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $763 m0 *1 522.48,317.52
X$763 14074 29 2489 1943 2488 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $766 r0 *1 542.08,277.2
X$766 14074 29 2055 1943 2110 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $769 m0 *1 528.08,307.44
X$769 14074 29 2420 1943 2458 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $771 r0 *1 357.28,176.4
X$771 14074 29 1152 514 1178 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $773 m0 *1 516.32,327.6
X$773 14074 29 2551 1943 2655 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $775 r0 *1 552.16,246.96
X$775 14074 29 1879 1137 1926 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $777 r0 *1 850.64,206.64
X$777 14074 29 1371 1225 1439 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $779 r0 *1 569.52,236.88
X$779 14074 29 1767 1137 1636 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $781 r0 *1 503.44,297.36
X$781 14074 29 2354 1943 2353 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $783 m0 *1 876.96,196.56
X$783 14074 29 1223 591 1271 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $785 r0 *1 549.92,257.04
X$785 14074 29 1946 1137 1945 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $787 r0 *1 879.2,196.56
X$787 14074 29 1224 1225 1438 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $790 r0 *1 480.48,317.52
X$790 14074 29 2591 1943 2617 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $792 r0 *1 571.2,246.96
X$792 14074 29 1826 1137 1825 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $795 m0 *1 483.84,317.52
X$795 14074 29 2550 1943 2549 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $798 r0 *1 480.48,307.44
X$798 14074 29 2418 1943 2456 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $800 m0 *1 747.04,196.56
X$800 14074 29 1269 1046 1268 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $803 m0 *1 471.52,196.56
X$803 14074 29 1262 867 1289 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $805 r0 *1 465.92,186.48
X$805 14074 29 1215 867 1156 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $808 r0 *1 745.36,156.24
X$808 14074 29 752 142 939 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $810 m0 *1 757.68,206.64
X$810 14074 29 1369 1046 1393 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $812 r0 *1 742,176.4
X$812 14074 29 1162 1046 1190 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $815 r0 *1 752.08,186.48
X$815 14074 29 1221 1046 1314 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $817 r0 *1 467.04,206.64
X$817 14074 29 1361 867 1494 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $819 r0 *1 501.76,226.8
X$819 14074 29 1634 867 1633 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $821 m0 *1 733.6,216.72
X$821 14074 29 1417 1046 1446 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $823 r0 *1 500.64,206.64
X$823 14074 29 1363 867 1496 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $825 m0 *1 470.96,216.72
X$825 14074 29 1410 867 1464 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $827 r0 *1 432.88,176.4
X$827 14074 29 1043 867 1019 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $829 m0 *1 478.8,236.88
X$829 14074 29 1705 1357 1704 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $831 m0 *1 444.08,156.24
X$831 14074 29 831 867 829 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $833 r0 *1 438.48,156.24
X$833 14074 29 832 867 857 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1149 r0 *1 929.6,206.64
X$1149 14074 892 29 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $1151 m0 *1 468.72,25.2
X$1151 14074 14073 30 52 55 83 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1159 r0 *1 464.8,55.44
X$1159 14074 319 31 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1208 r0 *1 456.96,55.44
X$1208 14074 14073 31 14166 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $1224 m0 *1 473.76,35.28
X$1224 14074 149 104 32 83 106 53 105 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1227 m0 *1 467.04,45.36
X$1227 14074 199 150 32 51 197 144 83 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1233 r0 *1 491.12,15.12
X$1233 14074 14073 101 52 43 32 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1236 m0 *1 526.4,25.2
X$1236 14074 14073 33 54 55 49 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1239 r0 *1 520.24,35.28
X$1239 14074 250 150 108 34 251 107 49 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1243 m0 *1 509.04,45.36
X$1243 14074 201 104 34 107 106 151 176 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1247 m0 *1 509.6,25.2
X$1247 14074 14073 78 54 84 34 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1251 m0 *1 568.4,468.72
X$1251 14074 4282 14073 35 4283 4277 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $1253 r0 *1 595.28,35.28
X$1253 14074 180 150 112 156 153 155 36 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1257 r0 *1 593.04,25.2
X$1257 14074 110 104 59 87 154 36 112 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1263 m0 *1 588,25.2
X$1263 14074 14073 82 58 57 36 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1265 m0 *1 734.16,15.12
X$1265 14074 40 39 37 79 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1267 r0 *1 799.68,35.28
X$1267 14074 14073 37 14149 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $1296 r0 *1 899.36,25.2
X$1296 14074 40 134 37 130 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1299 r0 *1 905.52,15.12
X$1299 14074 40 70 37 69 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1301 m0 *1 917.28,15.12
X$1301 14074 40 47 37 44 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1303 r0 *1 729.12,35.28
X$1303 14074 40 164 37 163 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1305 r0 *1 879.2,35.28
X$1305 14074 40 168 37 167 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1307 r0 *1 854.56,25.2
X$1307 14074 40 128 37 127 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1309 m0 *1 847.84,25.2
X$1309 14074 40 68 37 66 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1311 r0 *1 804.16,35.28
X$1311 14074 271 37 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $1314 m0 *1 820.96,25.2
X$1314 14074 40 96 37 100 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1316 m0 *1 779.52,75.6
X$1316 14074 40 345 37 374 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1318 r0 *1 809.76,45.36
X$1318 14074 40 125 37 217 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1320 r0 *1 749.28,15.12
X$1320 14074 40 48 37 141 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1323 m0 *1 808.64,35.28
X$1323 14074 40 124 37 137 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1325 m0 *1 779.52,45.36
X$1325 14074 40 120 37 218 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1327 m0 *1 779.52,25.2
X$1327 14074 40 95 37 121 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1329 m0 *1 765.52,35.28
X$1329 14074 40 119 37 118 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1331 r0 *1 768.32,15.12
X$1331 14074 40 76 37 63 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1337 r0 *1 817.04,15.12
X$1337 14074 40 65 37 64 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1339 r0 *1 794.64,25.2
X$1339 14074 40 122 37 123 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1341 r0 *1 835.52,25.2
X$1341 14074 40 126 37 135 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1343 m0 *1 881.44,35.28
X$1343 14074 40 131 37 129 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1345 m0 *1 820.4,15.12
X$1345 14074 40 42 37 41 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1347 r0 *1 721.84,15.12
X$1347 14074 40 38 37 60 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1349 m0 *1 725.2,45.36
X$1349 14074 40 187 37 223 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1351 m0 *1 696.64,35.28
X$1351 14074 40 162 37 115 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1353 r0 *1 750.96,35.28
X$1353 14074 40 188 37 221 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1355 m0 *1 772.8,85.68
X$1355 14074 40 301 37 322 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1357 m0 *1 729.12,25.2
X$1357 14074 14073 60 62 55 38 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1360 r0 *1 750.4,25.2
X$1360 14074 116 94 76 38 92 39 48 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1362 m0 *1 750.4,25.2
X$1362 14074 93 61 76 38 91 39 48 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $1373 m0 *1 739.76,25.2
X$1373 14074 14073 79 62 57 39 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $1375 r0 *1 1153.04,156.24
X$1375 14074 40 954 71 956 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1377 m0 *1 896.56,418.32
X$1377 14074 40 3489 3365 3602 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1380 m0 *1 886.48,408.24
X$1380 14074 40 3487 2796 3547 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1383 r0 *1 1038.8,85.68
X$1383 14074 40 441 71 444 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1386 m0 *1 920.08,408.24
X$1386 14074 40 3422 3365 3559 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1388 r0 *1 1126.16,156.24
X$1388 14074 40 953 472 952 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1391 m0 *1 914.48,378
X$1391 14074 40 3364 2796 3294 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1394 m0 *1 864.08,55.44
X$1394 14074 40 235 233 234 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1396 m0 *1 917.84,418.32
X$1396 14074 40 3423 3365 3603 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1400 r0 *1 1046.64,95.76
X$1400 14074 40 505 472 504 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1403 m0 *1 1130.08,156.24
X$1403 14074 40 849 472 852 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1407 m0 *1 967.68,226.8
X$1407 14074 40 1527 1423 1598 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1409 r0 *1 971.6,246.96
X$1409 14074 40 1832 1423 1916 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1412 r0 *1 899.36,357.84
X$1412 14074 40 3053 2796 3052 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1415 r0 *1 973.28,267.12
X$1415 14074 40 1833 1423 2075 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1417 r0 *1 899.36,347.76
X$1417 14074 40 2985 2796 3002 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1419 r0 *1 904.96,337.68
X$1419 14074 40 2726 2796 2874 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1421 m0 *1 1061.76,146.16
X$1421 14074 40 810 472 809 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1424 r0 *1 1013.6,257.04
X$1424 14074 40 1783 1423 1966 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1426 r0 *1 908.88,307.44
X$1426 14074 40 2502 1225 2581 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1428 r0 *1 931.28,367.92
X$1428 14074 40 3230 2780 3243 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1431 m0 *1 1051.68,95.76
X$1431 14074 40 443 472 442 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1434 m0 *1 1032.08,95.76
X$1434 14074 40 471 71 470 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1436 m0 *1 918.96,367.92
X$1436 14074 40 3141 2796 3244 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1441 r0 *1 932.4,378
X$1441 14074 40 3296 2780 3295 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1443 m0 *1 894.88,337.68
X$1443 14074 40 2775 2796 2839 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1445 r0 *1 1016.96,277.2
X$1445 14074 40 1902 1799 2182 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1448 r0 *1 918.4,327.6
X$1448 14074 40 2623 2796 2700 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1450 m0 *1 1004.64,287.28
X$1450 14074 40 1836 1799 2181 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1452 r0 *1 1036,126
X$1452 14074 40 643 472 727 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1454 m0 *1 1049.44,186.48
X$1454 14074 40 1062 1064 1172 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1457 r0 *1 636.16,45.36
X$1457 14074 40 183 86 204 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1459 m0 *1 626.64,75.6
X$1459 14074 40 295 86 392 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1461 r0 *1 630.56,65.52
X$1461 14074 40 294 86 293 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1464 m0 *1 1031.52,176.4
X$1464 14074 40 1013 1064 1069 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1466 r0 *1 653.52,65.52
X$1466 14074 40 269 86 268 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1469 m0 *1 642.88,85.68
X$1469 14074 40 296 86 401 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1471 r0 *1 635.6,35.28
X$1471 14074 40 158 86 157 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1474 m0 *1 856.24,105.84
X$1474 14074 40 467 233 538 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1476 r0 *1 879.2,85.68
X$1476 14074 40 430 233 451 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1478 m0 *1 1039.92,156.24
X$1478 14074 40 815 472 816 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1481 m0 *1 859.04,95.76
X$1481 14074 40 466 233 476 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1483 r0 *1 879.2,105.84
X$1483 14074 40 558 233 564 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1485 m0 *1 674.8,75.6
X$1485 14074 40 342 142 341 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1487 m0 *1 862.4,136.08
X$1487 14074 40 667 233 708 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1489 r0 *1 861.84,146.16
X$1489 14074 40 800 591 842 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1492 r0 *1 706.16,45.36
X$1492 14074 40 186 142 257 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1494 r0 *1 879.2,136.08
X$1494 14074 40 758 233 757 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1498 m0 *1 721.28,55.44
X$1498 14074 40 207 142 258 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1501 r0 *1 679.84,35.28
X$1501 14074 40 161 142 160 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1504 m0 *1 679.84,45.36
X$1504 14074 40 205 142 222 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1508 m0 *1 719.6,75.6
X$1508 14074 40 343 142 391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1510 m0 *1 856.24,126
X$1510 14074 40 666 233 635 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1512 r0 *1 656.88,25.2
X$1512 14074 40 90 142 88 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1514 m0 *1 654.64,35.28
X$1514 14074 40 159 86 114 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1516 r0 *1 875.84,115.92
X$1516 14074 40 594 233 609 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1518 m0 *1 1048.88,257.04
X$1518 14074 40 1786 1799 1724 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1521 m0 *1 1034.32,246.96
X$1521 14074 40 1784 1064 1845 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1523 m0 *1 1142.96,196.56
X$1523 14074 40 1275 1064 1329 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1525 r0 *1 1153.04,186.48
X$1525 14074 40 1232 1064 1170 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1528 m0 *1 1165.92,206.64
X$1528 14074 40 1324 1064 1433 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1531 r0 *1 1170.96,196.56
X$1531 14074 40 1323 1064 1325 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1536 m0 *1 1072.96,105.84
X$1536 14074 40 507 472 506 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1542 m0 *1 1055.04,246.96
X$1542 14074 40 1785 1799 1787 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1548 r0 *1 702.24,75.6
X$1548 14074 40 372 142 404 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1551 m0 *1 1078,176.4
X$1551 14074 40 1063 1064 1067 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1553 m0 *1 876.4,85.68
X$1553 14074 40 429 233 452 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1555 r0 *1 770,95.76
X$1555 14074 40 498 142 481 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1558 r0 *1 750.96,95.76
X$1558 14074 40 497 142 496 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1561 r0 *1 745.36,105.84
X$1561 14074 40 530 142 557 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1563 r0 *1 679.84,75.6
X$1563 14074 40 297 142 360 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1566 m0 *1 1093.12,156.24
X$1566 14074 40 899 472 853 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1568 m0 *1 779.52,95.76
X$1568 14074 40 464 233 478 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1571 m0 *1 732.48,85.68
X$1571 14074 40 358 142 415 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1573 r0 *1 738.64,75.6
X$1573 14074 40 344 142 413 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1576 m0 *1 670.32,428.4
X$1576 14074 40 3786 3670 3890 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1578 r0 *1 668.08,418.32
X$1578 14074 40 3727 3670 3666 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1580 m0 *1 1008,156.24
X$1580 14074 40 808 472 894 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1583 r0 *1 1024.24,156.24
X$1583 14074 40 898 472 945 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1585 r0 *1 1022,146.16
X$1585 14074 40 807 472 847 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1587 m0 *1 705.6,428.4
X$1587 14074 40 3728 3670 3788 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1589 r0 *1 704.48,438.48
X$1589 14074 40 3931 3670 4058 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1591 m0 *1 683.76,448.56
X$1591 14074 40 3930 3670 4136 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1593 m0 *1 681.52,438.48
X$1593 14074 40 3929 3670 4059 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1595 r0 *1 998.48,146.16
X$1595 14074 40 846 472 845 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1597 r0 *1 700,398.16
X$1597 14074 40 3546 2871 3483 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1599 m0 *1 706.16,398.16
X$1599 14074 40 3484 2871 3517 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1601 m0 *1 696.08,408.24
X$1601 14074 40 3545 2871 3543 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1603 m0 *1 941.92,15.12
X$1603 14074 40 46 71 45 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1605 m0 *1 644.56,448.56
X$1605 14074 40 4006 3718 4100 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1608 m0 *1 1001.84,186.48
X$1608 14074 40 1167 1064 1238 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1610 r0 *1 806.4,519.12
X$1610 14074 40 4938 4315 5039 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1613 r0 *1 929.6,15.12
X$1613 14074 40 75 71 72 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1615 m0 *1 688.24,509.04
X$1615 14074 40 4695 4694 4756 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1617 m0 *1 671.44,519.12
X$1617 14074 40 4827 4694 4934 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1621 m0 *1 971.04,115.92
X$1621 14074 40 503 71 559 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1623 r0 *1 969.92,115.92
X$1623 14074 40 446 71 638 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1625 m0 *1 689.92,478.8
X$1625 14074 40 4422 3670 4524 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1627 r0 *1 658.56,498.96
X$1627 14074 40 4755 4694 4754 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1629 m0 *1 686,498.96
X$1629 14074 40 4696 4694 4733 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1631 m0 *1 711.2,509.04
X$1631 14074 40 4625 4315 4784 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1634 r0 *1 716.24,509.04
X$1634 14074 40 4627 4315 4887 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1636 r0 *1 959.28,105.84
X$1636 14074 40 502 71 533 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1638 m0 *1 703.36,468.72
X$1638 14074 40 4217 3670 4250 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1641 r0 *1 999.6,115.92
X$1641 14074 40 599 71 640 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1643 r0 *1 700,468.72
X$1643 14074 40 4357 3670 4523 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1645 r0 *1 1007.44,136.08
X$1645 14074 40 773 472 772 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1647 m0 *1 941.92,25.2
X$1647 14074 40 99 71 73 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1649 r0 *1 674.24,478.8
X$1649 14074 40 4421 3670 4443 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1652 m0 *1 1024.8,115.92
X$1652 14074 40 600 472 604 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1657 m0 *1 999.04,115.92
X$1657 14074 40 598 71 605 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1660 r0 *1 719.04,468.72
X$1660 14074 40 4287 3670 4286 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1662 m0 *1 1013.6,126
X$1662 14074 40 642 472 641 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1664 m0 *1 978.32,75.6
X$1664 14074 40 384 71 382 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1666 m0 *1 964.88,45.36
X$1666 14074 40 195 71 194 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1668 m0 *1 959.84,55.44
X$1668 14074 40 241 71 246 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1670 m0 *1 1020.88,216.72
X$1670 14074 40 1426 1064 1537 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1672 m0 *1 1001.84,216.72
X$1672 14074 40 1425 1064 1595 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1675 r0 *1 992.32,45.36
X$1675 14074 40 243 71 245 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1677 m0 *1 957.6,206.64
X$1677 14074 40 1373 1225 1372 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1679 r0 *1 647.92,418.32
X$1679 14074 40 3664 2871 3662 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1682 r0 *1 992.88,156.24
X$1682 14074 40 944 472 963 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1684 r0 *1 1003.52,65.52
X$1684 14074 40 313 71 350 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1687 r0 *1 654.64,408.24
X$1687 14074 40 3665 2871 3598 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1689 r0 *1 992.88,216.72
X$1689 14074 40 1480 1423 1597 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1691 m0 *1 1016.4,206.64
X$1691 14074 40 1427 1064 1437 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1693 r0 *1 998.48,55.44
X$1693 14074 40 275 71 244 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1695 r0 *1 967.68,206.64
X$1695 14074 40 1424 1423 1422 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1697 m0 *1 1004.64,65.52
X$1697 14074 40 242 71 276 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1699 m0 *1 689.92,549.36
X$1699 14074 40 5193 4694 5359 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1701 m0 *1 687.68,529.2
X$1701 14074 40 5146 4694 5073 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1703 m0 *1 799.68,529.2
X$1703 14074 40 4831 4315 4830 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1705 m0 *1 778.4,519.12
X$1705 14074 40 4936 4315 5150 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1707 m0 *1 679.84,539.28
X$1707 14074 40 5224 4694 5223 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1710 m0 *1 779.52,488.88
X$1710 14074 40 4424 4315 4439 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1712 r0 *1 750.4,509.04
X$1712 14074 40 4760 4315 4886 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1715 m0 *1 659.12,569.52
X$1715 14074 40 5357 4694 5547 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1717 r0 *1 666.96,569.52
X$1717 14074 40 5417 4694 5684 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1720 m0 *1 896.56,85.68
X$1720 14074 40 381 233 409 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1723 m0 *1 906.08,115.92
X$1723 14074 40 596 233 595 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1725 m0 *1 639.52,579.6
X$1725 14074 40 5440 3718 5804 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1727 r0 *1 647.92,569.52
X$1727 14074 40 5418 3718 5717 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1730 m0 *1 762.16,529.2
X$1730 14074 40 4829 4315 5190 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1733 m0 *1 756.56,539.28
X$1733 14074 40 4828 4315 5227 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1735 m0 *1 884.8,65.52
X$1735 14074 40 307 233 318 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1737 m0 *1 891.52,75.6
X$1737 14074 40 349 233 355 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1739 m0 *1 719.6,559.44
X$1739 14074 40 5147 4694 5476 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1741 r0 *1 787.36,519.12
X$1741 14074 40 4937 4315 4880 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1744 m0 *1 719.6,539.28
X$1744 14074 40 5226 4694 5250 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1746 r0 *1 910,105.84
X$1746 14074 40 560 233 562 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1749 r0 *1 792.96,448.56
X$1749 14074 40 3851 3670 3850 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1752 r0 *1 929.04,105.84
X$1752 14074 40 597 71 607 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1754 m0 *1 935.2,105.84
X$1754 14074 40 532 71 537 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1756 r0 *1 955.36,65.52
X$1756 14074 40 312 71 311 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1758 r0 *1 926.8,45.36
X$1758 14074 40 238 71 214 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1760 m0 *1 939.12,95.76
X$1760 14074 40 433 71 432 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1762 m0 *1 917.28,85.68
X$1762 14074 40 310 233 431 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1765 r0 *1 734.16,448.56
X$1765 14074 40 3933 3670 4135 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1768 m0 *1 742.56,478.8
X$1768 14074 40 4423 3670 4441 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1771 r0 *1 936.32,65.52
X$1771 14074 40 274 71 314 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1773 m0 *1 766.64,458.64
X$1773 14074 40 3934 3670 4056 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1775 m0 *1 700,569.52
X$1775 14074 40 5225 4694 5587 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1777 r0 *1 700.56,569.52
X$1777 14074 40 5292 4694 5801 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1780 m0 *1 742.56,498.96
X$1780 14074 40 4570 4315 4569 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1783 r0 *1 745.36,488.88
X$1783 14074 40 4490 4315 4489 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1785 m0 *1 706.16,579.6
X$1785 14074 40 5368 4694 5800 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1787 r0 *1 950.32,55.44
X$1787 14074 40 213 71 240 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1790 r0 *1 773.92,468.72
X$1790 14074 40 4359 3670 4384 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1792 r0 *1 792.96,468.72
X$1792 14074 40 4289 3670 4521 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1794 r0 *1 774.48,478.8
X$1794 14074 40 4492 3670 4491 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1796 r0 *1 945.84,95.76
X$1796 14074 40 434 71 508 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1798 r0 *1 597.52,509.04
X$1798 14074 40 4823 3718 4981 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1800 r0 *1 615.44,478.8
X$1800 14074 40 4353 3718 4487 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1802 m0 *1 612.08,468.72
X$1802 14074 40 4284 3718 4326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1804 m0 *1 618.8,498.96
X$1804 14074 40 4692 3718 4728 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1806 r0 *1 652.96,488.88
X$1806 14074 40 4420 4694 4675 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1808 r0 *1 768.88,549.36
X$1808 14074 40 5421 4315 5367 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1810 m0 *1 1007.44,85.68
X$1810 14074 40 439 71 408 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1813 m0 *1 603.68,509.04
X$1813 14074 40 4752 3718 4789 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1815 m0 *1 613.2,519.12
X$1815 14074 40 4824 3718 5047 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1817 m0 *1 620.48,478.8
X$1817 14074 40 4354 3718 4418 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1821 r0 *1 640.64,468.72
X$1821 14074 40 4356 3718 4355 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1824 r0 *1 651.84,448.56
X$1824 14074 40 4007 3718 4004 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1826 r0 *1 632.8,448.56
X$1826 14074 40 4101 3718 4188 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1830 m0 *1 600.32,478.8
X$1830 14074 40 4352 3718 4529 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1833 r0 *1 1002.96,85.68
X$1833 14074 40 438 71 437 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1835 r0 *1 654.64,478.8
X$1835 14074 40 4419 3718 4488 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1838 m0 *1 618.8,549.36
X$1838 14074 40 5355 3718 5354 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1840 r0 *1 745.92,549.36
X$1840 14074 40 5420 4694 5419 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1842 m0 *1 743.68,559.44
X$1842 14074 40 5477 4694 5585 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1845 m0 *1 742,529.2
X$1845 14074 40 4758 4315 5077 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1847 m0 *1 895.44,55.44
X$1847 14074 40 237 233 236 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1849 r0 *1 739.76,589.68
X$1849 14074 40 5839 4694 5912 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1851 m0 *1 744.24,589.68
X$1851 14074 40 5838 4694 5913 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1853 m0 *1 762.72,569.52
X$1853 14074 40 5549 4694 5642 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1855 m0 *1 646.8,519.12
X$1855 14074 40 4826 3718 4932 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1857 r0 *1 642.88,539.28
X$1857 14074 40 5291 3718 5290 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1860 r0 *1 628.32,519.12
X$1860 14074 40 4825 3718 4980 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1862 m0 *1 625.52,559.44
X$1862 14074 40 5356 3718 5508 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1864 r0 *1 621.04,539.28
X$1864 14074 40 5256 3718 5221 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1867 r0 *1 879.2,357.84
X$1867 14074 40 3051 2796 3143 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1870 r0 *1 952.56,226.8
X$1870 14074 40 1582 1423 1600 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1872 m0 *1 876.96,357.84
X$1872 14074 40 3050 2796 2983 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1875 m0 *1 1106.56,146.16
X$1875 14074 40 717 472 813 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1878 m0 *1 1110.48,126
X$1878 14074 40 673 71 675 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1881 m0 *1 945.84,216.72
X$1881 14074 40 1478 1423 1542 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1883 m0 *1 867.44,337.68
X$1883 14074 40 2622 2796 2840 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1885 m0 *1 948.64,246.96
X$1885 14074 40 1720 1423 1719 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1887 m0 *1 928.48,246.96
X$1887 14074 40 1778 1423 1804 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1890 r0 *1 872.48,337.68
X$1890 14074 40 2620 2796 2873 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1892 m0 *1 931.28,236.88
X$1892 14074 40 1652 1423 1668 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1894 m0 *1 779.52,609.84
X$1894 14074 40 5750 4694 6169 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1896 r0 *1 764.96,599.76
X$1896 14074 40 5915 4694 6109 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1899 m0 *1 757.12,599.76
X$1899 14074 40 5914 4694 6002 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1902 m0 *1 859.6,287.28
X$1902 14074 40 2233 1225 2266 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1905 m0 *1 855.12,297.36
X$1905 14074 40 2176 2060 2326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1907 m0 *1 911.12,287.28
X$1907 14074 40 2237 1423 2264 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1910 m0 *1 799.68,599.76
X$1910 14074 40 5842 4694 5841 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1912 r0 *1 805.28,599.76
X$1912 14074 40 5751 4694 5916 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1915 r0 *1 785.12,599.76
X$1915 14074 40 5840 4694 6108 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1918 m0 *1 915.04,277.2
X$1918 14074 40 2118 1423 2117 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1920 m0 *1 894.32,277.2
X$1920 14074 40 2062 1225 2080 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1922 m0 *1 871.92,327.6
X$1922 14074 40 2621 1225 2699 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1924 m0 *1 941.36,257.04
X$1924 14074 40 1896 1423 1895 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1926 r0 *1 942.48,257.04
X$1926 14074 40 1897 1423 2025 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1929 r0 *1 864.08,327.6
X$1929 14074 40 2619 2796 2727 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1931 r0 *1 870.8,277.2
X$1931 14074 40 2116 1225 2137 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1933 r0 *1 878.64,287.28
X$1933 14074 40 2234 1225 2175 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1935 r0 *1 901.04,277.2
X$1935 14074 40 2177 1225 2077 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1937 r0 *1 1071.84,115.92
X$1937 14074 40 644 472 645 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1939 r0 *1 818.72,418.32
X$1939 14074 40 3731 2796 3756 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1942 m0 *1 823.76,418.32
X$1942 14074 40 3673 2796 3755 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1944 m0 *1 1078.56,136.08
X$1944 14074 40 671 472 721 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1946 r0 *1 842.24,408.24
X$1946 14074 40 3601 3365 3621 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1948 m0 *1 842.8,418.32
X$1948 14074 40 3674 3365 3751 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1950 m0 *1 809.76,448.56
X$1950 14074 40 3937 3670 3970 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1952 r0 *1 1000.72,236.88
X$1952 14074 40 1723 1423 1740 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1954 m0 *1 1091.44,126
X$1954 14074 40 672 472 676 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1957 m0 *1 885.36,166.32
X$1957 14074 40 802 591 943 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1959 m0 *1 882.56,156.24
X$1959 14074 40 803 591 907 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1962 m0 *1 857.92,388.08
X$1962 14074 40 3293 2796 3359 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1964 m0 *1 766.64,448.56
X$1964 14074 40 4010 3670 4102 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1967 m0 *1 857.36,398.16
X$1967 14074 40 3361 2796 3485 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1970 r0 *1 858.48,378
X$1970 14074 40 3292 2796 3324 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1972 m0 *1 745.36,448.56
X$1972 14074 40 3932 3670 4009 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1975 r0 *1 1149.12,146.16
X$1975 14074 40 850 472 851 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1977 m0 *1 876.4,398.16
X$1977 14074 40 3362 2796 3486 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1980 r0 *1 791.28,438.48
X$1980 14074 40 3936 3670 4055 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1982 r0 *1 803.6,428.4
X$1982 14074 40 3852 3670 3813 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1984 m0 *1 1080.8,146.16
X$1984 14074 40 812 472 811 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1987 r0 *1 765.52,418.32
X$1987 14074 40 3672 3670 3757 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1990 m0 *1 755.44,418.32
X$1990 14074 40 3600 3670 3623 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1992 r0 *1 736.96,418.32
X$1992 14074 40 3730 3670 3729 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $1995 r0 *1 741.44,408.24
X$1995 14074 40 3671 3670 3599 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $2301 r0 *1 1162,15.12
X$2301 14074 40 74 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $2304 m0 *1 1161.44,186.48
X$2304 14074 40 1116 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $2306 m0 *1 571.2,498.96
X$2306 14074 40 4562 3652 4565 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $2308 r0 *1 561.12,468.72
X$2308 14074 40 4417 3652 4330 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $2310 m0 *1 566.72,478.8
X$2310 14074 40 4483 3652 4414 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $2313 m0 *1 820.4,45.36
X$2313 14074 14073 41 67 55 42 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2316 r0 *1 846.72,35.28
X$2316 14074 191 94 68 42 166 65 128 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2318 m0 *1 828.8,45.36
X$2318 14074 189 190 42 124 208 125 65 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2326 r0 *1 854,15.12
X$2326 14074 14073 66 67 43 68 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2330 r0 *1 532,25.2
X$2330 14074 14073 139 54 43 108 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2332 m0 *1 600.32,25.2
X$2332 14074 14073 80 58 43 59 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2335 m0 *1 661.92,25.2
X$2335 14074 14073 88 89 43 90 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2338 m0 *1 769.44,25.2
X$2338 14074 14073 63 62 43 76 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2341 m0 *1 681.52,136.08
X$2341 14074 14073 736 551 43 661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2343 r0 *1 948.64,25.2
X$2343 14074 14073 45 97 43 46 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2346 m0 *1 987.84,55.44
X$2346 14074 14073 244 212 43 275 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2348 m0 *1 570.08,186.48
X$2348 14074 14073 1192 1218 43 1158 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2351 m0 *1 512.4,186.48
X$2351 14074 14073 1188 830 43 1189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2354 r0 *1 504.56,236.88
X$2354 14074 14073 1807 1699 43 1766 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2376 m0 *1 560,327.6
X$2376 14074 14073 2688 43 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2378 m0 *1 922.32,25.2
X$2378 14074 14073 44 97 55 47 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2387 r0 *1 929.6,25.2
X$2387 14074 133 94 46 47 98 75 99 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2391 m0 *1 928.48,35.28
X$2391 14074 170 132 46 47 169 75 99 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2405 m0 *1 756,35.28
X$2405 14074 14073 141 48 117 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2414 m0 *1 532.56,35.28
X$2414 14074 172 104 108 49 106 81 152 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2419 m0 *1 459.2,25.2
X$2419 14074 14073 50 52 84 51 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2422 r0 *1 453.6,35.28
X$2422 14074 145 104 51 144 106 147 146 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2430 r0 *1 409.36,65.52
X$2430 14074 14073 352 52 288 328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2432 r0 *1 418.88,65.52
X$2432 14074 14073 317 52 354 281 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2434 r0 *1 433.44,55.44
X$2434 14074 14073 259 260 261 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2436 m0 *1 391.44,75.6
X$2436 14074 14073 361 52 329 282 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2439 r0 *1 370.72,156.24
X$2439 14074 14073 827 52 870 789 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2442 r0 *1 385.28,115.92
X$2442 14074 14073 647 52 573 648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2445 m0 *1 391.44,136.08
X$2445 14074 14073 723 52 689 651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2447 m0 *1 400.96,136.08
X$2447 14074 14073 690 52 878 614 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2449 m0 *1 440.72,115.92
X$2449 14074 14073 575 52 463 617 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2451 m0 *1 400.96,95.76
X$2451 14074 14073 445 52 453 418 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2455 m0 *1 461.44,55.44
X$2455 14074 14073 248 52 228 146 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2458 m0 *1 453.04,55.44
X$2458 14074 14073 249 52 225 147 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2462 m0 *1 478.8,25.2
X$2462 14074 14073 77 52 57 53 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2466 m0 *1 450.24,105.84
X$2466 14074 14073 484 52 511 485 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2468 m0 *1 447.44,85.68
X$2468 14074 14073 410 52 396 395 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2505 r0 *1 467.6,105.84
X$2505 14074 14073 516 518 523 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2507 r0 *1 470.96,126
X$2507 14074 14073 683 620 625 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2510 r0 *1 458.08,136.08
X$2510 14074 14073 693 618 626 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2512 m0 *1 492.8,35.28
X$2512 14074 14073 136 105 117 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2514 r0 *1 445.2,35.28
X$2514 14074 14073 171 144 148 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2517 r0 *1 414.96,105.84
X$2517 14074 14073 483 515 500 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2519 m0 *1 416.64,85.68
X$2519 14074 14073 419 386 292 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2521 m0 *1 434,55.44
X$2521 14074 14073 247 215 224 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2523 r0 *1 420.56,115.92
X$2523 14074 14073 615 616 549 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2526 r0 *1 428.96,115.92
X$2526 14074 14073 608 543 460 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2529 r0 *1 373.52,115.92
X$2529 14074 14073 606 574 1037 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2532 r0 *1 379.12,156.24
X$2532 14074 14073 854 790 887 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2535 m0 *1 377.44,156.24
X$2535 14074 14073 901 791 834 52 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2537 m0 *1 538.16,519.12
X$2537 14074 14073 5188 52 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2541 r0 *1 474.88,35.28
X$2541 14074 216 150 105 146 197 147 53 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2546 m0 *1 512.96,35.28
X$2546 14074 14073 138 107 148 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2550 m0 *1 515.2,55.44
X$2550 14074 14073 202 54 228 176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2553 r0 *1 503.44,45.36
X$2553 14074 14073 200 54 225 151 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2556 r0 *1 500.64,65.52
X$2556 14074 14073 283 54 329 284 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2558 m0 *1 467.04,75.6
X$2558 14074 14073 356 54 288 331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2562 m0 *1 535.36,25.2
X$2562 14074 14073 56 54 57 81 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2566 m0 *1 519.12,85.68
X$2566 14074 14073 398 54 396 366 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2568 r0 *1 518,95.76
X$2568 14074 14073 487 54 511 520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2570 r0 *1 478.8,85.68
X$2570 14074 14073 397 54 354 364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2573 m0 *1 506.24,95.76
X$2573 14074 14073 423 54 453 365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2576 m0 *1 484.4,126
X$2576 14074 14073 621 611 500 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2578 r0 *1 488.88,146.16
X$2578 14074 14073 858 833 834 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2580 r0 *1 491.12,126
X$2580 14074 14073 730 54 463 623 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2582 m0 *1 539.84,176.4
X$2582 14074 14073 1098 54 689 996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2584 r0 *1 519.12,166.32
X$2584 14074 14073 1045 54 573 876 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2587 m0 *1 542.64,156.24
X$2587 14074 14073 906 54 878 877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2589 m0 *1 497.28,166.32
X$2589 14074 14073 1021 54 870 993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2633 r0 *1 470.4,85.68
X$2633 14074 14073 450 363 292 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2636 r0 *1 490.56,105.84
X$2636 14074 14073 546 566 460 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2638 r0 *1 491.12,136.08
X$2638 14074 14073 740 622 549 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2640 m0 *1 470.96,55.44
X$2640 14074 14073 226 227 261 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2642 m0 *1 533.12,126
X$2642 14074 14073 624 579 625 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2644 m0 *1 528.64,105.84
X$2644 14074 14073 521 522 523 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2646 m0 *1 515.2,126
X$2646 14074 14073 653 577 626 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2649 r0 *1 516.88,55.44
X$2649 14074 14073 262 263 224 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2651 m0 *1 547.12,45.36
X$2651 14074 14073 196 152 117 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2653 r0 *1 546.56,166.32
X$2653 14074 14073 994 995 748 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2656 m0 *1 488.88,166.32
X$2656 14074 14073 965 929 887 54 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2658 m0 *1 570.64,509.04
X$2658 14074 14073 5071 54 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2662 m0 *1 641.2,45.36
X$2662 14074 14073 204 89 55 183 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2665 r0 *1 651.28,105.84
X$2665 14074 14073 490 551 55 491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2667 m0 *1 576.8,25.2
X$2667 14074 14073 103 58 55 87 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2671 m0 *1 1002.96,126
X$2671 14074 14073 640 440 55 599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2673 m0 *1 1005.2,75.6
X$2673 14074 14073 350 212 55 313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2677 r0 *1 540.4,196.56
X$2677 14074 14073 1216 1218 55 1217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2679 r0 *1 500.64,196.56
X$2679 14074 14073 1186 830 55 1157 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2682 m0 *1 501.76,236.88
X$2682 14074 14073 1633 1699 55 1634 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2706 m0 *1 530.88,337.68
X$2706 14074 14073 2844 55 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2711 r0 *1 642.88,105.84
X$2711 14074 14073 542 551 57 552 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2716 m0 *1 641.2,35.28
X$2716 14074 14073 157 89 57 158 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2718 m0 *1 812.56,25.2
X$2718 14074 14073 64 67 57 65 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2721 m0 *1 933.52,25.2
X$2721 14074 14073 72 97 57 75 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2724 r0 *1 548.8,196.56
X$2724 14074 14073 1291 1218 57 1263 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2726 r0 *1 509.04,246.96
X$2726 14074 14073 1876 1699 57 1823 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2729 m0 *1 510.16,216.72
X$2729 14074 14073 1496 830 57 1363 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2752 m0 *1 957.6,65.52
X$2752 14074 14073 311 212 57 312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2754 m0 *1 531.44,267.12
X$2754 14074 14073 2054 57 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2756 m0 *1 600.32,166.32
X$2756 14074 14073 1025 58 870 998 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2758 m0 *1 600.32,176.4
X$2758 14074 14073 1134 1100 887 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2760 m0 *1 602.56,105.84
X$2760 14074 14073 513 489 523 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2762 m0 *1 604.24,85.68
X$2762 14074 14073 414 58 354 369 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2770 r0 *1 574,45.36
X$2770 14074 14073 220 58 84 109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2772 m0 *1 621.04,35.28
X$2772 14074 14073 174 58 113 156 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2774 r0 *1 619.36,45.36
X$2774 14074 14073 182 58 193 155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2777 m0 *1 577.36,65.52
X$2777 14074 14073 286 58 288 287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2780 r0 *1 544.32,65.52
X$2780 14074 14073 336 58 329 338 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2783 m0 *1 551.04,85.68
X$2783 14074 14073 412 58 453 368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2785 r0 *1 568.96,105.84
X$2785 14074 14073 569 524 500 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2787 m0 *1 570.64,105.84
X$2787 14074 14073 541 58 463 525 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2789 m0 *1 559.44,85.68
X$2789 14074 14073 337 58 396 285 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2791 m0 *1 583.52,126
X$2791 14074 14073 582 58 511 528 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2794 m0 *1 556.08,136.08
X$2794 14074 14073 732 58 573 733 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2797 r0 *1 621.04,670.32
X$2797 14073 6972 7338 14074 58 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $2799 m0 *1 590.8,156.24
X$2799 14074 14073 835 58 878 744 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2802 r0 *1 576.24,156.24
X$2802 14074 14073 909 58 689 743 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2839 m0 *1 564.48,136.08
X$2839 14074 14073 734 696 748 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2842 m0 *1 571.76,115.92
X$2842 14074 14073 570 580 549 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2844 r0 *1 567.28,126
X$2844 14074 14073 686 581 460 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2846 r0 *1 562.8,55.44
X$2846 14074 14073 278 264 224 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2849 r0 *1 567.84,35.28
X$2849 14074 14073 177 178 148 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2851 r0 *1 584.08,176.4
X$2851 14074 14073 1133 1099 834 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2853 r0 *1 601.44,126
X$2853 14074 14073 687 583 626 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2855 r0 *1 607.6,115.92
X$2855 14074 14073 550 572 625 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2858 m0 *1 606.48,45.36
X$2858 14074 14073 111 112 117 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2860 m0 *1 590.8,65.52
X$2860 14074 14073 290 291 292 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2863 r0 *1 609.84,65.52
X$2863 14074 14073 340 339 261 58 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $2869 m0 *1 580.16,35.28
X$2869 14074 173 150 59 109 153 178 87 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2927 r0 *1 1021.44,246.96
X$2927 14074 1801 670 1842 1899 61 1837 1901 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2929 m0 *1 885.92,146.16
X$2929 14074 801 61 803 800 277 758 802 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2931 m0 *1 967.12,156.24
X$2931 14074 964 61 771 769 277 805 712 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2933 m0 *1 967.68,216.72
X$2933 14074 1487 61 1527 1478 1479 1373 1424 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2936 r0 *1 1011.92,216.72
X$2936 14074 1584 61 1427 1480 1479 1425 1426 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2938 m0 *1 925.12,115.92
X$2938 14074 510 61 532 596 277 560 597 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2941 m0 *1 920.08,45.36
X$2941 14074 14073 61 132 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2943 m0 *1 1141.84,126
X$2943 14074 14073 61 603 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $2945 m0 *1 519.68,246.96
X$2945 14074 1944 61 1766 1634 1465 1823 1824 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2948 m0 *1 571.2,257.04
X$2948 14074 1947 61 1826 1946 1465 1879 1767 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2950 m0 *1 561.12,206.64
X$2950 14074 1499 61 1158 1217 1465 1263 1310 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2952 r0 *1 550.48,216.72
X$2952 14074 1544 61 1468 1466 1465 1514 1467 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2954 r0 *1 504.56,267.12
X$2954 14074 61 2108 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $2956 r0 *1 678.16,105.84
X$2956 14074 700 61 480 459 91 493 427 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2958 m0 *1 643.44,136.08
X$2958 14074 699 61 658 657 91 585 698 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2960 m0 *1 652.4,75.6
X$2960 14074 394 61 269 295 91 294 296 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2962 r0 *1 655.2,45.36
X$2962 14074 370 61 90 183 91 158 159 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2964 r0 *1 651.84,176.4
X$2964 14074 882 61 1103 1160 91 1000 1102 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2967 r0 *1 642.88,156.24
X$2967 14074 881 61 879 935 91 880 936 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2969 m0 *1 619.36,216.72
X$2969 14074 1497 61 1470 1469 1465 1264 1366 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2971 m0 *1 600.32,216.72
X$2971 14074 1498 61 1515 1364 1465 1312 1412 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2973 r0 *1 705.6,136.08
X$2973 14074 824 61 706 701 91 703 705 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2976 r0 *1 711.2,115.92
X$2976 14074 650 61 462 554 91 495 555 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2978 m0 *1 662.48,136.08
X$2978 14074 836 61 661 491 91 552 628 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2980 r0 *1 700.56,65.52
X$2980 14074 298 61 343 297 91 342 372 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2982 m0 *1 748.16,45.36
X$2982 14074 359 61 188 187 91 164 207 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2985 r0 *1 776.72,35.28
X$2985 14074 280 61 95 119 91 120 122 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2988 r0 *1 1155.28,236.88
X$2988 14074 1793 61 1529 1658 1838 1592 1659 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2990 m0 *1 1155.28,257.04
X$2990 14074 1912 61 1911 1907 1838 1908 1909 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2992 m0 *1 875.28,115.92
X$2992 14074 563 61 430 466 277 467 429 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2994 m0 *1 879.2,126
X$2994 14074 636 61 558 666 277 667 594 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2996 r0 *1 700,35.28
X$2996 14074 229 61 186 205 91 161 162 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $2998 r0 *1 815.92,146.16
X$2998 14074 14073 61 821 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3000 r0 *1 778.96,126
X$3000 14074 588 61 590 630 91 589 633 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3002 m0 *1 763.84,105.84
X$3002 14074 565 61 464 530 91 497 498 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3004 r0 *1 761.04,75.6
X$3004 14074 390 61 301 344 91 358 345 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3006 r0 *1 831.6,206.64
X$3006 14074 890 61 1371 1370 277 1344 1317 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3008 m0 *1 752.64,156.24
X$3008 14074 915 61 840 750 91 751 752 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3010 m0 *1 740.32,55.44
X$3010 14074 14073 163 62 256 164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3013 r0 *1 729.68,45.36
X$3013 14074 14073 223 62 206 187 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3019 r0 *1 733.6,55.44
X$3019 14074 14073 258 62 239 207 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3022 r0 *1 781.2,45.36
X$3022 14074 14073 218 62 193 120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3025 r0 *1 780.08,75.6
X$3025 14074 14073 374 62 354 345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3027 r0 *1 782.32,65.52
X$3027 14074 14073 322 301 261 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3031 m0 *1 799.68,35.28
X$3031 14074 14073 123 62 113 122 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3034 m0 *1 790.16,35.28
X$3034 14074 14073 121 62 84 95 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3037 m0 *1 759.92,146.16
X$3037 14074 14073 839 62 669 840 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3039 m0 *1 799.68,115.92
X$3039 14074 14073 592 590 523 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3041 m0 *1 767.76,95.76
X$3041 14074 14073 481 62 463 498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3043 m0 *1 751.52,85.68
X$3043 14074 14073 413 62 288 344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3046 r0 *1 768.88,115.92
X$3046 14074 14073 629 62 511 630 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3048 r0 *1 718.48,589.68
X$3048 14074 6038 62 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3050 r0 *1 779.52,166.32
X$3050 14074 14073 1050 1006 1049 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3052 m0 *1 785.12,156.24
X$3052 14074 14073 884 62 896 885 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3054 m0 *1 750.96,166.32
X$3054 14074 14073 939 62 770 752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3056 m0 *1 743.68,156.24
X$3056 14074 14073 864 62 573 750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3089 r0 *1 725.76,75.6
X$3089 14074 14073 415 358 292 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3091 m0 *1 757.12,55.44
X$3091 14074 14073 221 188 224 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3094 m0 *1 771.12,45.36
X$3094 14074 14073 118 119 148 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3097 r0 *1 799.12,126
X$3097 14074 14073 634 633 625 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3099 r0 *1 745.36,136.08
X$3099 14074 14073 749 751 748 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3102 m0 *1 757.68,115.92
X$3102 14074 14073 496 497 549 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3104 m0 *1 782.32,126
X$3104 14074 14073 632 589 626 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3107 r0 *1 789.04,95.76
X$3107 14074 14073 478 464 460 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3109 m0 *1 752.64,105.84
X$3109 14074 14073 557 530 500 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3111 r0 *1 803.6,156.24
X$3111 14074 14073 971 862 887 62 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3130 r0 *1 823.2,25.2
X$3130 14074 14073 100 67 84 96 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3133 r0 *1 828.8,45.36
X$3133 14074 14073 217 67 193 125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3137 m0 *1 856.8,65.52
X$3137 14074 14073 305 67 239 306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3139 m0 *1 846.72,35.28
X$3139 14074 14073 135 67 113 126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3141 r0 *1 859.6,176.4
X$3141 14074 14073 1163 67 669 1054 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3144 r0 *1 833.28,95.76
X$3144 14074 14073 465 67 206 387 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3146 m0 *1 831.6,115.92
X$3146 14074 14073 610 67 463 593 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3148 r0 *1 815.92,85.68
X$3148 14074 14073 477 377 380 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3150 m0 *1 833.84,85.68
X$3150 14074 14073 428 67 256 405 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3153 r0 *1 853.44,146.16
X$3153 14074 14073 860 67 573 891 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3155 m0 *1 808.08,85.68
X$3155 14074 14073 411 67 288 375 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3158 m0 *1 816.48,85.68
X$3158 14074 14073 389 67 354 376 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3162 m0 *1 813.12,166.32
X$3162 14074 14073 1007 1008 1049 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3164 r0 *1 823.2,206.64
X$3164 14074 14073 1441 1344 626 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3166 m0 *1 823.76,216.72
X$3166 14074 14073 1490 67 511 1370 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3168 m0 *1 859.04,196.56
X$3168 14074 14073 1222 67 770 1053 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3170 r0 *1 811.44,186.48
X$3170 14074 14073 1051 67 896 1052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3208 r0 *1 829.92,640.08
X$3208 14074 6826 67 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3210 m0 *1 815.92,65.52
X$3210 14074 14073 321 302 261 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3212 r0 *1 814.8,25.2
X$3212 14074 14073 137 124 148 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3215 m0 *1 857.36,35.28
X$3215 14074 14073 127 128 117 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3217 m0 *1 817.04,146.16
X$3217 14074 14073 785 754 500 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3219 m0 *1 822.08,126
X$3219 14074 14073 688 663 549 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3221 m0 *1 847.28,105.84
X$3221 14074 14073 499 379 531 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3223 m0 *1 838.32,126
X$3223 14074 14073 664 665 460 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3226 m0 *1 860.16,166.32
X$3226 14074 14073 942 941 748 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3228 m0 *1 852.88,206.64
X$3228 14074 14073 1439 1371 523 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3230 m0 *1 840,196.56
X$3230 14074 14073 1316 1317 625 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3233 m0 *1 811.44,186.48
X$3233 14074 14073 1185 1105 887 67 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3235 m0 *1 847.84,45.36
X$3235 14074 255 190 68 96 208 126 128 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3242 m0 *1 910.56,25.2
X$3242 14074 14073 69 97 84 70 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3246 m0 *1 904.96,35.28
X$3246 14074 192 132 70 168 169 131 134 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3249 m0 *1 901.04,45.36
X$3249 14074 210 94 70 168 209 131 134 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3256 r0 *1 988.96,75.6
X$3256 14074 271 71 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $3312 m0 *1 988.96,85.68
X$3312 14074 14073 71 14142 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $3324 m0 *1 947.52,35.28
X$3324 14074 14073 73 99 117 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3363 m0 *1 528.08,45.36
X$3363 14074 252 150 152 176 203 151 81 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3380 r0 *1 657.44,55.44
X$3380 14074 14073 268 89 84 269 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3385 r0 *1 643.44,126
X$3385 14074 14073 627 551 84 658 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3388 m0 *1 949.2,65.52
X$3388 14074 14073 240 212 84 213 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3390 r0 *1 556.08,206.64
X$3390 14074 14073 1445 1218 84 1468 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3393 r0 *1 468.16,176.4
X$3393 14074 14073 1156 830 84 1215 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3396 r0 *1 484.4,236.88
X$3396 14074 14073 1704 1699 84 1705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3428 m0 *1 562.24,246.96
X$3428 14074 14073 1878 84 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3430 r0 *1 516.88,458.64
X$3430 85 4208 4479 4210 14073 14074 3655 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $3435 m0 *1 515.2,458.64
X$3435 14074 14073 85 4249 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $3500 m0 *1 600.32,65.52
X$3500 14074 319 86 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $3516 m0 *1 636.72,65.52
X$3516 14074 14073 293 89 193 294 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3518 r0 *1 645.68,75.6
X$3518 14074 14073 401 89 113 296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3522 r0 *1 687.12,65.52
X$3522 14074 14073 360 89 288 297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3525 m0 *1 702.8,55.44
X$3525 14074 14073 115 89 239 162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3527 r0 *1 682.08,45.36
X$3527 14074 14073 160 89 256 161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3530 r0 *1 690.48,45.36
X$3530 14074 14073 222 89 206 205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3534 m0 *1 725.76,176.4
X$3534 14074 14073 1138 89 896 1004 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3536 r0 *1 714,146.16
X$3536 14074 14073 837 89 770 705 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3538 m0 *1 728.56,146.16
X$3538 14074 14073 747 89 669 706 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3541 m0 *1 710.64,85.68
X$3541 14074 14073 404 89 354 372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3543 m0 *1 726.32,95.76
X$3543 14074 14073 461 462 523 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3545 r0 *1 688.24,136.08
X$3545 14074 14073 823 89 573 701 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3548 m0 *1 728,115.92
X$3548 14074 14073 556 555 625 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3550 r0 *1 682.08,95.76
X$3550 14074 14073 425 89 463 427 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3553 m0 *1 700.56,115.92
X$3553 14074 14073 553 89 511 554 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3594 m0 *1 661.36,105.84
X$3594 14074 14073 458 459 500 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3596 m0 *1 669.76,105.84
X$3596 14074 14073 492 493 549 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3598 r0 *1 721.28,65.52
X$3598 14074 14073 391 343 261 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3601 r0 *1 635.6,75.6
X$3601 14074 14073 392 295 148 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3604 m0 *1 660.24,45.36
X$3604 14074 14073 114 159 117 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3606 m0 *1 711.76,126
X$3606 14074 14073 494 495 626 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3608 m0 *1 720.16,146.16
X$3608 14074 14073 746 703 748 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3610 r0 *1 690.48,95.76
X$3610 14074 14073 479 480 460 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3612 m0 *1 717.36,176.4
X$3612 14074 14073 1080 1002 1049 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3614 r0 *1 703.92,176.4
X$3614 14074 14073 1048 1001 887 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3616 r0 *1 678.72,65.52
X$3616 14074 14073 341 342 292 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3619 m0 *1 711.76,55.44
X$3619 14074 14073 257 186 224 89 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3621 r0 *1 619.36,246.96
X$3621 14074 1882 89 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3624 r0 *1 655.76,35.28
X$3624 14074 393 185 90 183 184 158 159 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3663 m0 *1 626.08,95.76
X$3663 14074 91 154 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $3675 m0 *1 724.08,166.32
X$3675 14073 1002 91 14074 1024 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3677 r0 *1 721.28,166.32
X$3677 14074 14073 1003 1001 91 1004 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3686 r0 *1 763.28,65.52
X$3686 14074 300 94 301 344 92 358 345 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3694 m0 *1 739.2,75.6
X$3694 14074 232 92 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3697 r0 *1 748.72,45.36
X$3697 14074 219 94 188 187 92 164 207 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3699 r0 *1 775.6,25.2
X$3699 14074 140 94 95 119 92 120 122 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3704 r0 *1 778.96,115.92
X$3704 14074 631 94 590 630 92 589 633 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3707 r0 *1 753.76,136.08
X$3707 14074 735 94 840 750 92 751 752 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3709 r0 *1 764.4,105.84
X$3709 14074 662 94 464 530 92 497 498 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3711 m0 *1 760.48,75.6
X$3711 14074 373 279 280 390 299 359 93 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3716 r0 *1 794.64,146.16
X$3716 14074 14073 799 862 94 1006 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3751 m0 *1 921.76,55.44
X$3751 14074 309 94 274 235 98 237 238 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3754 m0 *1 910.56,75.6
X$3754 14074 385 94 310 307 98 381 349 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3757 r0 *1 899.36,146.16
X$3757 14074 759 94 803 800 272 758 802 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3761 r0 *1 971.6,45.36
X$3761 14074 211 94 213 195 272 241 242 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3763 r0 *1 978.88,65.52
X$3763 14074 351 94 275 313 272 312 243 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3765 r0 *1 924.56,115.92
X$3765 14074 637 94 532 596 272 560 597 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3767 r0 *1 972.72,85.68
X$3767 14074 447 94 384 446 272 434 433 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3769 m0 *1 974.4,105.84
X$3769 14074 435 94 439 502 272 503 438 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3771 m0 *1 821.52,75.6
X$3771 14074 320 94 302 375 166 377 376 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3773 m0 *1 827.68,35.28
X$3773 14074 165 94 96 124 166 125 126 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3783 r0 *1 879.2,126
X$3783 14074 685 94 558 666 272 667 594 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3789 r0 *1 781.2,146.16
X$3789 14073 94 885 14074 863 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $3792 r0 *1 739.76,115.92
X$3792 14074 94 153 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $3794 m0 *1 878.08,95.76
X$3794 14074 561 94 430 466 272 467 429 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3796 r0 *1 843.92,75.6
X$3796 14074 304 94 379 387 166 405 306 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $3815 r0 *1 889.84,65.52
X$3815 14074 14073 318 97 288 307 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3818 m0 *1 887.6,45.36
X$3818 14074 14073 129 97 193 131 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3821 m0 *1 867.44,65.52
X$3821 14074 14073 234 97 206 235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3823 r0 *1 865.76,95.76
X$3823 14074 14073 476 466 500 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3825 r0 *1 870.8,85.68
X$3825 14074 14073 452 97 463 429 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3829 r0 *1 973.84,126
X$3829 14074 14073 668 97 669 771 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3831 m0 *1 970.48,136.08
X$3831 14074 14073 711 97 770 712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3834 r0 *1 899.36,95.76
X$3834 14074 14073 451 430 460 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3836 r0 *1 921.76,85.68
X$3836 14074 14073 431 310 261 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3838 r0 *1 911.68,115.92
X$3838 14074 14073 595 97 511 596 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3841 r0 *1 900.48,55.44
X$3841 14074 14073 236 97 256 237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3843 r0 *1 899.36,65.52
X$3843 14074 14073 355 97 354 349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3846 m0 *1 940.8,55.44
X$3846 14074 14073 214 97 239 238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3848 m0 *1 940.8,65.52
X$3848 14074 14073 314 274 224 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3850 r0 *1 904.96,35.28
X$3850 14074 14073 130 97 113 134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3853 r0 *1 958.16,136.08
X$3853 14074 14073 768 97 573 769 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3856 r0 *1 932.4,196.56
X$3856 14074 14073 1342 97 896 1059 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3901 r0 *1 903.28,75.6
X$3901 14074 14073 409 381 380 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3903 r0 *1 948.08,105.84
X$3903 14074 14073 537 532 523 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3905 m0 *1 916.72,126
X$3905 14074 14073 562 560 626 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3908 r0 *1 918.96,186.48
X$3908 14074 14073 1240 1058 1049 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3910 m0 *1 924.56,186.48
X$3910 14074 14073 1179 1110 887 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3912 r0 *1 943.6,115.92
X$3912 14074 14073 607 597 625 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3915 r0 *1 978.88,146.16
X$3915 14074 14073 856 805 748 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3917 m0 *1 962.08,650.16
X$3917 14074 6803 97 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $3919 m0 *1 879.2,45.36
X$3919 14074 14073 167 168 148 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3922 r0 *1 865.76,105.84
X$3922 14074 14073 538 467 549 97 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3929 r0 *1 918.96,45.36
X$3929 14074 14073 231 98 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $3945 r0 *1 524.16,529.2
X$3945 5132 14073 5049 5136 14074 102 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $3955 m0 *1 540.96,509.04
X$3955 14074 14073 4791 4479 4691 102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $3961 m0 *1 445.76,378
X$3961 14074 104 3113 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $3998 r0 *1 456.4,115.92
X$3998 14074 680 104 518 485 106 618 620 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4000 m0 *1 495.6,126
X$4000 14074 742 104 566 611 612 622 623 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4003 m0 *1 558.88,75.6
X$4003 14074 266 104 264 338 154 368 285 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4006 m0 *1 580.16,75.6
X$4006 14074 265 104 339 287 154 291 369 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4009 m0 *1 475.44,75.6
X$4009 14074 333 104 227 331 106 363 364 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4013 m0 *1 421.12,75.6
X$4013 14074 353 104 260 328 106 386 281 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4015 m0 *1 428.4,85.68
X$4015 14074 362 104 215 282 106 418 395 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4017 m0 *1 525.84,115.92
X$4017 14074 578 104 522 520 612 577 579 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4020 r0 *1 566.72,115.92
X$4020 14074 654 104 581 524 154 580 525 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4022 r0 *1 570.08,136.08
X$4022 14074 786 104 744 733 154 696 743 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4024 m0 *1 515.76,75.6
X$4024 14074 334 104 263 284 106 365 366 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4028 m0 *1 506.8,206.64
X$4028 14074 1286 104 1189 1157 1362 1363 1309 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4031 m0 *1 529.2,166.32
X$4031 14074 818 104 877 876 612 995 996 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4033 r0 *1 445.76,166.32
X$4033 14074 991 104 992 831 1041 832 871 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4035 m0 *1 468.72,206.64
X$4035 14074 1287 104 1215 1262 1362 1361 1410 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4038 m0 *1 422.8,126
X$4038 14074 681 104 543 515 612 616 617 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4040 r0 *1 394.24,126
X$4040 14074 678 104 614 648 612 574 651 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4043 r0 *1 388.64,206.64
X$4043 14074 1212 104 1306 1305 1041 1409 1360 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4045 r0 *1 403.2,176.4
X$4045 14074 1182 104 962 1039 1041 927 1040 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4048 m0 *1 433.44,176.4
X$4048 14074 1155 104 1043 869 1041 928 1042 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4051 r0 *1 419.44,246.96
X$4051 14074 1941 104 1871 1870 1698 1819 1763 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4053 r0 *1 390.88,277.2
X$4053 14074 2102 104 2104 2103 1698 2156 2157 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4055 r0 *1 392,236.88
X$4055 14074 2030 104 1700 1629 1698 1697 1566 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4057 m0 *1 600.32,115.92
X$4057 14074 584 104 489 528 154 583 572 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4060 r0 *1 590.24,45.36
X$4060 14074 254 104 109 178 154 155 156 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4062 m0 *1 473.76,378
X$4062 14074 14073 104 3217 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4073 m0 *1 390.32,146.16
X$4073 14074 14073 792 790 106 789 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4076 r0 *1 504,166.32
X$4076 14074 14073 1022 929 106 993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4078 r0 *1 471.52,277.2
X$4078 14074 106 1463 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $4109 r0 *1 528.08,206.64
X$4109 14074 14073 106 1465 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4132 r0 *1 585.76,55.44
X$4132 14074 267 279 254 265 289 266 110 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4147 r0 *1 631.68,136.08
X$4147 14074 14073 788 551 113 698 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4150 r0 *1 1027.04,115.92
X$4150 14074 14073 604 440 113 600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4152 r0 *1 1017.52,55.44
X$4152 14074 14073 276 212 113 242 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4157 m0 *1 879.2,367.92
X$4157 14074 14073 2983 2984 113 3050 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4159 r0 *1 1017.52,357.84
X$4159 14074 14073 3075 2929 113 3056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4162 m0 *1 782.88,226.8
X$4162 14074 14073 1604 1220 113 1519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4165 m0 *1 825.44,287.28
X$4165 14074 14073 2231 2229 113 2232 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4168 m0 *1 677.04,317.52
X$4168 14074 14073 2557 2221 113 2559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4194 r0 *1 633.92,267.12
X$4194 14074 14073 228 113 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4196 m0 *1 878.64,287.28
X$4196 14074 14073 2175 1477 113 2234 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4202 m0 *1 757.68,65.52
X$4202 14074 323 270 300 140 303 116 219 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4207 r0 *1 1121.12,176.4
X$4207 14074 14073 1066 1117 117 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4209 m0 *1 1128.4,478.8
X$4209 14074 14073 4368 4229 117 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4211 m0 *1 902.72,367.92
X$4211 14074 14073 3052 3053 117 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4214 r0 *1 1117.76,488.88
X$4214 14074 14073 4647 4640 117 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4223 m0 *1 1037.12,388.08
X$4223 14074 14073 3316 3057 117 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4226 r0 *1 1079.12,95.76
X$4226 14074 14073 506 507 117 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4230 r0 *1 1126.16,216.72
X$4230 14074 14073 1531 1588 117 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4233 m0 *1 666.96,126
X$4233 14074 14073 660 628 117 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4237 m0 *1 999.04,55.44
X$4237 14074 14073 245 243 117 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4239 r0 *1 918.4,287.28
X$4239 14074 14073 2264 2237 117 1420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4241 r0 *1 519.68,206.64
X$4241 14074 14073 1440 1309 117 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4243 r0 *1 576.24,196.56
X$4243 14074 14073 1346 1310 117 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4246 m0 *1 799.68,216.72
X$4246 14074 14073 1491 1419 117 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4248 r0 *1 1128.4,408.24
X$4248 14074 14073 3552 3430 117 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4250 m0 *1 847.28,317.52
X$4250 14074 14073 2652 2564 117 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4252 r0 *1 520.8,246.96
X$4252 14074 14073 1877 1824 117 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4254 r0 *1 701.12,347.76
X$4254 14074 14073 3011 2770 117 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4257 m0 *1 582.4,378
X$4257 14074 14073 3253 3220 117 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4306 m0 *1 1128.96,347.76
X$4306 14074 14073 2876 2709 117 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4309 m0 *1 542.08,418.32
X$4309 14074 14073 3635 117 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4386 r0 *1 920.08,55.44
X$4386 14074 316 132 274 235 169 237 238 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4388 r0 *1 911.12,65.52
X$4388 14074 308 132 310 307 169 381 349 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4398 r0 *1 914.48,75.6
X$4398 14074 406 270 385 210 407 133 309 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4464 m0 *1 709.52,105.84
X$4464 14074 319 142 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $4489 m0 *1 701.68,105.84
X$4489 14074 14073 142 14162 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $4510 r0 *1 3.36,35.28
X$4510 14074 14073 143 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $4522 m0 *1 440.16,75.6
X$4522 14074 420 332 145 353 289 362 149 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4546 r0 *1 1018.64,115.92
X$4546 14074 14073 641 642 148 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4548 r0 *1 965.44,35.28
X$4548 14074 14073 194 195 148 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4550 r0 *1 539.28,206.64
X$4550 14074 14073 1442 1466 148 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4552 m0 *1 469.28,257.04
X$4552 14074 14073 1873 1821 148 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4554 r0 *1 515.2,347.76
X$4554 14074 2867 2921 14073 148 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4556 m0 *1 463.12,196.56
X$4556 14074 14073 1289 1262 148 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4589 m0 *1 626.64,126
X$4589 14074 14073 655 657 148 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4591 r0 *1 744.24,337.68
X$4591 14074 14073 148 1711 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4598 m0 *1 446.88,539.28
X$4598 5211 14073 14074 150 4349 5010 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $4600 m0 *1 689.36,257.04
X$4600 14073 1883 1951 150 1925 1987 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $4602 m0 *1 417.2,559.44
X$4602 150 5465 5506 5370 14073 14074 5507 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $4605 r0 *1 591.92,156.24
X$4605 14073 969 14074 932 527 150 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $4607 r0 *1 413.28,186.48
X$4607 14074 150 1125 14073 1260 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $4609 m0 *1 633.92,267.12
X$4609 519 2012 150 1983 14073 14074 2010 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $4675 r0 *1 446.32,105.84
X$4675 14074 544 150 518 543 251 515 485 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4677 m0 *1 497.28,85.68
X$4677 14074 457 150 366 364 251 363 365 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4679 m0 *1 494.48,75.6
X$4679 14074 422 150 263 227 251 331 284 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4683 m0 *1 506.8,115.92
X$4683 14074 567 150 522 566 251 611 520 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4685 r0 *1 509.6,115.92
X$4685 14074 547 150 579 623 251 622 577 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4687 m0 *1 454.16,126
X$4687 14074 619 150 620 617 203 616 618 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4690 r0 *1 427.28,65.52
X$4690 14074 330 150 215 260 203 328 282 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4692 r0 *1 432.88,85.68
X$4692 14074 448 150 395 281 251 386 418 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4694 m0 *1 580.16,115.92
X$4694 14074 512 150 489 581 153 524 528 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4699 m0 *1 495.04,246.96
X$4699 14074 1856 150 1766 1705 203 1821 1634 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4702 m0 *1 496.72,257.04
X$4702 14074 1924 150 1824 1874 203 1875 1823 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4704 m0 *1 490.56,216.72
X$4704 14074 1678 150 1309 1410 197 1361 1363 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4707 m0 *1 487.76,206.64
X$4707 14074 1568 150 1189 1215 197 1262 1157 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4709 r0 *1 442.96,287.28
X$4709 14074 2324 150 2107 2161 197 2160 2052 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4711 m0 *1 442.4,166.32
X$4711 14074 990 150 831 869 872 928 832 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4714 m0 *1 452.48,176.4
X$4714 14074 1044 150 992 1043 872 1042 871 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4716 r0 *1 584.64,156.24
X$4716 14074 14073 150 969 859 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4718 r0 *1 586.32,115.92
X$4718 14074 571 150 572 525 153 580 583 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4720 r0 *1 653.52,126
X$4720 14074 659 150 661 658 185 657 491 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4722 r0 *1 653.52,136.08
X$4722 14074 822 150 628 698 185 585 552 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4725 m0 *1 651.28,176.4
X$4725 14074 1288 150 1102 936 403 880 1000 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4728 r0 *1 618.24,216.72
X$4728 14074 1769 150 1470 1515 153 1364 1469 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4730 r0 *1 616,206.64
X$4730 14074 1413 150 1366 1412 403 1312 1264 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4732 r0 *1 390.88,730.8
X$4732 14074 8222 150 5341 7839 5533 6776 8122 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $4734 m0 *1 389.2,317.52
X$4734 14074 14073 2548 2485 2320 150 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4736 m0 *1 502.88,317.52
X$4736 14074 2686 150 2420 2418 2419 2591 2551 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4738 r0 *1 503.44,317.52
X$4738 14074 2687 150 2354 2486 2419 2550 2489 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4740 r0 *1 434,347.76
X$4740 14074 150 2917 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $4743 r0 *1 454.16,297.36
X$4743 14074 2325 150 2164 2215 197 2159 2163 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4745 m0 *1 660.24,186.48
X$4745 14074 1161 150 1103 879 403 935 1160 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4747 m0 *1 668.64,246.96
X$4747 14074 1770 150 1473 1472 1572 1771 1772 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4749 m0 *1 666.96,236.88
X$4749 14074 1637 150 1639 1570 1572 1707 1708 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4751 r0 *1 693.28,246.96
X$4751 14074 14073 150 1925 1545 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $4770 m0 *1 590.8,186.48
X$4770 14074 14073 997 1100 153 1099 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4772 r0 *1 567.28,277.2
X$4772 14074 14073 2008 2111 153 2292 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4774 r0 *1 570.64,257.04
X$4774 14074 14073 2036 1879 153 1767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4776 r0 *1 580.16,257.04
X$4776 14074 14073 2037 1946 153 1826 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4801 r0 *1 580.72,75.6
X$4801 14074 400 153 339 287 367 291 369 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4804 r0 *1 560,75.6
X$4804 14074 399 153 264 338 367 368 285 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4807 r0 *1 568.4,146.16
X$4807 14074 859 153 744 733 872 696 743 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4811 r0 *1 563.36,267.12
X$4811 14073 153 2055 14074 2006 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4813 m0 *1 561.12,287.28
X$4813 14074 153 1308 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $4819 r0 *1 612.08,257.04
X$4819 14074 1983 153 1949 1881 2216 1827 1768 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4821 m0 *1 722.4,236.88
X$4821 14074 153 1572 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $4823 r0 *1 595.84,186.48
X$4823 14073 154 1099 14074 1101 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $4825 r0 *1 611.52,176.4
X$4825 14074 14073 1135 1100 154 998 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4854 r0 *1 532.56,267.12
X$4854 14074 154 2166 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $4858 r0 *1 600.32,267.12
X$4858 14074 154 1571 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $4897 m0 *1 698.88,45.36
X$4897 14074 230 185 186 205 184 161 162 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4921 m0 *1 835.52,65.52
X$4921 14074 378 270 320 165 303 191 304 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4931 m0 *1 830.48,55.44
X$4931 14074 232 166 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $4954 m0 *1 903.84,65.52
X$4954 14074 14073 277 169 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $4961 m0 *1 917.84,65.52
X$4961 14074 315 14073 308 273 316 348 170 192 gf180mcu_fd_sc_mcu9t5v0__mux4_4
* cell instance $4967 r0 *1 514.08,65.52
X$4967 14074 335 332 201 333 289 334 172 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $4971 m0 *1 589.68,45.36
X$4971 14074 14073 179 173 181 180 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4980 r0 *1 291.76,277.2
X$4980 14074 14073 2286 2047 1147 175 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4983 m0 *1 291.2,297.36
X$4983 14074 14073 2285 2213 1144 175 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4989 m0 *1 303.52,267.12
X$4989 14074 14073 2024 1998 866 175 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $4991 r0 *1 301.28,267.12
X$4991 14074 14073 2081 1998 980 175 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5011 m0 *1 580.16,105.84
X$5011 14074 526 519 527 424 270 179 488 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5019 r0 *1 662.48,236.88
X$5019 181 14074 1684 1770 14073 1810 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5021 r0 *1 471.52,45.36
X$5021 14074 14073 198 199 181 216 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5024 r0 *1 590.24,95.76
X$5024 14074 14073 488 512 181 571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5026 m0 *1 528.64,55.44
X$5026 14074 14073 253 250 181 252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5028 m0 *1 654.08,146.16
X$5028 14074 14073 795 659 181 822 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5046 r0 *1 458.08,85.68
X$5046 421 270 181 448 14073 14074 455 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5048 r0 *1 502.88,95.76
X$5048 421 270 181 457 14073 14074 539 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5051 r0 *1 516.32,105.84
X$5051 519 545 181 547 14073 14074 540 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5053 m0 *1 458.08,115.92
X$5053 519 545 181 619 14073 14074 486 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5055 m0 *1 657.44,277.2
X$5055 14074 2219 181 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $5067 m0 *1 652.4,65.52
X$5067 14074 325 185 269 295 184 294 296 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5069 r0 *1 705.6,126
X$5069 14074 704 185 706 701 184 703 705 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5071 m0 *1 708.96,115.92
X$5071 14074 586 185 462 554 184 495 555 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5082 m0 *1 678.16,105.84
X$5082 14074 529 185 480 459 184 493 427 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5086 r0 *1 706.72,156.24
X$5086 14074 184 14073 938 914 934 1004 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $5088 m0 *1 700.56,75.6
X$5088 14074 371 185 343 297 184 342 372 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5090 m0 *1 681.52,55.44
X$5090 14074 231 184 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5110 r0 *1 700.56,55.44
X$5110 14074 403 185 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $5139 r0 *1 829.36,65.52
X$5139 14074 347 348 189 346 388 357 255 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5230 m0 *1 964.88,257.04
X$5230 14074 1779 190 1833 1896 1479 1897 1832 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5232 r0 *1 986.16,176.4
X$5232 14074 1113 639 1174 1166 190 1112 1123 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5234 m0 *1 1112.72,196.56
X$5234 14074 1332 190 1231 1169 601 1321 1117 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5237 r0 *1 979.44,55.44
X$5237 14074 383 190 275 213 277 242 243 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5239 m0 *1 969.92,65.52
X$5239 14074 436 190 313 195 277 241 312 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5241 m0 *1 915.04,176.4
X$5241 14074 821 14073 1109 190 1055 1057 1058 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5243 m0 *1 1093.68,196.56
X$5243 14074 1281 190 1230 1273 601 1274 1115 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5246 r0 *1 950.32,236.88
X$5246 14074 1802 190 1582 1778 1479 1652 1720 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5248 r0 *1 968.8,95.76
X$5248 14074 468 190 446 502 277 503 434 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5251 r0 *1 987.84,95.76
X$5251 14074 474 190 384 439 277 438 433 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5254 m0 *1 629.44,690.48
X$5254 14074 14073 190 7341 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $5256 r0 *1 945.28,438.48
X$5256 14074 14073 190 2236 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5259 m0 *1 1028.72,357.84
X$5259 14074 2930 190 3058 2989 2980 3056 3057 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5261 r0 *1 1015.84,367.92
X$5261 14074 2932 190 3177 3055 2980 3127 3175 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5264 r0 *1 1033.76,307.44
X$5264 14074 2241 14073 2507 190 2505 2517 2566
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5266 m0 *1 986.16,307.44
X$5266 14074 2241 14073 2178 190 1056 2436 2304
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5269 r0 *1 482.16,609.84
X$5269 14073 190 5740 14074 6143 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5271 m0 *1 840.56,75.6
X$5271 14074 357 190 379 302 208 376 306 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5277 r0 *1 824.88,75.6
X$5277 14074 346 190 387 375 208 377 405 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5280 r0 *1 388.08,650.16
X$5280 14074 6821 190 5341 6835 5533 6776 6698 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $5282 r0 *1 570.64,408.24
X$5282 820 1318 190 3280 14073 14074 3596 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5284 r0 *1 542.08,428.4
X$5284 14074 3842 190 3762 3780 1698 3841 3840 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5286 m0 *1 576.8,428.4
X$5286 14074 3781 190 3542 3723 3669 3657 3783 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5288 m0 *1 512.96,438.48
X$5288 14074 3893 190 3921 3920 3919 3975 3918 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5290 m0 *1 480.48,357.84
X$5290 14074 2821 190 2973 2918 1698 2971 3032 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5292 m0 *1 409.92,357.84
X$5292 14074 14073 3084 3005 2320 190 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5294 m0 *1 428.4,367.92
X$5294 14074 3030 190 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5298 r0 *1 500.64,307.44
X$5298 14074 2487 190 2420 2418 1698 2486 2354 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5300 m0 *1 497.28,327.6
X$5300 14074 2843 190 2551 2591 1698 2550 2489 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5302 m0 *1 885.92,176.4
X$5302 14074 821 14073 1108 190 1055 1076 1165 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5304 m0 *1 824.32,176.4
X$5304 14074 821 14073 1106 190 1055 940 1008 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5306 m0 *1 666.96,226.8
X$5306 14074 1549 190 1639 1570 1571 1472 1473 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5308 r0 *1 669.2,236.88
X$5308 14074 1548 190 1708 1707 1571 1771 1772 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5310 m0 *1 697.2,226.8
X$5310 14074 1546 190 1574 1367 1571 1449 1573 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5313 r0 *1 787.92,166.32
X$5313 14074 821 14073 1005 190 1056 883 1006 gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5315 r0 *1 886.48,236.88
X$5315 14074 1648 14073 1893 190 1056 1747 1777
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $5333 r0 *1 991.2,115.92
X$5333 14074 14073 605 440 193 598 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5335 m0 *1 978.88,55.44
X$5335 14074 14073 246 212 193 241 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5346 r0 *1 637.28,115.92
X$5346 14074 14073 613 551 193 585 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5348 m0 *1 621.04,55.44
X$5348 14074 14073 225 193 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5362 m0 *1 400.96,126
X$5362 14074 14073 652 648 197 614 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5364 m0 *1 380.8,146.16
X$5364 14074 14073 738 790 197 791 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5366 m0 *1 427.84,226.8
X$5366 14074 14073 1567 1510 197 1511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5368 r0 *1 451.92,176.4
X$5368 14074 14073 1184 990 197 1044 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5407 r0 *1 449.12,196.56
X$5407 14074 1308 197 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5414 r0 *1 549.92,226.8
X$5414 14074 1680 197 1468 1466 367 1514 1467 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5417 r0 *1 557.2,196.56
X$5417 14074 1411 197 1158 1217 367 1263 1310 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5419 r0 *1 512.4,166.32
X$5419 14073 197 993 14074 930 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5421 m0 *1 383.04,136.08
X$5421 14074 14073 724 574 197 651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5423 r0 *1 371.28,136.08
X$5423 14073 789 197 14074 778 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5426 m0 *1 375.76,196.56
X$5426 14073 197 1210 14074 1340 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5428 m0 *1 403.76,176.4
X$5428 14074 1125 197 962 1039 872 927 1040 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5430 r0 *1 423.92,257.04
X$5430 14074 1979 197 1871 1870 1599 1819 1763 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5433 r0 *1 391.44,246.96
X$5433 14074 1918 197 1700 1629 1599 1697 1566 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5435 m0 *1 375.2,277.2
X$5435 14073 197 1939 14074 2133 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $5437 r0 *1 391.44,297.36
X$5437 14074 14073 2389 2388 2320 197 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5441 m0 *1 477.68,136.08
X$5441 14074 198 656 14073 694 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5454 m0 *1 548.24,176.4
X$5454 14074 14073 1023 995 203 996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5456 r0 *1 504.56,156.24
X$5456 14074 14073 966 929 203 833 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5459 r0 *1 384.72,287.28
X$5459 14074 14073 2134 2156 203 2157 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5461 m0 *1 403.2,277.2
X$5461 14074 14073 2135 2103 203 2104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5464 r0 *1 376.32,267.12
X$5464 14074 14073 2084 2002 203 1940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5484 r0 *1 478.24,196.56
X$5484 14074 1308 203 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $5487 m0 *1 526.4,156.24
X$5487 14074 14073 875 876 203 877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5495 r0 *1 646.24,186.48
X$5495 14074 14073 1244 551 206 1160 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5498 m0 *1 638.4,216.72
X$5498 14074 14073 1471 1218 206 1469 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5506 m0 *1 650.16,307.44
X$5506 14074 14073 2358 2221 206 2422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5508 m0 *1 750.96,186.48
X$5508 14074 14073 1190 1220 206 1162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5529 m0 *1 629.44,85.68
X$5529 14074 14073 329 206 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5544 m0 *1 825.44,65.52
X$5544 14074 14073 277 208 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5551 r0 *1 670.32,226.8
X$5551 209 14074 1684 1637 14073 1638 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $5554 r0 *1 1155.84,317.52
X$5554 14074 2513 1729 2635 2632 209 2633 2634 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5556 r0 *1 1121.12,317.52
X$5556 14074 2512 1729 2631 2707 209 2708 2709 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5576 m0 *1 1046.08,287.28
X$5576 14074 2240 1729 2242 2184 209 2064 2120 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5579 r0 *1 922.32,257.04
X$5579 14074 1580 209 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $5583 r0 *1 1120,297.36
X$5583 14074 2371 1729 2185 2244 209 2307 2246 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5585 r0 *1 663.6,186.48
X$5585 798 715 209 1161 14073 14074 1219 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $5587 m0 *1 1154.72,297.36
X$5587 14074 2310 1729 2251 2247 209 2248 2250 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5589 r0 *1 700,257.04
X$5589 14074 14073 209 1640 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5591 m0 *1 882.56,297.36
X$5591 14074 2366 895 2116 2176 209 2233 2234 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5599 m0 *1 960.96,85.68
X$5599 14074 449 270 435 211 407 351 447 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5602 m0 *1 867.44,156.24
X$5602 14074 14073 842 212 511 800 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5604 m0 *1 866.88,115.92
X$5604 14074 14073 609 212 463 594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5606 r0 *1 861.28,126
X$5606 14074 14073 635 666 500 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5608 m0 *1 1001.84,95.76
X$5608 14074 14073 437 212 354 438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5610 m0 *1 973.28,126
X$5610 14074 14073 638 212 649 446 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5612 r0 *1 943.6,156.24
X$5612 14074 14073 905 212 770 893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5623 r0 *1 937.44,95.76
X$5623 14074 14073 508 212 256 434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5625 r0 *1 941.36,85.68
X$5625 14074 14073 432 212 239 433 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5629 m0 *1 963.76,105.84
X$5629 14074 14073 533 212 288 502 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5632 m0 *1 919.52,136.08
X$5632 14074 14073 709 212 573 764 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5635 r0 *1 937.44,146.16
X$5635 14074 14073 817 212 669 804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5638 m0 *1 896,196.56
X$5638 14074 14073 1271 212 896 1223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5682 r0 *1 920.08,136.08
X$5682 14074 14073 762 763 748 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5684 m0 *1 894.32,115.92
X$5684 14074 14073 564 558 460 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5686 r0 *1 889.84,206.64
X$5686 14074 14073 1438 1224 887 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5688 r0 *1 889.84,156.24
X$5688 14074 14073 943 802 625 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5691 m0 *1 909.44,156.24
X$5691 14074 14073 907 803 523 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5695 m0 *1 980,85.68
X$5695 14074 14073 382 384 224 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5697 r0 *1 978.32,105.84
X$5697 14074 14073 559 503 380 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5700 m0 *1 1010.24,95.76
X$5700 14074 14073 408 439 261 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5702 m0 *1 856.24,660.24
X$5702 14074 7156 212 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5704 r0 *1 862.96,136.08
X$5704 14074 14073 708 667 549 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5706 r0 *1 880.88,146.16
X$5706 14074 14073 757 758 626 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5708 r0 *1 884.24,186.48
X$5708 14074 14073 1164 1165 1049 212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5761 r0 *1 635.04,206.64
X$5761 14074 14073 1451 1470 224 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5771 m0 *1 679.28,186.48
X$5771 14074 14073 1191 1103 224 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5775 m0 *1 661.36,307.44
X$5775 14074 14073 2491 2423 224 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5779 r0 *1 411.04,236.88
X$5779 14074 14073 1744 1700 224 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5781 m0 *1 509.04,357.84
X$5781 14074 3033 2869 14073 224 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $5783 r0 *1 763.28,196.56
X$5783 14074 14073 1393 1369 224 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5816 m0 *1 987.28,277.2
X$5816 14074 14073 224 531 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5818 r0 *1 412.16,156.24
X$5818 14074 14073 961 962 224 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5821 m0 *1 738.08,599.76
X$5821 14074 14073 5912 5615 225 5839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5826 m0 *1 1066.24,559.44
X$5826 14074 14073 5563 4503 225 5233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5828 r0 *1 598.64,388.08
X$5828 14074 14073 3394 3036 225 3331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5830 m0 *1 679.28,549.36
X$5830 14074 14073 5223 3544 225 5224 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5832 m0 *1 980,609.84
X$5832 14074 14073 6106 4295 225 6089 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5834 r0 *1 899.36,609.84
X$5834 14074 14073 6291 4163 225 6084 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5836 m0 *1 610.4,549.36
X$5836 14074 14073 5354 3663 225 5355 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5838 r0 *1 842.8,609.84
X$5838 14074 14073 6208 4317 225 6078 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5840 r0 *1 474.88,267.12
X$5840 14074 14073 1942 1699 225 1875 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5842 r0 *1 677.04,347.76
X$5842 14074 14073 2872 2221 225 2558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5845 r0 *1 541.52,226.8
X$5845 14074 14073 1679 1218 225 1514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5848 m0 *1 462.56,216.72
X$5848 14074 14073 1494 830 225 1361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5885 r0 *1 1061.76,226.8
X$5885 14074 14073 225 1585 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5888 r0 *1 520.8,388.08
X$5888 14074 14073 3114 2867 225 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $5906 m0 *1 609.84,357.84
X$5906 14074 14073 3035 3036 228 3037 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5909 r0 *1 547.68,206.64
X$5909 14074 14073 1443 1218 228 1467 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5911 r0 *1 483.28,267.12
X$5911 14074 14073 2035 1699 228 1874 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5913 r0 *1 476,216.72
X$5913 14074 14073 1464 830 228 1410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5931 m0 *1 636.72,337.68
X$5931 14074 14073 228 1532 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5933 m0 *1 526.96,357.84
X$5933 14074 14073 2972 2867 228 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $5937 m0 *1 700,65.52
X$5937 14074 14073 324 229 299 298 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $5943 m0 *1 687.68,85.68
X$5943 14074 426 270 371 325 402 393 230 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $5967 m0 *1 1029.84,166.32
X$5967 14074 231 534 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $5969 r0 *1 1019.2,105.84
X$5969 14074 231 713 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $5972 r0 *1 899.36,297.36
X$5972 14074 14073 231 2368 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5974 r0 *1 866.32,55.44
X$5974 14074 231 272 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5977 m0 *1 839.44,136.08
X$5977 14074 231 756 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $5980 m0 *1 684.88,297.36
X$5980 14074 1580 231 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $5993 r0 *1 1074.08,287.28
X$5993 14074 14073 232 2121 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $5995 m0 *1 888.16,206.64
X$5995 14074 1580 232 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $6001 m0 *1 1140.72,257.04
X$6001 14074 232 1727 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $6004 m0 *1 823.2,257.04
X$6004 14074 232 1891 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $6008 m0 *1 880.32,105.84
X$6008 14074 271 233 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6063 r0 *1 876.96,95.76
X$6063 14074 233 14178 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $6094 m0 *1 637.84,206.64
X$6094 14074 14073 1365 1218 239 1366 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6098 r0 *1 648.48,287.28
X$6098 14074 14073 2220 2221 239 2222 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6102 r0 *1 676.48,166.32
X$6102 14074 14073 1047 551 239 1102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6106 r0 *1 754.88,196.56
X$6106 14074 14073 1314 1220 239 1221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6123 r0 *1 664.16,85.68
X$6123 14074 14073 396 239 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6175 m0 *1 391.44,196.56
X$6175 14074 14073 1259 1305 251 1306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6178 r0 *1 376.32,186.48
X$6178 14074 14073 1211 1152 251 1038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6180 r0 *1 380.24,206.64
X$6180 14074 14073 1359 1409 251 1360 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6182 m0 *1 438.48,216.72
X$6182 14074 14073 1493 1462 251 1513 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6209 r0 *1 534.24,287.28
X$6209 14074 1308 251 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $6215 m0 *1 526.96,136.08
X$6215 14074 656 253 14073 731 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6226 m0 *1 658.56,166.32
X$6226 14074 14073 999 551 256 1000 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6228 m0 *1 636.72,196.56
X$6228 14074 14073 1290 1218 256 1264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6230 m0 *1 693.28,287.28
X$6230 14074 14073 453 256 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6238 m0 *1 644.56,317.52
X$6238 14074 14073 2555 2221 256 2556 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6243 m0 *1 673.68,367.92
X$6243 14074 14073 3119 3036 256 3120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6246 m0 *1 749.28,206.64
X$6246 14074 14073 1268 1220 256 1269 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6289 m0 *1 631.68,156.24
X$6289 14074 14073 910 879 261 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6291 r0 *1 1057.84,85.68
X$6291 14074 14073 442 443 261 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6295 m0 *1 608.72,226.8
X$6295 14074 14073 1608 1515 261 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6304 m0 *1 437.92,267.12
X$6304 14074 14073 2032 1871 261 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6306 m0 *1 509.04,347.76
X$6306 14074 2920 2869 14073 261 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6308 r0 *1 447.44,226.8
X$6308 14074 14073 1674 1513 261 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6310 r0 *1 741.44,196.56
X$6310 14074 14073 1285 1242 261 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6342 r0 *1 1048.32,337.68
X$6342 14074 14073 261 1432 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6369 m0 *1 593.6,136.08
X$6369 14074 692 267 14073 697 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $6381 m0 *1 459.2,95.76
X$6381 421 270 454 330 14073 14074 456 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6384 m0 *1 498.4,95.76
X$6384 421 270 454 422 14073 14074 475 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $6412 r0 *1 899.36,136.08
X$6412 14074 779 270 761 685 407 759 760 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6414 m0 *1 927.92,136.08
X$6414 14074 765 270 728 561 407 637 710 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6420 m0 *1 464.8,246.96
X$6420 14073 519 270 14074 1703 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $6422 m0 *1 459.2,267.12
X$6422 14074 14073 2162 270 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6426 m0 *1 693.84,136.08
X$6426 14074 737 270 704 529 402 586 702 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6433 m0 *1 770.56,136.08
X$6433 14074 753 270 735 662 402 631 707 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6436 r0 *1 832.16,166.32
X$6436 14074 1107 270 1020 755 303 1009 1078 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6438 m0 *1 934.64,186.48
X$6438 14074 931 271 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6454 m0 *1 1099.28,287.28
X$6454 14074 271 1799 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6456 m0 *1 962.64,267.12
X$6456 14074 271 1423 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6458 r0 *1 1098.72,206.64
X$6458 14074 271 1064 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6460 r0 *1 1042.72,146.16
X$6460 14074 271 472 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6468 r0 *1 771.12,317.52
X$6468 14074 271 2060 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6470 m0 *1 821.52,166.32
X$6470 14074 271 591 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6473 m0 *1 877.52,246.96
X$6473 14074 271 1225 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $6494 m0 *1 922.88,156.24
X$6494 14074 761 403 804 764 272 763 893 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6497 m0 *1 974.96,146.16
X$6497 14074 728 844 771 769 272 805 712 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6503 r0 *1 846.72,176.4
X$6503 14073 348 14074 1129 968 273 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6505 m0 *1 830.48,156.24
X$6505 14074 14073 911 890 273 841 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6508 r0 *1 700,226.8
X$6508 14074 14073 1516 1683 273 1492 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6510 m0 *1 663.6,337.68
X$6510 14074 14073 2769 2657 273 2737 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6512 m0 *1 649.6,367.92
X$6512 14074 14073 3157 3156 273 3197 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6514 m0 *1 626.64,388.08
X$6514 14074 14073 3395 3392 273 3393 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6516 r0 *1 910,95.76
X$6516 14074 14073 501 510 273 563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6518 r0 *1 889.28,146.16
X$6518 14074 14073 843 801 273 636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6520 m0 *1 763.84,226.8
X$6520 14074 1576 279 1603 1605 273 1606 1518 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6522 r0 *1 883.68,226.8
X$6522 14073 348 14074 1524 1670 273 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6524 r0 *1 908.32,156.24
X$6524 14073 348 14074 967 908 273 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6526 r0 *1 700,317.52
X$6526 14074 14073 2656 2618 273 2590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6528 m0 *1 917.28,166.32
X$6528 14073 348 14074 964 1010 273 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6557 r0 *1 603.12,317.52
X$6557 14074 289 273 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $6560 m0 *1 852.32,246.96
X$6560 14074 14073 1647 1716 273 1892 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6562 m0 *1 752.64,287.28
X$6562 14074 2174 279 2015 2190 273 2173 2138 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6584 m0 *1 822.08,186.48
X$6584 14074 14073 1106 1105 277 1052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6588 m0 *1 827.68,146.16
X$6588 14074 841 821 665 754 277 663 593 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6590 r0 *1 844.48,257.04
X$6590 14074 1892 1648 1961 1959 277 1958 1960 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6592 m0 *1 799.68,166.32
X$6592 14074 14073 1005 862 277 885 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6595 r0 *1 899.36,186.48
X$6595 14074 14073 1108 1224 277 1223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6636 m0 *1 920.08,267.12
X$6636 14074 277 2014 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $6644 r0 *1 924.56,156.24
X$6644 14074 967 821 804 764 277 763 893 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6646 m0 *1 958.16,176.4
X$6646 14074 14073 277 1060 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6653 m0 *1 851.76,176.4
X$6653 14074 1129 821 1054 891 277 941 1053 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6655 m0 *1 849.52,236.88
X$6655 14074 1716 1648 1649 1776 277 1715 1578 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6657 r0 *1 790.72,216.72
X$6657 14074 1518 1642 1520 1391 277 1270 1419 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6659 r0 *1 786.8,226.8
X$6659 14074 1603 1642 1645 1644 277 1577 1519 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6666 m0 *1 622.72,287.28
X$6666 14074 14073 2170 2003 279 1981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6668 m0 *1 671.44,327.6
X$6668 14074 14073 2692 2769 279 2656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6670 r0 *1 764.4,156.24
X$6670 14073 279 14074 915 913 299 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $6695 r0 *1 578.48,267.12
X$6695 14074 2396 279 2094 1947 1681 2091 1948 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6697 r0 *1 589.12,136.08
X$6697 14074 787 279 654 786 289 745 584 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6701 m0 *1 655.76,156.24
X$6701 14074 937 279 699 881 299 882 836 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6704 r0 *1 641.2,186.48
X$6704 14074 14073 820 1104 279 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $6707 m0 *1 701.12,146.16
X$6707 14074 825 279 700 824 299 797 650 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6710 r0 *1 669.2,216.72
X$6710 14074 1414 279 1548 1546 388 1516 1549 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6713 r0 *1 574.56,327.6
X$6713 14074 2764 279 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $6767 r0 *1 889.84,398.16
X$6767 14074 14073 3547 2984 288 3487 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6770 r0 *1 635.6,176.4
X$6770 14074 14073 1136 551 288 935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6772 r0 *1 1148.56,468.72
X$6772 14074 14073 4372 3739 288 4369 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6774 r0 *1 1146.88,267.12
X$6774 14074 14073 2068 1581 288 1907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6776 m0 *1 1146.32,297.36
X$6776 14074 14073 2308 2063 288 2247 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6778 m0 *1 1128.96,549.36
X$6778 14074 14073 5298 4503 288 5235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6785 r0 *1 1140.72,196.56
X$6785 14074 14073 1329 806 288 1275 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6787 r0 *1 733.04,196.56
X$6787 14074 14073 1266 1220 288 1267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6790 m0 *1 837.76,579.6
X$6790 14074 14073 5616 4317 288 5617 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6793 r0 *1 700,478.8
X$6793 14074 14073 4524 3544 288 4422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6795 r0 *1 634.48,357.84
X$6795 14074 14073 3038 3036 288 3118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6797 m0 *1 609.84,317.52
X$6797 14074 14073 2658 2221 288 2552 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6799 m0 *1 787.36,559.44
X$6799 14074 14073 5583 4571 288 5478 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6801 m0 *1 603.12,519.12
X$6801 14074 14073 4981 3663 288 4823 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6803 m0 *1 1037.12,85.68
X$6803 14074 14073 444 440 288 441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6806 r0 *1 800.8,378
X$6806 14074 14073 3358 2229 288 3227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6808 r0 *1 1057.84,398.16
X$6808 14074 14073 3501 2929 288 3314 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6810 r0 *1 586.88,206.64
X$6810 14074 14073 1448 1218 288 1364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6813 m0 *1 863.52,327.6
X$6813 14074 14073 2727 1477 288 2619 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6815 r0 *1 1147.44,388.08
X$6815 14074 14073 3431 2299 288 3432 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6817 m0 *1 409.36,267.12
X$6817 14074 14073 2031 1699 288 1870 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6888 m0 *1 906.64,589.68
X$6888 14074 14073 5869 4163 288 5753 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6890 r0 *1 1002.96,559.44
X$6890 14074 14073 5559 4295 288 5560 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6892 m0 *1 411.04,226.8
X$6892 14074 14073 1461 830 288 1462 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6894 m0 *1 472.08,418.32
X$6894 14074 3654 288 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $6900 r0 *1 624.96,347.76
X$6900 14074 2130 289 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $6902 m0 *1 498.4,347.76
X$6902 14074 14073 2822 2919 289 2945 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6930 m0 *1 519.68,146.16
X$6930 14074 794 332 742 818 289 793 578 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6934 m0 *1 442.4,196.56
X$6934 14074 1343 1214 1287 1261 289 1182 1286 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6936 r0 *1 425.04,186.48
X$6936 14074 1213 1214 1155 1212 289 1154 991 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6938 r0 *1 422.24,126
X$6938 14074 679 332 681 678 289 691 680 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $6940 r0 *1 430.08,267.12
X$6940 14074 14073 289 2005 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6942 r0 *1 645.12,85.68
X$6942 14074 14073 289 299 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $6945 m0 *1 425.04,357.84
X$6945 14074 14073 3030 289 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $6958 m0 *1 640.08,156.24
X$6958 14074 14073 912 880 292 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6961 m0 *1 600.32,226.8
X$6961 14074 14073 1311 1312 292 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6964 r0 *1 727.44,226.8
X$6964 14074 14073 1682 1575 292 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6970 r0 *1 411.04,246.96
X$6970 14074 14073 1919 1819 292 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $6972 m0 *1 524.16,367.92
X$6972 14074 3114 2920 14073 292 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7000 m0 *1 419.44,226.8
X$7000 14074 14073 1509 1510 292 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7002 m0 *1 636.16,347.76
X$7002 14074 14073 292 380 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7036 r0 *1 658,75.6
X$7036 14074 14073 416 370 299 394 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7040 m0 *1 771.12,115.92
X$7040 14074 14073 587 588 299 565 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7083 m0 *1 1055.04,458.64
X$7083 14074 4107 3302 4175 4034 303 3955 4168 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7085 r0 *1 1125.04,448.56
X$7085 14074 4111 3302 4171 3946 303 4170 4028 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7087 r0 *1 640.64,277.2
X$7087 14073 2139 14074 2114 1684 303 2191 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $7089 m0 *1 581.84,85.68
X$7089 14074 14073 424 399 303 400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7091 r0 *1 579.6,347.76
X$7091 14074 303 3092 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $7094 r0 *1 1126.72,307.44
X$7094 14074 2637 715 2310 2371 303 2512 2513 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7096 r0 *1 438.48,246.96
X$7096 14074 14073 1854 1918 303 1979 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7098 m0 *1 1055.6,317.52
X$7098 14074 2629 715 2573 2240 303 2376 2574 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7162 r0 *1 943.04,75.6
X$7162 14074 14073 303 407 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7164 r0 *1 1118.32,146.16
X$7164 14074 14073 303 714 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7166 m0 *1 978.88,408.24
X$7166 14074 3556 3302 3607 3558 303 3550 3557 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7168 r0 *1 568.96,226.8
X$7168 14074 14073 1635 1411 303 1680 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7171 m0 *1 1048.88,378
X$7171 14074 3232 3302 3313 3129 303 3231 3059 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7174 m0 *1 510.16,166.32
X$7174 14074 874 303 875 930 454 966 1023 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7177 m0 *1 1067.92,408.24
X$7177 14074 303 3488 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $7179 m0 *1 562.8,267.12
X$7179 14074 2009 303 2037 2006 2007 2008 2036 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7181 m0 *1 952,327.6
X$7181 14074 2702 715 2717 2701 303 2624 2521 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7184 r0 *1 376.32,136.08
X$7184 14074 729 303 652 778 454 738 724 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7186 r0 *1 376.32,196.56
X$7186 14074 1341 303 1259 1340 1599 1211 1359 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7189 m0 *1 441.84,236.88
X$7189 454 14074 303 1493 14073 1702 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7191 m0 *1 380.24,277.2
X$7191 14074 2051 303 2135 2133 454 2084 2134 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7194 m0 *1 1128.96,388.08
X$7194 14074 3424 3302 3374 3311 303 3375 3235 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7198 r0 *1 746.48,65.52
X$7198 14074 14073 303 402 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7200 r0 *1 1126.16,246.96
X$7200 14074 1913 715 1906 1914 303 1728 1792 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7202 m0 *1 472.08,448.56
X$7202 14074 14073 303 3844 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7204 m0 *1 772.8,327.6
X$7204 14074 2730 303 2453 2731 2331 2561 2362 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7207 m0 *1 607.6,398.16
X$7207 14074 14073 3518 3415 303 3416 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7209 m0 *1 548.8,347.76
X$7209 2218 14074 303 2924 14073 2940 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $7212 m0 *1 868.56,257.04
X$7212 14074 1962 715 1746 1920 303 1806 1963 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7215 m0 *1 886.48,307.44
X$7215 14074 2447 715 2433 2366 303 2385 2446 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7275 r0 *1 912.24,176.4
X$7275 14074 1127 1831 315 692 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $7302 m0 *1 550.48,146.16
X$7302 14074 319 548 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7306 m0 *1 497.84,196.56
X$7306 14074 319 867 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7309 m0 *1 552.72,166.32
X$7309 14074 931 319 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7312 r0 *1 552.72,156.24
X$7312 14074 319 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* cell instance $7315 r0 *1 395.36,136.08
X$7315 14074 319 514 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7317 m0 *1 409.36,257.04
X$7317 14074 319 1357 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7324 r0 *1 728,216.72
X$7324 14074 319 1046 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $7343 r0 *1 774.48,136.08
X$7343 14074 14073 782 753 798 323 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $7347 m0 *1 689.36,176.4
X$7347 14074 324 1104 14073 1082 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7354 r0 *1 3.92,65.52
X$7354 14074 14073 326 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7357 m0 *1 3.92,75.6
X$7357 14074 14073 327 gf180mcu_fd_sc_mcu9t5v0__tiel
* cell instance $7369 m0 *1 386.4,176.4
X$7369 14074 14073 988 830 329 1039 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7373 m0 *1 905.52,569.52
X$7373 14074 14073 5575 4163 329 5484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7376 r0 *1 846.72,549.36
X$7376 14074 14073 5435 4317 329 5480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7378 r0 *1 708.96,458.64
X$7378 14074 14073 4250 3544 329 4217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7381 r0 *1 650.16,357.84
X$7381 14074 14073 3039 3036 329 3040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7383 m0 *1 635.6,519.12
X$7383 14074 14073 4980 3663 329 4825 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7385 r0 *1 372.4,236.88
X$7385 14074 14073 1565 1699 329 1629 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7423 m0 *1 826,458.64
X$7423 14074 14073 329 649 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7426 r0 *1 751.52,569.52
X$7426 14074 14073 5419 5615 329 5420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7428 m0 *1 954.8,579.6
X$7428 14074 14073 5557 4295 329 5558 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7431 m0 *1 484.4,398.16
X$7431 14074 14073 2921 3033 329 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $7463 r0 *1 431.2,196.56
X$7463 14074 14073 332 1214 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7468 m0 *1 424.48,277.2
X$7468 14074 2165 332 2105 2102 2005 2050 2136 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7470 m0 *1 494.48,337.68
X$7470 14074 2768 332 2843 2821 2109 2822 2487 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7473 r0 *1 544.88,327.6
X$7473 14074 14073 2764 332 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $7484 m0 *1 520.24,136.08
X$7484 14074 692 335 14073 695 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $7543 r0 *1 838.88,146.16
X$7543 14074 861 2115 347 692 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $7545 r0 *1 907.2,428.4
X$7545 14073 348 14074 3855 3879 2130 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7549 r0 *1 986.16,509.04
X$7549 14073 348 14074 4866 4868 4008 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7551 m0 *1 929.6,509.04
X$7551 14073 348 14074 4873 4839 4008 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7554 m0 *1 971.04,327.6
X$7554 14073 348 14074 2716 2718 2130 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7556 r0 *1 578.48,428.4
X$7556 14074 14073 3785 3781 348 3842 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7559 r0 *1 1063.44,307.44
X$7559 14073 348 14074 2509 2515 1589 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7622 m0 *1 999.04,246.96
X$7622 14073 692 348 14074 1722 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7625 r0 *1 1068.48,236.88
X$7625 14073 820 348 14074 1788 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $7627 m0 *1 972.72,95.76
X$7627 14074 469 348 436 468 639 474 383 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7629 m0 *1 744.24,519.12
X$7629 14074 5149 348 5012 4969 4008 4757 4663 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7631 m0 *1 669.76,539.28
X$7631 14074 14073 5252 5011 348 5222 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7634 m0 *1 843.92,549.36
X$7634 14073 348 14074 5185 5014 4008 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7637 m0 *1 852.32,589.68
X$7637 14074 5872 348 5951 5871 4008 5481 5920 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7639 m0 *1 728,438.48
X$7639 14074 4698 348 3973 3974 4008 3759 3814 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7641 r0 *1 662.48,468.72
X$7641 14074 4933 14073 4285 4008 3928 348 4387 4325
+ gf180mcu_fd_sc_mcu9t5v0__mux4_4
* cell instance $7643 r0 *1 900.48,388.08
X$7643 14074 3420 348 3363 3442 2927 3382 3323 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7645 r0 *1 917.28,589.68
X$7645 14074 5949 348 5948 5950 4008 5554 5922 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7647 r0 *1 1098.72,529.2
X$7647 14074 5169 348 5162 5168 4008 4773 5021 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7649 m0 *1 972.16,589.68
X$7649 14074 5863 348 5925 5862 4008 5845 5947 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7651 r0 *1 1029.28,519.12
X$7651 14074 5174 348 5018 5027 4008 4847 4766 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7654 m0 *1 1045.52,448.56
X$7654 14074 4114 348 3945 4113 2130 4119 3867 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7656 m0 *1 1112.72,317.52
X$7656 14074 2572 348 2571 2374 2130 2570 2569 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7658 m0 *1 890.96,327.6
X$7658 14074 2794 348 2387 2650 639 2724 2235 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7660 r0 *1 1110.48,438.48
X$7660 14074 4030 348 3951 4019 2130 4026 4020 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7662 r0 *1 1109.36,378
X$7662 14074 3239 348 3310 3305 2130 3180 3306 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7665 m0 *1 582.4,438.48
X$7665 820 348 3979 3893 14073 14074 3980 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $7667 m0 *1 825.44,357.84
X$7667 14074 2981 348 2498 3007 2130 3048 2886 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7669 m0 *1 779.52,357.84
X$7669 14074 2978 348 3046 2523 2130 2977 3045 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $7672 m0 *1 569.52,327.6
X$7672 14074 2764 348 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $7695 m0 *1 647.92,166.32
X$7695 14074 14073 972 551 354 936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7705 r0 *1 738.08,206.64
X$7705 14074 14073 1446 1220 354 1417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7710 m0 *1 1036.56,105.84
X$7710 14074 14073 504 440 354 505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7713 r0 *1 424.48,236.88
X$7713 14074 14073 1762 1699 354 1763 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7715 m0 *1 433.44,236.88
X$7715 14074 14073 1631 830 354 1511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7741 m0 *1 590.8,216.72
X$7741 14074 14073 1500 1218 354 1412 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7744 r0 *1 1012.48,307.44
X$7744 14074 354 1481 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $7746 m0 *1 514.64,357.84
X$7746 14074 14073 2972 2920 354 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $7830 r0 *1 464.8,317.52
X$7830 14074 872 367 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $7854 m0 *1 770,166.32
X$7854 14073 974 14074 373 1517 692 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $7887 r0 *1 836.08,176.4
X$7887 14074 14073 1131 1107 798 378 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $7895 r0 *1 1038.24,95.76
X$7895 14074 14073 470 471 380 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7897 r0 *1 903.28,408.24
X$7897 14074 14073 3602 3489 380 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7899 m0 *1 1153.04,186.48
X$7899 14074 14073 1170 1232 380 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7901 m0 *1 1001.84,569.52
X$7901 14074 14073 5619 5620 380 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7904 r0 *1 1160.32,478.8
X$7904 14074 14073 4231 4232 380 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7906 r0 *1 1162.56,287.28
X$7906 14074 14073 2252 2248 380 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7908 m0 *1 1155.84,277.2
X$7908 14074 14073 1970 1908 380 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7912 r0 *1 1140.72,549.36
X$7912 14074 14073 5236 5164 380 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7915 m0 *1 915.6,579.6
X$7915 14074 14073 5708 5754 380 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7917 m0 *1 829.36,579.6
X$7917 14074 14073 5710 5690 380 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7919 r0 *1 700,498.96
X$7919 14074 14073 4733 4696 380 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7921 r0 *1 624.4,317.52
X$7921 14074 14073 2659 2660 380 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7923 m0 *1 647.36,408.24
X$7923 14074 14073 3564 3352 380 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7926 r0 *1 796.88,549.36
X$7926 14074 14073 5423 5422 380 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7929 m0 *1 622.72,509.04
X$7929 14074 14073 4789 4752 380 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7931 m0 *1 873.04,347.76
X$7931 14074 14073 2873 2620 380 1579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7933 m0 *1 1160.32,388.08
X$7933 14074 14073 3307 3369 380 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7935 m0 *1 808.64,367.92
X$7935 14074 14073 3047 3122 380 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $7937 m0 *1 1054.48,388.08
X$7937 14074 14073 3366 3367 380 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8032 m0 *1 715.68,166.32
X$8032 14074 14073 797 1024 388 1003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8042 r0 *1 644,176.4
X$8042 14074 14073 1159 388 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8074 r0 *1 949.76,569.52
X$8074 14074 14073 5639 4295 396 5618 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8076 m0 *1 406,186.48
X$8076 14074 14073 989 830 396 1040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8079 m0 *1 924.56,569.52
X$8079 14074 14073 5555 4163 396 5486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8083 r0 *1 883.12,559.44
X$8083 14074 14073 5577 4317 396 5482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8086 m0 *1 674.8,398.16
X$8086 14074 14073 3449 3036 396 3286 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8088 m0 *1 730.24,509.04
X$8088 14074 14073 4887 3544 396 4627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8090 r0 *1 770.56,569.52
X$8090 14074 14073 5642 5615 396 5549 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8092 m0 *1 662.48,509.04
X$8092 14074 14073 4754 3663 396 4755 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8094 m0 *1 391.44,236.88
X$8094 14074 14073 1630 1699 396 1566 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8130 m0 *1 790.72,448.56
X$8130 14074 14073 396 955 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8133 m0 *1 512.96,367.92
X$8133 14074 14073 2972 3033 396 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $8157 r0 *1 824.88,176.4
X$8157 14074 14073 1132 1105 403 1008 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8160 m0 *1 706.72,166.32
X$8160 14074 14073 938 1001 403 1002 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8162 r0 *1 945.84,176.4
X$8162 14074 14073 1126 1110 403 1058 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8164 r0 *1 907.76,186.48
X$8164 14074 14073 1241 1224 403 1165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8191 m0 *1 927.92,176.4
X$8191 14073 403 1059 14074 1072 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8197 r0 *1 829.92,136.08
X$8197 14074 755 403 665 754 756 663 593 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8200 r0 *1 851.76,166.32
X$8200 14074 1020 403 1054 891 756 941 1053 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8202 m0 *1 824.32,156.24
X$8202 14073 403 1052 14074 889 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8205 m0 *1 784,186.48
X$8205 14074 1187 403 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $8207 m0 *1 833.84,206.64
X$8207 14074 1009 403 1371 1370 756 1344 1317 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8209 r0 *1 893.2,186.48
X$8209 14073 403 1223 14074 1181 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8212 m0 *1 600.32,287.28
X$8212 14074 2191 403 2217 2112 2007 2113 2167 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8228 r0 *1 931.28,136.08
X$8228 14074 14073 780 765 767 406 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $8279 r0 *1 686.56,166.32
X$8279 14073 14074 825 820 1082 416 1139 1081 gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $8282 m0 *1 275.52,257.04
X$8282 14074 14073 1996 1865 1144 417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8284 r0 *1 278.32,226.8
X$8284 14074 14073 1666 1538 980 417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8290 r0 *1 274.4,236.88
X$8290 14074 14073 1759 1624 1147 417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8292 r0 *1 272.16,216.72
X$8292 14074 14073 1594 1538 866 417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8306 r0 *1 441.28,126
X$8306 14074 14073 682 679 692 420 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $8310 r0 *1 889.84,438.48
X$8310 14074 14073 4011 4047 421 3514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8312 r0 *1 1054.48,448.56
X$8312 14074 14073 4106 4107 421 4111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8314 r0 *1 983.36,589.68
X$8314 14074 14073 5923 5017 421 5924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8316 r0 *1 518,650.16
X$8316 14073 14074 6756 421 6783 6786 6845 6789 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $8319 r0 *1 1062.32,539.28
X$8319 14074 14073 5294 5295 421 5161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8324 r0 *1 596.96,700.56
X$8324 14073 7525 14074 7612 7668 421 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $8330 r0 *1 718.48,458.64
X$8330 421 3302 3089 4248 14073 14074 4247 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8332 m0 *1 907.2,599.76
X$8332 14074 14073 6007 4963 421 6024 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8334 m0 *1 637.84,498.96
X$8334 421 3302 3843 4788 14073 14074 4731 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8336 r0 *1 641.76,498.96
X$8336 421 3302 2223 4753 14073 14074 4693 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8339 m0 *1 783.44,579.6
X$8339 14074 14073 5689 5079 421 5688 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $8341 m0 *1 854,599.76
X$8341 14074 14073 6006 4879 421 5953 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8343 r0 *1 464.8,418.32
X$8343 14073 421 3302 14074 1872 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $8386 m0 *1 773.92,398.16
X$8386 14074 3356 3302 3354 3290 421 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $8388 r0 *1 445.2,327.6
X$8388 14074 2171 421 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $8402 r0 *1 700,146.16
X$8402 14074 14073 838 737 798 426 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $8479 r0 *1 1076.32,136.08
X$8479 14074 14073 645 440 777 644 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8481 m0 *1 999.04,226.8
X$8481 14074 14073 1597 440 511 1480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8483 m0 *1 1041.6,136.08
X$8483 14074 14073 727 440 720 643 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8485 m0 *1 1107.12,166.32
X$8485 14074 14073 951 440 955 718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8491 m0 *1 970.48,196.56
X$8491 14074 14073 1226 1227 1049 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8493 m0 *1 999.6,156.24
X$8493 14074 14073 845 440 669 846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8495 m0 *1 999.04,166.32
X$8495 14074 14073 963 440 770 944 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8498 r0 *1 977.76,176.4
X$8498 14074 14073 1124 440 573 1061 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8501 r0 *1 1013.04,186.48
X$8501 14074 14073 1238 440 896 1167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8505 r0 *1 1109.92,146.16
X$8505 14074 14073 813 440 848 717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8507 r0 *1 964.88,216.72
X$8507 14074 14073 1422 440 463 1424 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8510 r0 *1 957.6,206.64
X$8510 14074 14073 1372 1373 1651 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8512 r0 *1 1089.2,126
X$8512 14074 14073 721 440 674 671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8515 r0 *1 1100.96,126
X$8515 14074 14073 676 440 649 672 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8555 r0 *1 1112.16,126
X$8555 14074 14073 675 673 531 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8558 m0 *1 1008,226.8
X$8558 14074 14073 1595 1425 626 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8561 m0 *1 1019.76,226.8
X$8561 14074 14073 1537 1426 625 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8564 m0 *1 986.72,226.8
X$8564 14074 14073 1598 1527 1583 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8567 m0 *1 969.36,186.48
X$8567 14074 14073 1177 1111 887 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8569 m0 *1 975.52,166.32
X$8569 14074 14073 1018 1011 748 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8572 r0 *1 1027.04,206.64
X$8572 14074 14073 1437 1427 523 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8574 r0 *1 955.92,216.72
X$8574 14074 14073 1542 1478 1522 440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8581 m0 *1 963.76,640.08
X$8581 14074 6656 440 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $8584 m0 *1 1047.2,105.84
X$8584 14074 535 536 443 441 534 471 505 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8588 m0 *1 1047.2,115.92
X$8588 14074 602 603 443 441 601 471 505 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $8631 r0 *1 944.72,136.08
X$8631 14074 14073 766 779 767 449 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $8648 r0 *1 387.52,156.24
X$8648 14074 14073 960 830 453 927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8652 r0 *1 903.28,559.44
X$8652 14074 14073 5427 4163 453 5485 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8655 m0 *1 962.08,559.44
X$8655 14074 14073 5488 4295 453 5489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8659 m0 *1 851.2,569.52
X$8659 14074 14073 5578 4317 453 5552 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8661 r0 *1 727.44,498.96
X$8661 14074 14073 4784 3544 453 4625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8663 r0 *1 648.48,519.12
X$8663 14074 14073 4932 3663 453 4826 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8665 r0 *1 380.8,236.88
X$8665 14074 14073 1743 1699 453 1697 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8699 r0 *1 864.08,448.56
X$8699 14074 14073 453 848 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8701 m0 *1 752.64,569.52
X$8701 14074 14073 5585 5615 453 5477 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8704 m0 *1 516.32,378
X$8704 14074 14073 3114 3033 453 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $8708 r0 *1 500.64,105.84
X$8708 519 545 454 567 14073 14074 568 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8711 r0 *1 390.88,317.52
X$8711 14074 14073 2651 2649 2320 454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8714 r0 *1 459.2,206.64
X$8714 14074 14073 1543 454 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $8744 m0 *1 449.68,115.92
X$8744 519 545 454 544 14073 14074 509 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $8747 m0 *1 590.24,166.32
X$8747 14074 454 14073 997 932 934 998 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $8750 r0 *1 480.48,438.48
X$8750 14074 14073 454 4054 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8753 r0 *1 463.12,95.76
X$8753 456 486 509 455 14074 14073 517 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $8770 m0 *1 652.96,226.8
X$8770 14074 14073 1569 1570 460 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8778 r0 *1 611.52,297.36
X$8778 14074 14073 2335 2217 460 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8782 m0 *1 436.8,327.6
X$8782 14074 14073 2729 2215 460 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8784 r0 *1 861.28,267.12
X$8784 14074 14073 2082 1961 460 1579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8786 m0 *1 750.96,277.2
X$8786 14074 14073 2058 2016 460 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8788 m0 *1 487.76,307.44
X$8788 14074 14073 2456 2418 460 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8822 r0 *1 437.36,166.32
X$8822 14074 14073 1019 1043 460 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8825 m0 *1 504.56,388.08
X$8825 14074 14073 3411 460 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $8836 r0 *1 659.68,216.72
X$8836 14074 14073 1495 551 463 1472 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8840 m0 *1 1056.72,196.56
X$8840 14074 14073 1272 806 463 1319 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8846 m0 *1 1043.84,277.2
X$8846 14074 14073 2119 2063 463 2120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8851 r0 *1 603.12,297.36
X$8851 14074 14073 2293 1218 463 2167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8854 m0 *1 745.36,246.96
X$8854 14074 14073 1830 1220 463 1888 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8857 m0 *1 949.2,267.12
X$8857 14074 14073 2025 1581 463 1897 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8859 r0 *1 850.08,267.12
X$8859 14074 14073 2061 1579 463 1960 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8861 m0 *1 441.28,297.36
X$8861 14074 14073 2323 1699 463 2161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8863 m0 *1 474.88,317.52
X$8863 14074 14073 2653 2221 463 2486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8911 r0 *1 444.08,186.48
X$8911 14074 14073 1183 830 463 1042 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $8915 m0 *1 577.92,347.76
X$8915 14074 2986 463 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $8946 r0 *1 901.6,166.32
X$8946 14074 1074 1128 469 692 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $8958 r0 *1 1042.72,136.08
X$8958 14074 14073 472 14144 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $9016 r0 *1 1106,156.24
X$9016 14074 1116 718 472 951 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $9036 m0 *1 400.96,115.92
X$9036 14074 473 1017 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $9045 r0 *1 508.48,105.84
X$9045 475 540 568 539 14074 14073 576 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9074 r0 *1 239.68,267.12
X$9074 14074 14073 2074 2045 866 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9083 m0 *1 240.8,277.2
X$9083 14074 14073 2098 2045 980 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9086 r0 *1 255.92,307.44
X$9086 14074 14073 2518 2412 1144 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9088 m0 *1 246.4,297.36
X$9088 14074 14073 2281 2150 1147 482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9170 m0 *1 648.48,236.88
X$9170 14074 14073 1753 1707 500 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9173 r0 *1 426.72,156.24
X$9173 14074 14073 868 869 500 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9175 r0 *1 726.32,257.04
X$9175 14074 14073 1953 2013 500 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9186 m0 *1 587.44,297.36
X$9186 14074 14073 2334 2112 500 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9188 m0 *1 429.52,307.44
X$9188 14074 14073 2322 2159 500 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9190 r0 *1 830.48,267.12
X$9190 14074 14073 2085 1959 500 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9192 r0 *1 502.32,337.68
X$9192 14074 2867 2868 14073 500 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $9194 r0 *1 482.16,327.6
X$9194 14074 14073 2617 2591 500 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9233 r0 *1 866.32,216.72
X$9233 14074 14073 500 1522 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9238 m0 *1 909.44,166.32
X$9238 14074 14073 888 1073 501 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9273 r0 *1 1070.16,126
X$9273 14074 722 536 671 599 534 644 507 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9275 m0 *1 1070.16,126
X$9275 14074 677 603 671 599 601 644 507 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9291 m0 *1 1051.12,488.88
X$9291 14074 14073 4591 4503 511 4639 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9293 r0 *1 672.56,246.96
X$9293 14074 14073 1829 551 511 1708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9295 r0 *1 939.12,307.44
X$9295 14074 14073 2445 2299 511 2434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9299 r0 *1 591.36,246.96
X$9299 14074 14073 1880 1218 511 1881 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9301 m0 *1 950.32,388.08
X$9301 14074 14073 3319 2929 511 3297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9304 r0 *1 1044.4,166.32
X$9304 14074 14073 1069 806 511 1013 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9306 m0 *1 964.32,468.72
X$9306 14074 14073 4294 4295 511 4296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9309 r0 *1 889.28,478.8
X$9309 14074 14073 4436 4163 511 4361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9313 r0 *1 1055.04,267.12
X$9313 14074 14073 2072 2063 511 2065 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9317 r0 *1 447.44,146.16
X$9317 14074 14073 829 830 511 831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9322 r0 *1 778.4,488.88
X$9322 14074 14073 4491 4385 511 4492 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9325 r0 *1 821.52,468.72
X$9325 14074 14073 4290 4317 511 4219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9327 m0 *1 644,488.88
X$9327 14074 14073 4355 3663 511 4356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9329 m0 *1 958.72,226.8
X$9329 14074 14073 1600 1581 511 1582 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9331 r0 *1 1050.56,428.4
X$9331 14074 14073 3870 3739 511 3799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9333 m0 *1 756.56,367.92
X$9333 14074 14073 3149 2229 511 3043 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9335 r0 *1 836.08,236.88
X$9335 14074 14073 1775 1650 511 1776 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9337 m0 *1 769.44,277.2
X$9337 14074 14073 2059 1220 511 2017 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9339 r0 *1 450.24,317.52
X$9339 14074 14073 2685 1699 511 2163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9342 m0 *1 824.32,428.4
X$9342 14074 14073 3756 2984 511 3731 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9346 r0 *1 522.48,317.52
X$9346 14074 14073 2655 2221 511 2551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9348 r0 *1 775.04,438.48
X$9348 14074 14073 4056 3544 511 3934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9350 m0 *1 521.92,428.4
X$9350 14074 14073 3761 3036 511 3762 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9440 m0 *1 495.6,378
X$9440 14074 14073 3250 511 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9490 r0 *1 395.36,146.16
X$9490 14074 514 14078 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $9512 r0 *1 477.12,136.08
X$9512 694 781 517 14074 14073 741 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $9522 m0 *1 416.64,529.2
X$9522 519 14074 5065 4928 14073 5128 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $9524 m0 *1 428.4,539.28
X$9524 14074 5309 5010 14073 4922 519 5065 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $9533 r0 *1 637.84,488.88
X$9533 519 2012 2223 4526 14073 14074 4676 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9535 m0 *1 636.16,488.88
X$9535 519 2012 3843 4527 14073 14074 4568 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $9576 m0 *1 617.12,408.24
X$9576 14074 14073 519 3660 3482 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9580 m0 *1 449.68,246.96
X$9580 14073 519 545 14074 1820 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $9584 m0 *1 497.28,287.28
X$9584 14074 14073 519 656 2162 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9586 r0 *1 406.56,650.16
X$9586 14074 6817 519 5341 6915 5533 6776 6779 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $9588 m0 *1 406,327.6
X$9588 14074 14073 2728 2723 2320 519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9590 m0 *1 427.84,327.6
X$9590 14074 14073 2763 519 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9593 r0 *1 561.68,337.68
X$9593 14074 14073 519 2870 2823 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $9596 m0 *1 408.8,549.36
X$9596 519 5065 4922 5010 14074 14073 5343 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $9616 m0 *1 963.2,297.36
X$9616 14074 14073 2318 2302 523 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9618 m0 *1 978.88,277.2
X$9618 14074 14073 2075 1833 523 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9620 r0 *1 680.96,246.96
X$9620 14074 14073 1927 1639 523 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9622 r0 *1 1083.6,267.12
X$9622 14074 14073 2066 2067 523 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9625 m0 *1 1069.6,176.4
X$9625 14074 14073 1067 1063 523 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9628 m0 *1 999.04,478.8
X$9628 14074 14073 4377 4366 523 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9631 m0 *1 924,458.64
X$9631 14074 14073 4161 4162 523 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9635 m0 *1 1079.68,488.88
X$9635 14074 14073 4504 4582 523 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9641 r0 *1 987.84,388.08
X$9641 14074 14073 3505 3301 523 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9643 m0 *1 679.84,478.8
X$9643 14074 14073 4443 4421 523 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9647 m0 *1 799.68,488.88
X$9647 14074 14073 4521 4289 523 4571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9649 r0 *1 849.52,468.72
X$9649 14074 14073 4185 4184 523 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9651 r0 *1 770,458.64
X$9651 14074 14073 4102 4010 523 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9654 m0 *1 1083.6,438.48
X$9654 14074 14073 3954 3858 523 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9656 r0 *1 867.44,226.8
X$9656 14074 14073 1672 1649 523 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9659 m0 *1 801.92,277.2
X$9659 14074 14073 2087 2018 523 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9661 r0 *1 856.8,418.32
X$9661 14074 14073 3751 3674 523 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9663 m0 *1 519.68,307.44
X$9663 14074 14073 2458 2420 523 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9666 r0 *1 473.2,297.36
X$9666 14074 14073 2393 2164 523 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9670 m0 *1 471.52,176.4
X$9670 14074 14073 1077 992 523 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9673 m0 *1 523.04,448.56
X$9673 14074 14073 4057 3921 523 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9733 r0 *1 480.48,408.24
X$9733 14074 14073 3567 523 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9735 m0 *1 768.88,367.92
X$9735 14074 14073 3148 3044 523 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9737 r0 *1 633.36,257.04
X$9737 14074 14073 1984 1949 523 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9759 r0 *1 616.56,126
X$9759 14074 14073 526 684 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9783 m0 *1 1152.48,156.24
X$9783 14074 14073 851 850 531 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9786 r0 *1 918.4,317.52
X$9786 14074 14073 2700 2623 531 1477 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9789 m0 *1 1170.4,226.8
X$9789 14074 14073 1591 1529 531 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9791 m0 *1 1156.96,509.04
X$9791 14074 14073 4853 4770 531 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9794 m0 *1 933.52,378
X$9794 14074 14073 3243 3230 531 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9796 r0 *1 991.76,559.44
X$9796 14074 14073 5570 5490 531 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9799 m0 *1 938,559.44
X$9799 14074 14073 5556 5487 531 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9802 r0 *1 874.72,559.44
X$9802 14074 14073 5483 5426 531 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9804 r0 *1 671.44,398.16
X$9804 14074 14073 3285 3287 531 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9807 r0 *1 675.36,509.04
X$9807 14074 14073 4934 4827 531 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9809 m0 *1 722.4,468.72
X$9809 14074 14073 4286 4287 531 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9811 r0 *1 1167.04,357.84
X$9811 14074 14073 3066 3065 531 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9813 m0 *1 773.92,549.36
X$9813 14074 14073 5367 5421 531 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9815 r0 *1 1174.88,438.48
X$9815 14074 14073 4025 4021 531 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9817 m0 *1 1091.44,357.84
X$9817 14074 14073 2995 2994 531 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9821 r0 *1 833.28,388.08
X$9821 14074 14073 3388 3291 531 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9860 r0 *1 1174.88,317.52
X$9860 14074 14073 2636 2635 531 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $9872 m0 *1 1036.56,126
X$9872 14074 726 536 643 642 534 598 600 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9874 r0 *1 1008,206.64
X$9874 14074 1374 895 1427 1480 534 1425 1426 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9887 m0 *1 967.68,246.96
X$9887 14074 1851 895 1833 1582 534 1720 1832 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9889 m0 *1 1104.88,136.08
X$9889 14074 716 536 673 672 534 717 718 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9892 r0 *1 973.28,216.72
X$9892 14074 1339 895 1527 1478 534 1373 1424 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9894 r0 *1 993.44,166.32
X$9894 14074 1012 844 846 1061 534 1011 944 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9898 m0 *1 1051.68,136.08
X$9898 14074 775 715 535 726 714 722 716 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $9911 m0 *1 1036,146.16
X$9911 14074 14073 895 536 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9949 m0 *1 519.12,650.16
X$9949 14073 14074 6756 545 6783 6786 6674 3446 gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $9951 m0 *1 575.68,710.64
X$9951 14073 7525 14074 7612 7760 545 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $9957 m0 *1 587.44,337.68
X$9957 14074 14073 2766 545 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $9982 r0 *1 446.88,519.12
X$9982 14074 14073 545 5045 4615 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10024 m0 *1 546,146.16
X$10024 14074 14073 548 14130 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $10051 m0 *1 589.12,287.28
X$10051 14074 14073 2193 2113 549 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10053 m0 *1 656.32,246.96
X$10053 14074 14073 1828 1771 549 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10055 m0 *1 431.2,166.32
X$10055 14074 14073 903 928 549 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10066 m0 *1 426.16,287.28
X$10066 14074 14073 2158 2160 549 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10068 r0 *1 743.68,246.96
X$10068 14074 14073 1885 1886 549 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10070 m0 *1 842.24,267.12
X$10070 14074 14073 1982 1958 549 1420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10072 m0 *1 522.48,347.76
X$10072 14074 2867 2895 14073 549 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $10074 m0 *1 488.88,327.6
X$10074 14074 14073 2549 2550 549 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10112 r0 *1 858.48,216.72
X$10112 14074 14073 549 1651 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10125 r0 *1 708.96,257.04
X$10125 14074 14073 1952 551 896 1574 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10133 r0 *1 708.4,206.64
X$10133 14074 14073 1447 551 669 1368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10136 m0 *1 711.2,196.56
X$10136 14074 14073 1313 551 770 1265 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10138 r0 *1 689.36,196.56
X$10138 14074 14073 1395 551 573 1367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10189 m0 *1 636.16,589.68
X$10189 14074 14073 5965 551 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10196 r0 *1 690.48,206.64
X$10196 14074 14073 1416 1449 748 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10198 m0 *1 677.6,216.72
X$10198 14074 14073 1415 1473 625 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10208 m0 *1 678.16,277.2
X$10208 14074 14073 2090 1772 626 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10210 r0 *1 708.4,226.8
X$10210 14074 14073 1641 1573 887 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10213 r0 *1 707.28,246.96
X$10213 14074 14073 1858 1710 1049 551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10320 r0 *1 374.64,216.72
X$10320 14074 14073 1541 830 573 1305 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10327 m0 *1 1006.88,146.16
X$10327 14074 14073 772 806 573 773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10335 r0 *1 376.32,287.28
X$10335 14074 14073 2263 1699 573 2103 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10337 r0 *1 462,347.76
X$10337 14074 14073 2944 2221 573 2918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10381 m0 *1 554.4,267.12
X$10381 14074 14073 1945 1218 573 1946 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10385 r0 *1 754.88,327.6
X$10385 14074 573 2239 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $10388 m0 *1 482.16,347.76
X$10388 14074 14073 2868 2920 573 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $10391 m0 *1 879.76,226.8
X$10391 14074 14073 1523 1579 573 1525 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10408 r0 *1 520.24,136.08
X$10408 731 783 576 14074 14073 784 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $10473 m0 *1 776.16,156.24
X$10473 14074 14073 888 973 587 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $10542 m0 *1 848.4,156.24
X$10542 14074 892 891 591 860 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10544 r0 *1 841.12,156.24
X$10544 14074 892 941 591 942 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10548 r0 *1 821.52,156.24
X$10548 14074 14073 591 14158 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $10552 r0 *1 809.2,166.32
X$10552 14074 892 1008 591 1007 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10557 r0 *1 855.68,186.48
X$10557 14074 892 1053 591 1222 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10559 m0 *1 855.68,186.48
X$10559 14074 892 1054 591 1163 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10564 m0 *1 814.8,206.64
X$10564 14074 892 1370 591 1490 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10566 r0 *1 797.44,206.64
X$10566 14074 892 1419 591 1491 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10570 r0 *1 804.72,176.4
X$10570 14074 892 1105 591 1185 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10572 m0 *1 805.28,176.4
X$10572 14074 892 1052 591 1051 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10574 r0 *1 805.84,226.8
X$10574 14074 892 1520 591 1521 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $10609 r0 *1 1037.68,115.92
X$10609 14074 646 603 643 642 601 598 600 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10632 m0 *1 1043.84,146.16
X$10632 14074 14073 814 807 601 808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10634 m0 *1 1074.08,156.24
X$10634 14074 1114 603 899 773 601 810 812 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10636 r0 *1 1055.6,206.64
X$10636 14074 1229 603 1430 1375 601 1429 1319 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10638 r0 *1 1107.12,136.08
X$10638 14074 776 603 673 672 601 717 718 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10656 m0 *1 1126.16,216.72
X$10656 14074 1528 601 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $10658 r0 *1 1037.68,166.32
X$10658 14073 601 898 14074 946 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10660 r0 *1 1150.8,196.56
X$10660 14074 1379 603 1324 1275 601 1232 1323 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10662 m0 *1 1050.56,176.4
X$10662 14074 1120 603 1063 1013 601 815 1062 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10667 r0 *1 1143.52,166.32
X$10667 14074 1378 603 850 953 601 849 954 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10673 r0 *1 1047.76,136.08
X$10673 14074 14073 774 776 670 602 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10736 m0 *1 385.84,156.24
X$10736 14073 612 791 14074 855 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10759 m0 *1 477.68,257.04
X$10759 14074 1923 1512 1705 1821 612 1875 1874 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10762 r0 *1 450.8,206.64
X$10762 14074 14073 612 1362 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10765 r0 *1 452.48,277.2
X$10765 14074 2136 1512 2164 2163 612 2052 2107 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10770 m0 *1 466.48,186.48
X$10770 14074 1463 612 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $10773 m0 *1 509.04,156.24
X$10773 14073 612 833 14074 873 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $10777 m0 *1 434.56,287.28
X$10777 14074 2105 1512 2215 2159 612 2160 2161 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $10846 m0 *1 1071.28,488.88
X$10846 14074 14073 4590 4581 625 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10848 m0 *1 983.92,257.04
X$10848 14074 14073 1916 1832 625 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10851 r0 *1 621.04,236.88
X$10851 14074 14073 1809 1768 625 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10853 m0 *1 1068.48,186.48
X$10853 14074 14073 1172 1062 625 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10855 m0 *1 934.64,468.72
X$10855 14074 14073 4313 4293 625 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10863 r0 *1 672,488.88
X$10863 14074 14073 4675 4420 625 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10865 m0 *1 840,468.72
X$10865 14074 14073 4245 4159 625 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10867 m0 *1 799.68,478.8
X$10867 14074 14073 4439 4424 625 4571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10871 r0 *1 1082.48,428.4
X$10871 14074 14073 3865 3857 625 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10873 m0 *1 467.6,156.24
X$10873 14074 14073 904 871 625 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10876 m0 *1 868.56,236.88
X$10876 14074 14073 1673 1578 625 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10878 m0 *1 800.8,267.12
X$10878 14074 14073 2033 1957 625 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10880 m0 *1 481.04,287.28
X$10880 14074 14073 2192 2107 625 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10883 r0 *1 952.56,297.36
X$10883 14074 14073 2381 2301 625 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10886 m0 *1 509.6,307.44
X$10886 14074 14073 2353 2354 625 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10888 r0 *1 491.12,438.48
X$10888 14074 14073 4053 3918 625 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10891 m0 *1 774.48,418.32
X$10891 14074 14073 3757 3672 625 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10957 r0 *1 1085.84,277.2
X$10957 14074 14073 2123 2124 625 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10959 m0 *1 1007.44,478.8
X$10959 14074 14073 4431 4425 625 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10962 r0 *1 991.2,378
X$10962 14074 14073 3318 3300 625 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10965 r0 *1 527.52,378
X$10965 14074 14073 3327 625 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $10967 m0 *1 777.84,378
X$10967 14074 14073 3226 3224 625 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10969 m0 *1 846.72,408.24
X$10969 14074 14073 3621 3601 625 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10971 m0 *1 1059.52,488.88
X$10971 14074 14073 4579 4580 626 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10974 m0 *1 1052.24,146.16
X$10974 14074 14073 816 815 626 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10976 r0 *1 1058.4,277.2
X$10976 14074 14073 2129 2122 626 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10980 m0 *1 983.36,478.8
X$10980 14074 14073 4378 4500 626 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10986 r0 *1 458.08,146.16
X$10986 14074 14073 857 832 626 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10989 m0 *1 965.44,398.16
X$10989 14074 14073 3437 3298 626 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10991 r0 *1 813.12,468.72
X$10991 14074 14073 4321 4218 626 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10995 m0 *1 887.04,478.8
X$10995 14074 14073 4291 4292 626 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $10998 m0 *1 789.6,478.8
X$10998 14074 14073 4384 4359 626 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11001 m0 *1 655.2,488.88
X$11001 14074 14073 4488 4419 626 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11003 m0 *1 951.44,236.88
X$11003 14074 14073 1719 1720 626 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11005 r0 *1 836.64,246.96
X$11005 14074 14073 1714 1715 626 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11007 m0 *1 782.32,267.12
X$11007 14074 14073 2034 1956 626 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11011 r0 *1 461.44,267.12
X$11011 14074 14073 2089 2052 626 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11013 r0 *1 830.48,428.4
X$11013 14074 14073 3755 3673 626 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11015 r0 *1 526.96,307.44
X$11015 14074 14073 2488 2489 626 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11018 r0 *1 522.48,428.4
X$11018 14074 14073 3889 3840 626 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11020 r0 *1 760.48,408.24
X$11020 14074 14073 3623 3600 626 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11022 m0 *1 935.76,297.36
X$11022 14074 14073 2384 2321 626 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11024 r0 *1 757.68,388.08
X$11024 14074 14073 3418 3225 626 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11089 m0 *1 1064.56,428.4
X$11089 14074 14073 3744 3743 626 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11091 r0 *1 538.72,388.08
X$11091 14074 14073 3454 626 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11094 m0 *1 608.72,246.96
X$11094 14074 14073 1859 1827 626 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11144 r0 *1 969.36,236.88
X$11144 14074 14073 1742 1779 639 1802 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11147 r0 *1 1051.68,156.24
X$11147 14074 14073 947 946 639 814 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11149 r0 *1 1088.64,196.56
X$11149 14074 14073 1320 1332 639 1281 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11151 r0 *1 787.36,347.76
X$11151 14074 14073 2977 2935 639 2774 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11153 r0 *1 752.64,317.52
X$11153 14074 14073 2173 2494 639 2732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11172 r0 *1 997.36,347.76
X$11172 14074 14073 639 2927 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11174 r0 *1 787.36,176.4
X$11174 14074 1315 639 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11209 r0 *1 1055.04,126
X$11209 14074 14073 725 677 670 646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11224 r0 *1 914.48,378
X$11224 14074 14073 3294 2984 649 3364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11226 m0 *1 1131.76,166.32
X$11226 14074 14073 952 806 649 953 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11229 r0 *1 1130.08,498.96
X$11229 14074 14073 4710 4503 649 4711 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11233 r0 *1 1145.2,367.92
X$11233 14074 14073 3184 2299 649 3132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11235 m0 *1 886.48,337.68
X$11235 14074 14073 2840 1477 649 2622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11237 m0 *1 1056.16,367.92
X$11237 14074 14073 2990 2929 649 2991 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11240 m0 *1 821.52,398.16
X$11240 14074 14073 3445 2229 649 3228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11266 m0 *1 1148,337.68
X$11266 14074 14073 2783 2063 649 2632 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11269 r0 *1 1147.44,438.48
X$11269 14074 14073 3947 3739 649 3948 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11271 m0 *1 1147.44,236.88
X$11271 14074 14073 1657 1581 649 1658 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11299 r0 *1 654.64,146.16
X$11299 14074 656 795 14073 796 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $11303 r0 *1 568.4,267.12
X$11303 14073 1130 14074 2009 1635 2056 656 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $11305 m0 *1 761.04,317.52
X$11305 14074 1130 2730 2587 656 14073 2697 gf180mcu_fd_sc_mcu9t5v0__oai22_4
* cell instance $11319 m0 *1 677.04,307.44
X$11319 14074 14073 656 2424 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11385 m0 *1 1080.24,478.8
X$11385 14074 14073 4375 3739 669 4225 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11387 m0 *1 948.08,519.12
X$11387 14074 14073 5034 4163 669 4843 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11390 m0 *1 1018.08,509.04
X$11390 14074 14073 4776 4295 669 4775 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11392 m0 *1 989.52,458.64
X$11392 14074 14073 4221 2929 669 3942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11395 r0 *1 924,448.56
X$11395 14074 14073 4042 2984 669 3961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11399 r0 *1 1082.48,529.2
X$11399 14074 14073 4946 4503 669 4849 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11403 r0 *1 1060.08,236.88
X$11403 14074 14073 1787 1581 669 1785 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11406 r0 *1 723.52,428.4
X$11406 14074 14073 3788 3544 669 3728 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11410 m0 *1 1080.8,317.52
X$11410 14074 14073 2630 2063 669 2511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11413 m0 *1 809.76,509.04
X$11413 14074 14073 4830 4571 669 4831 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11415 m0 *1 857.92,519.12
X$11415 14074 14073 4966 4317 669 5015 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11419 r0 *1 994,327.6
X$11419 14074 14073 2626 2299 669 2642 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11421 r0 *1 742.56,297.36
X$11421 14074 14073 2226 1220 669 2228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11423 m0 *1 799.68,327.6
X$11423 14074 14073 2363 2229 669 2364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11425 r0 *1 1089.2,146.16
X$11425 14074 14073 853 806 669 899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11428 r0 *1 900.48,206.64
X$11428 14074 14073 1421 1420 669 1476 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11476 r0 *1 702.8,378
X$11476 14074 14073 878 669 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11479 r0 *1 998.48,226.8
X$11479 14074 14073 1665 1584 670 1487 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11493 m0 *1 1008.56,277.2
X$11493 14074 14073 2130 670 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11495 r0 *1 1049.44,186.48
X$11495 14074 1236 14073 1229 670 1120 1318 947 1114
+ gf180mcu_fd_sc_mcu9t5v0__mux4_4
* cell instance $11514 r0 *1 1130.64,236.88
X$11514 14074 14073 1655 1581 674 1656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11516 m0 *1 1141.84,468.72
X$11516 14074 14073 4303 3739 674 4230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11518 r0 *1 1115.52,498.96
X$11518 14074 14073 4768 4503 674 4850 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11520 m0 *1 906.64,357.84
X$11520 14074 14073 3002 2984 674 2985 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11522 m0 *1 1131.76,196.56
X$11522 14074 14073 1278 806 674 1231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11525 m0 *1 1130.64,337.68
X$11525 14074 14073 2781 2063 674 2631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11527 m0 *1 666.96,579.6
X$11527 14074 14073 5684 3663 674 5417 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11530 m0 *1 723.52,569.52
X$11530 14074 14073 5476 3544 674 5147 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11532 r0 *1 982.8,630
X$11532 14074 14073 6449 4295 674 6365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11534 r0 *1 929.6,640.08
X$11534 14074 14073 6624 4163 674 6361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11536 r0 *1 811.44,589.68
X$11536 14074 14073 5916 5615 674 5751 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11538 r0 *1 920.08,277.2
X$11538 14074 14073 2117 1650 674 2118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11540 r0 *1 874.16,630
X$11540 14074 14073 6445 4317 674 6359 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11543 r0 *1 809.76,216.72
X$11543 14074 14073 1521 1220 674 1520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11545 m0 *1 1120.56,388.08
X$11545 14074 14073 3376 2299 674 3368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11547 m0 *1 855.68,317.52
X$11547 14074 14073 2584 2229 674 2500 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11550 m0 *1 713.44,327.6
X$11550 14074 14073 2735 2221 674 2695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11552 r0 *1 570.64,388.08
X$11552 14074 14073 3115 3036 674 3116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11593 m0 *1 1037.12,367.92
X$11593 14074 14073 3128 2929 674 3058 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11595 r0 *1 566.72,337.68
X$11595 14074 14073 2688 674 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11630 r0 *1 521.92,740.88
X$11630 14074 14073 682 8180 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11632 m0 *1 520.8,740.88
X$11632 14074 682 8369 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11642 r0 *1 934.08,720.72
X$11642 14073 684 7552 14074 7913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11645 m0 *1 922.88,720.72
X$11645 14074 684 7712 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $11665 m0 *1 383.6,216.72
X$11665 14074 14073 1358 830 689 1360 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11668 r0 *1 654.64,438.48
X$11668 14074 14073 4004 3663 689 4007 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11672 r0 *1 555.52,408.24
X$11672 14074 14073 3634 3036 689 3595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11674 r0 *1 383.04,297.36
X$11674 14074 14073 2386 1699 689 2157 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11676 m0 *1 466.48,357.84
X$11676 14074 14073 3087 2221 689 2970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11679 m0 *1 574.56,236.88
X$11679 14074 14073 1636 1218 689 1767 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11708 r0 *1 710.64,378
X$11708 14074 14073 689 2987 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11711 r0 *1 511.84,367.92
X$11711 14074 14073 3172 2920 689 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $11713 m0 *1 710.64,307.44
X$11713 14074 14073 689 770 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11717 r0 *1 386.4,146.16
X$11717 14074 14073 691 855 828 792 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11722 m0 *1 666.4,206.64
X$11722 14074 1450 1396 937 692 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $11724 r0 *1 830.48,156.24
X$11724 14073 968 861 940 970 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11726 r0 *1 441.28,196.56
X$11726 14073 1307 14074 1343 1394 692 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11734 m0 *1 977.76,378
X$11734 14073 3241 14074 3239 3240 692 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11736 r0 *1 1039.36,337.68
X$11736 14073 14074 1236 3427 692 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $11738 r0 *1 971.04,317.52
X$11738 14073 2718 3241 2436 2644 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11741 r0 *1 1048.88,438.48
X$11741 14074 692 4030 14073 4018 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $11744 m0 *1 878.64,236.88
X$11744 14073 1670 1717 1747 1671 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11746 r0 *1 764.96,287.28
X$11746 14074 2189 2328 1576 692 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $11749 m0 *1 897.68,176.4
X$11749 14073 908 1074 1076 1075 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11751 r0 *1 916.72,166.32
X$11751 14073 1010 1127 1057 1073 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11754 r0 *1 1046.08,307.44
X$11754 14073 2515 2508 2517 2516 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11756 m0 *1 1047.76,317.52
X$11756 14073 2508 14074 2572 2567 692 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11758 r0 *1 580.72,226.8
X$11758 14074 14073 1706 692 1547 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $11761 r0 *1 772.24,156.24
X$11761 14073 913 974 883 973 692 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $11804 r0 *1 982.24,236.88
X$11804 14073 692 1318 14074 1780 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $11806 r0 *1 980,418.32
X$11806 14074 14073 692 3796 3734 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $11809 r0 *1 452.48,408.24
X$11809 14074 692 3633 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $11811 r0 *1 871.36,357.84
X$11811 14074 14073 692 2925 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $11820 r0 *1 520.8,146.16
X$11820 14073 695 14074 794 819 820 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $11831 m0 *1 600.32,146.16
X$11831 14074 697 933 787 820 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $11856 m0 *1 708.4,156.24
X$11856 14074 14073 914 702 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $11883 r0 *1 786.24,146.16
X$11883 14074 14073 707 863 886 799 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11890 r0 *1 936.32,166.32
X$11890 14074 14073 710 1072 886 1126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $11921 r0 *1 1038.8,236.88
X$11921 14074 1844 895 1785 1902 713 1784 1786 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11923 r0 *1 1117.76,186.48
X$11923 14074 1322 950 1231 1230 713 1115 1117 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11925 r0 *1 1072.4,156.24
X$11925 14074 959 950 899 773 713 810 812 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11928 m0 *1 1162,196.56
X$11928 14074 1276 950 1324 1275 713 1232 1323 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11930 r0 *1 1052.8,166.32
X$11930 14074 949 895 1063 1013 713 815 1062 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11933 m0 *1 1060.08,206.64
X$11933 14074 948 950 1430 1375 713 1429 1319 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11935 r0 *1 1099.84,196.56
X$11935 14074 1331 950 1169 1273 713 1274 1321 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11938 m0 *1 1141.28,166.32
X$11938 14074 1014 950 850 953 713 849 954 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11940 r0 *1 950.88,246.96
X$11940 14074 1853 895 1896 1778 713 1652 1897 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11943 r0 *1 1120,196.56
X$11943 14074 1330 715 1276 1331 714 1322 1014 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11945 r0 *1 995.12,196.56
X$11945 14074 1336 715 1012 1339 714 1374 1228 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11955 r0 *1 996.24,246.96
X$11955 14074 1898 715 1844 1853 714 1851 1850 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11957 m0 *1 1058.96,166.32
X$11957 14074 1173 715 959 948 714 949 900 14073 gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $11962 r0 *1 632.8,277.2
X$11962 2011 715 2218 1769 14073 14074 2139 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $12009 r0 *1 632.8,287.28
X$12009 14074 14073 2162 715 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12013 r0 *1 753.2,236.88
X$12013 798 715 1891 1752 14073 14074 1922 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $12036 r0 *1 186.48,267.12
X$12036 14074 14073 2069 1992 866 719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12046 r0 *1 201.6,257.04
X$12046 14074 1972 1140 14073 1147 1144 719 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $12050 m0 *1 211.68,257.04
X$12050 14074 1934 1140 14073 1147 1143 719 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $12052 m0 *1 189.28,267.12
X$12052 14074 14073 2043 1992 980 719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12054 m0 *1 207.76,267.12
X$12054 14074 14073 1993 1994 1144 719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12056 m0 *1 1131.76,267.12
X$12056 14074 14073 2022 1581 720 1969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12059 m0 *1 1131.2,297.36
X$12059 14074 14073 2314 2063 720 2185 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12061 r0 *1 1119.44,539.28
X$12061 14074 14073 5363 4503 720 5234 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12063 r0 *1 1102.64,186.48
X$12063 14074 14073 1168 806 720 1169 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12066 m0 *1 1128.4,357.84
X$12066 14074 14073 3061 2299 720 3179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12068 r0 *1 619.92,378
X$12068 14074 14073 3332 3036 720 3282 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12070 r0 *1 1010.8,599.76
X$12070 14074 14073 6092 4295 720 6091 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12072 m0 *1 939.12,609.84
X$12072 14074 14073 6288 4163 720 6086 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12074 r0 *1 704.48,559.44
X$12074 14074 14073 5587 3544 720 5225 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12076 r0 *1 636.72,549.36
X$12076 14074 14073 5508 3663 720 5356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12078 m0 *1 790.16,246.96
X$12078 14074 14073 1774 1220 720 1645 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12080 r0 *1 889.84,277.2
X$12080 14074 14073 2137 1420 720 2116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12082 m0 *1 887.6,367.92
X$12082 14074 14073 3143 2984 720 3051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12084 r0 *1 876.96,599.76
X$12084 14074 14073 6081 4317 720 6080 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12086 m0 *1 1023.12,347.76
X$12086 14074 14073 2928 2929 720 2989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12089 r0 *1 1136.8,428.4
X$12089 14074 14073 3800 3739 720 3801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12092 m0 *1 770.56,609.84
X$12092 14074 14073 6109 5615 720 5915 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12094 r0 *1 833.28,297.36
X$12094 14074 14073 2391 2229 720 2365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12096 r0 *1 700,297.36
X$12096 14074 14073 2397 2221 720 2455 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12143 m0 *1 600.88,257.04
X$12143 14074 14073 1878 720 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12167 r0 *1 1045.52,226.8
X$12167 14074 1653 14073 774 1664 725 1654 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $12182 r0 *1 471.52,136.08
X$12182 14074 729 739 14073 781 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12223 m0 *1 516.88,156.24
X$12223 14074 739 874 14073 783 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12229 m0 *1 563.36,176.4
X$12229 14074 14073 1130 739 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12241 m0 *1 938,710.64
X$12241 14074 7719 741 7635 7643 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $12244 r0 *1 561.68,710.64
X$12244 14074 741 7726 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $12261 m0 *1 608.72,176.4
X$12261 14074 14073 745 1101 1159 1135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12272 r0 *1 1068.48,468.72
X$12272 14074 14073 4306 4224 748 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12274 m0 *1 722.4,297.36
X$12274 14074 14073 2333 2172 748 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12277 r0 *1 929.6,529.2
X$12277 14074 14073 5182 4841 748 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12279 m0 *1 1065.68,156.24
X$12279 14074 14073 809 810 748 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12281 r0 *1 995.68,498.96
X$12281 14074 14073 4707 4765 748 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12283 m0 *1 971.04,458.64
X$12283 14074 14073 4104 3940 748 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12285 r0 *1 899.36,448.56
X$12285 14074 14073 4129 4103 748 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12287 r0 *1 1040.48,246.96
X$12287 14074 14073 1845 1784 748 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12290 m0 *1 1070.16,519.12
X$12290 14074 14073 4944 4945 748 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12295 r0 *1 681.52,438.48
X$12295 14074 14073 4059 3929 748 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12297 r0 *1 837.76,539.28
X$12297 14074 14073 5080 5081 748 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12302 r0 *1 799.12,509.04
X$12302 14074 14073 4880 4937 748 4571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12304 m0 *1 647.92,458.64
X$12304 14074 14073 4100 4006 748 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12309 r0 *1 977.76,337.68
X$12309 14074 14073 2832 2704 748 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12311 r0 *1 557.76,418.32
X$12311 14074 14073 3656 3657 748 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12313 r0 *1 787.92,287.28
X$12313 14074 14073 2268 2267 748 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12315 r0 *1 912.8,226.8
X$12315 14074 14073 1669 1474 748 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12318 r0 *1 1070.16,327.6
X$12318 14074 14073 2788 2510 748 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12320 m0 *1 560,257.04
X$12320 14074 14073 1926 1879 748 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12387 m0 *1 538.16,347.76
X$12387 14074 14073 1037 748 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12432 m0 *1 888.16,226.8
X$12432 14074 1746 895 1476 1525 756 1474 1475 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $12448 m0 *1 903.28,186.48
X$12448 14074 14073 760 1181 886 1241 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12477 m0 *1 942.48,740.88
X$12477 14074 7827 14073 8151 7551 766 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $12479 m0 *1 945.84,730.8
X$12479 14074 766 8090 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $12481 r0 *1 958.16,388.08
X$12481 14074 14073 3438 2702 767 3424 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12485 r0 *1 1047.2,398.16
X$12485 14074 14073 4017 3556 767 3232 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12487 m0 *1 875.84,307.44
X$12487 14074 14073 2501 1962 767 2447 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12504 m0 *1 1000.72,257.04
X$12504 14074 14073 3125 1898 767 1913 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12506 r0 *1 1067.36,196.56
X$12506 14074 14073 1376 1173 767 1330 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12509 m0 *1 1046.08,196.56
X$12509 14074 14073 1337 1336 767 775 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12512 r0 *1 1058.96,317.52
X$12512 14074 14073 2628 2629 767 2637 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $12515 r0 *1 656.88,287.28
X$12515 14074 14073 2171 767 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12528 m0 *1 1080.24,166.32
X$12528 14074 14073 811 806 770 812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12531 m0 *1 1052.24,236.88
X$12531 14074 14073 1724 1581 770 1786 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12535 r0 *1 1081.92,297.36
X$12535 14074 14073 2369 2063 770 2370 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12540 r0 *1 799.68,287.28
X$12540 14074 14073 2230 2229 770 2297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12544 m0 *1 911.12,216.72
X$12544 14074 14073 1526 1477 770 1475 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12571 m0 *1 729.68,307.44
X$12571 14074 14073 2454 1220 770 2227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12603 r0 *1 1109.92,468.72
X$12603 14074 14073 4426 3739 777 4228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12605 m0 *1 1109.92,226.8
X$12605 14074 14073 1586 1581 777 1587 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12607 r0 *1 1023.12,398.16
X$12607 14074 14073 3502 2929 777 3175 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12609 m0 *1 1102.64,488.88
X$12609 14074 14073 4583 4503 777 4584 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12612 r0 *1 1102.08,176.4
X$12612 14074 14073 1065 806 777 1115 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12615 m0 *1 832.72,327.6
X$12615 14074 14073 2698 2229 777 2563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12617 r0 *1 907.76,267.12
X$12617 14074 14073 2077 1420 777 2177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12619 r0 *1 709.52,347.76
X$12619 14074 14073 2976 2221 777 2693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12623 r0 *1 860.16,398.16
X$12623 14074 14073 3485 2984 777 3361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12625 m0 *1 1110.48,408.24
X$12625 14074 14073 3555 2299 777 3429 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12627 m0 *1 790.16,196.56
X$12627 14074 14073 1345 1220 777 1270 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12647 m0 *1 1112.16,327.6
X$12647 14074 14073 2785 2063 777 2708 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12650 m0 *1 810.88,277.2
X$12650 14074 14073 2054 777 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12664 m0 *1 941.92,720.72
X$12664 14074 780 7809 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $12667 r0 *1 1039.36,720.72
X$12667 14073 780 7635 14074 7907 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12675 r0 *1 851.76,700.56
X$12675 14073 7551 782 7647 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $12677 r0 *1 840,700.56
X$12677 14074 14073 782 7540 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12693 r0 *1 566.16,700.56
X$12693 14074 784 7669 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $12695 m0 *1 568.4,700.56
X$12695 14074 14073 784 7572 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12739 r0 *1 512.96,156.24
X$12739 14074 14073 793 873 828 1022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12752 r0 *1 667.52,257.04
X$12752 14074 1950 1951 2492 796 14073 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $12754 r0 *1 681.52,257.04
X$12754 1951 796 1950 14074 14073 1986 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $12779 m0 *1 656.32,267.12
X$12779 14074 14073 2011 798 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12826 m0 *1 1160.32,166.32
X$12826 14074 14073 956 806 955 954 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12835 r0 *1 1099.84,216.72
X$12835 14074 14073 1377 806 1418 1230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12838 r0 *1 1108.24,216.72
X$12838 14074 14073 1533 806 1532 1321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12841 m0 *1 1088.08,216.72
X$12841 14074 14073 1485 806 1585 1274 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12843 m0 *1 1169.84,216.72
X$12843 14074 14073 1325 806 1481 1323 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12851 r0 *1 1011.92,156.24
X$12851 14074 14073 894 806 896 808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12853 r0 *1 1135.68,146.16
X$12853 14074 14073 852 806 848 849 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12884 r0 *1 1029.28,166.32
X$12884 14074 14073 945 898 1049 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12887 r0 *1 1047.2,216.72
X$12887 14074 14073 1536 1429 1651 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12890 r0 *1 1038.8,216.72
X$12890 14074 14073 1428 1375 1522 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12896 r0 *1 1168.16,206.64
X$12896 14074 14073 1433 1324 1432 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12900 r0 *1 1060.64,216.72
X$12900 14074 14073 1535 1430 1583 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12903 m0 *1 1027.6,146.16
X$12903 14074 14073 847 807 887 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12905 m0 *1 1085.84,226.8
X$12905 14074 14073 1593 1273 1711 806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12909 r0 *1 998.48,660.24
X$12909 14074 6985 806 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $12912 r0 *1 1043.28,156.24
X$12912 14074 14073 902 807 895 898 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $12926 m0 *1 1022,166.32
X$12926 14073 895 808 14074 897 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $12971 r0 *1 561.68,166.32
X$12971 14074 14073 819 1079 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $12975 r0 *1 1025.92,529.2
X$12975 14073 5177 14074 5174 5156 820 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12977 r0 *1 1046.64,448.56
X$12977 14073 4018 14074 4114 4115 820 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $12979 r0 *1 665.28,206.64
X$12979 14074 820 1414 14073 1450 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12981 m0 *1 436.8,196.56
X$12981 14074 820 1213 14073 1307 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $12986 r0 *1 840,589.68
X$12986 820 14074 5013 5099 14073 6028 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $12988 r0 *1 725.2,519.12
X$12988 14074 4935 5041 4698 820 5100 3667 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $12990 r0 *1 590.24,297.36
X$12990 14074 14073 2355 820 2396 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $12992 r0 *1 614.32,428.4
X$12992 820 1318 3280 3765 14073 14074 3894 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $12996 m0 *1 623.84,438.48
X$12996 3927 14073 14074 3726 820 3785 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $12998 m0 *1 746.48,549.36
X$12998 14074 14073 5687 820 5149 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $13001 m0 *1 850.08,357.84
X$13001 14073 3006 14074 2978 2982 820 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $13007 r0 *1 757.68,277.2
X$13007 14074 820 2174 14073 2189 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13089 r0 *1 691.04,388.08
X$13089 14074 14073 820 1081 1318 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13091 r0 *1 667.52,539.28
X$13091 14074 5311 5358 820 4933 5222 3667 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $13093 m0 *1 642.32,690.48
X$13093 14074 14073 820 7449 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13095 r0 *1 1049.44,347.76
X$13095 14073 820 1318 14074 1654 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13098 m0 *1 828.24,599.76
X$13098 14073 6030 14074 6296 6003 820 5917 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $13100 r0 *1 462.56,599.76
X$13100 820 14073 5674 5740 14074 5991 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $13106 m0 *1 374.08,670.32
X$13106 14074 7012 820 5341 7018 5533 6776 6942 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $13108 m0 *1 440.16,408.24
X$13108 14074 820 3478 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $13112 m0 *1 672,337.68
X$13112 14074 2824 3787 2768 820 2656 1081 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $13115 m0 *1 623.28,297.36
X$13115 14074 2336 2490 2165 820 1981 1081 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $13118 r0 *1 421.68,378
X$13118 14074 14073 3277 3325 2320 820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13155 r0 *1 105.84,216.72
X$13155 826 14073 14074 1551 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $13162 m0 *1 381.92,186.48
X$13162 14074 14073 1154 1153 828 1180 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13166 r0 *1 389.76,267.12
X$13166 14074 14073 2050 2086 828 2029 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13178 m0 *1 502.88,277.2
X$13178 14074 14073 828 2109 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13181 m0 *1 523.6,277.2
X$13181 14074 14073 2053 828 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13186 m0 *1 371.28,206.64
X$13186 14074 14073 1390 1409 1037 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13189 m0 *1 400.96,206.64
X$13189 14074 14073 1392 830 878 1306 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13199 m0 *1 367.36,196.56
X$13199 14074 14073 1284 830 870 1210 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13266 m0 *1 365.12,186.48
X$13266 14074 14073 1178 1152 887 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13270 m0 *1 376.88,176.4
X$13270 14074 14073 1071 1038 834 830 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13275 m0 *1 549.36,509.04
X$13275 14074 5316 830 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $13307 r0 *1 381.36,257.04
X$13307 14074 14073 1978 1940 834 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13309 r0 *1 489.44,367.92
X$13309 14074 14073 3196 3112 834 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13311 r0 *1 506.24,367.92
X$13311 14074 3033 3172 14073 834 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $13313 r0 *1 562.8,327.6
X$13313 14074 14073 2765 2292 834 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13330 m0 *1 588.56,357.84
X$13330 14074 14073 834 1049 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13343 m0 *1 912.24,710.64
X$13343 14074 838 7632 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $13345 r0 *1 913.36,710.64
X$13345 14074 14073 838 7716 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13362 r0 *1 892.64,166.32
X$13362 14074 14073 888 1075 843 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $13364 r0 *1 988.4,186.48
X$13364 14074 14073 1237 1111 844 1227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13372 m0 *1 990.08,156.24
X$13372 14074 14073 895 844 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13375 r0 *1 999.6,186.48
X$13375 14073 844 1167 14074 1239 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $13388 m0 *1 999.04,176.4
X$13388 14074 14073 1112 944 1060 846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13393 r0 *1 923.44,378
X$13393 14074 14073 3244 2984 848 3141 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13395 m0 *1 1135.68,488.88
X$13395 14074 14073 4585 4503 848 4586 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13398 r0 *1 1154.72,216.72
X$13398 14074 14073 1590 1581 848 1592 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13400 m0 *1 1151.36,357.84
X$13400 14074 14073 3063 2299 848 3064 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13402 m0 *1 1156.4,337.68
X$13402 14074 14073 2710 2063 848 2633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13408 m0 *1 1152.48,448.56
X$13408 14074 14073 4029 3739 848 3861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13410 r0 *1 883.12,327.6
X$13410 14074 14073 2699 1477 848 2621 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13412 m0 *1 1064.56,347.76
X$13412 14074 14073 2931 2929 848 2992 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13414 m0 *1 847.84,378
X$13414 14074 14073 3085 2229 848 3049 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13501 m0 *1 207.76,196.56
X$13501 14074 1348 1140 14073 1147 1143 865 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $13504 r0 *1 216.72,156.24
X$13504 14074 14073 917 918 866 865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13508 r0 *1 216.16,166.32
X$13508 14074 14073 1029 918 980 865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13512 m0 *1 217.84,196.56
X$13512 14074 1434 1140 14073 1147 1144 865 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $13514 r0 *1 217.84,196.56
X$13514 14074 14073 1300 1301 1144 865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13516 m0 *1 336,176.4
X$13516 14074 14073 1097 1035 866 958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13518 m0 *1 340.48,166.32
X$13518 14074 14073 1016 926 866 987 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13520 m0 *1 115.92,196.56
X$13520 14074 14073 1193 1194 866 1246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13523 r0 *1 122.64,166.32
X$13523 14074 14073 1026 1027 866 975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13525 m0 *1 118.72,206.64
X$13525 14074 14073 1380 1397 866 1293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13527 m0 *1 110.32,257.04
X$13527 14074 14073 1930 1755 866 1756 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13529 m0 *1 111.44,236.88
X$13529 14074 14073 1686 1687 866 1688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13531 m0 *1 120.4,267.12
X$13531 14074 14073 1988 1990 866 1989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13533 m0 *1 192.08,236.88
X$13533 14074 14073 1662 1614 866 1559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13535 m0 *1 259.28,267.12
X$13535 14074 14073 2076 1995 866 1695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13537 m0 *1 229.6,317.52
X$13537 14074 14073 2578 2539 866 2540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13543 r0 *1 246.96,226.8
X$13543 14074 14073 1620 1621 866 1622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13545 r0 *1 190.4,297.36
X$13545 14074 14073 2347 2348 866 2259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13548 m0 *1 234.64,347.76
X$13548 14074 14073 2885 2855 866 919 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13550 m0 *1 131.04,347.76
X$13550 14074 14073 2933 2904 866 2852 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13553 m0 *1 131.04,357.84
X$13553 14074 14073 3069 2954 866 2951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13555 r0 *1 258.16,156.24
X$13555 14074 14073 920 921 866 922 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13558 m0 *1 119.84,287.28
X$13558 14074 14073 2253 2142 866 2038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13560 m0 *1 282.24,166.32
X$13560 14074 14073 923 924 866 957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13564 m0 *1 241.36,176.4
X$13564 14074 14073 1093 1094 866 1030 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13566 m0 *1 191.52,166.32
X$13566 14074 14073 976 977 866 978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13570 r0 *1 341.6,216.72
X$13570 14074 14073 1539 1540 866 1564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13573 m0 *1 338.8,257.04
X$13573 14074 14073 1977 1938 866 1868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13575 m0 *1 305.76,226.8
X$13575 14074 14073 1596 1561 866 925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13577 m0 *1 307.44,166.32
X$13577 14074 14073 984 985 866 986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13612 m0 *1 208.32,357.84
X$13612 14074 14073 2998 866 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13614 m0 *1 117.04,226.8
X$13614 14074 14073 1550 1552 866 1551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13617 m0 *1 122.64,307.44
X$13617 14074 14073 2405 2407 866 2406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13620 r0 *1 125.44,327.6
X$13620 14074 14073 2744 2745 866 2600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13628 m0 *1 493.36,196.56
X$13628 14074 14073 867 14143 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $13706 m0 *1 600.32,408.24
X$13706 14074 14073 3566 3036 870 3542 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13709 r0 *1 370.72,246.96
X$13709 14074 14073 1869 1699 870 1939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13711 r0 *1 542.64,357.84
X$13711 14074 14073 3090 2221 870 2973 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13744 m0 *1 651.28,418.32
X$13744 14074 14073 3662 3663 870 3664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13746 m0 *1 544.88,277.2
X$13746 14074 14073 2110 1218 870 2055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13749 m0 *1 733.04,206.64
X$13749 14074 14073 870 896 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13751 m0 *1 482.72,388.08
X$13751 14074 14073 2868 3033 870 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $13754 r0 *1 735.28,347.76
X$13754 14074 14073 870 2305 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13782 r0 *1 442.96,257.04
X$13782 14074 14073 872 1599 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13785 m0 *1 446.88,317.52
X$13785 14074 2294 872 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $13812 m0 *1 669.76,418.32
X$13812 14074 14073 3666 3663 878 3727 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13814 r0 *1 608.16,408.24
X$13814 14074 14073 3597 3036 878 3659 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13818 m0 *1 400.96,287.28
X$13818 14074 14073 2265 1699 878 2104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13820 m0 *1 576.24,246.96
X$13820 14074 14073 1825 1218 878 1826 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13845 r0 *1 481.04,418.32
X$13845 14074 14073 3592 878 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $13847 r0 *1 478.8,337.68
X$13847 14074 14073 2893 2221 878 2866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13890 m0 *1 1041.04,458.64
X$13890 14074 14073 4168 4166 886 4167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13892 r0 *1 1042.72,498.96
X$13892 14074 14073 4774 4717 886 4578 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13895 m0 *1 836.08,176.4
X$13895 14074 14073 1078 889 886 1132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13898 r0 *1 997.36,398.16
X$13898 14074 14073 3557 3504 886 3503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13900 m0 *1 1027.04,156.24
X$13900 14074 14073 900 897 886 902 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13902 r0 *1 739.2,428.4
X$13902 886 14074 1684 3886 14073 3887 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13906 r0 *1 1004.64,186.48
X$13906 14074 14073 1228 1239 886 1237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13908 m0 *1 758.24,257.04
X$13908 886 14074 1684 1954 14073 1889 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $13910 r0 *1 977.76,307.44
X$13910 14074 14073 2521 2435 886 2520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13912 r0 *1 780.64,388.08
X$13912 3357 14073 14074 1684 886 3289 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $13914 m0 *1 887.6,257.04
X$13914 14074 14073 1963 1980 886 1805 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13916 m0 *1 819.84,317.52
X$13916 14074 14073 2587 2497 886 2586 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13920 m0 *1 1039.36,317.52
X$13920 14074 14073 2574 2576 886 2577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13956 m0 *1 1014.72,246.96
X$13956 14074 14073 1850 1835 886 1782 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13958 r0 *1 721.28,277.2
X$13958 14074 2219 886 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $13960 r0 *1 781.2,236.88
X$13960 14074 14073 1773 1712 886 1646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13967 m0 *1 1020.32,478.8
X$13967 14074 14073 4367 4164 887 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13969 r0 *1 1027.04,478.8
X$13969 14074 14073 4501 4502 887 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13972 m0 *1 965.44,488.88
X$13972 14074 14073 4593 4499 887 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13974 r0 *1 935.2,478.8
X$13974 14074 14073 4514 4498 887 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13977 r0 *1 1004.08,418.32
X$13977 14074 14073 3679 3551 887 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13981 r0 *1 700.56,408.24
X$13981 14074 14073 3543 3545 887 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13983 m0 *1 660.24,418.32
X$13983 14074 14073 3598 3665 887 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13987 r0 *1 869.68,468.72
X$13987 14074 14073 4383 4360 887 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13989 m0 *1 761.6,478.8
X$13989 14074 14073 4441 4423 887 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13992 r0 *1 778.96,347.76
X$13992 14074 14073 2936 2562 887 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13995 m0 *1 889.84,267.12
X$13995 14074 14073 1718 1745 887 1420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $13998 m0 *1 1025.36,327.6
X$13998 14074 14073 2713 2705 887 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14000 r0 *1 367.92,267.12
X$14000 14074 14073 2001 2002 887 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14002 r0 *1 990.08,297.36
X$14002 14074 14073 2317 2238 887 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14006 m0 *1 866.32,448.56
X$14006 14074 14073 3853 3793 887 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14008 r0 *1 483.84,378
X$14008 14074 14073 3326 3032 887 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14012 m0 *1 547.12,297.36
X$14012 14074 14073 2329 2111 887 1218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14014 r0 *1 736.96,327.6
X$14014 14074 14073 2799 2771 887 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14017 m0 *1 526.96,388.08
X$14017 14074 14073 3389 887 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $14084 m0 *1 1012.48,236.88
X$14084 14074 14073 1740 1723 887 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14086 m0 *1 571.76,448.56
X$14086 14074 14073 4099 3783 887 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $14099 r0 *1 816.48,156.24
X$14099 14074 14073 888 970 911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14101 m0 *1 815.36,196.56
X$14101 14074 14073 1318 888 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $14104 r0 *1 875.84,226.8
X$14104 14074 14073 888 1671 1647 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $14123 r0 *1 248.08,1013.04
X$14123 14074 892 12435 11275 12493 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14125 m0 *1 326.48,801.36
X$14125 14074 892 9048 7427 9212 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14128 r0 *1 301.28,811.44
X$14128 14074 892 9398 7427 9397 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14131 r0 *1 324.24,791.28
X$14131 14074 892 8906 7427 9049 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14134 r0 *1 264.32,1023.12
X$14134 14074 892 12575 11275 12633 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14137 m0 *1 469.28,781.2
X$14137 14074 892 8230 8365 8739 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14139 m0 *1 714,287.28
X$14139 14074 892 2172 1137 2333 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14141 m0 *1 465.92,771.12
X$14141 14074 892 7868 6424 8707 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14144 m0 *1 436.24,771.12
X$14144 14074 892 7693 6424 8613 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14146 m0 *1 318.64,791.28
X$14146 14074 892 8846 7427 9011 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14148 r0 *1 712.88,287.28
X$14148 14074 892 2225 2060 2395 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14152 r0 *1 333.2,519.12
X$14152 14074 892 5061 4203 5000 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14155 r0 *1 356.16,771.12
X$14155 14074 892 8636 7427 8702 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14159 m0 *1 350,519.12
X$14159 14074 892 4920 4203 4783 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14161 r0 *1 347.76,509.04
X$14161 14074 892 4809 4203 4876 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14163 m0 *1 324.24,781.2
X$14163 14074 892 8733 7427 8821 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14166 m0 *1 339.36,750.96
X$14166 14074 892 8361 7427 8308 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14170 m0 *1 333.76,761.04
X$14170 14074 892 8456 7427 8457 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14172 r0 *1 342.16,539.28
X$14172 14074 892 5276 4924 5306 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14175 r0 *1 324.8,750.96
X$14175 14074 892 8358 7427 8455 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14177 r0 *1 478.8,750.96
X$14177 14074 892 8227 8365 8430 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14179 m0 *1 402.08,761.04
X$14179 14074 892 8122 6424 8458 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14181 r0 *1 406,750.96
X$14181 14074 892 8032 6424 8424 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14183 m0 *1 521.92,509.04
X$14183 14074 892 4479 3652 4791 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14185 m0 *1 416.08,771.12
X$14185 14074 892 8121 6424 8553 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14187 m0 *1 366.8,750.96
X$14187 14074 892 8224 7427 8423 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14189 r0 *1 521.92,448.56
X$14189 14074 892 3975 3718 4133 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14191 r0 *1 436.24,982.8
X$14191 14074 892 12039 12036 12103 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14193 m0 *1 428.96,730.8
X$14193 14074 892 7954 6424 8091 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14196 r0 *1 501.2,468.72
X$14196 14074 892 4208 3652 4445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14199 r0 *1 570.64,448.56
X$14199 14074 892 3783 3718 4099 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14201 r0 *1 377.44,791.28
X$14201 14074 892 9051 7427 8939 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14203 m0 *1 400.96,579.6
X$14203 14074 892 5666 4924 5791 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14205 m0 *1 413.84,589.68
X$14205 14074 892 5787 4924 5959 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14207 m0 *1 361.76,781.2
X$14207 14074 892 8734 7427 8907 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14210 r0 *1 379.68,771.12
X$14210 14074 892 8638 7427 8637 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14213 m0 *1 647.36,297.36
X$14213 14074 892 2222 1137 2220 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14215 m0 *1 326.48,861.84
X$14215 14074 892 9937 9132 10122 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14217 m0 *1 437.92,609.84
X$14217 14074 892 6140 4924 6139 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14219 m0 *1 417.2,619.92
X$14219 14074 892 6138 4924 6238 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14221 m0 *1 407.12,630
X$14221 14074 892 6329 4924 6474 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14223 r0 *1 184.8,1103.76
X$14223 14074 892 13457 12994 13557 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14225 r0 *1 351.68,861.84
X$14225 14074 892 10270 9132 10123 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14228 r0 *1 173.6,1083.6
X$14228 14074 892 13266 12994 13383 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14230 r0 *1 402.08,599.76
X$14230 14074 892 5989 4924 6058 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14232 m0 *1 433.44,650.16
X$14232 14074 892 6668 4924 6699 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14235 m0 *1 431.2,599.76
X$14235 14074 892 5957 4924 5990 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14237 m0 *1 333.76,871.92
X$14237 14074 892 10031 9132 10229 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14239 m0 *1 431.76,640.08
X$14239 14074 892 6498 4924 6592 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14241 m0 *1 542.08,670.32
X$14241 14074 892 6112 6424 7022 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14243 m0 *1 533.68,660.24
X$14243 14074 892 6500 6424 6925 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14245 m0 *1 409.36,650.16
X$14245 14074 892 6698 4924 6751 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14247 m0 *1 530.88,599.76
X$14247 14074 892 5902 3652 6113 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14250 r0 *1 422.8,650.16
X$14250 14074 892 6779 4924 6778 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14253 r0 *1 396.48,660.24
X$14253 14074 892 6942 4924 6996 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14255 r0 *1 514.08,619.92
X$14255 14074 892 6337 6424 6475 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14257 r0 *1 520.8,630
X$14257 14074 892 6502 6424 6506 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14259 m0 *1 252.56,1103.76
X$14259 14074 892 13411 12994 13605 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14261 m0 *1 460.88,730.8
X$14261 14074 892 7870 6424 8098 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14263 m0 *1 275.52,1093.68
X$14263 14074 892 12942 12994 13447 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14265 r0 *1 239.12,1053.36
X$14265 14074 892 12805 12994 13170 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14268 r0 *1 542.08,670.32
X$14268 14074 892 6940 6424 7212 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14270 r0 *1 211.68,1093.68
X$14270 14074 892 13409 12994 13601 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14272 m0 *1 225.12,1093.68
X$14272 14074 892 12871 12994 13443 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14275 r0 *1 169.12,1053.36
X$14275 14074 892 12990 11275 13036 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14277 r0 *1 454.16,690.48
X$14277 14074 892 6913 6424 7326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14280 m0 *1 469.28,720.72
X$14280 14074 892 7234 6424 7842 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14282 r0 *1 275.52,1103.76
X$14282 14074 892 12728 12994 13608 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14284 r0 *1 258.16,1053.36
X$14284 14074 892 13062 12994 13040 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14287 r0 *1 192.64,1063.44
X$14287 14074 892 13061 12994 13060 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14289 m0 *1 339.36,882
X$14289 14074 892 10459 9132 10432 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14292 r0 *1 277.2,1063.44
X$14292 14074 892 13119 12994 13118 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14294 r0 *1 301.84,680.4
X$14294 14074 892 7228 7427 7389 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14296 m0 *1 316.96,700.56
X$14296 14074 892 7429 7427 7580 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14298 m0 *1 310.8,710.64
X$14298 14074 892 7516 7427 7605 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14300 r0 *1 311.92,730.8
X$14300 14074 892 8088 7427 8086 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14302 m0 *1 310.24,831.6
X$14302 14074 9541 7427 9718 892 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $14305 m0 *1 315.28,730.8
X$14305 14074 892 7948 7427 8087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14307 m0 *1 336,700.56
X$14307 14074 892 7431 6424 7428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14309 r0 *1 417.76,690.48
X$14309 14074 892 7323 6424 7322 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14312 m0 *1 340.48,831.6
X$14312 14074 892 9654 7427 9542 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14314 m0 *1 419.44,700.56
X$14314 14074 892 7519 6424 7586 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14316 m0 *1 332.08,720.72
X$14316 14074 892 7772 7427 7835 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14318 m0 *1 428.96,680.4
X$14318 14074 892 7231 6424 7120 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14320 r0 *1 436.8,589.68
X$14320 14074 892 5901 4924 5900 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14322 m0 *1 329.28,619.92
X$14322 14074 892 6233 4924 6385 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14324 m0 *1 313.04,821.52
X$14324 14074 892 9436 7427 9505 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14326 r0 *1 302.4,851.76
X$14326 14074 9936 9132 9934 892 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $14329 m0 *1 342.72,680.4
X$14329 14074 892 7116 6424 7195 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14331 m0 *1 288.96,841.68
X$14331 14074 9539 9132 9761 892 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $14333 r0 *1 515.2,589.68
X$14333 14074 892 5410 3652 5879 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14335 r0 *1 240.8,962.64
X$14335 14074 892 11712 11275 11700 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14337 m0 *1 731.92,388.08
X$14337 14074 892 3223 2871 3390 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14339 m0 *1 728.56,378
X$14339 14074 892 3195 2871 3251 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14341 r0 *1 281.12,932.4
X$14341 14074 892 11351 11275 11276 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14343 m0 *1 669.76,388.08
X$14343 14074 892 3286 2871 3449 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14345 r0 *1 669.2,378
X$14345 14074 892 3287 2871 3285 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14347 m0 *1 236.88,942.48
X$14347 14074 892 10981 10555 11350 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14349 m0 *1 112,398.16
X$14349 14074 892 3401 2536 3460 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14351 r0 *1 123.76,398.16
X$14351 14074 892 3461 2536 3462 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14354 r0 *1 243.04,902.16
X$14354 14074 892 5119 10555 10775 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14357 m0 *1 209.44,922.32
X$14357 14074 892 10980 9428 10979 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14359 r0 *1 593.6,367.92
X$14359 14074 892 3117 2871 3158 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14362 r0 *1 613.76,337.68
X$14362 14074 892 2738 1943 2892 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14364 r0 *1 278.32,529.2
X$14364 14074 892 4961 4203 5176 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14366 r0 *1 618.8,327.6
X$14366 14074 892 2660 1943 2659 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14369 m0 *1 607.04,327.6
X$14369 14074 892 2554 1943 2553 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14372 m0 *1 629.44,367.92
X$14372 14074 892 3118 2871 3038 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14374 m0 *1 612.64,337.68
X$14374 14074 892 2552 1943 2658 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14376 r0 *1 645.12,367.92
X$14376 14074 892 3040 2871 3039 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14379 r0 *1 604.8,357.84
X$14379 14074 892 3037 2871 3035 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14382 m0 *1 706.72,337.68
X$14382 14074 892 2695 2060 2735 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14385 m0 *1 729.12,337.68
X$14385 14074 892 2771 2060 2799 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14387 r0 *1 724.08,367.92
X$14387 14074 892 3152 2871 3121 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14390 r0 *1 646.8,297.36
X$14390 14074 892 2422 1137 2358 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14392 r0 *1 639.52,317.52
X$14392 14074 892 2556 1943 2555 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14394 r0 *1 585.76,438.48
X$14394 14074 892 3723 2871 3925 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14396 r0 *1 600.88,378
X$14396 14074 892 3331 2871 3394 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14398 m0 *1 604.24,418.32
X$14398 14074 892 3659 2871 3597 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14401 r0 *1 248.64,932.4
X$14401 14074 892 11273 10555 11331 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14403 r0 *1 120.4,569.52
X$14403 14074 5526 892 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $14405 m0 *1 259.84,942.48
X$14405 14074 892 11274 10555 11405 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14408 r0 *1 273.84,942.48
X$14408 14074 892 11424 11275 11492 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14410 r0 *1 604.8,438.48
X$14410 14074 892 3841 3718 3981 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14412 r0 *1 281.12,458.64
X$14412 14074 892 4201 4203 4240 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14414 r0 *1 262.08,458.64
X$14414 14074 892 4202 4203 4309 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14416 m0 *1 636.72,398.16
X$14416 14074 892 3353 2871 3417 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14418 r0 *1 642.32,398.16
X$14418 14074 892 3352 2871 3564 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14420 m0 *1 632.24,378
X$14420 14074 892 3252 2871 3222 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14423 m0 *1 613.2,378
X$14423 14074 892 3282 2871 3332 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14425 m0 *1 140.56,408.24
X$14425 14074 892 3615 2536 3530 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14427 r0 *1 241.36,841.68
X$14427 14074 892 9833 9132 9756 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14429 m0 *1 168.56,418.32
X$14429 14074 892 3465 3578 3688 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14431 r0 *1 157.36,408.24
X$14431 14074 892 3574 2536 3614 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14434 r0 *1 142.24,388.08
X$14434 14074 892 3403 2536 3496 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14436 r0 *1 179.2,398.16
X$14436 14074 892 3467 2536 3466 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14438 m0 *1 259.84,841.68
X$14438 14074 892 9759 9132 9757 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14441 r0 *1 255.36,831.6
X$14441 14074 892 9648 9132 9714 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14443 m0 *1 281.68,892.08
X$14443 14074 892 10556 9132 10623 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14445 m0 *1 266,902.16
X$14445 14074 892 10778 10555 10777 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14448 m0 *1 254.24,912.24
X$14448 14074 892 10982 10555 10941 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14450 r0 *1 589.68,448.56
X$14450 14074 892 3926 3718 4003 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14452 r0 *1 182,438.48
X$14452 14074 892 3908 2762 4033 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14454 r0 *1 186.48,408.24
X$14454 14074 892 3576 2536 3575 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14457 r0 *1 173.04,428.4
X$14457 14074 892 3830 2762 3871 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14459 m0 *1 269.92,861.84
X$14459 14074 10118 9132 10223 892 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $14461 r0 *1 281.12,871.92
X$14461 14074 892 10268 9132 10526 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14463 m0 *1 416.08,1033.2
X$14463 14074 892 12582 12438 12660 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14466 m0 *1 310.8,932.4
X$14466 14074 892 10985 8365 11245 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14468 m0 *1 829.92,337.68
X$14468 14074 892 2563 2796 2698 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14470 m0 *1 285.04,912.24
X$14470 14074 892 10779 9132 10879 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14472 r0 *1 793.52,297.36
X$14472 14074 892 2364 2060 2363 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14475 r0 *1 395.36,992.88
X$14475 14074 892 12211 12036 12338 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14478 m0 *1 779.52,307.44
X$14478 14074 892 2361 2060 2394 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14480 r0 *1 826,337.68
X$14480 14074 892 2499 2796 2887 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14482 m0 *1 842.24,327.6
X$14482 14074 892 2564 2060 2652 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14484 r0 *1 371.28,1023.12
X$14484 14074 892 12522 12438 12577 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14487 m0 *1 292.32,942.48
X$14487 14074 892 10983 11275 11406 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14490 r0 *1 767.76,226.8
X$14490 14074 892 1644 1046 1643 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14492 r0 *1 837.76,357.84
X$14492 14074 892 3049 2796 3085 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14494 r0 *1 306.32,942.48
X$14494 14074 892 11353 11275 11494 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14496 m0 *1 836.08,367.92
X$14496 14074 892 3124 2796 3123 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14498 m0 *1 804.72,357.84
X$14498 14074 892 2979 2796 3008 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14500 r0 *1 804.72,357.84
X$14500 14074 892 3122 2796 3047 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14502 r0 *1 387.52,1083.6
X$14502 14074 892 13310 12438 13359 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14505 m0 *1 775.6,337.68
X$14505 14074 892 2654 2796 2826 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14508 m0 *1 799.68,388.08
X$14508 14074 892 3227 2796 3358 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14511 r0 *1 775.6,378
X$14511 14074 892 3224 2796 3226 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14513 r0 *1 769.44,357.84
X$14513 14074 892 3044 2060 3148 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14516 r0 *1 771.68,216.72
X$14516 14074 892 1519 1046 1604 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14518 m0 *1 277.76,972.72
X$14518 14074 892 11793 11275 11771 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14520 m0 *1 361.76,1063.44
X$14520 14074 892 12947 12438 13103 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14522 m0 *1 778.96,206.64
X$14522 14074 892 1391 1046 1444 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14525 m0 *1 371.28,1103.76
X$14525 14074 892 13576 12438 13653 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14527 m0 *1 554.4,418.32
X$14527 14074 892 3657 2871 3656 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14529 m0 *1 738.08,307.44
X$14529 14074 892 2227 2060 2454 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14532 r0 *1 379.12,1043.28
X$14532 14074 892 12879 12438 12733 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14534 m0 *1 773.36,347.76
X$14534 14074 892 2562 2060 2936 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14536 r0 *1 773.36,337.68
X$14536 14074 892 2773 2060 2797 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14538 r0 *1 789.6,236.88
X$14538 14074 892 1645 1046 1774 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14540 r0 *1 750.4,357.84
X$14540 14074 892 3043 2060 3149 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14543 m0 *1 737.52,367.92
X$14543 14074 892 3042 2060 3041 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14546 r0 *1 340.48,912.24
X$14546 14074 892 10986 8365 11057 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14549 r0 *1 820.96,287.28
X$14549 14074 892 2232 2060 2231 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14551 m0 *1 819.84,297.36
X$14551 14074 892 2298 2060 2392 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14553 r0 *1 354.48,1002.96
X$14553 14074 892 12278 11275 12254 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14555 m0 *1 854,226.8
X$14555 14074 892 1578 1225 1673 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14557 m0 *1 305.76,1033.2
X$14557 14074 892 12654 11275 12653 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14560 m0 *1 779.52,297.36
X$14560 14074 892 2267 2060 2268 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14562 r0 *1 906.08,246.96
X$14562 14074 892 1777 1423 1855 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14564 m0 *1 852.32,267.12
X$14564 14074 892 1961 1225 2082 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14566 m0 *1 847.28,277.2
X$14566 14074 892 1960 1225 2061 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14568 m0 *1 799.68,297.36
X$14568 14074 892 2297 2060 2230 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14570 m0 *1 809.76,236.88
X$14570 14074 892 1577 1225 1751 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14573 r0 *1 301.28,982.8
X$14573 14074 892 11871 11275 12097 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14575 m0 *1 830.48,236.88
X$14575 14074 892 1715 1225 1714 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14577 r0 *1 848.4,226.8
X$14577 14074 892 1649 1225 1672 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14579 r0 *1 825.44,257.04
X$14579 14074 892 1958 1225 1982 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14581 m0 *1 833.28,246.96
X$14581 14074 892 1776 1225 1775 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14583 m0 *1 823.2,267.12
X$14583 14074 892 1959 1225 2085 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14585 m0 *1 299.6,1002.96
X$14585 14074 892 12275 11275 12250 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14587 r0 *1 320.32,1013.04
X$14587 14074 892 12359 11275 12436 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14589 r0 *1 347.2,932.4
X$14589 14074 892 11280 8365 11410 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14592 r0 *1 848.4,307.44
X$14592 14074 892 2500 2060 2584 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14594 m0 *1 911.12,226.8
X$14594 14074 892 1474 1423 1669 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14597 m0 *1 813.68,307.44
X$14597 14074 892 2431 2060 2430 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14599 r0 *1 738.08,287.28
X$14599 14074 892 2228 2060 2226 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14601 r0 *1 841.68,297.36
X$14601 14074 892 2365 2060 2391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14603 m0 *1 888.16,236.88
X$14603 14074 892 1745 1225 1718 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14605 m0 *1 330.96,952.56
X$14605 14074 892 10662 8365 11584 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14607 m0 *1 329.84,942.48
X$14607 14074 892 11279 8365 11354 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14609 m0 *1 408.24,992.88
X$14609 14074 892 12034 12036 12258 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14612 r0 *1 334.88,1033.2
X$14612 14074 892 12662 11275 12732 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14614 m0 *1 896,257.04
X$14614 14074 892 1964 1225 1894 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14616 m0 *1 325.92,962.64
X$14616 14074 892 10661 11275 11597 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14618 r0 *1 346.08,1023.12
X$14618 14074 892 12434 11275 12713 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14621 m0 *1 907.2,236.88
X$14621 14074 892 1475 1225 1526 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14623 m0 *1 202.16,1033.2
X$14623 14074 892 12650 11275 12709 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14625 r0 *1 180.32,1033.2
X$14625 14074 892 12723 11275 12708 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14627 m0 *1 459.76,347.76
X$14627 14074 892 2918 2762 2944 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14629 r0 *1 459.76,337.68
X$14629 14074 892 2866 2762 2893 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14631 r0 *1 360.08,942.48
X$14631 14074 892 5579 8365 11428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14633 r0 *1 455.84,357.84
X$14633 14074 892 2970 2762 3087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14635 m0 *1 459.2,367.92
X$14635 14074 892 2971 2762 3111 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14638 r0 *1 730.8,317.52
X$14638 14074 892 2493 2060 2524 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14640 r0 *1 875.28,216.72
X$14640 14074 892 1525 1225 1523 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14643 m0 *1 333.76,1083.6
X$14643 14074 892 13066 12438 13344 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14646 r0 *1 464.8,378
X$14646 14074 892 3032 2762 3326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14648 r0 *1 357.28,1083.6
X$14648 14074 892 13311 12438 13400 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14650 r0 *1 344.4,1093.68
X$14650 14074 892 13353 12438 13467 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14652 m0 *1 482.72,367.92
X$14652 14074 892 3112 2762 3196 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14655 m0 *1 358.96,962.64
X$14655 14074 892 11427 8365 11775 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14657 r0 *1 672,367.92
X$14657 14074 892 3120 2871 3119 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14659 m0 *1 540.4,357.84
X$14659 14074 892 2973 1943 3090 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14661 m0 *1 670.88,347.76
X$14661 14074 892 2558 2871 2872 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14663 r0 *1 672,337.68
X$14663 14074 892 2559 2871 2557 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14665 m0 *1 562.24,367.92
X$14665 14074 892 3116 1943 3115 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14667 r0 *1 566.16,367.92
X$14667 14074 892 3220 2871 3253 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14670 m0 *1 702.24,347.76
X$14670 14074 892 2736 2060 2694 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14673 m0 *1 703.36,357.84
X$14673 14074 892 2770 2060 3011 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14675 r0 *1 703.36,357.84
X$14675 14074 892 2693 2060 2976 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14677 r0 *1 679.84,307.44
X$14677 14074 892 2455 1137 2397 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14679 r0 *1 658,307.44
X$14679 14074 892 2423 1137 2491 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14682 m0 *1 729.12,327.6
X$14682 14074 892 2696 2060 2734 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14684 m0 *1 686.56,307.44
X$14684 14074 892 2425 2060 2457 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14687 m0 *1 241.92,982.8
X$14687 14074 892 11950 11275 11949 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14689 r0 *1 308.56,488.88
X$14689 14074 892 4611 4203 4594 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14691 m0 *1 299.04,478.8
X$14691 14074 892 4403 4203 4440 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14693 m0 *1 481.6,438.48
X$14693 14074 892 3918 3718 4053 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14696 r0 *1 903.28,216.72
X$14696 14074 892 1476 1225 1421 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14699 m0 *1 339.92,1073.52
X$14699 14074 892 13067 12438 13189 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14701 m0 *1 533.12,428.4
X$14701 14074 892 3780 3718 3818 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14703 m0 *1 578.48,408.24
X$14703 14074 892 3542 2871 3566 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14705 m0 *1 547.12,388.08
X$14705 14074 892 3218 1943 3391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14707 m0 *1 550.48,408.24
X$14707 14074 892 3595 2871 3634 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14709 m0 *1 246.4,972.72
X$14709 14074 892 11791 11275 11842 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14712 r0 *1 500.64,438.48
X$14712 14074 892 3920 3718 4002 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14715 r0 *1 503.44,428.4
X$14715 14074 892 3840 3718 3889 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14717 r0 *1 544.32,378
X$14717 14074 892 3219 1943 3278 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14719 m0 *1 754.88,398.16
X$14719 14074 892 3225 2871 3418 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14721 r0 *1 520.8,438.48
X$14721 14074 892 3921 3718 4057 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14724 r0 *1 515.2,418.32
X$14724 14074 892 3762 3718 3761 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14726 r0 *1 814.24,388.08
X$14726 14074 892 3228 2796 3445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14728 m0 *1 824.32,388.08
X$14728 14074 892 3291 2796 3388 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14731 r0 *1 301.28,1083.6
X$14731 14074 892 12808 12438 13393 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14734 m0 *1 801.36,398.16
X$14734 14074 892 3229 2796 3515 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14737 m0 *1 278.32,982.8
X$14737 14074 892 11953 11275 12003 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14739 r0 *1 787.92,196.56
X$14739 14074 892 1270 1046 1345 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $14741 m0 *1 302.96,1053.36
X$14741 14074 892 12880 12438 12917 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $15128 m0 *1 225.12,388.08
X$15128 14074 892 3339 2536 3270 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $15130 r0 *1 234.64,519.12
X$15130 14074 892 4995 4203 4914 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $15133 r0 *1 539.84,468.72
X$15133 14074 892 4281 3652 4391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* cell instance $15149 m0 *1 828.24,317.52
X$15149 14074 2586 1601 2564 2232 895 2298 2563 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15151 r0 *1 899.36,236.88
X$15151 14074 14073 1805 1745 895 1777 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15153 r0 *1 1019.76,236.88
X$15153 14074 14073 1782 1723 895 1783 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15156 r0 *1 1015.84,246.96
X$15156 14073 895 1836 14074 1835 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15192 m0 *1 901.6,297.36
X$15192 14074 2385 895 2118 2062 2368 2177 2237 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15201 r0 *1 1060.08,156.24
X$15201 14074 14073 895 950 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15207 r0 *1 899.36,327.6
X$15207 14074 2433 895 2726 2619 2368 2620 2775 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15209 r0 *1 899.36,317.52
X$15209 14074 2446 895 2623 2622 2368 2621 2502 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15211 r0 *1 804.72,327.6
X$15211 14074 2421 895 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $15213 r0 *1 828.8,307.44
X$15213 14074 2497 1601 2500 2365 895 2431 2499 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15215 m0 *1 844.48,257.04
X$15215 14074 1920 895 1961 1959 1891 1958 1960 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15217 r0 *1 882.56,257.04
X$15217 14073 895 1964 14074 1980 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15220 r0 *1 849.52,236.88
X$15220 14074 1806 895 1649 1776 1891 1715 1578 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $15226 r0 *1 719.04,398.16
X$15226 14074 14073 3517 3544 896 3484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15232 r0 *1 777.84,327.6
X$15232 14074 14073 2797 2229 896 2773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15235 r0 *1 728.56,327.6
X$15235 14074 14073 2734 1220 896 2696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15261 r0 *1 899.36,257.04
X$15261 14074 14073 1894 1579 896 1964 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15346 r0 *1 110.88,166.32
X$15346 916 14073 14074 975 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $15352 m0 *1 209.44,166.32
X$15352 14074 918 979 917 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15365 r0 *1 243.04,337.68
X$15365 14074 14073 2856 2855 980 919 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15368 m0 *1 250.88,357.84
X$15368 14074 14073 919 2962 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $15371 m0 *1 240.24,357.84
X$15371 14073 919 2677 14074 3072 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $15375 r0 *1 252,166.32
X$15375 14074 921 979 920 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15378 m0 *1 258.16,166.32
X$15378 14074 14073 981 921 980 922 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15384 m0 *1 260.4,186.48
X$15384 14074 14073 1146 1095 1147 922 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15387 r0 *1 262.08,186.48
X$15387 14074 14073 1202 1203 1144 922 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15396 r0 *1 281.12,156.24
X$15396 14074 924 983 923 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15398 r0 *1 283.36,166.32
X$15398 14074 14073 1031 924 980 957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15405 m0 *1 302.4,257.04
X$15405 14074 14073 1937 1866 1144 925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15411 r0 *1 301.28,226.8
X$15411 14074 14073 1667 1561 980 925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15413 r0 *1 301.28,236.88
X$15413 14074 14073 1760 1626 1147 925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15415 m0 *1 323.68,166.32
X$15415 14074 926 983 1016 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15418 r0 *1 339.36,166.32
X$15418 14074 14073 1036 926 980 987 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15450 m0 *1 948.64,478.8
X$15450 14074 931 3176 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $15453 r0 *1 584.08,398.16
X$15453 14074 931 2169 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $15455 r0 *1 757.68,307.44
X$15455 14074 2495 931 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $15466 r0 *1 613.2,670.32
X$15466 14074 14073 933 7042 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15468 m0 *1 612.08,670.32
X$15468 14074 14073 933 6945 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15481 r0 *1 595.28,317.52
X$15481 14074 14073 934 2689 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15484 m0 *1 711.2,277.2
X$15484 14074 14073 934 1884 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15486 m0 *1 675.36,297.36
X$15486 14073 2295 2219 934 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $15597 m0 *1 1174.88,236.88
X$15597 14074 14073 1660 1581 955 1659 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15599 m0 *1 910.56,317.52
X$15599 14074 14073 2581 1579 955 2502 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15601 r0 *1 1150.24,488.88
X$15601 14074 14073 4641 4503 955 4712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15605 m0 *1 1169.84,337.68
X$15605 14074 14073 2784 2063 955 2634 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15607 r0 *1 839.44,367.92
X$15607 14074 14073 3123 2229 955 3124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15609 r0 *1 1167.6,428.4
X$15609 14074 14073 3802 3739 955 3803 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15612 r0 *1 1089.2,357.84
X$15612 14074 14073 3136 2929 955 2993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15632 m0 *1 935.76,398.16
X$15632 14074 14073 3295 2984 955 3296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15634 r0 *1 1172.64,367.92
X$15634 14074 14073 3133 2299 955 3181 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15646 m0 *1 282.24,186.48
X$15646 14074 14073 1148 1096 1147 957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15649 m0 *1 290.64,186.48
X$15649 14074 14073 1149 1150 1144 957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15654 m0 *1 336.56,206.64
X$15654 14074 14073 1356 1209 1147 958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15656 r0 *1 335.44,206.64
X$15656 14074 14073 1489 1408 1144 958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15659 m0 *1 337.68,186.48
X$15659 14074 14073 1151 1035 980 958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15729 m0 *1 160.72,186.48
X$15729 14074 1141 1140 14073 1147 1143 975 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $15735 m0 *1 132.16,176.4
X$15735 14074 14073 1086 1027 980 975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15740 r0 *1 169.12,186.48
X$15740 14074 14073 1234 1142 1144 975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15742 m0 *1 170.8,186.48
X$15742 14074 1118 1140 14073 1147 1144 975 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $15746 r0 *1 182.56,166.32
X$15746 14074 977 979 976 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15748 r0 *1 199.36,166.32
X$15748 14074 14073 1068 977 980 978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15760 m0 *1 190.4,206.64
X$15760 14074 1297 1140 14073 1147 1143 978 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $15764 m0 *1 202.16,206.64
X$15764 14074 14073 1349 1251 1144 978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15767 m0 *1 180.88,196.56
X$15767 14074 1279 1140 14073 1147 1144 978 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $15772 m0 *1 263.76,236.88
X$15772 14074 1624 979 1623 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15774 r0 *1 234.08,176.4
X$15774 14074 1094 979 1093 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15777 r0 *1 152.32,186.48
X$15777 14074 1142 979 1088 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15801 m0 *1 288.96,226.8
X$15801 14074 1561 979 1596 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15804 m0 *1 264.32,226.8
X$15804 14074 1538 979 1594 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15807 m0 *1 149.52,226.8
X$15807 14074 1502 979 1554 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15809 r0 *1 176.4,236.88
X$15809 14074 1556 979 1733 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15811 m0 *1 252,196.56
X$15811 14074 1203 979 1302 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15813 m0 *1 280,176.4
X$15813 14074 1096 979 1122 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15816 m0 *1 254.24,176.4
X$15816 14074 1095 979 1121 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15818 m0 *1 290.64,166.32
X$15818 14074 1015 979 982 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15820 r0 *1 185.36,226.8
X$15820 14074 1614 979 1662 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15822 r0 *1 193.76,236.88
X$15822 14074 1503 979 1557 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15824 r0 *1 202.16,226.8
X$15824 14074 1617 979 1615 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15826 r0 *1 188.72,186.48
X$15826 14074 1251 979 1198 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15828 m0 *1 280.56,206.64
X$15828 14074 1150 979 1387 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15832 r0 *1 188.72,176.4
X$15832 14074 1028 979 1119 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15834 m0 *1 222.32,206.64
X$15834 14074 1301 979 1385 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15836 m0 *1 235.2,196.56
X$15836 14074 1201 979 1200 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15838 r0 *1 226.24,196.56
X$15838 14074 1504 979 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $15844 r0 *1 283.36,186.48
X$15844 14074 1205 979 1204 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15846 r0 *1 226.24,206.64
X$15846 14074 14073 979 14167 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $15849 m0 *1 239.12,216.72
X$15849 14074 1456 979 1486 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15851 m0 *1 152.88,196.56
X$15851 14074 1294 979 1250 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15853 m0 *1 208.88,176.4
X$15853 14074 1092 979 1091 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $15859 r0 *1 129.92,186.48
X$15859 14074 14073 1277 1194 980 1246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15861 r0 *1 128.24,206.64
X$15861 14074 14073 1398 1397 980 1293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15863 r0 *1 113.68,236.88
X$15863 14074 14073 1794 1687 980 1688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15865 r0 *1 130.48,236.88
X$15865 14074 14073 1796 1755 980 1756 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15867 m0 *1 125.44,226.8
X$15867 14074 14073 1553 1552 980 1551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15870 r0 *1 140.56,347.76
X$15870 14074 14073 2953 2954 980 2951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15872 m0 *1 201.6,236.88
X$15872 14074 14073 1558 1614 980 1559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15874 m0 *1 186.48,388.08
X$15874 14074 3404 980 14073 3101 3210 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $15877 r0 *1 255.36,277.2
X$15877 14074 14073 2188 1995 980 1695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15879 r0 *1 228.48,317.52
X$15879 14074 14073 2640 2539 980 2540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15882 m0 *1 250.32,236.88
X$15882 14074 14073 1619 1621 980 1622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15886 r0 *1 190.4,307.44
X$15886 14074 14073 2471 2348 980 2259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15890 m0 *1 243.04,186.48
X$15890 14074 14073 1235 1094 980 1030 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15894 m0 *1 128.24,287.28
X$15894 14074 14073 2254 2142 980 2038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15897 m0 *1 190.96,418.32
X$15897 14073 3465 3746 980 3689 3576 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $15900 r0 *1 138.88,327.6
X$15900 14074 14073 2830 2745 980 2600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15902 m0 *1 132.72,307.44
X$15902 14074 14073 2443 2407 980 2406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15905 m0 *1 345.52,226.8
X$15905 14074 14073 1459 1540 980 1564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15907 r0 *1 344.4,267.12
X$15907 14074 14073 2083 1938 980 1868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15911 m0 *1 305.2,176.4
X$15911 14074 14073 1070 985 980 986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15958 r0 *1 198.24,398.16
X$15958 14074 14073 3467 980 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $15960 r0 *1 169.12,388.08
X$15960 14074 980 14073 3379 3103 1147 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $15963 m0 *1 201.6,357.84
X$15963 2959 14074 980 1140 14073 2998 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $15965 r0 *1 133.28,267.12
X$15965 14074 14073 2039 1990 980 1989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15968 m0 *1 141.12,347.76
X$15968 14074 14073 2880 2904 980 2852 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15973 r0 *1 257.6,176.4
X$15973 14074 14073 1121 981 1032 1095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15977 m0 *1 296.8,176.4
X$15977 14074 14073 982 1070 1032 1015 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $15979 r0 *1 331.52,226.8
X$15979 14074 1504 983 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $15981 m0 *1 401.52,317.52
X$15981 14074 2294 983 2651 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $15983 r0 *1 399.84,297.36
X$15983 14074 2390 983 2389 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $15986 r0 *1 341.6,287.28
X$15986 14074 2162 983 2214 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $15988 m0 *1 328.72,226.8
X$15988 14074 1460 983 1458 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16005 m0 *1 295.68,246.96
X$16005 14074 1866 983 1848 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16009 r0 *1 301.28,166.32
X$16009 14074 985 983 984 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16012 r0 *1 329.28,176.4
X$16012 14074 1035 983 1097 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16014 r0 *1 322.56,166.32
X$16014 14074 1034 983 1033 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16017 m0 *1 332.64,196.56
X$16017 14074 1209 983 1208 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16019 r0 *1 318.64,196.56
X$16019 14074 1304 983 1257 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16021 m0 *1 333.76,267.12
X$16021 14074 2049 983 2000 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16023 m0 *1 333.76,236.88
X$16023 14074 1540 983 1539 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16025 m0 *1 318.64,216.72
X$16025 14074 1408 983 1406 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16027 r0 *1 331.52,216.72
X$16027 14074 983 14073 gf180mcu_fd_sc_mcu9t5v0__inv_8
* cell instance $16029 r0 *1 318.64,236.88
X$16029 14074 1818 983 1741 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16032 r0 *1 317.52,267.12
X$16032 14074 2048 983 2027 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16035 r0 *1 329.84,257.04
X$16035 14074 1938 983 1977 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16050 r0 *1 301.28,176.4
X$16050 14074 14073 1175 1015 1147 986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16052 r0 *1 301.28,186.48
X$16052 14074 14073 1206 1205 1144 986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16063 m0 *1 329.28,186.48
X$16063 14074 14073 1176 1034 1147 987 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16066 r0 *1 335.44,196.56
X$16066 14074 14073 1389 1304 1144 987 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16189 m0 *1 989.52,176.4
X$16189 14074 14073 1123 1011 1060 1061 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16224 r0 *1 464.8,166.32
X$16224 14074 1017 1602 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $16263 m0 *1 115.36,176.4
X$16263 14074 1027 1084 1026 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16271 r0 *1 196.56,196.56
X$16271 1028 14073 1195 1196 14074 1298 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $16273 m0 *1 192.08,176.4
X$16273 14074 14073 1119 1068 1032 1028 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16278 m0 *1 192.64,186.48
X$16278 1328 14073 14074 1140 1028 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $16280 r0 *1 214.48,176.4
X$16280 14074 14073 1091 1029 1032 1092 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16283 m0 *1 255.92,216.72
X$16283 14074 14073 1457 1456 1144 1030 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16295 m0 *1 245.84,206.64
X$16295 14074 14073 1505 1201 1147 1030 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16297 r0 *1 283.36,176.4
X$16297 14074 14073 1122 1031 1032 1096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16300 m0 *1 327.6,176.4
X$16300 14074 14073 1033 1036 1032 1034 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16302 m0 *1 128.24,196.56
X$16302 14074 14073 1247 1277 1032 1248 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16304 r0 *1 127.12,216.72
X$16304 14074 14073 1453 1398 1032 1482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16306 r0 *1 128.8,226.8
X$16306 14074 14073 1611 1553 1032 1612 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16308 r0 *1 122.08,236.88
X$16308 14074 14073 1795 1794 1032 1689 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16310 r0 *1 150.64,347.76
X$16310 14074 14073 2955 2880 1032 2956 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16313 m0 *1 188.72,287.28
X$16313 14074 14073 2144 2043 1032 2145 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16315 r0 *1 220.08,317.52
X$16315 14074 14073 2604 2640 1032 2676 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16317 m0 *1 236.32,287.28
X$16317 14074 14073 2210 2098 1032 2150 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16320 m0 *1 249.76,287.28
X$16320 14074 14073 2099 2188 1032 2100 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16323 r0 *1 269.92,226.8
X$16323 14074 14073 1623 1666 1032 1624 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16325 m0 *1 189.28,317.52
X$16325 14074 14073 2538 2471 1032 2601 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16327 r0 *1 241.36,186.48
X$16327 14074 14073 1200 1235 1032 1201 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16331 r0 *1 133.28,287.28
X$16331 14074 14073 2312 2254 1032 2205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16333 r0 *1 131.6,277.2
X$16333 14074 14073 2095 2039 1032 2096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16337 r0 *1 135.52,307.44
X$16337 14074 14073 2466 2443 1032 2467 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16339 m0 *1 335.44,216.72
X$16339 14074 14073 1458 1459 1032 1460 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16341 r0 *1 336.56,186.48
X$16341 14074 14073 1208 1151 1032 1209 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16344 r0 *1 336,267.12
X$16344 14074 14073 2000 2083 1032 2049 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16346 r0 *1 291.76,267.12
X$16346 14074 14073 2079 2081 1032 2047 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16348 r0 *1 291.76,226.8
X$16348 14074 14073 1625 1667 1032 1626 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16385 r0 *1 238.56,226.8
X$16385 14074 14073 1618 1619 1032 1694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16387 m0 *1 176.96,378
X$16387 14074 3265 1032 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $16389 m0 *1 243.04,347.76
X$16389 14074 14073 2906 2856 1032 2907 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16391 r0 *1 134.4,257.04
X$16391 14074 14073 1991 1796 1032 1931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16393 m0 *1 131.6,186.48
X$16393 14074 14073 1085 1086 1032 1087 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16395 m0 *1 201.6,226.8
X$16395 14074 14073 1557 1558 1032 1503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16397 m0 *1 139.44,357.84
X$16397 14074 14073 2952 2953 1032 3102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16399 m0 *1 137.2,337.68
X$16399 14074 14073 2806 2830 1032 2807 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16421 r0 *1 367.92,287.28
X$16421 14074 14073 2155 2156 1037 1699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16424 r0 *1 464.24,367.92
X$16424 14074 14073 3111 2971 1037 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16426 r0 *1 525.84,357.84
X$16426 14074 2895 2920 14073 1037 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $16440 r0 *1 379.68,176.4
X$16440 14073 1041 1038 14074 1153 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16456 m0 *1 373.52,186.48
X$16456 14074 14073 1180 1152 1041 1210 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16472 m0 *1 384.16,226.8
X$16472 14074 14073 1698 1041 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16495 r0 *1 723.52,216.72
X$16495 1046 14073 14074 14080 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $16570 m0 *1 1008,297.36
X$16570 14074 14073 2303 2304 1049 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16575 m0 *1 1033.2,488.88
X$16575 14074 14073 4592 4577 1049 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16577 r0 *1 1036.56,468.72
X$16577 14074 14073 4307 4105 1049 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16579 r0 *1 925.68,468.72
X$16579 14074 14073 4380 4363 1049 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16582 r0 *1 950.88,468.72
X$16582 14074 14073 4364 4365 1049 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16586 m0 *1 982.24,418.32
X$16586 14074 14073 3681 3606 1049 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16588 r0 *1 675.92,428.4
X$16588 14074 14073 3890 3786 1049 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16590 m0 *1 705.04,418.32
X$16590 14074 14073 3483 3546 1049 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16594 r0 *1 882,488.88
X$16594 14074 14073 4572 4573 1049 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16596 r0 *1 744.8,478.8
X$16596 14074 14073 4489 4490 1049 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16598 m0 *1 588.56,448.56
X$16598 14074 14073 4003 3926 1049 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16600 r0 *1 740.32,307.44
X$16600 14074 14073 2524 2493 1049 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16602 r0 *1 792.4,337.68
X$16602 14074 14073 2826 2654 1049 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16604 m0 *1 912.24,246.96
X$16604 14074 14073 1855 1777 1049 1650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16607 r0 *1 879.2,438.48
X$16607 14074 14073 4050 3794 1049 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16611 m0 *1 1024.8,337.68
X$16611 14074 14073 2641 2566 1049 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16656 m0 *1 1014.72,257.04
X$16656 14074 14073 1966 1783 1049 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16691 m0 *1 907.2,176.4
X$16691 14074 14073 1056 1055 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16696 m0 *1 790.72,267.12
X$16696 14073 1315 2014 14074 1056 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16714 r0 *1 969.92,307.44
X$16714 14074 14073 1056 2505 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16731 m0 *1 932.96,176.4
X$16731 14074 14073 1109 1110 1060 1059 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16740 m0 *1 989.52,186.48
X$16740 14074 14073 1174 1111 1060 1167 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16745 m0 *1 982.24,186.48
X$16745 14073 1060 1227 14074 1166 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $16773 r0 *1 1048.32,196.56
X$16773 14074 1116 1319 1064 1272 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16775 m0 *1 1098.72,216.72
X$16775 14074 1116 1321 1064 1533 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16778 r0 *1 1036.56,206.64
X$16778 14074 1116 1375 1064 1428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16804 m0 *1 1047.2,216.72
X$16804 14074 1116 1430 1064 1535 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16807 m0 *1 1041.04,206.64
X$16807 14074 1116 1429 1064 1536 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16809 r0 *1 1078.56,216.72
X$16809 14074 1116 1273 1064 1593 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16811 m0 *1 1099.28,176.4
X$16811 14074 1116 1115 1064 1065 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16814 m0 *1 1099.28,186.48
X$16814 14074 1116 1169 1064 1168 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16821 r0 *1 1163.12,216.72
X$16821 14074 1116 1529 1064 1591 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16827 m0 *1 1094.24,206.64
X$16827 14074 14073 1064 14161 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $16830 r0 *1 1078.56,206.64
X$16830 14074 1116 1274 1064 1485 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16835 m0 *1 1102.08,206.64
X$16835 14074 1116 1230 1064 1377 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16839 r0 *1 1106.56,226.8
X$16839 14074 1116 1587 1064 1586 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16842 m0 *1 1093.12,236.88
X$16842 14074 1116 1726 1064 1725 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16844 m0 *1 1121.68,186.48
X$16844 14074 1116 1231 1064 1278 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16850 r0 *1 1125.6,226.8
X$16850 14074 1116 1656 1064 1655 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16853 m0 *1 1122.24,226.8
X$16853 14074 1116 1588 1064 1531 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16855 r0 *1 1168.72,226.8
X$16855 14074 1116 1659 1064 1660 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16858 r0 *1 1145.76,226.8
X$16858 14074 1116 1658 1064 1657 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16861 m0 *1 1151.36,226.8
X$16861 14074 1116 1592 1064 1590 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16863 m0 *1 1118.32,176.4
X$16863 14074 1116 1117 1064 1066 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $16926 r0 *1 603.12,650.16
X$16926 14074 14073 1079 6712 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16931 r0 *1 843.92,660.24
X$16931 14074 14073 6903 1517 6883 1079 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $16939 m0 *1 630.56,398.16
X$16939 14074 14073 3846 1081 3395 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $16952 r0 *1 679.84,398.16
X$16952 14074 14073 1081 3667 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $16961 r0 *1 92.4,186.48
X$16961 1083 14073 14074 1246 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $16964 r0 *1 113.12,186.48
X$16964 14074 1194 1084 1193 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16966 r0 *1 111.44,206.64
X$16966 14074 1397 1084 1380 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16968 m0 *1 123.2,246.96
X$16968 14074 1689 1084 1795 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16971 m0 *1 128.8,267.12
X$16971 14074 1931 1084 1991 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16994 r0 *1 157.92,267.12
X$16994 14074 1933 1084 2040 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16996 r0 *1 111.44,226.8
X$16996 14074 1552 1084 1550 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $16999 m0 *1 124.32,236.88
X$16999 14074 1612 1084 1611 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17001 r0 *1 118.72,246.96
X$17001 14074 1084 14177 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $17003 r0 *1 117.6,257.04
X$17003 14074 1755 1084 1930 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17005 m0 *1 118.72,257.04
X$17005 14074 1504 1084 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $17009 r0 *1 145.04,246.96
X$17009 14074 1812 1084 1811 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17011 m0 *1 106.4,246.96
X$17011 14074 1687 1084 1686 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17014 m0 *1 127.12,277.2
X$17014 14074 2096 1084 2095 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17016 r0 *1 116.48,287.28
X$17016 14074 2142 1084 2253 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17019 m0 *1 124.32,297.36
X$17019 14074 2205 1084 2312 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17021 r0 *1 116.48,267.12
X$17021 14074 1990 1084 1988 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17024 r0 *1 127.12,176.4
X$17024 14074 1087 1084 1085 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17028 r0 *1 129.36,196.56
X$17028 14074 1248 1084 1247 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17030 m0 *1 122.08,216.72
X$17030 14074 1482 1084 1453 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17032 r0 *1 118.72,307.44
X$17032 14074 2407 1084 2405 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17034 r0 *1 80.08,327.6
X$17034 14074 2638 1084 2599 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17036 m0 *1 91.84,307.44
X$17036 14074 2278 1084 2277 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17039 r0 *1 84,297.36
X$17039 14074 2346 1084 2345 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $17047 m0 *1 145.6,186.48
X$17047 1089 14073 14074 1140 1087 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $17053 r0 *1 144.48,186.48
X$17053 1087 14073 1195 1196 14074 1233 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $17056 r0 *1 153.44,176.4
X$17056 1171 1249 1089 1088 1090 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $17063 r0 *1 162.96,176.4
X$17063 14074 14073 1090 1141 1197 1118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $17069 r0 *1 217.28,186.48
X$17069 1386 14073 14074 1140 1092 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $17072 r0 *1 209.44,186.48
X$17072 1092 14073 1195 1196 14074 1199 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $17133 r0 *1 624.4,287.28
X$17133 14074 1104 2003 14073 2336 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $17137 r0 *1 666.4,337.68
X$17137 14074 1104 2769 14073 2824 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $17152 r0 *1 646.8,408.24
X$17152 14074 14073 1104 3661 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $17198 m0 *1 987.84,236.88
X$17198 14074 1780 14073 1665 1721 1113 1722 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $17212 m0 *1 1093.68,468.72
X$17212 14074 1116 4169 3736 4226 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17214 r0 *1 1000.72,519.12
X$17214 14074 1116 4846 4708 5093 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17217 m0 *1 1024.24,539.28
X$17217 14074 1116 5158 4708 5084 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17219 m0 *1 1066.24,498.96
X$17219 14074 1116 4581 4708 4590 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17221 m0 *1 946.4,569.52
X$17221 14074 1116 5618 5016 5639 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17224 r0 *1 1052.8,488.88
X$17224 14074 1116 4580 4708 4579 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17227 m0 *1 1066.24,468.72
X$17227 14074 1116 4224 3736 4306 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17229 m0 *1 1046.64,498.96
X$17229 14074 1116 4639 4708 4591 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17232 r0 *1 1055.6,458.64
X$17232 14074 1116 4223 3736 4222 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17234 r0 *1 1120.56,257.04
X$17234 14074 1116 1969 1799 2022 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17237 m0 *1 1122.8,468.72
X$17237 14074 1116 4230 3736 4303 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17239 m0 *1 1108.8,478.8
X$17239 14074 1116 4228 3736 4426 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17243 r0 *1 985.6,287.28
X$17243 14074 1116 2238 1423 2317 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17245 r0 *1 1130.64,488.88
X$17245 14074 1116 4586 4708 4585 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17247 m0 *1 1075.2,277.2
X$17247 14074 1116 2124 1799 2123 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17249 m0 *1 1137.92,478.8
X$17249 14074 1116 4369 3736 4372 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17252 r0 *1 1016.96,569.52
X$17252 14074 1116 5621 5016 5704 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17255 r0 *1 1125.04,468.72
X$17255 14074 1116 4229 3736 4368 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17260 r0 *1 1150.24,257.04
X$17260 14074 1116 1908 1799 1970 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17262 r0 *1 1100.96,287.28
X$17262 14074 1116 2244 1799 2243 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17264 r0 *1 1028.16,589.68
X$17264 14074 1116 5926 5622 5848 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17266 m0 *1 1000.16,579.6
X$17266 14074 1116 5560 5016 5559 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17268 m0 *1 1011.92,569.52
X$17268 14074 1116 5562 5016 5561 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17270 m0 *1 1103.76,297.36
X$17270 14074 1116 2307 1799 2306 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17272 r0 *1 997.92,569.52
X$17272 14074 1116 5620 5016 5619 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17274 r0 *1 1167.6,468.72
X$17274 14074 1116 4297 2782 4300 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17277 r0 *1 1168.72,478.8
X$17277 14074 1116 4298 2782 4428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17281 r0 *1 1158.08,458.64
X$17281 14074 1116 4232 2782 4231 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17283 m0 *1 1084.72,297.36
X$17283 14074 1116 2067 1799 2066 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17285 r0 *1 1170.96,257.04
X$17285 14074 1116 1909 1799 1971 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17287 r0 *1 1151.92,509.04
X$17287 14074 1116 4770 4708 4853 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17290 r0 *1 994,539.28
X$17290 14074 1116 5232 5016 5247 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17293 m0 *1 1148,498.96
X$17293 14074 1116 4712 4708 4641 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17295 r0 *1 1017.52,539.28
X$17295 14074 1116 5157 4708 5303 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17298 r0 *1 991.76,529.2
X$17298 14074 1116 4845 5016 5179 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17301 r0 *1 1170.96,287.28
X$17301 14074 1116 2251 1799 2249 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17303 m0 *1 1170.96,287.28
X$17303 14074 1116 2250 1799 2186 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17305 m0 *1 1112.72,509.04
X$17305 14074 1116 4850 4708 4768 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17308 m0 *1 1027.04,549.36
X$17308 14074 1116 5159 4708 5365 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17311 r0 *1 1078.56,468.72
X$17311 14074 1116 4225 3736 4375 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17313 r0 *1 1037.68,277.2
X$17313 14074 1116 2120 1799 2119 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17316 m0 *1 1044.4,297.36
X$17316 14074 1116 2242 1799 2377 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17319 m0 *1 1023.68,287.28
X$17319 14074 1116 2184 1799 2183 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17322 r0 *1 1102.08,458.64
X$17322 14074 1116 4227 3736 4236 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17324 m0 *1 971.6,549.36
X$17324 14074 1116 5155 5016 5154 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17326 m0 *1 978.88,559.44
X$17326 14074 1116 5490 5016 5570 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17329 r0 *1 1115.52,267.12
X$17329 14074 1116 1968 1799 2070 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17331 m0 *1 1024.8,277.2
X$17331 14074 1116 2064 1799 2073 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17333 m0 *1 1128.96,498.96
X$17333 14074 1116 4711 4708 4710 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17335 r0 *1 1122.8,277.2
X$17335 14074 1116 2185 1799 2314 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17338 r0 *1 959.84,569.52
X$17338 14074 1116 5489 5016 5488 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17340 r0 *1 1120,287.28
X$17340 14074 1116 2246 1799 2245 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17342 m0 *1 964.32,529.2
X$17342 14074 1116 5094 5016 5083 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17344 m0 *1 1168.72,267.12
X$17344 14074 1116 1911 1799 1910 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17346 r0 *1 1143.52,287.28
X$17346 14074 1116 2247 1799 2308 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17348 m0 *1 1109.92,498.96
X$17348 14074 1116 4640 4708 4647 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17350 m0 *1 956.48,539.28
X$17350 14074 1116 5181 5016 5231 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17352 m0 *1 1083.04,579.6
X$17352 14074 1116 5759 5622 5780 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17354 r0 *1 1004.64,498.96
X$17354 14074 1116 4775 4708 4776 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17356 m0 *1 1154.72,539.28
X$17356 14074 1116 5166 4708 5237 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17358 m0 *1 999.04,509.04
X$17358 14074 1116 4765 4708 4707 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17360 r0 *1 1147.44,539.28
X$17360 14074 1116 5165 4708 5086 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17362 r0 *1 1024.8,488.88
X$17362 14074 1116 4577 4708 4592 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17365 m0 *1 1021.44,498.96
X$17365 14074 1116 4637 4708 4576 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17367 r0 *1 1023.68,498.96
X$17367 14074 1116 4502 4708 4501 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17369 m0 *1 1109.36,549.36
X$17369 14074 1116 5234 4708 5363 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17371 r0 *1 1106.56,549.36
X$17371 14074 1116 5297 4708 5428 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17377 m0 *1 1135.68,539.28
X$17377 14074 1116 5164 4708 5236 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17381 r0 *1 985.6,458.64
X$17381 14074 1116 3942 3736 4221 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17384 r0 *1 1017.52,468.72
X$17384 14074 1116 4164 3736 4367 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17386 m0 *1 1012.48,468.72
X$17386 14074 1116 4105 3736 4307 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17388 r0 *1 987.84,468.72
X$17388 14074 1116 4366 3736 4377 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17390 r0 *1 988.96,478.8
X$17390 14074 1116 4425 3736 4431 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17393 r0 *1 979.44,448.56
X$17393 14074 1116 3941 3736 4123 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17396 r0 *1 1078.56,569.52
X$17396 14074 1116 5627 5622 5626 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17399 r0 *1 959.28,468.72
X$17399 14074 1116 4296 3736 4294 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17401 r0 *1 968.24,478.8
X$17401 14074 1116 4500 3736 4378 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17404 r0 *1 956.48,448.56
X$17404 14074 1116 3939 3365 4182 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17407 m0 *1 1069.6,569.52
X$17407 14074 1116 5636 5622 5625 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17410 r0 *1 1114.96,569.52
X$17410 14074 1116 5629 5622 5628 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17415 r0 *1 1150.24,569.52
X$17415 14074 1116 5698 5622 5697 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17420 m0 *1 1156.4,579.6
X$17420 14074 1116 5771 5622 5777 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17423 r0 *1 938,488.88
X$17423 14074 1116 4636 3736 4652 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17425 m0 *1 944.16,488.88
X$17425 14074 1116 4499 3736 4593 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17428 r0 *1 1128.4,539.28
X$17428 14074 1116 5235 4708 5298 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17433 r0 *1 946.4,478.8
X$17433 14074 1116 4365 3736 4364 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17435 m0 *1 1093.68,509.04
X$17435 14074 1116 4709 4708 4767 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17438 r0 *1 1017.52,388.08
X$17438 14074 1116 3177 3365 3436 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17440 m0 *1 1018.08,388.08
X$17440 14074 1116 3175 3365 3502 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17442 r0 *1 1026.48,378
X$17442 14074 1116 3057 2780 3316 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17445 m0 *1 1084.72,549.36
X$17445 14074 1116 5296 4708 5361 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17447 m0 *1 1084.72,539.28
X$17447 14074 1116 5020 4708 5170 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17450 m0 *1 999.04,408.24
X$17450 14074 1116 3490 3365 3426 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17453 r0 *1 1063.44,267.12
X$17453 14074 1116 2065 1799 2072 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17455 r0 *1 1074.08,488.88
X$17455 14074 1116 4582 4708 4504 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17457 m0 *1 1052.8,277.2
X$17457 14074 1116 2122 1799 2129 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17459 r0 *1 1098.72,488.88
X$17459 14074 1116 4584 4708 4583 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17461 r0 *1 953.12,559.44
X$17461 14074 1116 5558 5016 5557 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17463 r0 *1 1078.56,509.04
X$17463 14074 1116 4849 4708 4946 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17466 r0 *1 1062.88,559.44
X$17466 14074 1116 5233 4708 5563 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17468 r0 *1 1015.28,428.4
X$17468 14074 1116 3873 3736 3856 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17470 m0 *1 1011.36,438.48
X$17470 14074 1116 3943 3736 4038 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17472 m0 *1 1037.68,569.52
X$17472 14074 1116 5624 5622 5637 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17475 r0 *1 1098.72,257.04
X$17475 14074 1116 1905 1799 1967 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17478 m0 *1 1093.68,257.04
X$17478 14074 1116 1904 1799 1903 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17481 r0 *1 1012.48,458.64
X$17481 14074 1116 4165 3736 4239 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17483 r0 *1 977.2,408.24
X$17483 14074 1116 3606 3365 3681 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17485 m0 *1 1065.68,539.28
X$17485 14074 1116 4945 4708 4944 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17488 m0 *1 1054.48,529.2
X$17488 14074 1116 5019 4708 5092 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17491 r0 *1 1042.16,549.36
X$17491 14074 1116 5160 4708 5293 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17493 m0 *1 999.04,418.32
X$17493 14074 1116 3551 3365 3679 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17495 m0 *1 961.52,448.56
X$17495 14074 1116 3940 3365 4104 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17497 r0 *1 1029.84,418.32
X$17497 14074 1116 3737 3365 3677 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17499 m0 *1 1023.12,428.4
X$17499 14074 1116 3798 3736 3874 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17501 r0 *1 1112.16,640.08
X$17501 14074 1116 6630 5622 6643 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17503 m0 *1 1153.6,650.16
X$17503 14074 1116 6810 5622 6812 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17505 r0 *1 1154.72,640.08
X$17505 14074 1116 6632 5622 6633 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17507 m0 *1 1154.72,609.84
X$17507 14074 1116 6181 5622 6180 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17509 r0 *1 1154.72,609.84
X$17509 14074 1116 6274 5622 6273 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17511 r0 *1 1106.56,609.84
X$17511 14074 1116 6175 5622 6278 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17514 m0 *1 1165.36,367.92
X$17514 14074 1116 3181 2782 3133 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17516 r0 *1 1147.44,357.84
X$17516 14074 1116 3064 2782 3063 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17519 m0 *1 1143.52,367.92
X$17519 14074 1116 3132 2782 3184 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17521 m0 *1 1123.36,367.92
X$17521 14074 1116 3179 2780 3061 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17523 r0 *1 1117.76,357.84
X$17523 14074 1116 3062 2780 3070 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17526 r0 *1 1078.56,327.6
X$17526 14074 1116 2511 2780 2630 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17529 m0 *1 1161.44,357.84
X$17529 14074 1116 3065 2782 3066 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17531 m0 *1 1079.68,307.44
X$17531 14074 1116 2370 1799 2369 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17533 m0 *1 1151.36,327.6
X$17533 14074 1116 2633 1799 2710 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17535 m0 *1 1151.92,307.44
X$17535 14074 1116 2248 1799 2252 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17537 r0 *1 1144.08,327.6
X$17537 14074 1116 2632 2782 2783 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17540 m0 *1 1170.4,327.6
X$17540 14074 1116 2635 1799 2636 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17542 r0 *1 1168.72,327.6
X$17542 14074 1116 2634 2782 2784 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17545 r0 *1 1125.04,327.6
X$17545 14074 1116 2631 2780 2781 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17547 r0 *1 1128.96,337.68
X$17547 14074 1116 2709 2782 2876 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17549 m0 *1 1001.84,619.92
X$17549 14074 1116 6090 5016 6267 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17551 r0 *1 998.48,670.32
X$17551 14074 1116 7168 7166 7167 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17553 m0 *1 1000.72,609.84
X$17553 14074 1116 6091 5016 6092 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17556 m0 *1 1000.16,670.32
X$17556 14074 1116 7046 7166 7078 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17558 r0 *1 960.4,630
X$17558 14074 1116 6266 5016 6363 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17560 r0 *1 972.72,599.76
X$17560 14074 1116 6089 5016 6106 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17562 m0 *1 960.96,609.84
X$17562 14074 1116 6088 5016 6087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17564 m0 *1 978.88,630
X$17564 14074 1116 6365 5016 6449 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17567 r0 *1 985.6,650.16
X$17567 14074 1116 6010 5622 6804 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17569 m0 *1 1116.64,690.48
X$17569 14074 1116 7174 7166 7360 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17572 r0 *1 954.24,619.92
X$17572 14074 1116 6265 5016 6362 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17575 m0 *1 949.76,630
X$17575 14074 1116 6364 5016 6448 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17577 r0 *1 1078.56,690.48
X$17577 14074 1116 7262 7166 7370 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17579 m0 *1 1081.92,680.4
X$17579 14074 1116 6733 7166 7069 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17581 m0 *1 1081.92,690.48
X$17581 14074 1116 7261 7166 7270 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17584 r0 *1 1053.36,609.84
X$17584 14074 1116 6012 5622 6192 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17587 m0 *1 1062.88,640.08
X$17587 14074 1116 6534 5622 6551 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17589 m0 *1 1154.72,690.48
X$17589 14074 1116 7177 7166 7178 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17591 m0 *1 1149.12,680.4
X$17591 14074 1116 7263 7166 7266 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17594 r0 *1 1033.76,680.4
X$17594 14074 1116 6982 7166 7274 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17596 m0 *1 1058.96,690.48
X$17596 14074 1116 7170 7166 7359 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17599 m0 *1 1073.52,428.4
X$17599 14074 1116 3857 2782 3865 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17602 m0 *1 1098.72,428.4
X$17602 14074 1116 3740 2782 3738 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17605 m0 *1 1146.32,398.16
X$17605 14074 1116 3432 2782 3431 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17608 r0 *1 1098.72,428.4
X$17608 14074 1116 3860 2782 3859 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17610 r0 *1 1078,438.48
X$17610 14074 1116 3858 3736 3954 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17612 m0 *1 1168.72,388.08
X$17612 14074 1116 3372 2782 3433 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17614 m0 *1 1045.52,428.4
X$17614 14074 1116 3799 3736 3870 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17616 m0 *1 1008.56,357.84
X$17616 14074 1116 3056 2780 3075 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17618 r0 *1 1055.6,418.32
X$17618 14074 1116 3743 3736 3744 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17621 r0 *1 1020.32,347.76
X$17621 14074 1116 2989 2780 2928 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17624 m0 *1 1162.56,428.4
X$17624 14074 1116 3803 2782 3802 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17626 m0 *1 1117.76,428.4
X$17626 14074 1116 3742 2782 3741 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17629 m0 *1 1136.8,428.4
X$17629 14074 1116 3801 2782 3800 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17631 m0 *1 1018.08,317.52
X$17631 14074 1116 2566 1423 2641 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17633 r0 *1 1006.88,297.36
X$17633 14074 1116 2304 1799 2303 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17635 m0 *1 1143.52,438.48
X$17635 14074 1116 3948 2782 3947 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17638 r0 *1 1168.16,408.24
X$17638 14074 1116 3371 2782 3370 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17640 r0 *1 1148.56,428.4
X$17640 14074 1116 3861 2782 4029 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17642 m0 *1 1167.04,448.56
X$17642 14074 1116 4021 2782 4025 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17644 m0 *1 1165.36,398.16
X$17644 14074 1116 3369 2782 3307 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17647 r0 *1 1123.92,398.16
X$17647 14074 1116 3368 2782 3376 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17649 r0 *1 1016.4,317.52
X$17649 14074 1116 2627 1423 2639 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17651 r0 *1 1014.72,327.6
X$17651 14074 1116 2705 2780 2713 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17653 m0 *1 1124.48,408.24
X$17653 14074 1116 3430 2782 3552 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17655 r0 *1 1034.88,367.92
X$17655 14074 1116 3058 2780 3128 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17657 m0 *1 1080.8,367.92
X$17657 14074 1116 2993 2780 3136 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17659 m0 *1 999.04,367.92
X$17659 14074 1116 3127 2780 3126 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17661 m0 *1 1102.64,337.68
X$17661 14074 1116 2708 2780 2785 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17663 m0 *1 1101.52,367.92
X$17663 14074 1116 3131 2780 3190 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17665 r0 *1 1098.72,357.84
X$17665 14074 1116 3178 2780 3060 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17668 m0 *1 1050.56,357.84
X$17668 14074 1116 2991 2780 2990 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17670 r0 *1 1078.56,347.76
X$17670 14074 1116 2994 2780 2995 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17672 m0 *1 1044.96,327.6
X$17672 14074 1116 2568 1799 2711 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17674 r0 *1 1099.28,327.6
X$17674 14074 1116 2707 2780 2706 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17677 m0 *1 1064.56,327.6
X$17677 14074 1116 2510 1799 2788 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17679 r0 *1 1059.52,347.76
X$17679 14074 1116 2992 2780 2931 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17681 m0 *1 1100.96,398.16
X$17681 14074 1116 3428 2782 3492 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17683 m0 *1 1076.32,398.16
X$17683 14074 1116 3303 2782 3491 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17686 r0 *1 998.48,357.84
X$17686 14074 1116 3055 2780 3076 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17688 r0 *1 1052.24,388.08
X$17688 14074 1116 3367 2780 3366 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17690 r0 *1 1104.88,398.16
X$17690 14074 1116 3429 2782 3555 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17693 m0 *1 1045.52,398.16
X$17693 14074 1116 3314 2780 3501 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17696 r0 *1 1071.28,388.08
X$17696 14074 1116 3304 2782 3377 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17923 r0 *1 988.96,277.2
X$17923 14074 2300 1116 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $17927 m0 *1 1144.64,267.12
X$17927 14074 1116 1907 1799 2068 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $17971 m0 *1 894.32,720.72
X$17971 14074 14073 7807 1128 6883 3787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $17979 r0 *1 883.68,720.72
X$17979 14074 14073 1128 8249 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $17986 m0 *1 649.6,267.12
X$17986 14074 14073 2011 1130 2012 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $17988 r0 *1 654.64,428.4
X$17988 14074 1130 3847 14073 3848 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $17991 m0 *1 591.36,418.32
X$17991 1130 3722 3766 3697 14073 14074 3658 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $18021 m0 *1 857.36,700.56
X$18021 14073 1131 7551 14074 7570 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $18024 r0 *1 840,710.64
X$18024 14074 1131 7713 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $18114 m0 *1 621.6,246.96
X$18114 14074 2169 1137 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $18128 r0 *1 710.08,186.48
X$18128 14074 14073 1139 1243 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $18131 r0 *1 138.32,216.72
X$18131 1530 14073 14074 1140 1482 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18133 r0 *1 216.72,216.72
X$18133 1735 14073 14074 1140 1503 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18135 m0 *1 162.4,347.76
X$18135 14074 2853 1140 14073 1147 1143 2600 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18137 m0 *1 214.48,226.8
X$18137 14074 1616 1140 14073 1147 1143 1559 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18139 m0 *1 161.84,337.68
X$18139 14074 2881 1140 14073 1147 1144 2600 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18142 r0 *1 150.08,307.44
X$18142 2514 14073 14074 1140 2467 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18145 m0 *1 170.24,307.44
X$18145 14074 2444 1140 14073 1147 1144 2406 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18147 m0 *1 160.16,307.44
X$18147 14074 2408 1140 14073 1147 1143 2406 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18151 r0 *1 175.28,226.8
X$18151 14074 1613 1140 14073 1147 1143 1551 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18153 m0 *1 201.6,327.6
X$18153 2603 14073 14074 1140 2601 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18158 m0 *1 216.72,388.08
X$18158 14074 14073 3317 1140 3207 2959 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18164 r0 *1 156.8,206.64
X$18164 14074 1483 1140 14073 1147 1143 1293 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18167 m0 *1 158.48,216.72
X$18167 14074 1484 1140 14073 1147 1144 1293 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18169 m0 *1 187.6,398.16
X$18169 3101 14073 1140 3210 14074 3405 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18171 m0 *1 190.4,277.2
X$18171 2126 14073 14074 1140 2145 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18174 m0 *1 281.12,287.28
X$18174 2152 14073 1140 1338 14074 2261 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18176 m0 *1 216.16,267.12
X$18176 14074 2023 1140 14073 1147 1143 1989 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18178 m0 *1 217.28,277.2
X$18178 14074 2128 1140 14073 1147 1144 1989 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18180 m0 *1 224.56,226.8
X$18180 14074 1737 1140 14073 1147 1144 1559 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18182 r0 *1 159.04,287.28
X$18182 14074 2208 1140 14073 1147 1143 2038 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18184 m0 *1 156.8,236.88
X$18184 14074 1692 1140 14073 1147 1143 1688 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18186 m0 *1 159.6,246.96
X$18186 14074 1841 1140 14073 1147 1144 1688 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18188 m0 *1 162.4,257.04
X$18188 14074 2042 1140 14073 1147 1143 1756 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18190 m0 *1 201.6,307.44
X$18190 14074 2409 1140 14073 1147 1144 2259 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18192 m0 *1 201.6,317.52
X$18192 14074 2473 1140 14073 1147 1143 2259 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18194 m0 *1 182.56,226.8
X$18194 14074 1734 1140 14073 1147 1144 1551 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18196 m0 *1 165.76,267.12
X$18196 14074 2125 1140 14073 1147 1144 1756 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18198 m0 *1 160.72,287.28
X$18198 14074 2207 1140 14073 1147 1144 2038 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18200 r0 *1 141.68,287.28
X$18200 2313 14073 14074 1140 2205 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18203 r0 *1 162.4,196.56
X$18203 14074 1347 1140 14073 1147 1143 1246 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18205 m0 *1 231.28,398.16
X$18205 14074 3440 1140 14073 2951 1144 1147 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18207 r0 *1 218.96,378
X$18207 14074 1143 14073 3317 3264 3211 3270 1140
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $18211 m0 *1 170.24,196.56
X$18211 14074 1295 1140 14073 1147 1144 1246 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $18215 r0 *1 312.48,236.88
X$18215 1696 14073 1140 1338 14074 1739 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18308 r0 *1 239.68,257.04
X$18308 1935 14073 1140 1338 14074 1974 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18310 r0 *1 294,246.96
X$18310 1816 14073 1140 1338 14074 1849 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18312 m0 *1 201.6,287.28
X$18312 2147 14073 14074 1140 2096 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18315 m0 *1 282.8,246.96
X$18315 1815 14073 1140 1338 14074 1847 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18318 m0 *1 248.64,307.44
X$18318 2411 14073 1140 1338 14074 2448 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18321 m0 *1 222.88,337.68
X$18321 2747 14073 1140 1338 14074 2833 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18323 r0 *1 256.48,297.36
X$18323 2283 14073 1140 1338 14074 2378 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18325 r0 *1 168.56,236.88
X$18325 1693 14073 14074 1140 1612 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18327 m0 *1 148.4,267.12
X$18327 2020 14073 14074 1140 1931 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18329 r0 *1 152.88,337.68
X$18329 2809 14073 14074 1140 2807 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18331 m0 *1 166.88,388.08
X$18331 14074 14073 3378 1140 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $18334 r0 *1 206.64,378
X$18334 1143 1147 2951 1140 14073 14074 3269 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $18336 m0 *1 215.6,367.92
X$18336 3102 14074 1140 1145 14073 3166 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $18339 r0 *1 249.76,357.84
X$18339 3020 14073 1140 1338 14074 3021 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18341 m0 *1 228.48,367.92
X$18341 14074 3105 1338 1254 3191 1140 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $18344 r0 *1 138.88,236.88
X$18344 1730 14073 14074 1140 1689 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18346 m0 *1 144.48,196.56
X$18346 1381 14073 14074 1140 1248 1145 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $18348 r0 *1 282.24,206.64
X$18348 1303 14073 1140 1338 14074 1404 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18350 r0 *1 266.56,196.56
X$18350 1253 14073 1140 1338 14074 1333 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18353 r0 *1 235.76,206.64
X$18353 1401 14073 1140 1338 14074 1435 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18356 m0 *1 313.04,196.56
X$18356 1258 14073 1140 1338 14074 1283 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18358 r0 *1 301.28,196.56
X$18358 1256 14073 1140 1338 14074 1335 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18361 r0 *1 313.04,206.64
X$18361 1407 14073 1140 1338 14074 1436 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18363 m0 *1 312.48,267.12
X$18363 1999 14073 1140 1338 14074 2026 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18368 m0 *1 153.44,186.48
X$18368 14074 1233 14073 1171 1299 1142 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $18376 r0 *1 192.64,337.68
X$18376 1143 14073 2259 2852 14074 2831 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18386 m0 *1 222.32,367.92
X$18386 1143 14073 3101 3210 14074 3105 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18389 m0 *1 234.08,378
X$18389 14074 14073 1255 3211 1143 3207 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18391 r0 *1 241.92,378
X$18391 14074 14073 3339 1143 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18428 m0 *1 231.84,327.6
X$18428 14073 1143 2540 14074 2677 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $18435 m0 *1 169.12,357.84
X$18435 14074 14073 1143 1145 1147 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $18437 r0 *1 178.64,367.92
X$18437 14074 14073 1143 3189 3103 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $18439 m0 *1 174.16,357.84
X$18439 1143 1147 2957 3103 14074 14073 2997 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $18441 m0 *1 190.96,357.84
X$18441 1143 2905 2959 3103 14074 14073 3071 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $18444 r0 *1 230.72,367.92
X$18444 14074 1143 14073 3191 3210 3101 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $18451 r0 *1 197.12,347.76
X$18451 14074 14073 2908 2960 1144 2905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18453 r0 *1 171.36,307.44
X$18453 14074 14073 2413 2470 1144 2406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18456 m0 *1 188.72,246.96
X$18456 14074 14073 1761 1556 1144 1551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18458 m0 *1 202.72,337.68
X$18458 14074 14073 2812 2674 1144 2259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18462 r0 *1 162.96,216.72
X$18462 14074 14073 1506 1502 1144 1293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18465 m0 *1 271.6,297.36
X$18465 14074 14073 2284 2212 1144 1695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18468 m0 *1 166.32,297.36
X$18468 14074 14073 2315 2187 1144 2038 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18471 r0 *1 249.2,246.96
X$18471 14074 14073 1843 1863 1144 1622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18476 r0 *1 226.24,226.8
X$18476 14074 14073 1563 1617 1144 1559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18478 m0 *1 222.32,287.28
X$18478 14074 14073 2148 2149 1144 1989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18480 r0 *1 255.92,357.84
X$18480 14074 14073 2999 3020 1144 2962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18482 r0 *1 245.28,327.6
X$18482 14074 2677 14073 2749 2714 1144 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $18484 r0 *1 220.64,367.92
X$18484 14074 14073 3168 3167 1144 2951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18486 r0 *1 161.84,246.96
X$18486 14074 14073 1813 1812 1144 1688 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18488 r0 *1 169.12,257.04
X$18488 14074 14073 1861 1933 1144 1756 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18493 r0 *1 173.6,196.56
X$18493 14074 14073 1296 1294 1144 1246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18501 r0 *1 330.96,246.96
X$18501 14074 14073 1852 1818 1144 1564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18503 m0 *1 330.96,277.2
X$18503 14074 14073 2131 2048 1144 1868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18581 m0 *1 167.44,327.6
X$18581 14074 14073 2605 2673 1144 2600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18584 m0 *1 195.44,388.08
X$18584 14074 14073 1144 3268 3103 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $18586 m0 *1 214.48,398.16
X$18586 14073 1144 2951 14074 3499 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $18589 r0 *1 198.8,337.68
X$18589 1144 14073 2674 2854 14074 2883 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18591 m0 *1 190.96,367.92
X$18591 1144 2905 2959 3103 14074 14073 3139 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $18594 r0 *1 243.6,357.84
X$18594 1144 14073 2714 3142 14074 3073 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18603 m0 *1 218.96,408.24
X$18603 3468 1353 3103 3577 1144 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $18605 m0 *1 246.4,388.08
X$18605 14074 14073 3339 1144 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $18650 r0 *1 260.4,206.64
X$18650 14074 14073 1402 1146 1353 1296 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18654 r0 *1 258.72,186.48
X$18654 14074 14073 1146 1252 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18664 r0 *1 183.68,378
X$18664 14074 1147 3268 14073 3205 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $18666 m0 *1 180.32,388.08
X$18666 14074 14073 3267 1147 3268 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $18671 r0 *1 263.76,277.2
X$18671 14074 14073 2151 2100 1147 1695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18674 r0 *1 223.44,327.6
X$18674 14074 14073 2746 2676 1147 2540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18676 r0 *1 243.6,236.88
X$18676 14074 14073 1758 1694 1147 1622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18682 m0 *1 254.24,357.84
X$18682 14074 14073 3022 2961 1147 2962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18690 m0 *1 232.96,428.4
X$18690 14074 3831 3958 3212 1147 14073 3618 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $18693 r0 *1 337.68,236.88
X$18693 14074 14073 1628 1460 1147 1564 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18766 r0 *1 201.04,357.84
X$18766 14074 14073 1147 2959 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18791 r0 *1 231.84,398.16
X$18791 1147 14073 3500 3407 14074 3470 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $18794 m0 *1 201.6,418.32
X$18794 14074 14073 3576 1147 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $18796 m0 *1 339.36,277.2
X$18796 14074 14073 2101 2049 1147 1868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18799 r0 *1 273.84,206.64
X$18799 14074 14073 1403 1148 1353 1300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18803 r0 *1 280,196.56
X$18803 14074 14073 1148 1334 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18806 r0 *1 288.4,206.64
X$18806 14074 14073 1405 1149 1355 1300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18810 r0 *1 295.12,196.56
X$18810 14074 14073 1150 1303 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18849 m0 *1 631.68,186.48
X$18849 14074 14073 1315 1159 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $18860 m0 *1 743.68,236.88
X$18860 14074 1752 1601 1369 1242 1572 1267 1162 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $18863 m0 *1 752.64,216.72
X$18863 14074 1606 1642 1369 1162 1571 1269 1221 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $18914 m0 *1 306.32,206.64
X$18914 14074 14073 1352 1175 1353 1234 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18921 m0 *1 285.6,196.56
X$18921 14074 14073 1175 1282 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18923 m0 *1 319.76,206.64
X$18923 14074 14073 1388 1176 1353 1349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $18928 r0 *1 324.24,186.48
X$18928 14074 14073 1176 1207 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $18963 m0 *1 455.84,246.96
X$18963 14073 1872 1184 14074 1764 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $18978 r0 *1 568.96,287.28
X$18978 14074 14073 1308 1187 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19016 r0 *1 196,287.28
X$19016 2145 14073 1195 1196 14074 2260 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19018 m0 *1 143.36,297.36
X$19018 2205 14073 1195 1196 14074 2143 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19037 r0 *1 155.68,257.04
X$19037 1931 14073 1195 1196 14074 1932 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19040 r0 *1 169.12,226.8
X$19040 1612 14073 1195 1196 14074 1555 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19042 m0 *1 211.12,277.2
X$19042 2096 14073 1195 1196 14074 2097 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19044 m0 *1 152.88,347.76
X$19044 14074 14073 3101 1195 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19047 r0 *1 207.76,357.84
X$19047 14073 1195 1196 14074 3019 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19049 m0 *1 186.48,327.6
X$19049 2601 14073 1195 1196 14074 2712 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19052 m0 *1 149.52,337.68
X$19052 2807 14073 1195 1196 14074 2808 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19054 m0 *1 143.92,236.88
X$19054 1689 14073 1195 1196 14074 1690 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19057 m0 *1 143.92,216.72
X$19057 1482 14073 1195 1196 14074 1454 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19059 r0 *1 206.08,216.72
X$19059 1503 14073 1195 1196 14074 1534 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19064 r0 *1 146.72,196.56
X$19064 1248 14073 1195 1196 14074 1326 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19066 r0 *1 143.92,307.44
X$19066 2467 14073 1195 1196 14074 2468 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $19100 r0 *1 222.88,357.84
X$19100 14074 14073 3101 1338 1196 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $19111 m0 *1 222.88,428.4
X$19111 14074 14073 3805 1196 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19115 r0 *1 190.4,357.84
X$19115 14074 14073 3018 3139 1197 3071 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19117 r0 *1 161.28,307.44
X$19117 14074 14073 2469 2408 1197 2444 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19119 r0 *1 211.68,257.04
X$19119 14074 14073 1973 1934 1197 1972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19121 r0 *1 160.72,337.68
X$19121 14074 14073 2810 2853 1197 2881 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19123 m0 *1 180.88,236.88
X$19123 14074 14073 1732 1613 1197 1734 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19126 m0 *1 192.08,196.56
X$19126 14074 14073 1280 1297 1197 1279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19128 m0 *1 150.08,216.72
X$19128 14074 14073 1455 1483 1197 1484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19131 r0 *1 150.64,287.28
X$19131 14074 14073 2255 2208 1197 2207 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19134 m0 *1 220.64,236.88
X$19134 14074 14073 1736 1616 1197 1737 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19137 r0 *1 158.48,236.88
X$19137 14074 14073 1798 1692 1197 1841 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19139 r0 *1 204.4,307.44
X$19139 14074 14073 2472 2473 1197 2409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19142 m0 *1 165.2,277.2
X$19142 14074 14073 2041 2042 1197 2125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19144 r0 *1 216.72,206.64
X$19144 14074 14073 1399 1348 1197 1434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19147 m0 *1 163.52,206.64
X$19147 14074 14073 1383 1347 1197 1295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19168 r0 *1 215.6,267.12
X$19168 14074 14073 2044 2023 1197 2128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19171 m0 *1 182.56,367.92
X$19171 14074 14073 3165 1197 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19174 r0 *1 183.12,196.56
X$19174 1327 1249 1328 1198 1280 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19177 r0 *1 210.56,196.56
X$19177 14074 1199 14073 1384 1299 1301 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $19187 m0 *1 270.48,206.64
X$19187 14074 14073 1350 1296 1353 1202 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19191 m0 *1 268.8,196.56
X$19191 14074 14073 1203 1253 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19194 m0 *1 288.96,196.56
X$19194 14074 1282 14073 1254 1335 1255 1204 1256
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19203 m0 *1 302.4,196.56
X$19203 14074 14073 1205 1256 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19206 m0 *1 297.36,206.64
X$19206 14074 14073 1351 1234 1353 1206 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19209 m0 *1 319.2,196.56
X$19209 14074 1207 14073 1254 1283 1255 1257 1258
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19267 m0 *1 602.56,660.24
X$19267 14073 6924 6869 14074 1218 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $19342 m0 *1 663.04,257.04
X$19342 1219 1810 1638 1928 14074 14073 1950 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $19353 r0 *1 784,206.64
X$19353 14074 14073 1444 1220 1418 1391 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19357 r0 *1 814.8,236.88
X$19357 14074 14073 1751 1220 1585 1577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19362 r0 *1 724.64,297.36
X$19362 14074 14073 2395 1220 2239 2225 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19412 r0 *1 788.48,388.08
X$19412 14074 14073 3419 1220 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19423 m0 *1 771.12,236.88
X$19423 14074 14073 1643 1644 1711 1220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19425 m0 *1 744.8,226.8
X$19425 14074 1808 1601 1221 1417 1572 1575 1269 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $19492 r0 *1 876.96,246.96
X$19492 14074 1225 14175 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $19597 r0 *1 743.68,226.8
X$19597 14074 1605 1642 1242 1267 1571 1575 1417 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $19612 m0 *1 722.96,660.24
X$19612 14074 14073 1243 6841 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $19614 r0 *1 840,781.2
X$19614 14074 14073 1243 8868 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19623 r0 *1 110.32,196.56
X$19623 1245 14073 14074 1293 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $19649 m0 *1 181.44,357.84
X$19649 3017 1249 2997 2958 3018 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19651 r0 *1 199.92,317.52
X$19651 2675 1249 2603 2602 2472 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19653 r0 *1 183.68,367.92
X$19653 14074 14073 1249 3205 3165 3189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19655 m0 *1 149.52,297.36
X$19655 2206 1249 2313 2280 2255 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19676 m0 *1 201.6,277.2
X$19676 2127 1249 2126 2071 1973 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19678 m0 *1 147.28,246.96
X$19678 1691 1249 1730 1811 1798 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19681 m0 *1 171.36,236.88
X$19681 1731 1249 1693 1733 1732 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19683 m0 *1 211.12,287.28
X$19683 2209 1249 2147 2146 2044 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19685 m0 *1 156.24,267.12
X$19685 2021 1249 2020 2040 2041 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19687 m0 *1 203.84,378
X$19687 14074 3238 14073 3206 3104 1249 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $19689 r0 *1 152.88,327.6
X$19689 2786 1249 2809 2787 2810 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19691 m0 *1 156.24,317.52
X$19691 2537 1249 2514 2575 2469 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19693 m0 *1 211.12,236.88
X$19693 1663 1249 1735 1615 1736 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19695 r0 *1 146.16,216.72
X$19695 1661 1249 1530 1554 1455 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19698 m0 *1 212.8,206.64
X$19698 1384 1249 1386 1385 1399 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19700 m0 *1 154,206.64
X$19700 1382 1249 1381 1250 1383 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $19710 r0 *1 202.72,196.56
X$19710 14074 1298 14073 1327 1299 1251 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $19712 m0 *1 254.8,206.64
X$19712 14074 1252 14073 1254 1333 1255 1302 1253
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19720 m0 *1 319.76,236.88
X$19720 14074 1627 14073 1254 1739 1255 1741 1696
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19742 m0 *1 238,257.04
X$19742 14074 1936 14073 1254 1974 1255 1862 1935
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19744 m0 *1 271.04,246.96
X$19744 14074 1814 14073 1254 1847 1255 1846 1815
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19746 m0 *1 236.88,307.44
X$19746 14074 2410 14073 1254 2448 1255 2349 2411
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19748 r0 *1 231.84,327.6
X$19748 14074 2789 14073 1254 2833 1255 2834 2747
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19750 m0 *1 255.36,297.36
X$19750 14074 2282 14073 1254 2378 1255 2211 2283
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19752 m0 *1 287.28,287.28
X$19752 14074 2316 14073 1254 2261 1255 2262 2152
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19756 m0 *1 250.88,367.92
X$19756 14074 1254 14073 3022 3021 1255 3169 3020
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19758 r0 *1 283.36,196.56
X$19758 14074 1334 14073 1254 1404 1255 1387 1303
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19762 r0 *1 241.92,206.64
X$19762 14074 1400 14073 1254 1435 1255 1486 1401
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19765 r0 *1 319.2,206.64
X$19765 14074 1488 14073 1254 1436 1255 1406 1407
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19767 r0 *1 301.28,246.96
X$19767 14074 1915 14073 1254 1849 1255 1848 1816
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19769 m0 *1 318.64,267.12
X$19769 14074 2028 14073 1254 2026 1255 2027 1999
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $19821 r0 *1 330.96,186.48
X$19821 14074 14073 1304 1258 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $19830 r0 *1 444.64,236.88
X$19830 1820 1260 1803 1702 14074 14073 1748 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $19832 r0 *1 435.12,216.72
X$19832 14074 1261 1512 1513 1462 1362 1510 1511 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $19860 m0 *1 711.2,216.72
X$19860 14074 14073 1492 1265 1571 1368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $19862 r0 *1 700,216.72
X$19862 14074 1545 1572 1368 1367 1640 1449 1265 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $19886 m0 *1 799.68,226.8
X$19886 14074 1646 1601 1419 1519 1713 1577 1270 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $19978 m0 *1 657.44,257.04
X$19978 14074 1887 1288 14073 1928 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $19996 r0 *1 75.6,246.96
X$19996 1292 14073 14074 1756 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $20015 r0 *1 154,196.56
X$20015 14074 1326 14073 1382 1299 1294 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20046 r0 *1 218.96,226.8
X$20046 14074 1534 14073 1663 1299 1617 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20048 r0 *1 222.88,246.96
X$20048 14074 14073 1338 1299 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20051 r0 *1 199.92,277.2
X$20051 14074 2260 14073 2127 1299 1994 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20054 r0 *1 150.08,236.88
X$20054 14074 1690 14073 1691 1299 1812 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20056 r0 *1 152.88,226.8
X$20056 14074 1454 14073 1661 1299 1502 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20059 m0 *1 175.28,226.8
X$20059 14074 1555 14073 1731 1299 1556 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20062 r0 *1 214.48,287.28
X$20062 14074 2097 14073 2209 1299 2149 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20064 r0 *1 161.84,257.04
X$20064 14074 1932 14073 2021 1299 1933 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20066 m0 *1 153.44,287.28
X$20066 14074 2143 14073 2206 1299 2187 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20069 m0 *1 152.88,327.6
X$20069 14074 2808 14073 2786 1299 2673 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20071 m0 *1 148.96,317.52
X$20071 14074 2468 14073 2537 1299 2470 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20074 m0 *1 193.2,327.6
X$20074 14074 2712 14073 2675 1299 2674 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20142 r0 *1 419.44,297.36
X$20142 14074 2390 1308 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $20144 m0 *1 496.16,307.44
X$20144 14074 14073 1308 2419 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20146 r0 *1 677.6,317.52
X$20146 14074 1308 2295 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $20148 m0 *1 558.88,307.44
X$20148 14074 1308 2421 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $20191 r0 *1 616,267.12
X$20191 14074 14073 2053 1315 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20249 m0 *1 830.48,519.12
X$20249 14073 1318 4833 14074 5013 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20252 m0 *1 975.52,428.4
X$20252 14074 3734 1318 3875 3686 2130 3299 3735 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $20254 m0 *1 967.68,509.04
X$20254 14074 14073 1318 4764 4870 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20256 r0 *1 911.68,509.04
X$20256 14074 14073 1318 4874 4838 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20260 r0 *1 573.44,216.72
X$20260 14074 1547 1318 1498 1544 1681 1499 1497 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $20262 r0 *1 1055.6,307.44
X$20262 14074 14073 1318 2516 2258 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20265 r0 *1 959.84,317.52
X$20265 14074 14073 1318 2644 2645 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20267 r0 *1 852.32,428.4
X$20267 14074 14073 1318 3881 3882 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20269 r0 *1 573.44,357.84
X$20269 14074 14073 1318 3031 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20271 m0 *1 554.4,367.92
X$20271 14074 14073 2923 1318 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20286 r0 *1 1079.12,226.8
X$20286 14074 1653 14073 1431 1738 1320 1654 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $20359 r0 *1 1056.16,720.72
X$20359 14073 1337 7635 14074 7906 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20372 r0 *1 1057.28,710.64
X$20372 14074 1337 7546 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $20437 m0 *1 450.8,236.88
X$20437 14073 1749 1341 14074 1675 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20473 m0 *1 328.16,206.64
X$20473 14074 14073 1354 1389 1355 1349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20476 m0 *1 276.08,388.08
X$20476 1350 1507 1351 3340 14073 14074 3215 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20479 r0 *1 362.88,468.72
X$20479 14074 14073 4344 1350 2320 4408 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20481 m0 *1 330.96,458.64
X$20481 14074 14073 4183 1350 2606 1354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20497 r0 *1 276.08,408.24
X$20497 14074 14073 3649 2610 1350 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20499 r0 *1 285.04,398.16
X$20499 14073 1350 3441 14074 3272 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20501 m0 *1 326.48,367.92
X$20501 14074 1350 14073 3108 2759 3107 3146 2911
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $20503 m0 *1 323.68,438.48
X$20503 14074 1975 14073 3410 4086 2967 1350 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $20505 r0 *1 363.44,367.92
X$20505 14074 14073 1350 3248 3194 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20507 m0 *1 351.12,367.92
X$20507 14073 2608 3147 1350 2544 3109 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $20509 m0 *1 342.16,398.16
X$20509 14073 14074 3506 2759 1350 2757 3507 3475
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $20511 r0 *1 282.8,337.68
X$20511 14074 14073 2857 1351 2606 1405 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20513 r0 *1 271.6,388.08
X$20513 3441 14073 14074 1351 1507 3340 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $20515 m0 *1 371.28,337.68
X$20515 1351 2474 2477 2819 2759 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $20517 r0 *1 318.64,327.6
X$20517 14074 1351 2680 14073 2752 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20520 r0 *1 364,408.24
X$20520 14073 1351 14074 2755 3628 3110 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20523 r0 *1 334.88,337.68
X$20523 14074 14073 2864 1351 2911 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $20526 m0 *1 373.52,498.96
X$20526 14074 14073 4614 1351 2320 4810 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20550 m0 *1 283.92,327.6
X$20550 14073 2541 1351 14074 2719 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20552 r0 *1 294,408.24
X$20552 2414 14073 2542 1351 14074 3582 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20556 r0 *1 344.96,408.24
X$20556 14074 1351 14073 3626 2816 3344 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20558 m0 *1 363.44,347.76
X$20558 14074 2910 14073 2865 2914 1351 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20560 m0 *1 313.6,307.44
X$20560 14074 2380 1352 14073 2451 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $20567 m0 *1 330.96,317.52
X$20567 14074 2289 2479 2544 2585 2647 1352 1867 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $20569 r0 *1 285.6,297.36
X$20569 14074 14073 2450 2286 1353 2315 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20571 r0 *1 277.2,307.44
X$20571 14074 2519 14073 2610 2413 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20573 m0 *1 267.68,317.52
X$20573 14074 2579 14073 2541 2605 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20576 m0 *1 263.2,307.44
X$20576 14074 14073 2449 2151 1353 2413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20578 r0 *1 259.84,327.6
X$20578 14073 2748 14074 2749 2790 1353 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20580 r0 *1 257.6,257.04
X$20580 14074 14073 1975 1758 1353 1813 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20583 r0 *1 275.52,257.04
X$20583 14074 14073 1976 1759 1353 1861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20586 m0 *1 262.64,367.92
X$20586 14074 14073 3028 3022 1353 2908 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20588 m0 *1 245.84,337.68
X$20588 14074 14073 2811 2746 1353 2812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20591 m0 *1 260.4,337.68
X$20591 14074 14073 2679 2813 1353 2749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20594 r0 *1 246.96,317.52
X$20594 14074 14073 2643 2281 1353 2605 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20596 r0 *1 238.56,367.92
X$20596 1353 3073 3072 3168 14073 14074 3212 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $20599 r0 *1 250.32,216.72
X$20599 14074 14073 1507 1506 1353 1457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20601 r0 *1 240.8,216.72
X$20601 14074 14073 1560 1505 1353 1506 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20603 m0 *1 228.48,408.24
X$20603 14074 3168 14073 3619 3534 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20606 m0 *1 227.92,418.32
X$20606 14073 1353 14074 3645 3690 3468 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $20608 m0 *1 223.44,448.56
X$20608 14074 4145 1353 14073 4080 3910 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $20613 r0 *1 302.96,297.36
X$20613 14074 2153 14073 2380 2148 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20620 r0 *1 329.84,277.2
X$20620 14074 14073 2154 2101 1353 1993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20623 r0 *1 305.2,287.28
X$20623 14074 14073 2288 1760 1353 2148 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20625 m0 *1 324.24,246.96
X$20625 14074 14073 1817 1628 1353 1761 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20627 m0 *1 320.32,226.8
X$20627 14074 14073 1562 1356 1353 1563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20631 m0 *1 324.24,498.96
X$20631 14074 14073 4719 1353 2320 4720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20672 m0 *1 283.36,307.44
X$20672 14074 2350 14073 2580 2315 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20674 r0 *1 281.12,267.12
X$20674 14074 1997 14073 2078 1861 1353 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20677 r0 *1 260.96,347.76
X$20677 14073 1353 2908 14074 2963 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20680 r0 *1 264.32,357.84
X$20680 14074 14073 2751 2908 1353 2999 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20683 m0 *1 255.36,337.68
X$20683 14074 14073 1353 2748 2812 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20686 r0 *1 229.6,388.08
X$20686 14073 1353 3209 14074 3407 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20688 r0 *1 223.44,398.16
X$20688 1353 2959 3468 3268 14074 14073 3533 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $20690 r0 *1 223.44,438.48
X$20690 14074 14073 1353 4036 3910 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $20692 m0 *1 259.84,408.24
X$20692 14074 14073 3535 1353 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $20695 r0 *1 313.04,559.44
X$20695 14074 14073 5530 4720 5455 1353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20698 r0 *1 386.4,398.16
X$20698 14074 3539 1354 14073 2679 3510 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $20700 m0 *1 377.44,428.4
X$20700 14074 3811 14073 3812 2546 1354 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20703 r0 *1 380.8,468.72
X$20703 14074 14073 4346 1354 2320 4269 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20724 m0 *1 340.48,307.44
X$20724 14074 1354 14073 2480 2352 1817 2479 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $20727 r0 *1 347.76,297.36
X$20727 14074 2481 14073 1817 2351 2417 2383 1354
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $20729 m0 *1 313.04,388.08
X$20729 14074 3145 1405 14073 1508 1354 3345 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $20731 m0 *1 320.32,408.24
X$20731 1354 14073 3271 3272 14074 3712 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $20733 r0 *1 380.24,438.48
X$20733 14074 1354 14073 3836 3645 2816 4048 3344
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $20735 r0 *1 284.48,307.44
X$20735 14074 14073 2474 2285 1355 2315 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20737 m0 *1 271.6,307.44
X$20737 14074 14073 2414 2284 1355 2413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20740 r0 *1 259.84,246.96
X$20740 14074 14073 1864 1843 1355 1813 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20742 r0 *1 272.72,267.12
X$20742 14074 14073 2046 1996 1355 1861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20744 r0 *1 262.08,398.16
X$20744 14074 14073 3535 1355 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20747 r0 *1 323.12,216.72
X$20747 14074 14073 1508 1489 1355 1563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20750 m0 *1 322.56,277.2
X$20750 14074 14073 2132 2131 1355 1993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20752 m0 *1 299.6,297.36
X$20752 14074 14073 2287 1937 1355 2148 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20754 r0 *1 322.56,246.96
X$20754 14074 14073 1867 1852 1355 1761 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20774 r0 *1 271.6,307.44
X$20774 14073 1355 2284 14074 2519 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20777 m0 *1 262.64,317.52
X$20777 14073 1355 2518 14074 2579 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20780 r0 *1 264.32,317.52
X$20780 14074 14073 2606 2518 1355 2605 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $20782 r0 *1 280.56,297.36
X$20782 14073 1355 2285 14074 2350 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20784 m0 *1 275.52,267.12
X$20784 14073 1355 1996 14074 1997 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20786 m0 *1 265.44,357.84
X$20786 14074 2963 14073 3074 2999 1355 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $20788 m0 *1 300.16,287.28
X$20788 14073 1355 1937 14074 2153 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $20795 r0 *1 319.76,216.72
X$20795 14074 14073 1356 1488 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $20856 m0 *1 401.52,257.04
X$20856 14074 14073 1357 14160 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $20990 m0 *1 1072.4,730.8
X$20990 14074 1376 8194 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $20992 m0 *1 1068.48,720.72
X$20992 14073 7635 1376 7814 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $20997 r0 *1 1146.88,206.64
X$20997 14074 14073 1431 1378 1589 1379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21032 r0 *1 395.36,357.84
X$21032 14073 2479 1388 14074 3082 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21035 r0 *1 386.4,357.84
X$21035 14074 1388 14073 2481 3010 2967 1864 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $21046 m0 *1 779.52,236.88
X$21046 14074 1712 1601 1520 1645 1713 1644 1391 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $21063 r0 *1 454.72,236.88
X$21063 14074 1765 1394 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $21077 r0 *1 683.2,630
X$21077 14074 1396 6347 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $21079 m0 *1 685.44,630
X$21079 14074 14073 1396 6434 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $21091 m0 *1 244.72,226.8
X$21091 14074 14073 1505 1400 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21099 r0 *1 253.68,206.64
X$21099 14074 14073 1456 1401 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21102 m0 *1 308,317.52
X$21102 2543 14073 2416 1402 14074 2582 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21106 r0 *1 310.8,317.52
X$21106 14073 2479 1402 14074 2646 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $21108 r0 *1 292.32,347.76
X$21108 14073 2817 14074 1403 2862 2475 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21116 r0 *1 271.04,337.68
X$21116 14074 14073 2414 2814 1403 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21118 m0 *1 281.68,337.68
X$21118 14074 2815 14073 2837 1403 2606 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21120 r0 *1 291.2,337.68
X$21120 14074 14073 2838 2858 2679 1403 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21127 m0 *1 363.44,337.68
X$21127 14073 2610 14074 2818 2793 1405 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21129 r0 *1 393.68,468.72
X$21129 14074 14073 4316 1405 2320 4347 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21153 m0 *1 369.6,327.6
X$21153 1405 2610 2679 2792 14074 14073 2684 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $21155 m0 *1 376.88,327.6
X$21155 14074 2606 14073 2761 2615 2612 1405 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $21157 r0 *1 383.6,327.6
X$21157 14074 14073 1405 2795 2474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $21159 r0 *1 392,347.76
X$21159 14074 2547 14073 3029 2481 1405 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $21161 r0 *1 377.44,357.84
X$21161 14074 3274 14073 3079 3151 2479 1405 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $21163 m0 *1 379.12,357.84
X$21163 14074 2542 14073 2915 3080 2546 3009 1405
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $21165 m0 *1 303.52,428.4
X$21165 14074 1405 14073 3583 3807 3880 3752 3772
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $21167 r0 *1 352.24,398.16
X$21167 1405 14073 2679 2913 14074 3508 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $21170 m0 *1 370.72,317.52
X$21170 14074 2614 1405 2481 1562 2547 2417 2287 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $21176 r0 *1 343.84,206.64
X$21176 14074 14073 1408 1407 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $21214 m0 *1 641.76,267.12
X$21214 14073 2010 14074 1413 2092 1887 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $21235 m0 *1 1112.72,468.72
X$21235 14074 14073 4236 3739 1418 4227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21238 r0 *1 1098.72,236.88
X$21238 14074 14073 1725 1581 1418 1726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21242 m0 *1 1023.12,398.16
X$21242 14074 14073 3436 2929 1418 3177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21244 r0 *1 1098.72,498.96
X$21244 14074 14073 4767 4503 1418 4709 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21247 r0 *1 690.48,549.36
X$21247 14074 14073 5359 3544 1418 5193 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21249 m0 *1 965.44,619.92
X$21249 14074 14073 6363 4295 1418 6266 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21251 r0 *1 656.88,579.6
X$21251 14074 14073 5804 3663 1418 5440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21253 r0 *1 906.08,619.92
X$21253 14074 14073 6446 4163 1418 6360 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21255 m0 *1 831.04,347.76
X$21255 14074 14073 2887 2229 1418 2499 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21258 r0 *1 787.36,609.84
X$21258 14074 14073 6169 4571 1418 5750 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21261 r0 *1 899.36,267.12
X$21261 14074 14073 2080 1420 1418 2062 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21263 r0 *1 839.44,619.92
X$21263 14074 14073 6443 4317 1418 6358 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21265 m0 *1 705.04,327.6
X$21265 14074 14073 2694 2221 1418 2736 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21267 m0 *1 1102.08,408.24
X$21267 14074 14073 3492 2299 1418 3428 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21269 m0 *1 878.08,408.24
X$21269 14074 14073 3486 2984 1418 3362 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21306 m0 *1 1103.76,327.6
X$21306 14074 14073 2706 2063 1418 2707 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21309 r0 *1 557.76,388.08
X$21309 14074 14073 3391 3036 1418 3218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21311 r0 *1 552.16,337.68
X$21311 14074 14073 2844 1418 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $21340 m0 *1 827.68,640.08
X$21340 14074 2367 1420 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $21343 m0 *1 874.16,297.36
X$21343 14074 14073 2326 2176 1711 1420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21352 r0 *1 980.56,317.52
X$21352 14074 2300 2642 1423 2626 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21386 m0 *1 944.16,297.36
X$21386 14074 2300 2301 1423 2381 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21389 r0 *1 949.2,287.28
X$21389 14074 2300 2302 1423 2318 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21394 m0 *1 974.96,297.36
X$21394 14074 2300 2179 1423 2379 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21407 r0 *1 962.64,257.04
X$21407 14074 1423 14174 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $21416 m0 *1 931.84,307.44
X$21416 14074 2300 2434 1423 2445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21418 r0 *1 933.52,297.36
X$21418 14074 2300 2321 1423 2384 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $21481 r0 *1 941.36,579.6
X$21481 14074 14073 5866 5757 1432 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21483 r0 *1 1014.72,559.44
X$21483 14074 14073 5561 5562 1432 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21485 m0 *1 908.32,347.76
X$21485 14074 14073 2874 2726 1432 1579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21487 r0 *1 1171.52,246.96
X$21487 14074 14073 1910 1911 1432 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21489 r0 *1 1155.84,529.2
X$21489 14074 14073 5237 5166 1432 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21494 r0 *1 873.6,579.6
X$21494 14074 14073 5691 5692 1432 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21497 r0 *1 708.4,478.8
X$21497 14074 14073 4523 4357 1432 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21499 r0 *1 632.8,367.92
X$21499 14074 14073 3222 3252 1432 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21501 m0 *1 618.24,317.52
X$21501 14074 14073 2553 2554 1432 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21504 m0 *1 808.64,549.36
X$21504 14074 14073 5424 5425 1432 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21506 r0 *1 619.92,519.12
X$21506 14074 14073 5047 4824 1432 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21509 r0 *1 805.84,388.08
X$21509 14074 14073 3515 3229 1432 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21511 m0 *1 1081.92,388.08
X$21511 14074 14073 3377 3304 1432 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21551 r0 *1 929.04,398.16
X$21551 14074 14073 3559 3422 1432 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21553 m0 *1 1177.68,478.8
X$21553 14074 14073 4428 4298 1432 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21557 r0 *1 1174.88,398.16
X$21557 14074 14073 3433 3372 1432 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21560 m0 *1 1173.76,297.36
X$21560 14074 14073 2249 2251 1432 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21634 r0 *1 75.6,257.04
X$21634 1452 14073 14074 1989 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $21681 r0 *1 482.72,287.28
X$21681 14074 2327 1463 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $21705 m0 *1 608.72,257.04
X$21705 14074 1948 1648 1949 1881 1465 1827 1768 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $21765 m0 *1 892.08,216.72
X$21765 14074 1524 1648 1476 1525 1965 1474 1475 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $21789 m0 *1 913.92,337.68
X$21789 14074 14073 2839 1477 1481 2775 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21792 r0 *1 868.56,287.28
X$21792 14074 14073 2266 1477 1585 2233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21812 m0 *1 887.6,317.52
X$21812 14074 2367 1477 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $21833 r0 *1 983.92,257.04
X$21833 14074 14073 1528 1479 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $21845 r0 *1 918.96,408.24
X$21845 14074 14073 3603 2984 1481 3423 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21848 m0 *1 1019.2,579.6
X$21848 14074 14073 5704 4295 1481 5621 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21852 m0 *1 1148,529.2
X$21852 14074 14073 5086 4503 1481 5165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21857 r0 *1 882,579.6
X$21857 14074 14073 5792 4317 1481 5752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21859 r0 *1 820.96,559.44
X$21859 14074 14073 5580 4385 1481 5479 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21861 r0 *1 632.8,337.68
X$21861 14074 14073 2892 2221 1481 2738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21864 r0 *1 1173.76,297.36
X$21864 14074 14073 2186 2063 1481 2250 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21866 r0 *1 639.52,388.08
X$21866 14074 14073 3417 3036 1481 3353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21868 r0 *1 628.32,498.96
X$21868 14074 14073 4728 3663 1481 4692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21871 r0 *1 1174.88,388.08
X$21871 14074 14073 3370 2299 1481 3371 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21873 r0 *1 810.32,347.76
X$21873 14074 14073 3008 2229 1481 2979 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21876 r0 *1 1075.2,398.16
X$21876 14074 14073 3491 2929 1481 3303 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21906 r0 *1 690.48,498.96
X$21906 14074 14073 4756 3544 1481 4695 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21909 m0 *1 1176.56,468.72
X$21909 14074 14073 4300 3739 1481 4297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21912 m0 *1 936.32,579.6
X$21912 14074 14073 5756 4163 1481 5755 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21916 m0 *1 1174.32,257.04
X$21916 14074 14073 1971 1581 1481 1909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $21998 r0 *1 101.92,226.8
X$21998 1501 14073 14074 1688 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $22015 m0 *1 282.24,448.56
X$22015 14074 4085 1504 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22033 r0 *1 235.76,287.28
X$22033 14074 1504 1757 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22037 r0 *1 146.72,357.84
X$22037 14074 1504 2536 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22042 m0 *1 282.24,458.64
X$22042 14074 1504 14180 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22044 r0 *1 54.32,488.88
X$22044 14074 1504 3822 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22047 r0 *1 40.88,357.84
X$22047 14074 1504 2340 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22052 m0 *1 164.08,468.72
X$22052 14074 1504 3578 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22056 m0 *1 304.64,509.04
X$22056 14074 1504 4203 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22058 r0 *1 458.64,478.8
X$22058 14074 1504 3652 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22060 m0 *1 411.6,398.16
X$22060 14074 1504 2616 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $22073 r0 *1 372.96,498.96
X$22073 14074 14073 4877 1507 2320 4811 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22091 m0 *1 292.32,347.76
X$22091 14073 14074 2909 1507 2679 2859 2937 2815
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $22093 r0 *1 307.44,357.84
X$22093 14074 2913 14073 3144 1507 2414 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22096 m0 *1 313.04,357.84
X$22096 14074 14073 1507 3004 3026 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $22098 m0 *1 311.36,347.76
X$22098 14074 2414 14073 2811 2938 2914 1507 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22100 r0 *1 324.24,428.4
X$22100 14074 2288 14073 3410 3775 2967 1507 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22102 r0 *1 369.04,378
X$22102 14074 2683 14073 3450 1507 3110 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22104 r0 *1 373.52,398.16
X$22104 14073 14074 3538 2759 1507 2474 3477 3509
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $22107 r0 *1 358.96,337.68
X$22107 14073 1508 2474 14074 2683 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22111 r0 *1 325.36,468.72
X$22111 14074 14073 4342 1508 2320 4471 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22123 r0 *1 350,307.44
X$22123 14074 1508 14073 2482 2483 2154 2484 2479
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $22125 m0 *1 349.44,307.44
X$22125 14074 2481 14073 2154 2351 2417 2522 1508
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $22127 m0 *1 355.6,418.32
X$22127 14074 2132 14073 2760 3754 2541 1508 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22129 m0 *1 307.44,438.48
X$22129 14074 14073 3834 2287 3710 1508 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22131 r0 *1 343.84,367.92
X$22131 14073 14074 3216 3027 2608 1508 3247 3246
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $22133 r0 *1 356.72,388.08
X$22133 14074 3448 2543 1508 2546 2816 3447 2287 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $22135 m0 *1 323.12,388.08
X$22135 14073 14074 3383 1508 2859 2759 3384 3474
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $22167 m0 *1 502.32,287.28
X$22167 14074 14073 2108 1512 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22204 m0 *1 774.48,670.32
X$22204 14074 14073 1517 7091 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22231 m0 *1 939.12,347.76
X$22231 14074 14073 2882 2776 1522 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22234 m0 *1 1015.84,539.28
X$22234 14074 14073 5303 5157 1522 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22236 r0 *1 1030.96,287.28
X$22236 14074 14073 2183 2184 1522 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22238 r0 *1 959.84,539.28
X$22238 14074 14073 5231 5181 1522 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22242 m0 *1 946.4,418.32
X$22242 14074 14073 3675 3548 1522 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22244 r0 *1 1017.52,438.48
X$22244 14074 14073 4038 3943 1522 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22246 m0 *1 729.12,367.92
X$22246 14074 14073 3121 3152 1522 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22248 r0 *1 813.68,498.96
X$22248 14074 14073 4700 4630 1522 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22250 r0 *1 607.04,478.8
X$22250 14074 14073 4529 4352 1522 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22252 r0 *1 742.56,529.2
X$22252 14074 14073 5077 4758 1522 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22254 r0 *1 935.76,236.88
X$22254 14074 14073 1804 1778 1522 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22258 m0 *1 552.16,428.4
X$22258 14074 14073 3818 3780 1522 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22260 r0 *1 745.36,438.48
X$22260 14074 14073 4009 3932 1522 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22262 m0 *1 799.68,448.56
X$22262 14074 14073 4055 3936 1522 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22303 r0 *1 878.08,519.12
X$22303 14074 14073 4939 4940 1522 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22333 m0 *1 977.2,287.28
X$22333 14074 14073 1528 1965 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22335 r0 *1 954.24,277.2
X$22335 14074 2014 1528 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $22337 m0 *1 1026.48,267.12
X$22337 14074 14073 1528 1900 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22340 r0 *1 1048.88,257.04
X$22340 14074 14073 1528 2019 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22343 r0 *1 1057.84,246.96
X$22343 14074 14073 1528 1838 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22346 m0 *1 1155.84,236.88
X$22346 14074 1792 1729 1529 1658 1727 1592 1659 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $22361 m0 *1 1122.8,297.36
X$22361 14074 14073 2245 2063 1532 2246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22363 m0 *1 1117.2,277.2
X$22363 14074 14073 2070 1581 1532 1968 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22368 m0 *1 1109.36,559.44
X$22368 14074 14073 5428 4503 1532 5297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22371 m0 *1 1120,357.84
X$22371 14074 14073 3070 2299 1532 3062 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22373 r0 *1 1003.52,609.84
X$22373 14074 14073 6267 4295 1532 6090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22375 r0 *1 705.6,579.6
X$22375 14074 14073 5801 3544 1532 5292 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22377 r0 *1 926.8,609.84
X$22377 14074 14073 6289 4163 1532 6085 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22379 m0 *1 644.56,559.44
X$22379 14074 14073 5290 3663 1532 5291 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22382 r0 *1 857.92,609.84
X$22382 14074 14073 6294 4317 1532 6079 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22384 r0 *1 1118.88,418.32
X$22384 14074 14073 3741 3739 1532 3742 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22386 r0 *1 756.56,599.76
X$22386 14074 14073 6002 4571 1532 5914 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22462 m0 *1 465.36,297.36
X$22462 14074 14073 2294 1543 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22542 r0 *1 301.84,428.4
X$22542 14074 2078 1560 14073 3880 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22544 m0 *1 294.56,428.4
X$22544 14074 2967 14073 3651 3750 1560 2965 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22550 m0 *1 304.08,418.32
X$22550 2414 14073 2759 1560 14074 3692 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $22558 r0 *1 375.2,307.44
X$22558 14074 2684 14073 2613 1562 2479 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $22588 r0 *1 439.04,236.88
X$22588 14074 1701 1567 14073 1803 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $22592 r0 *1 491.12,226.8
X$22592 14074 14073 1677 1568 1632 1678 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22613 m0 *1 600.32,277.2
X$22613 14074 2094 1648 2217 2112 1571 2113 2167 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $22619 m0 *1 703.92,236.88
X$22619 14073 1571 1710 14074 1683 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $22626 m0 *1 708.96,236.88
X$22626 14074 14073 1709 1573 1572 1710 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22656 m0 *1 706.16,257.04
X$22656 14074 1640 14073 1709 1883 1884 1574 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $22707 r0 *1 888.72,297.36
X$22707 14074 14073 2367 1579 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22721 r0 *1 670.32,297.36
X$22721 14074 2224 1580 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $22723 r0 *1 708.4,297.36
X$22723 14074 14073 1580 2331 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22736 r0 *1 1010.24,287.28
X$22736 14074 14073 2181 1581 2305 1836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22739 r0 *1 1022.56,287.28
X$22739 14074 14073 2182 1581 2239 1902 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22742 m0 *1 1100.96,267.12
X$22742 14074 14073 1967 1581 1585 1905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22796 m0 *1 1092.56,267.12
X$22796 14074 14073 1903 1904 1711 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22802 r0 *1 942.48,246.96
X$22802 14074 14073 1895 1896 1583 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22804 r0 *1 939.68,226.8
X$22804 14074 14073 1668 1652 1651 1581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22809 m0 *1 1007.44,640.08
X$22809 14074 6653 1581 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $22822 r0 *1 958.72,337.68
X$22822 14074 14073 2875 2779 1583 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22824 m0 *1 999.04,539.28
X$22824 14074 14073 5247 5232 1583 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22828 m0 *1 973.84,418.32
X$22828 14074 14073 3616 3605 1583 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22830 r0 *1 1049.44,539.28
X$22830 14074 14073 5293 5160 1583 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22832 r0 *1 899.36,529.2
X$22832 14074 14073 5183 4837 1583 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22835 m0 *1 1036,418.32
X$22835 14074 14073 3677 3737 1583 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22837 r0 *1 770,529.2
X$22837 14074 14073 5190 4829 1583 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22839 m0 *1 851.2,498.96
X$22839 14074 14073 4781 4632 1583 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22842 m0 *1 756,458.64
X$22842 14074 14073 4135 3933 1583 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22844 r0 *1 626.08,488.88
X$22844 14074 14073 4418 4354 1583 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22847 r0 *1 742,357.84
X$22847 14074 14073 3041 3042 1583 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22850 m0 *1 820.96,438.48
X$22850 14074 14073 3970 3937 1583 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22853 r0 *1 1052.8,297.36
X$22853 14074 14073 2377 2242 1583 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22856 m0 *1 503.44,448.56
X$22856 14074 14073 4002 3920 1583 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22898 r0 *1 507.92,408.24
X$22898 14074 14073 3411 1583 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22906 m0 *1 1102.64,307.44
X$22906 14074 14073 2306 2063 1585 2307 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22908 r0 *1 1103.76,418.32
X$22908 14074 14073 3738 3739 1585 3740 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22912 r0 *1 824.88,297.36
X$22912 14074 14073 2392 2229 1585 2298 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22914 r0 *1 1103.2,367.92
X$22914 14074 14073 3190 2299 1585 3131 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22916 r0 *1 872.48,388.08
X$22916 14074 14073 3359 2984 1585 3293 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22918 r0 *1 1002.4,367.92
X$22918 14074 14073 3126 2929 1585 3127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22938 m0 *1 1118.88,236.88
X$22938 14074 1728 1729 1656 1726 1727 1587 1588 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $22940 r0 *1 1111.6,236.88
X$22940 14074 1790 1791 1656 1726 1838 1587 1588 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $22954 m0 *1 1114.4,246.96
X$22954 14074 14073 1797 1790 1589 1839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22957 m0 *1 1150.8,246.96
X$22957 14074 14073 1840 1793 1589 1912 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22960 r0 *1 1065.68,287.28
X$22960 14074 14073 2258 2256 1589 2257 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $22971 r0 *1 1111.6,337.68
X$22971 14074 14073 2130 1589 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $22973 m0 *1 1064.56,367.92
X$22973 14074 14073 2996 3137 1589 3130 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23024 r0 *1 715.68,418.32
X$23024 14073 3668 4323 1601 3760 1987 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23027 r0 *1 730.8,307.44
X$23027 14073 2589 2427 1601 2426 1987 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23060 r0 *1 708.4,529.2
X$23060 14074 5074 1601 5147 5225 3563 5146 5193 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23062 m0 *1 711.2,549.36
X$23062 14074 5075 1601 5226 5292 3563 5224 5368 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23064 r0 *1 710.64,418.32
X$23064 14074 14073 1601 3760 3888 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23066 m0 *1 710.64,478.8
X$23066 14074 4248 1601 4287 4357 3563 4422 4217 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23068 r0 *1 708.4,498.96
X$23068 14074 4158 1601 4627 4695 3563 4696 4625 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23070 r0 *1 756,438.48
X$23070 14074 3815 1601 4010 3933 3563 3932 3934 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23072 r0 *1 750.4,428.4
X$23072 14074 3886 1601 3672 3730 3563 3671 3600 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23075 m0 *1 756,378
X$23075 14074 3288 1601 3044 3042 2504 3152 3043 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23077 r0 *1 756.56,378
X$23077 14074 3289 1601 3224 3195 2504 3223 3225 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23079 r0 *1 810.88,378
X$23079 14074 3290 1601 3291 3229 2504 3227 3228 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23082 m0 *1 817.04,367.92
X$23082 14074 3173 1601 3124 2979 2504 3122 3049 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23087 r0 *1 735.28,297.36
X$23087 14074 14073 1601 2426 2330 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23089 m0 *1 699.44,367.92
X$23089 14074 2691 1601 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $23092 m0 *1 762.16,267.12
X$23092 14074 1955 1601 2018 2016 1985 2013 2017 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23097 r0 *1 757.12,257.04
X$23097 14074 1954 1601 1957 1888 1985 1886 1956 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23100 m0 *1 530.88,226.8
X$23100 14074 1602 1607 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $23123 r0 *1 596.4,277.2
X$23123 14074 1607 2168 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $23129 r0 *1 119.28,337.68
X$23129 1609 14073 14074 2852 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23136 r0 *1 175.84,287.28
X$23136 1610 14073 14074 2259 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23172 r0 *1 226.8,236.88
X$23172 14074 1694 1757 1618 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $23181 m0 *1 233.52,236.88
X$23181 14074 1621 1757 1620 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $23207 m0 *1 289.52,236.88
X$23207 14074 1626 1757 1625 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $23214 r0 *1 325.36,226.8
X$23214 14074 14073 1628 1627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23237 r0 *1 638.4,378
X$23237 14074 14073 3283 3329 1632 3328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23239 m0 *1 450.24,297.36
X$23239 14074 14073 2106 2325 1632 2324 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23242 r0 *1 491.12,246.96
X$23242 14074 14073 1822 1856 1632 1924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23244 r0 *1 506.8,327.6
X$23244 14074 14073 2798 2686 1632 2687 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23259 m0 *1 644.56,337.68
X$23259 14074 2823 2012 2825 2767 1632 2690 2845 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23262 r0 *1 640.64,287.28
X$23262 14074 14073 2219 1632 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23313 m0 *1 733.6,287.28
X$23313 14074 2190 1642 2228 2225 2014 2172 2227 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23317 m0 *1 777.84,277.2
X$23317 14074 2138 1642 2018 2017 2014 1956 1957 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23320 m0 *1 742,267.12
X$23320 14074 2015 1642 2016 2013 2014 1886 1888 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23325 m0 *1 782.88,257.04
X$23325 14074 14073 1648 1642 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23380 m0 *1 699.44,378
X$23380 14074 3221 1648 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $23382 r0 *1 772.24,367.92
X$23382 14074 3045 1648 3044 3043 2772 3225 3224 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23384 m0 *1 822.64,378
X$23384 14074 3048 1648 3291 3228 2772 3049 3124 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23386 m0 *1 832.72,307.44
X$23386 14074 2498 1648 2365 2431 2432 2298 2232 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23389 r0 *1 835.52,317.52
X$23389 14074 2886 1648 2500 2499 2432 2563 2564 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23392 r0 *1 744.8,367.92
X$23392 14074 3046 1648 3042 3152 2772 3223 3195 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23395 r0 *1 792.4,307.44
X$23395 14074 2523 1648 2364 2361 2432 2267 2297 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23397 m0 *1 685.44,317.52
X$23397 14074 2590 1648 2455 2425 2180 2558 2559 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23400 r0 *1 809.76,367.92
X$23400 14074 3007 1648 3229 3227 2772 3122 2979 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23402 m0 *1 626.08,327.6
X$23402 14074 2737 1648 2554 2552 2180 2660 2738 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23404 m0 *1 652.96,317.52
X$23404 14074 2657 1648 2423 2422 2180 2556 2222 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23407 r0 *1 702.8,337.68
X$23407 14074 2618 1648 2695 2736 2180 2693 2770 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $23440 r0 *1 873.6,297.36
X$23440 14074 2367 1650 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $23442 m0 *1 1032.08,529.2
X$23442 14074 14073 5084 5158 1651 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23445 r0 *1 950.32,337.68
X$23445 14074 14073 2835 2777 1651 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23447 r0 *1 1032.08,267.12
X$23447 14074 14073 2073 2064 1651 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23449 r0 *1 967.68,529.2
X$23449 14074 14073 5083 5094 1651 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23451 m0 *1 950.32,438.48
X$23451 14074 14073 3959 3549 1651 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23453 m0 *1 1022,448.56
X$23453 14074 14073 3856 3873 1651 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23455 r0 *1 734.16,378
X$23455 14074 14073 3390 3223 1651 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23457 r0 *1 886.48,519.12
X$23457 14074 14073 4965 4835 1651 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23459 m0 *1 610.96,438.48
X$23459 14074 14073 3981 3841 1651 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23461 r0 *1 611.52,468.72
X$23461 14074 14073 4326 4284 1651 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23465 m0 *1 743.12,418.32
X$23465 14074 14073 3599 3671 1651 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23467 r0 *1 795.2,428.4
X$23467 14074 14073 3850 3851 1651 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23493 r0 *1 822.08,498.96
X$23493 14074 14073 4726 4629 1651 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23495 m0 *1 750.4,509.04
X$23495 14074 14073 4886 4760 1651 4385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23506 m0 *1 1075.76,246.96
X$23506 14074 14073 1788 1653 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23512 r0 *1 1040.48,347.76
X$23512 14074 1654 14073 2879 2988 2996 1653 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23522 m0 *1 1085.28,246.96
X$23522 14074 1788 14073 1840 1781 1797 1654 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23573 r0 *1 1030.96,236.88
X$23573 14074 14073 1664 1800 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23613 m0 *1 456.96,236.88
X$23613 14074 1676 1764 1675 1748 1750 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $23631 r0 *1 548.24,710.64
X$23631 14074 14073 1676 7562 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23633 m0 *1 546,710.64
X$23633 14074 1676 7699 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $23639 m0 *1 471.52,236.88
X$23639 14073 1703 1677 14074 1750 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23656 m0 *1 539.28,267.12
X$23656 14074 14073 2005 1681 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23668 m0 *1 640.64,307.44
X$23668 14074 14073 2171 1684 2162 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $23671 m0 *1 762.16,428.4
X$23671 3354 14074 1684 3815 14073 3789 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $23688 m0 *1 758.8,388.08
X$23688 14073 14074 1684 3354 3288 1887 3355 3173
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $23691 m0 *1 765.52,257.04
X$23691 1891 14074 1684 1955 14073 1890 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $23696 r0 *1 109.76,297.36
X$23696 1685 14073 14074 2406 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $23756 m0 *1 332.64,246.96
X$23756 14074 14073 1818 1696 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $23764 r0 *1 604.24,418.32
X$23764 14074 14073 3764 3595 1698 3659 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23767 m0 *1 379.68,267.12
X$23767 14074 14073 2029 2002 1698 1939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23769 r0 *1 384.72,267.12
X$23769 14073 1698 1940 14074 2086 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23771 r0 *1 470.4,347.76
X$23771 14074 14073 2945 2970 1698 2866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $23773 r0 *1 471.52,418.32
X$23773 14074 1698 3596 14073 3716 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $23814 m0 *1 750.4,488.88
X$23814 14074 1698 3516 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $23816 m0 *1 614.32,428.4
X$23816 14074 1698 3669 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $23819 m0 *1 512.96,287.28
X$23819 14074 2166 1698 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $23826 m0 *1 500.64,438.48
X$23826 14074 14073 1698 3919 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23830 m0 *1 499.52,357.84
X$23830 14073 1698 3112 14074 2919 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $23833 r0 *1 842.8,388.08
X$23833 14074 3308 1698 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $23836 r0 *1 838.88,347.76
X$23836 14074 1698 2980 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $23840 r0 *1 585.76,367.92
X$23840 14074 14073 1698 3279 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23842 m0 *1 392,408.24
X$23842 14074 14073 1698 3155 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23917 m0 *1 570.64,458.64
X$23917 14074 14073 4415 1699 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $23926 m0 *1 564.48,428.4
X$23926 14074 14073 3697 1701 3720 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $23928 m0 *1 558.88,438.48
X$23928 14073 14074 3922 1701 3034 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $23933 r0 *1 433.44,519.12
X$23933 4661 1701 5101 5045 14073 14074 5059 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $23945 r0 *1 545.44,347.76
X$23945 14073 2943 3013 1701 1987 2940 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $23955 r0 *1 456.96,246.96
X$23955 14074 1820 14073 1854 1921 1822 1703 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $23965 m0 *1 583.52,418.32
X$23965 3924 14073 14074 1706 3453 2355 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $23967 r0 *1 584.08,388.08
X$23967 3453 14074 1706 2355 14073 3782 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $24004 m0 *1 612.64,367.92
X$24004 14074 14073 3158 3117 1711 3036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24006 r0 *1 1102.64,297.36
X$24006 14074 14073 2243 2244 1711 2063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24008 r0 *1 690.48,529.2
X$24008 14074 14073 5073 5146 1711 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24010 r0 *1 964.32,599.76
X$24010 14074 14073 6087 6088 1711 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24012 r0 *1 899.36,599.76
X$24012 14074 14073 6082 6083 1711 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24014 m0 *1 625.52,539.28
X$24014 14074 14073 5221 5256 1711 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24016 m0 *1 1103.2,438.48
X$24016 14074 14073 3859 3860 1711 3739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24018 r0 *1 834.4,609.84
X$24018 14074 14073 6076 6077 1711 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24021 m0 *1 746.48,599.76
X$24021 14074 14073 5913 5838 1711 5615 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24023 r0 *1 820.4,307.44
X$24023 14074 14073 2430 2431 1711 2229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24026 r0 *1 708.4,317.52
X$24026 14074 14073 2457 2425 1711 2221 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24029 m0 *1 865.2,378
X$24029 14074 14073 3324 3292 1711 2984 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24031 m0 *1 1102.08,378
X$24031 14074 14073 3060 3178 1711 2299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24069 m0 *1 1006.88,378
X$24069 14074 14073 3076 3055 1711 2929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24071 r0 *1 1089.2,549.36
X$24071 14074 14073 5361 5296 1711 4503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24079 m0 *1 787.36,287.28
X$24079 14074 14073 2296 1713 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $24096 m0 *1 882,347.76
X$24096 14073 1717 14074 2794 2934 2925 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $24117 r0 *1 992.32,267.12
X$24117 14074 14073 1721 2437 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $24124 r0 *1 987.28,236.88
X$24124 14074 1780 14073 1742 1834 1801 1722 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $24127 m0 *1 1024.24,246.96
X$24127 14074 14073 1837 1723 1900 1836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24156 m0 *1 1112.72,267.12
X$24156 14074 1914 1729 1969 1904 1727 1905 1968 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24160 r0 *1 1155.28,267.12
X$24160 14074 1906 1729 1911 1907 1727 1908 1909 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24179 r0 *1 1066.8,277.2
X$24179 14074 2376 1729 2067 2065 2121 2122 2124 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24184 m0 *1 1091.44,317.52
X$24184 14074 2504 1729 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $24186 r0 *1 1074.08,307.44
X$24186 14074 2573 1729 2511 2568 2121 2510 2370 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24225 r0 *1 1075.76,236.88
X$24225 14074 14073 1738 1789 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $24252 r0 *1 889.84,257.04
X$24252 14074 14073 1893 1745 1965 1964 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24272 m0 *1 440.72,539.28
X$24272 1749 14073 5187 5211 14074 5212 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $24274 r0 *1 440.16,539.28
X$24274 14074 5277 1749 14073 5187 5211 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $24285 r0 *1 452.48,267.12
X$24285 14074 1872 14073 2106 2004 2051 1749 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $24287 m0 *1 456.4,418.32
X$24287 14074 14073 1987 1749 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $24307 r0 *1 220.08,297.36
X$24307 1754 14073 14074 2540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $24331 r0 *1 250.88,267.12
X$24331 14074 1995 1757 2076 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24339 m0 *1 285.6,277.2
X$24339 14074 2047 1757 2079 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24341 m0 *1 250.88,277.2
X$24341 14074 2100 1757 2099 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24343 m0 *1 212.8,317.52
X$24343 14074 2539 1757 2578 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24366 r0 *1 232.4,246.96
X$24366 14074 1863 1757 1862 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24368 r0 *1 227.92,287.28
X$24368 14074 14073 1757 14170 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $24370 r0 *1 231.28,277.2
X$24370 14074 2045 1757 2074 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24372 r0 *1 268.24,246.96
X$24372 14074 1865 1757 1846 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24376 r0 *1 239.68,297.36
X$24376 14074 2412 1757 2349 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24378 m0 *1 286.72,267.12
X$24378 14074 1998 1757 2024 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24380 m0 *1 229.04,297.36
X$24380 14074 2150 1757 2210 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24382 m0 *1 258.16,287.28
X$24382 14074 2212 1757 2211 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24384 r0 *1 283.36,287.28
X$24384 14074 2213 1757 2262 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24387 r0 *1 194.88,267.12
X$24387 14074 1994 1757 2071 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24389 r0 *1 210.56,277.2
X$24389 14074 2149 1757 2146 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24391 r0 *1 182,277.2
X$24391 14074 2145 1757 2144 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24393 m0 *1 173.6,277.2
X$24393 14074 1992 1757 2069 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24395 r0 *1 246.4,367.92
X$24395 14074 3142 1757 3169 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24397 r0 *1 238.56,347.76
X$24397 14074 2907 1757 2906 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24400 r0 *1 226.24,337.68
X$24400 14074 2855 1757 2885 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24402 m0 *1 229.04,337.68
X$24402 14074 2714 1757 2834 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24404 m0 *1 183.68,307.44
X$24404 14074 2348 1757 2347 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24406 r0 *1 190.4,327.6
X$24406 14074 2674 1757 2602 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24408 m0 *1 213.92,327.6
X$24408 14074 2676 1757 2604 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $24414 r0 *1 236.32,257.04
X$24414 14074 14073 1758 1936 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24420 m0 *1 272.16,257.04
X$24420 14074 14073 1759 1814 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24428 m0 *1 299.04,257.04
X$24428 14074 14073 1760 1915 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24475 r0 *1 920.08,690.48
X$24475 14074 14073 7479 3876 6966 1765 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24477 m0 *1 864.08,781.2
X$24477 14074 14073 1765 8820 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24479 r0 *1 794.64,730.8
X$24479 14074 8179 14073 8084 1765 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24482 r0 *1 758.24,841.68
X$24482 14074 9731 14073 9855 9856 1765 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $24484 r0 *1 469.28,640.08
X$24484 14073 14074 6671 6420 6595 6422 6922 1765
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $24533 m0 *1 758.24,307.44
X$24533 14074 2424 1773 14073 2360 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $24570 m0 *1 988.4,246.96
X$24570 14073 1781 1834 1917 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $24581 m0 *1 1025.92,257.04
X$24581 14073 1900 1783 14074 1899 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24585 m0 *1 1030.96,257.04
X$24585 14074 14073 1901 1784 1900 1902 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24593 r0 *1 1049.44,246.96
X$24593 14074 14073 1842 1786 1838 1785 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $24626 m0 *1 1039.92,700.56
X$24626 14073 1789 3427 14074 7557 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $24628 m0 *1 1034.88,700.56
X$24628 14074 14073 1789 7563 3427 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24641 r0 *1 972.16,378
X$24641 14074 3299 1791 3301 3297 2980 3298 3300 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24643 r0 *1 1065.68,378
X$24643 14074 3130 1791 3304 3314 2980 3367 3303 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24645 m0 *1 1069.6,357.84
X$24645 14074 3137 1791 2994 2991 2980 2992 2993 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24648 r0 *1 1076.88,317.52
X$24648 14074 2509 1791 2511 2568 2438 2510 2370 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24650 r0 *1 1011.92,337.68
X$24650 14074 2506 1791 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $24652 m0 *1 978.88,327.6
X$24652 14074 2716 1791 2642 2703 2180 2704 2715 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24655 m0 *1 1112.72,257.04
X$24655 14074 1839 1791 1969 1904 1838 1905 1968 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $24773 m0 *1 985.6,660.24
X$24773 14073 1800 2437 6884 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $24777 m0 *1 980.56,660.24
X$24777 14074 14073 2437 6968 1800 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $24808 r0 *1 753.2,246.96
X$24808 14074 1887 1808 14073 1857 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $24840 r0 *1 285.04,246.96
X$24840 14074 14073 1865 1815 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24848 r0 *1 313.04,246.96
X$24848 14074 14073 1866 1816 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $24937 m0 *1 908.32,720.72
X$24937 14074 1831 7752 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $24939 r0 *1 916.72,720.72
X$24939 14074 14073 1831 7996 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $25056 r0 *1 758.8,246.96
X$25056 1922 1889 1890 1857 14074 14073 2429 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25067 r0 *1 67.2,267.12
X$25067 1860 14073 14074 2038 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $25087 r0 *1 245.84,257.04
X$25087 14074 14073 1863 1935 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $25090 r0 *1 274.96,367.92
X$25090 14073 1976 3213 2078 1864 2542 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $25092 m0 *1 272.16,398.16
X$25092 14074 2046 1864 14073 3340 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25095 r0 *1 271.6,428.4
X$25095 14073 1864 14074 2643 3833 2078 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $25097 r0 *1 400.4,438.48
X$25097 14074 14073 4049 1864 2320 3916 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25099 m0 *1 323.12,337.68
X$25099 1864 14073 2679 2888 14074 2681 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25121 r0 *1 294,428.4
X$25121 2287 14073 2543 1864 14074 3772 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25123 r0 *1 277.76,398.16
X$25123 14074 2078 14073 3471 1864 3345 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25125 r0 *1 278.32,378
X$25125 14074 14073 2078 3443 1864 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25127 m0 *1 327.6,307.44
X$25127 14073 2046 1864 14074 2416 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25129 r0 *1 330.96,317.52
X$25129 14074 14073 2046 2607 1864 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25132 m0 *1 369.04,428.4
X$25132 2543 14073 1864 3883 14074 3811 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25134 r0 *1 398.72,388.08
X$25134 14073 1864 14074 2319 3348 2474 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $25136 m0 *1 390.88,378
X$25136 3110 1864 3171 3194 14074 14073 3083 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $25151 r0 *1 343.28,498.96
X$25151 14074 14073 4684 1867 2320 4685 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25153 r0 *1 320.32,388.08
X$25153 14074 2132 1867 14073 3345 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25157 r0 *1 340.48,458.64
X$25157 14073 3997 4151 1867 3777 2320 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $25182 m0 *1 288.96,327.6
X$25182 14074 14073 2678 2719 2542 1867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25184 m0 *1 292.32,408.24
X$25184 1867 14073 2474 3561 14074 3581 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $25186 r0 *1 322,307.44
X$25186 14074 2415 14073 2477 2452 2476 1867 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25188 m0 *1 319.2,307.44
X$25188 14074 14073 2415 2451 2416 1867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25191 r0 *1 326.48,327.6
X$25191 14074 2607 14073 2753 1867 2132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25193 r0 *1 333.2,428.4
X$25193 14073 14074 3835 1867 2755 2606 3776 2757
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $25196 m0 *1 329.28,337.68
X$25196 14074 2841 14073 2752 2889 2546 1867 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25198 r0 *1 325.36,398.16
X$25198 14073 1867 3562 2380 2606 2416 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $25237 r0 *1 540.96,418.32
X$25237 14074 14073 1872 3724 3719 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25239 r0 *1 537.04,337.68
X$25239 14074 14073 1872 2894 2798 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25269 r0 *1 526.96,337.68
X$25269 14074 14073 2869 2867 1878 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $25292 r0 *1 619.36,640.08
X$25292 14074 14073 1882 6710 6246 6608 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25308 r0 *1 710.08,408.24
X$25308 14074 3843 14073 3624 3668 1884 3484 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25310 m0 *1 730.24,317.52
X$25310 14074 2331 14073 2560 2589 1884 2696 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25325 m0 *1 722.4,458.64
X$25325 14074 1887 4158 14073 4187 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $25327 r0 *1 640.08,297.36
X$25327 2171 14074 2162 2219 14073 1887 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $25496 m0 *1 879.76,740.88
X$25496 14074 14073 8173 1917 7887 8055 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $25499 m0 *1 871.92,740.88
X$25499 14074 14073 1917 7329 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $25517 m0 *1 454.16,267.12
X$25517 14074 14073 1921 2088 2004 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $25524 r0 *1 524.16,257.04
X$25524 14074 14073 1981 1944 2005 1923 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25544 r0 *1 103.6,317.52
X$25544 1929 14073 14074 2600 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $25599 r0 *1 421.68,267.12
X$25599 14074 14073 2003 2030 2005 1941 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25606 r0 *1 536.48,317.52
X$25606 14074 14073 1943 14146 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $25660 r0 *1 540.96,317.52
X$25660 14074 2169 1943 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $25782 r0 *1 899.36,287.28
X$25782 14074 2235 2236 2118 2116 1965 2234 2237 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $25789 m0 *1 888.72,287.28
X$25789 14074 2387 2236 2062 2176 1965 2233 2177 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $25824 r0 *1 310.8,438.48
X$25824 14073 3772 14074 1975 4041 2078 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $25832 m0 *1 337.68,448.56
X$25832 14074 14073 4128 4088 2758 1975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $25842 m0 *1 282.24,347.76
X$25842 14074 2815 14073 2857 3001 1976 2414 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $25844 m0 *1 285.6,357.84
X$25844 1976 2965 2964 3023 2750 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $25888 m0 *1 732.48,297.36
X$25888 14074 2330 1985 2228 2225 2331 2172 2227 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $25891 m0 *1 759.36,297.36
X$25891 14074 14073 2428 1985 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $25900 m0 *1 900.48,700.56
X$25900 14074 14073 1986 7466 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $25902 r0 *1 904.4,700.56
X$25902 14074 7568 14073 7645 7552 1986 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $25908 r0 *1 600.32,327.6
X$25908 14073 2171 2766 14074 1987 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $25981 m0 *1 319.2,277.2
X$25981 14074 14073 2048 1999 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $26019 m0 *1 578.48,297.36
X$26019 14074 14073 2216 2007 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26037 m0 *1 646.8,287.28
X$26037 14074 14073 2171 2011 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26041 m0 *1 618.24,398.16
X$26041 14074 14073 3482 3283 2012 3518 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26056 r0 *1 606.48,327.6
X$26056 14074 14073 2766 2012 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26067 m0 *1 559.44,277.2
X$26067 14074 14073 2093 2111 2014 2055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26087 m0 *1 953.68,337.68
X$26087 14074 2625 2506 2779 2776 2014 2777 2778 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $26089 m0 *1 1009.68,317.52
X$26089 14074 14073 2014 2438 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26091 m0 *1 751.52,337.68
X$26091 14074 2014 2772 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $26093 r0 *1 812,307.44
X$26093 14074 14073 2014 2432 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26095 m0 *1 546.56,317.52
X$26095 14074 2166 2014 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $26127 r0 *1 1046.08,287.28
X$26127 14074 2257 2241 2242 2184 2019 2064 2120 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $26132 m0 *1 1065.68,287.28
X$26132 14074 2256 2241 2067 2065 2019 2122 2124 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $26168 m0 *1 330.4,267.12
X$26168 14074 14073 2101 2028 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $26235 m0 *1 340.48,488.88
X$26235 14074 14073 4551 2046 2320 4613 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26239 r0 *1 353.36,428.4
X$26239 14073 2751 14074 2913 3968 2046 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26257 m0 *1 295.12,438.48
X$26257 2046 14073 2967 2544 14074 4126 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $26261 r0 *1 353.36,347.76
X$26261 2046 2759 2758 2914 14074 14073 2939 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $26307 m0 *1 621.04,367.92
X$26307 14074 14073 2053 3726 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26309 m0 *1 529.76,367.92
X$26309 14074 14073 3113 2053 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $26313 m0 *1 658.56,579.6
X$26313 14074 14073 5717 3663 2054 5418 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26315 m0 *1 903.28,640.08
X$26315 14074 14073 6530 4163 2054 6263 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26317 r0 *1 952,630
X$26317 14074 14073 6448 4295 2054 6364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26319 r0 *1 714,579.6
X$26319 14074 14073 5800 3544 2054 5368 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26321 m0 *1 799.68,609.84
X$26321 14074 14073 6108 5615 2054 5840 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26323 m0 *1 848.96,640.08
X$26323 14074 14073 6559 4317 2054 6444 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26325 r0 *1 546.56,388.08
X$26325 14074 14073 3278 3036 2054 3219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26349 m0 *1 525.84,398.16
X$26349 14074 14073 2922 3114 2054 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $26361 r0 *1 642.88,267.12
X$26361 14074 2114 2092 2056 14073 2057 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $26367 r0 *1 654.08,277.2
X$26367 14074 2057 2359 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $26373 r0 *1 766.64,317.52
X$26373 14074 14073 2060 14145 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $26472 r0 *1 1035.44,317.52
X$26472 14074 14073 2639 2063 2305 2627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26474 r0 *1 1058.96,327.6
X$26474 14074 14073 2711 2063 2239 2568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26510 m0 *1 1021.44,630
X$26510 14074 6652 2063 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $26587 m0 *1 268.24,438.48
X$26587 14074 2078 2449 14073 3960 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $26592 m0 *1 315.84,438.48
X$26592 14074 2078 2288 14073 3963 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $26595 m0 *1 365.12,438.48
X$26595 14073 2816 3969 2078 3971 3968 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $26598 r0 *1 362.32,428.4
X$26598 14074 2078 3810 14073 3883 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $26623 m0 *1 273.84,438.48
X$26623 2078 2414 2817 3962 2474 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $26628 m0 *1 344.96,317.52
X$26628 14074 2608 14073 2585 2078 2541 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26630 r0 *1 292.88,357.84
X$26630 14074 3024 14073 2858 2967 2078 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26632 r0 *1 365.68,438.48
X$26632 14074 2078 14073 3999 3274 2751 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26675 m0 *1 535.36,327.6
X$26675 14074 2088 2733 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $26686 m0 *1 553.84,277.2
X$26686 14074 2109 2093 14073 2091 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $26761 m0 *1 501.76,367.92
X$26761 14074 14073 3113 2108 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $26797 m0 *1 854.56,670.32
X$26797 14074 14073 6991 2115 6966 5041 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26801 r0 *1 841.68,670.32
X$26801 14074 2115 7233 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $26873 r0 *1 951.44,317.52
X$26873 14074 14073 2645 2503 2130 2625 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26876 r0 *1 612.64,418.32
X$26876 14074 14073 3765 3725 2130 3764 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26882 r0 *1 841.68,428.4
X$26882 14074 14073 3882 3790 2130 3967 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26907 m0 *1 724.08,448.56
X$26907 14074 2130 4008 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $26921 r0 *1 323.68,317.52
X$26921 14074 2545 2132 14073 2543 2607 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $26924 r0 *1 319.2,378
X$26924 14073 3271 14074 3272 3214 2132 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $26928 m0 *1 346.64,448.56
X$26928 14074 3997 14073 3998 3645 2965 4150 2132
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $26930 r0 *1 356.72,438.48
X$26930 14074 3274 14073 4045 2414 2132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26932 m0 *1 351.12,468.72
X$26932 14074 14073 4314 2132 2320 4267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26949 m0 *1 334.32,327.6
X$26949 14073 2132 2682 14074 2722 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $26951 m0 *1 358.4,327.6
X$26951 14074 14073 2648 2683 2606 2132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26956 m0 *1 358.4,428.4
X$26956 14074 14073 3810 2414 2287 2132 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $26958 r0 *1 346.08,428.4
X$26958 14074 3713 14073 4044 2481 2132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26960 r0 *1 324.8,418.32
X$26960 14074 3712 14073 3808 3713 2132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $26989 r0 *1 10.08,287.28
X$26989 2202 14073 14074 2140 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $26992 r0 *1 115.36,347.76
X$26992 2141 14073 14074 2951 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27040 r0 *1 262.64,297.36
X$27040 14074 14073 2151 2282 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27047 r0 *1 301.28,287.28
X$27047 14074 14073 2213 2152 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27117 m0 *1 347.2,297.36
X$27117 14074 14073 2214 2291 2320 2162 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27119 r0 *1 408.24,367.92
X$27119 14074 2162 3302 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $27121 r0 *1 595.84,327.6
X$27121 14074 14073 2162 2766 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27145 r0 *1 620.48,297.36
X$27145 14074 14073 2356 2165 2357 2170 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27163 m0 *1 477.12,297.36
X$27163 14074 2166 2327 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $27169 m0 *1 799.68,317.52
X$27169 14074 2166 2180 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $27181 r0 *1 656.88,327.6
X$27181 14074 2168 2495 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $27194 r0 *1 725.76,559.44
X$27194 14074 2169 4694 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $27196 m0 *1 600.32,488.88
X$27196 14074 2169 3718 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $27200 r0 *1 584.08,408.24
X$27200 14074 2169 14073 gf180mcu_fd_sc_mcu9t5v0__inv_20
* cell instance $27204 r0 *1 371.84,367.92
X$27204 14074 2169 2762 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $27207 r0 *1 647.92,388.08
X$27207 14074 2169 2871 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $27225 m0 *1 428.96,337.68
X$27225 14074 14073 2763 2171 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27265 m0 *1 988.4,287.28
X$27265 14074 14073 2178 2238 2180 2179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27273 m0 *1 977.76,307.44
X$27273 14073 2504 2179 14074 2435 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27275 r0 *1 979.44,297.36
X$27275 14074 14073 2379 2299 2305 2179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27277 m0 *1 910,327.6
X$27277 14074 2724 2236 2623 2726 2180 2775 2502 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27282 r0 *1 750.4,307.44
X$27282 14073 2180 2493 14074 2494 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $27302 r0 *1 947.52,307.44
X$27302 14074 2503 2506 2302 2434 2180 2321 2301 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27310 r0 *1 878.08,317.52
X$27310 14074 2650 2236 2622 2619 2180 2620 2621 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27329 m0 *1 1120,307.44
X$27329 14074 2571 2439 2185 2244 2438 2307 2246 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27342 r0 *1 148.96,297.36
X$27342 14074 2187 2536 2280 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $27368 m0 *1 10.08,287.28
X$27368 2201 14073 14074 2194 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27371 r0 *1 48.72,287.28
X$27371 2203 14073 14074 2195 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27374 r0 *1 57.12,287.28
X$27374 2204 14073 14074 2196 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27377 m0 *1 35.28,297.36
X$27377 2273 14073 14074 2197 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27380 m0 *1 10.08,297.36
X$27380 2372 14073 14074 2198 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27383 m0 *1 85.12,297.36
X$27383 2279 14073 14074 2199 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27386 m0 *1 18.48,297.36
X$27386 2272 14073 14074 2200 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $27390 m0 *1 6.72,378
X$27390 14074 14073 3254 3200 2401 2201 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27392 m0 *1 15.12,378
X$27392 14074 14073 2201 3199 2402 3200 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27397 r0 *1 19.04,307.44
X$27397 14074 14073 2202 2462 2402 2441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27401 m0 *1 8.4,307.44
X$27401 14074 14073 2440 2441 2401 2202 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27404 m0 *1 58.24,307.44
X$27404 14074 14073 2203 2442 2402 2403 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27409 m0 *1 45.36,307.44
X$27409 14074 14073 2375 2403 2275 2203 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27412 m0 *1 67.2,307.44
X$27412 14074 14073 2204 2404 2402 2276 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27418 m0 *1 71.12,297.36
X$27418 14074 14073 2311 2276 2275 2204 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27448 m0 *1 267.68,297.36
X$27448 14074 14073 2212 2283 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $27475 r0 *1 566.16,378
X$27475 14074 2216 3281 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $27477 r0 *1 560.56,438.48
X$27477 14074 14073 2216 3922 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27480 m0 *1 566.72,347.76
X$27480 14074 14073 2216 2218 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27482 r0 *1 555.52,297.36
X$27482 14074 2459 2216 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $27487 r0 *1 594.16,478.8
X$27487 14074 14073 2216 3843 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27501 r0 *1 664.72,287.28
X$27501 14074 14073 2269 2219 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $27511 r0 *1 670.32,287.28
X$27511 14074 14073 2219 2223 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27576 r0 *1 627.76,579.6
X$27576 14074 14073 6312 2221 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27599 r0 *1 637.84,327.6
X$27599 14074 2767 2691 2222 2738 2295 2660 2556 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27604 r0 *1 929.6,488.88
X$27604 14074 14073 4634 4635 2223 4595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27606 r0 *1 948.08,498.96
X$27606 14074 14073 4778 4704 2223 4721 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27608 r0 *1 865.2,488.88
X$27608 14074 14073 4633 4658 2223 4657 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27610 m0 *1 770,498.96
X$27610 14074 14073 4664 4667 2223 4668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27613 m0 *1 655.76,539.28
X$27613 14074 14073 5253 5255 2223 5254 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27615 m0 *1 859.04,438.48
X$27615 14074 14073 3966 3965 2223 3792 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27637 m0 *1 712.88,529.2
X$27637 14074 14073 5102 5074 2223 5075 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27639 r0 *1 608.72,539.28
X$27639 14074 14073 2223 5312 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27644 m0 *1 673.12,287.28
X$27644 14074 14073 2294 2224 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27669 m0 *1 628.88,650.16
X$27669 14074 6711 6754 14073 2229 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $27676 r0 *1 776.72,297.36
X$27676 14074 14073 2394 2229 2239 2361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27694 m0 *1 747.6,378
X$27694 14074 14073 3251 2229 2986 3195 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27804 m0 *1 914.48,398.16
X$27804 14074 3442 2236 3364 3487 2980 3489 3141 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27806 r0 *1 927.92,388.08
X$27806 14074 3382 2236 3230 3422 2980 3423 3296 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27809 r0 *1 917.84,488.88
X$27809 14074 4703 14073 4574 2236 2505 4656 4363
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $27811 m0 *1 953.12,498.96
X$27811 14074 4703 14073 4651 2236 2505 4705 4365
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $27814 r0 *1 899.36,367.92
X$27814 14074 3323 2236 2985 3051 2980 3050 3053 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27817 m0 *1 876.96,388.08
X$27817 14074 3363 2236 3362 3292 2980 3293 3361 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $27819 m0 *1 878.08,438.48
X$27819 14074 3676 14073 3938 2236 2505 3854 3794
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $27833 r0 *1 989.52,307.44
X$27833 14074 14073 2520 2238 2504 2304 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27838 r0 *1 1060.08,468.72
X$27838 14074 14073 4222 3739 2239 4223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27840 r0 *1 899.92,438.48
X$27840 14074 14073 4046 2984 2239 4012 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27842 m0 *1 962.64,458.64
X$27842 14074 14073 4182 2929 2239 3939 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27844 m0 *1 999.04,529.2
X$27844 14074 14073 5179 4295 2239 4845 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27847 r0 *1 1061.76,519.12
X$27847 14074 14073 5092 4503 2239 5019 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27849 m0 *1 921.2,529.2
X$27849 14074 14073 5035 4163 2239 4840 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27851 r0 *1 689.92,438.48
X$27851 14074 14073 4136 3544 2239 3930 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27854 m0 *1 590.8,438.48
X$27854 14074 14073 3925 3036 2239 3723 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27856 r0 *1 783.44,529.2
X$27856 14074 14073 5150 4385 2239 4936 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27859 m0 *1 638.96,458.64
X$27859 14074 14073 4188 3663 2239 4101 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27861 r0 *1 833.28,529.2
X$27861 14074 14073 5186 4317 2239 5153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27863 m0 *1 968.8,347.76
X$27863 14074 14073 2926 2299 2239 2703 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $27900 m0 *1 1009.12,307.44
X$27900 14074 14073 2506 2241 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $27940 r0 *1 1154.72,297.36
X$27940 14074 2374 2439 2251 2247 2438 2248 2250 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $28034 r0 *1 785.12,297.36
X$28034 14074 14073 2362 2267 2296 2297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28050 r0 *1 547.68,297.36
X$28050 14074 14073 2294 2269 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28054 r0 *1 75.6,297.36
X$28054 2344 14073 14074 2270 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $28057 r0 *1 27.44,307.44
X$28057 2463 14073 14074 2271 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $28061 r0 *1 27.44,297.36
X$28061 14074 14073 2272 2373 2402 2343 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28065 r0 *1 19.04,297.36
X$28065 14074 14073 2342 2343 2401 2272 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28068 m0 *1 44.24,297.36
X$28068 14074 14073 2274 2309 2275 2273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28073 m0 *1 48.72,317.52
X$28073 14074 14073 2273 2532 2402 2309 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28076 r0 *1 39.76,297.36
X$28076 14074 2309 2340 2274 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $28080 m0 *1 95.2,297.36
X$28080 14074 14073 2277 2278 2275 2279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28084 r0 *1 63.84,317.52
X$28084 14074 14073 2597 2598 2275 2533 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28088 m0 *1 83.44,307.44
X$28088 14074 14073 2345 2346 2275 2344 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28090 r0 *1 85.68,317.52
X$28090 14074 14073 2599 2638 2275 2534 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28097 m0 *1 75.04,317.52
X$28097 14074 14073 2401 2275 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28101 m0 *1 54.32,297.36
X$28101 14074 2276 2340 2311 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $28110 r0 *1 105.28,307.44
X$28110 14074 14073 2279 2465 2402 2278 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28123 r0 *1 239.68,307.44
X$28123 14074 14073 2281 2410 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28145 m0 *1 287.84,297.36
X$28145 14074 14073 2286 2316 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $28147 m0 *1 282.8,378
X$28147 2287 2541 3215 3242 14073 14074 3321 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $28149 m0 *1 283.36,438.48
X$28149 14074 3960 14073 3772 3962 2474 3914 2287
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $28152 m0 *1 314.16,317.52
X$28152 14073 2287 14074 2582 2583 2546 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28154 r0 *1 315.84,317.52
X$28154 14073 2287 14074 2416 2720 2414 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28156 r0 *1 415.52,448.56
X$28156 14074 14073 4093 2287 2320 4094 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28161 m0 *1 316.96,428.4
X$28161 14073 2287 14074 2546 3774 2913 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28165 r0 *1 327.6,357.84
X$28165 14073 2543 14074 3145 3077 2287 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28167 m0 *1 364,378
X$28167 2287 14074 3145 2541 14073 3194 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $28202 m0 *1 283.92,418.32
X$28202 14074 14073 2287 3650 3344 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28205 r0 *1 277.76,418.32
X$28205 14074 14073 3708 3709 2542 2287 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28208 m0 *1 277.76,398.16
X$28208 14073 14074 3471 2287 3340 2475 3472 2450
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $28210 r0 *1 279.44,388.08
X$28210 14073 2541 14074 3536 3345 2287 3215 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $28212 r0 *1 289.52,388.08
X$28212 2287 14073 2543 3443 14074 3343 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28215 r0 *1 344.96,307.44
X$28215 14073 2287 2546 14074 2351 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28218 r0 *1 323.68,367.92
X$28218 14074 3245 14073 2481 2967 2816 3192 2287
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $28221 r0 *1 313.6,367.92
X$28221 14073 2287 2416 14074 3025 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28224 r0 *1 309.68,307.44
X$28224 14074 14073 2287 2475 2416 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28227 m0 *1 381.36,367.92
X$28227 14074 2287 14073 2479 3153 3171 2967 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $28229 r0 *1 395.36,337.68
X$28229 14074 14073 2287 2861 2547 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $28231 r0 *1 301.28,418.32
X$28231 2287 14073 2476 3710 14074 3807 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $28235 m0 *1 352.8,388.08
X$28235 2287 2759 3215 3274 14074 14073 3409 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $28237 r0 *1 369.6,428.4
X$28237 14074 2759 14073 3884 2542 2287 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $28249 r0 *1 333.76,418.32
X$28249 14074 3753 2759 14073 2757 2288 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $28252 m0 *1 339.36,297.36
X$28252 14073 2289 14074 2290 2291 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $28257 r0 *1 342.16,297.36
X$28257 14074 14073 2290 2351 2382 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $28267 r0 *1 576.24,398.16
X$28267 14074 3596 14073 3453 2292 3516 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $28287 r0 *1 560.56,307.44
X$28287 14074 2294 2459 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $28290 m0 *1 667.52,297.36
X$28290 14074 14073 2294 2332 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28293 m0 *1 799.68,307.44
X$28293 14074 14073 2453 2361 2295 2364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28295 r0 *1 700,327.6
X$28295 14074 2845 2691 2695 2455 2295 2425 2736 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $28308 m0 *1 686,327.6
X$28308 14074 2825 2691 2770 2559 2295 2558 2693 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $28311 m0 *1 645.12,327.6
X$28311 14074 2690 2691 2423 2554 2295 2552 2422 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $28316 m0 *1 780.64,317.52
X$28316 14074 14073 2561 2562 2296 2654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28324 m0 *1 767.76,327.6
X$28324 14073 2296 2773 14074 2731 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $28326 r0 *1 768.88,297.36
X$28326 14074 14073 2421 2296 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $28346 m0 *1 949.2,357.84
X$28346 14074 14073 3000 2299 2986 2778 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28359 m0 *1 978.88,357.84
X$28359 14074 14073 3054 2299 2987 2715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $28400 r0 *1 943.04,650.16
X$28400 14074 6901 2299 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $28417 m0 *1 892.08,448.56
X$28417 14074 2300 4103 3365 4129 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28419 m0 *1 894.32,438.48
X$28419 14074 2300 4012 3365 4046 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28422 r0 *1 857.36,781.2
X$28422 14074 2300 8903 8178 9008 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28424 r0 *1 809.76,801.36
X$28424 14074 2300 9165 8178 9210 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28427 m0 *1 917.84,438.48
X$28427 14074 2300 3961 3365 4042 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28430 m0 *1 935.76,589.68
X$28430 14074 2300 5755 5016 5756 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28433 r0 *1 934.08,559.44
X$28433 14074 2300 5487 5016 5556 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28435 m0 *1 878.64,811.44
X$28435 14074 2300 9170 8178 9169 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28437 r0 *1 937.44,589.68
X$28437 14074 2300 5757 5016 5866 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28439 r0 *1 861.84,801.36
X$28439 14074 2300 9168 8178 9167 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28441 r0 *1 870.8,791.28
X$28441 14074 2300 8959 7166 8958 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28443 m0 *1 838.88,680.4
X$28443 14074 2300 7155 6960 7284 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28445 m0 *1 874.16,700.56
X$28445 14074 2300 7465 6960 7549 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28447 m0 *1 817.6,700.56
X$28447 14074 2300 7547 6960 7747 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28451 r0 *1 801.92,730.8
X$28451 14074 2300 8056 8178 8010 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28453 m0 *1 775.6,831.6
X$28453 14074 2300 9673 8178 9571 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28458 m0 *1 779.52,730.8
X$28458 14074 2300 7973 6960 7884 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28460 r0 *1 790.72,801.36
X$28460 14074 2300 9164 8178 9297 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28463 r0 *1 794.08,811.44
X$28463 14074 2300 9264 8178 9105 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28466 r0 *1 863.52,670.32
X$28466 14074 2300 7158 6960 7201 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28468 m0 *1 857.36,690.48
X$28468 14074 2300 7356 6960 7481 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28470 r0 *1 931.28,337.68
X$28470 14074 2300 2776 2780 2882 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28473 m0 *1 948.64,347.76
X$28473 14074 2300 2779 2780 2875 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28475 r0 *1 943.04,347.76
X$28475 14074 2300 2778 2780 3000 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28478 r0 *1 952,378
X$28478 14074 2300 3297 2780 3319 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28480 m0 *1 889.84,992.88
X$28480 14074 2300 11671 11330 11976 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28483 r0 *1 899.36,992.88
X$28483 14074 2300 11673 11330 12059 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28485 m0 *1 934.64,337.68
X$28485 14074 2300 2777 2780 2835 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28487 m0 *1 739.2,801.36
X$28487 14074 2300 9161 8178 9159 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28489 r0 *1 812.56,720.72
X$28489 14074 2300 7974 6960 7917 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28492 m0 *1 768.32,801.36
X$28492 14074 2300 9163 8178 9211 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28494 m0 *1 842.8,720.72
X$28494 14074 2300 7805 6960 7916 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28496 m0 *1 452.48,1013.04
X$28496 14074 2300 12035 12036 12502 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28498 m0 *1 764.96,761.04
X$28498 14074 2300 8482 6960 8481 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28500 r0 *1 796.32,771.12
X$28500 14074 2300 8610 8178 8657 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28502 r0 *1 436.8,1023.12
X$28502 14074 2300 12584 12036 12796 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28504 m0 *1 747.04,781.2
X$28504 14074 2300 8652 6960 8759 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28508 r0 *1 738.08,761.04
X$28508 14074 2300 8479 6960 8565 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28510 m0 *1 766.08,781.2
X$28510 14074 2300 8655 8178 8825 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28512 r0 *1 836.08,740.88
X$28512 14074 2300 8148 6960 8309 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28514 m0 *1 458.64,1023.12
X$28514 14074 2300 12585 12036 12645 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28516 m0 *1 153.44,1113.84
X$28516 14074 2300 13456 12477 13569 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28518 m0 *1 726.88,781.2
X$28518 14074 2300 8758 6960 8757 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28520 r0 *1 919.52,549.36
X$28520 14074 2300 5486 5229 5555 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28522 m0 *1 708.96,882
X$28522 14074 2300 7967 9567 10436 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28524 r0 *1 178.64,1134
X$28524 14074 2300 13800 12994 13910 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28527 m0 *1 940.24,529.2
X$28527 14074 2300 4842 5016 5096 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28529 r0 *1 940.8,519.12
X$28529 14074 2300 4843 5016 5034 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28531 m0 *1 904.96,458.64
X$28531 14074 2300 4162 3365 4161 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28533 m0 *1 883.12,468.72
X$28533 14074 2300 4292 4315 4291 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28535 r0 *1 914.48,478.8
X$28535 14074 2300 4498 3736 4514 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28537 r0 *1 726.88,851.76
X$28537 14074 2300 9961 9567 9960 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28540 m0 *1 915.6,468.72
X$28540 14074 2300 4293 3365 4313 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28543 m0 *1 898.24,488.88
X$28543 14074 2300 4497 4315 4496 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28545 m0 *1 920.08,478.8
X$28545 14074 2300 4363 3365 4380 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28548 m0 *1 730.8,831.6
X$28548 14074 2300 9568 9567 9729 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28550 m0 *1 893.76,942.48
X$28550 14074 2300 9786 11330 11399 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28552 m0 *1 822.08,771.12
X$28552 14074 2300 8570 8178 8569 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28554 m0 *1 891.52,952.56
X$28554 14074 2300 8003 11330 11545 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28557 m0 *1 271.6,1174.32
X$28557 14074 2300 13971 12994 14054 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28560 r0 *1 941.36,418.32
X$28560 14074 2300 3548 3365 3675 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28563 r0 *1 730.8,801.36
X$28563 14074 2300 9160 9567 9157 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28566 m0 *1 896.56,579.6
X$28566 14074 2300 5754 5229 5708 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28568 r0 *1 900.48,579.6
X$28568 14074 2300 5753 5229 5869 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28571 r0 *1 948.08,428.4
X$28571 14074 2300 3549 3365 3959 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28574 m0 *1 930.16,448.56
X$28574 14074 2300 4013 3365 4014 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28576 m0 *1 829.36,791.28
X$28576 14074 2300 8956 8178 9010 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28578 m0 *1 829.92,801.36
X$28578 14074 2300 9069 8178 9067 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28580 r0 *1 190.96,1164.24
X$28580 14074 2300 13933 12994 14021 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28582 m0 *1 281.68,1144.08
X$28582 14074 2300 13806 12438 13827 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28584 m0 *1 261.52,1134
X$28584 14074 2300 13736 12994 13697 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28587 r0 *1 148.4,1144.08
X$28587 14074 2300 13772 12477 13830 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28589 r0 *1 159.6,1134
X$28589 14074 2300 13773 12994 13798 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28591 r0 *1 916.16,519.12
X$28591 14074 2300 4840 5016 5035 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28593 r0 *1 154,1174.32
X$28593 14074 2300 13932 12994 14066 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28595 m0 *1 163.52,1174.32
X$28595 14074 2300 13966 12994 14043 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28598 m0 *1 975.52,398.16
X$28598 14074 2300 3301 3365 3505 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28600 r0 *1 960.4,418.32
X$28600 14074 2300 3604 3365 3733 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28603 r0 *1 958.16,408.24
X$28603 14074 2300 3605 3365 3616 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28605 r0 *1 239.12,1144.08
X$28605 14074 2300 13780 12994 13878 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28607 m0 *1 898.24,559.44
X$28607 14074 2300 5484 5229 5575 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28609 m0 *1 900.48,922.32
X$28609 14074 2300 9348 11330 10908 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28611 m0 *1 958.72,388.08
X$28611 14074 2300 3298 3365 3437 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28613 r0 *1 900.48,549.36
X$28613 14074 2300 5485 5229 5427 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28615 m0 *1 978.88,388.08
X$28615 14074 2300 3300 3365 3318 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28617 m0 *1 225.68,1174.32
X$28617 14074 2300 13879 12994 14037 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28620 r0 *1 211.68,1164.24
X$28620 14074 2300 12204 12994 14022 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28622 m0 *1 831.04,750.96
X$28622 14074 2300 8246 6960 8247 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28624 m0 *1 244.72,1174.32
X$28624 14074 2300 13934 12994 14038 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28627 r0 *1 217.84,1134
X$28627 14074 2300 11869 12994 13914 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28630 r0 *1 848.4,771.12
X$28630 14074 2300 8697 8178 8822 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28632 m0 *1 227.36,1123.92
X$28632 14074 2300 13658 12994 13694 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28634 m0 *1 884.24,529.2
X$28634 14074 2300 4836 5229 5037 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28637 m0 *1 863.52,771.12
X$28637 14074 2300 8659 8178 8695 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28639 m0 *1 890.4,539.28
X$28639 14074 2300 4837 5229 5183 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28641 r0 *1 910.56,529.2
X$28641 14074 2300 4841 5229 5182 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28644 m0 *1 777.28,912.24
X$28644 14074 2300 6829 9567 10904 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28646 m0 *1 637.28,1043.28
X$28646 14074 2300 12736 11294 12928 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28648 r0 *1 631.12,1002.96
X$28648 14074 2300 8480 11294 12257 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28650 r0 *1 871.92,569.52
X$28650 14074 2300 5692 5229 5691 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28653 m0 *1 770,932.4
X$28653 14074 2300 11208 9567 11261 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28655 r0 *1 640.64,1033.2
X$28655 14074 2300 12737 11294 12799 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28658 m0 *1 872.48,952.56
X$28658 14074 2300 7972 11330 11583 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28661 m0 *1 877.52,579.6
X$28661 14074 2300 5752 5229 5792 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28663 m0 *1 721.84,992.88
X$28663 14074 2300 9569 11294 12050 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28665 m0 *1 692.72,982.8
X$28665 14074 2300 8486 11294 11882 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28668 m0 *1 864.64,962.64
X$28668 14074 2300 11670 11330 11613 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28670 r0 *1 899.36,750.96
X$28670 14074 8255 7166 8487 2300 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $28673 r0 *1 750.96,952.56
X$28673 14074 2300 11207 9567 11643 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28675 r0 *1 789.6,942.48
X$28675 14074 2300 8146 9567 11455 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28677 r0 *1 836.64,559.44
X$28677 14074 2300 5552 5229 5578 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28679 m0 *1 832.16,569.52
X$28679 14074 2300 5617 5229 5616 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28682 r0 *1 831.6,569.52
X$28682 14074 2300 5690 5229 5710 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28685 m0 *1 732.48,912.24
X$28685 14074 2300 8245 9567 10902 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28687 m0 *1 733.6,962.64
X$28687 14074 2300 8650 11294 11664 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28689 r0 *1 756,932.4
X$28689 14074 2300 11206 9567 11506 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28691 r0 *1 674.24,1043.28
X$28691 14074 2300 12818 11294 12927 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28693 r0 *1 679.28,1073.52
X$28693 14074 2300 13194 12454 13271 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28696 m0 *1 405.44,1174.32
X$28696 14074 2300 13940 12036 13996 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28699 m0 *1 705.04,1063.44
X$28699 14074 2300 13007 11294 13005 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28701 r0 *1 841.12,922.32
X$28701 14074 2300 7354 9567 11120 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28704 m0 *1 683.76,1053.36
X$28704 14074 2300 12739 11294 13004 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28706 m0 *1 727.44,1083.6
X$28706 14074 2300 13197 12454 13339 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28708 m0 *1 700.56,1083.6
X$28708 14074 2300 13314 12454 13341 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28710 r0 *1 717.92,1083.6
X$28710 14074 2300 13196 12454 13397 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28712 r0 *1 420.56,1144.08
X$28712 14074 2300 13744 12036 13840 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28714 m0 *1 677.04,1083.6
X$28714 14074 2300 13128 12454 13399 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28716 m0 *1 374.08,1174.32
X$28716 14074 2300 13942 12438 14027 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28719 r0 *1 380.24,1144.08
X$28719 14074 2300 13811 12438 13836 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28721 r0 *1 861.28,932.4
X$28721 14074 2300 8387 9567 11374 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28723 m0 *1 691.04,1033.2
X$28723 14074 2300 12665 11294 12664 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28725 m0 *1 731.36,1053.36
X$28725 14074 2300 12820 11294 12888 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28727 m0 *1 463.68,1063.44
X$28727 14074 2300 13069 12036 13096 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28729 r0 *1 462,1073.52
X$28729 14074 2300 12950 12036 13299 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28731 r0 *1 464.24,1043.28
X$28731 14074 2300 12885 12036 12924 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28733 r0 *1 705.6,1073.52
X$28733 14074 2300 13195 12454 13398 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28735 m0 *1 470.4,1053.36
X$28735 14074 2300 12815 12036 12817 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28738 m0 *1 451.36,1093.68
X$28738 14074 2300 13000 12036 13402 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28740 r0 *1 719.04,1033.2
X$28740 14074 2300 12666 11294 12793 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28742 m0 *1 703.36,1043.28
X$28742 14074 2300 12740 11294 12926 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28744 r0 *1 446.88,1103.76
X$28744 14074 2300 12659 12036 13611 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28746 m0 *1 823.76,962.64
X$28746 14074 2300 11458 9567 11667 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28748 m0 *1 691.6,942.48
X$28748 14074 2300 8654 11294 11515 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28751 m0 *1 848.96,972.72
X$28751 14074 2300 11739 11330 11738 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28753 r0 *1 845.04,972.72
X$28753 14074 2300 11669 11330 11668 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28755 r0 *1 711.76,932.4
X$28755 14074 2300 8867 11294 11411 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28757 m0 *1 726.32,942.48
X$28757 14074 2300 10238 11294 11510 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28759 r0 *1 805.28,549.36
X$28759 14074 2300 5425 4315 5424 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28761 m0 *1 670.88,952.56
X$28761 14074 2300 8957 11294 11587 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28763 r0 *1 790.72,1033.2
X$28763 14074 2300 12670 12454 12790 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28765 r0 *1 865.2,982.8
X$28765 14074 2300 11974 11330 12096 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28768 m0 *1 844.48,1023.12
X$28768 14074 2300 12456 11330 12537 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28770 r0 *1 830.48,498.96
X$28770 14074 2300 4631 4315 4761 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28773 m0 *1 813.12,498.96
X$28773 14074 2300 4630 4315 4700 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28775 m0 *1 851.76,1013.04
X$28775 14074 2300 12457 11330 12378 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28777 r0 *1 814.24,488.88
X$28777 14074 2300 4629 4315 4726 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28779 m0 *1 818.72,468.72
X$28779 14074 2300 4219 3670 4290 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28781 m0 *1 884.24,640.08
X$28781 14074 2300 5944 5622 6529 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28783 m0 *1 840.56,992.88
X$28783 14074 2300 11889 11330 12006 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28785 m0 *1 850.08,1043.28
X$28785 14074 2300 9070 11330 12856 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28788 r0 *1 866.32,1023.12
X$28788 14074 2300 12458 11330 12379 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28790 m0 *1 818.16,1023.12
X$28790 14074 2300 12536 11330 12640 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28792 m0 *1 869.68,488.88
X$28792 14074 2300 4573 4315 4572 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28794 r0 *1 849.52,498.96
X$28794 14074 2300 4632 4315 4781 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28796 m0 *1 870.8,1023.12
X$28796 14074 2300 12459 11330 12560 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28798 r0 *1 874.72,509.04
X$28798 14074 2300 4835 4315 4965 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28800 m0 *1 924,640.08
X$28800 14074 2300 6361 5016 6624 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28802 r0 *1 879.2,1002.96
X$28802 14074 2300 9787 11330 12301 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28804 m0 *1 908.32,740.88
X$28804 14074 2300 7978 7166 8304 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28807 r0 *1 903.84,740.88
X$28807 14074 2300 7977 7166 8253 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28809 r0 *1 925.12,630
X$28809 14074 2300 6264 5016 6447 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28812 r0 *1 903.84,730.8
X$28812 14074 2300 7975 7166 8057 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28814 r0 *1 937.44,609.84
X$28814 14074 2300 6086 5016 6288 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28816 m0 *1 863.52,478.8
X$28816 14074 2300 4360 4315 4383 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28818 r0 *1 907.76,609.84
X$28818 14074 2300 6085 5229 6289 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28820 r0 *1 879.2,468.72
X$28820 14074 2300 4361 4315 4436 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28823 r0 *1 818.72,992.88
X$28823 14074 2300 11971 11330 12141 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28825 m0 *1 892.64,609.84
X$28825 14074 2300 6083 5229 6082 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28828 m0 *1 903.28,630
X$28828 14074 2300 6360 5229 6446 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28830 r0 *1 900.48,630
X$28830 14074 2300 6263 5229 6530 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28833 r0 *1 815.36,458.64
X$28833 14074 2300 4218 3670 4321 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28836 m0 *1 893.2,619.92
X$28836 14074 2300 6084 5229 6291 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28838 m0 *1 833.84,458.64
X$28838 14074 2300 4159 3670 4245 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28840 r0 *1 842.24,448.56
X$28840 14074 2300 4184 3670 4185 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28842 r0 *1 860.72,478.8
X$28842 14074 2300 4495 4315 4493 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28845 r0 *1 853.44,519.12
X$28845 14074 2300 5015 4315 4966 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28848 m0 *1 779.52,982.8
X$28848 14074 2300 11886 9567 11885 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28850 r0 *1 850.64,539.28
X$28850 14074 2300 5082 5229 5228 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28852 m0 *1 779.52,992.88
X$28852 14074 2300 11888 11294 12053 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28854 r0 *1 636.72,992.88
X$28854 14074 2300 8045 11294 12128 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28857 m0 *1 835.52,559.44
X$28857 14074 2300 5480 5229 5435 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28859 m0 *1 635.04,972.72
X$28859 14074 2300 8520 11294 11783 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28861 r0 *1 796.32,952.56
X$28861 14074 11296 9567 11611 2300 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $28863 m0 *1 876.4,559.44
X$28863 14074 2300 5482 5229 5577 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28865 m0 *1 826,539.28
X$28865 14074 2300 5153 4315 5186 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28867 m0 *1 799.68,982.8
X$28867 14074 2300 11887 9567 11936 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28869 r0 *1 869.12,549.36
X$28869 14074 2300 5426 5229 5483 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28872 m0 *1 643.44,962.64
X$28872 14074 2300 8568 11294 11658 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28874 m0 *1 830.48,529.2
X$28874 14074 2300 5081 4315 5080 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28876 r0 *1 781.76,559.44
X$28876 14074 2300 5478 4694 5583 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28878 r0 *1 804.72,569.52
X$28878 14074 2300 5479 5229 5580 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28880 m0 *1 799.68,569.52
X$28880 14074 2300 5422 5229 5423 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28882 m0 *1 732.48,1043.28
X$28882 14074 2300 12667 11294 12858 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28884 r0 *1 792.4,1013.04
X$28884 14074 2300 12376 12454 12453 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28886 m0 *1 799.68,992.88
X$28886 14074 2300 12057 11294 12054 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28888 m0 *1 779.52,1002.96
X$28888 14074 2300 12056 11294 12225 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28890 m0 *1 762.72,972.72
X$28890 14074 2300 11612 9567 11734 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28892 r0 *1 762.72,1013.04
X$28892 14074 2300 12375 11294 12452 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28896 r0 *1 963.76,347.76
X$28896 14074 2300 2703 2780 2926 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28899 m0 *1 840.56,882
X$28899 14074 2300 7153 8178 10528 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28901 r0 *1 973.84,357.84
X$28901 14074 2300 2715 2780 3054 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28903 m0 *1 779.52,871.92
X$28903 14074 2300 6798 9567 10355 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28905 m0 *1 806.96,619.92
X$28905 14074 2300 6170 6960 6261 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28908 m0 *1 801.36,670.32
X$28908 14074 2300 6881 6960 7087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28910 r0 *1 832.16,599.76
X$28910 14074 2300 6077 5229 6076 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28912 r0 *1 785.68,660.24
X$28912 14074 2300 6962 6960 6961 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28914 m0 *1 871.92,630
X$28914 14074 2300 6359 5229 6445 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28917 m0 *1 827.12,609.84
X$28917 14074 2300 6078 5229 6208 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28919 r0 *1 388.64,1063.44
X$28919 14074 2300 12937 12438 13106 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28921 r0 *1 797.44,700.56
X$28921 14074 2300 7543 6960 7629 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28923 r0 *1 800.24,861.84
X$28923 14074 2300 6801 9567 10233 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28925 r0 *1 866.32,609.84
X$28925 14074 2300 6079 5229 6294 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28927 m0 *1 873.6,609.84
X$28927 14074 2300 6080 5229 6081 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28930 m0 *1 423.36,1063.44
X$28930 14074 2300 12951 12438 13101 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28932 r0 *1 424.48,1073.52
X$28932 14074 2300 12813 12036 13300 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28934 r0 *1 777.28,690.48
X$28934 14074 2300 7353 6960 7484 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28936 r0 *1 862.4,1043.28
X$28936 14074 2300 12821 11330 12980 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28938 m0 *1 846.16,841.68
X$28938 14074 2300 9574 8178 9789 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28940 m0 *1 806.96,1093.68
X$28940 14074 2300 13204 12454 13441 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28942 r0 *1 831.6,821.52
X$28942 14074 2300 9575 8178 9572 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28944 r0 *1 842.24,1043.28
X$28944 14074 2300 12892 11330 12894 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28946 r0 *1 841.68,1053.36
X$28946 14074 2300 13071 12454 13011 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28948 m0 *1 827.68,1063.44
X$28948 14074 2300 12823 12454 13072 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28950 m0 *1 830.48,851.76
X$28950 14074 2300 7089 8178 9992 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28952 r0 *1 832.72,630
X$28952 14074 2300 6444 5229 6559 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28954 r0 *1 387.52,1013.04
X$28954 14074 2300 12524 12438 12568 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28956 m0 *1 836.64,630
X$28956 14074 2300 6358 5229 6443 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28959 m0 *1 828.24,861.84
X$28959 14074 2300 7545 8178 10158 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28961 r0 *1 860.16,640.08
X$28961 14074 2300 6528 5229 6658 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28963 m0 *1 869.12,670.32
X$28963 14074 2300 7041 6960 7040 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28965 m0 *1 818.16,831.6
X$28965 14074 2300 9573 8178 9722 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28967 r0 *1 820.4,660.24
X$28967 14074 2300 6882 6960 6964 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28969 m0 *1 352.8,1134
X$28969 14074 2300 13781 12438 13824 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28971 r0 *1 748.16,831.6
X$28971 14074 2300 9672 9567 9727 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28974 r0 *1 860.16,438.48
X$28974 14074 2300 3794 3365 4050 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28976 m0 *1 338.24,1123.92
X$28976 14074 2300 13703 12438 13662 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28978 r0 *1 757.68,720.72
X$28978 14074 2300 7918 6960 7882 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28980 r0 *1 862.4,428.4
X$28980 14074 2300 3793 3365 3853 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28983 m0 *1 303.52,1134
X$28983 14074 2300 13739 12438 13738 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28986 r0 *1 757.68,851.76
X$28986 14074 2300 8147 9567 10051 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28989 m0 *1 314.72,1113.84
X$28989 14074 2300 13574 12438 13686 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28991 r0 *1 873.6,418.32
X$28991 14074 2300 3732 3365 3748 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28993 m0 *1 846.72,932.4
X$28993 14074 2300 6959 9567 11334 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28995 r0 *1 641.2,1053.36
X$28995 14074 2300 13002 12454 13095 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28997 r0 *1 640.64,1043.28
X$28997 14074 2300 12586 11294 12985 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $28999 r0 *1 848.96,892.08
X$28999 14074 2300 7154 8178 10745 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29001 r0 *1 334.32,1174.32
X$29001 14074 2300 13936 12438 13994 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29003 m0 *1 418.88,1134
X$29003 14074 2300 13743 12036 13747 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29005 r0 *1 400.96,1123.92
X$29005 14074 2300 13666 12036 13746 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29007 m0 *1 314.16,1174.32
X$29007 14074 2300 13882 12438 14015 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29010 r0 *1 868,892.08
X$29010 14074 2300 8386 8178 10744 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29012 m0 *1 655.2,1073.52
X$29012 14074 2300 13127 12454 13251 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29014 r0 *1 790.16,841.68
X$29014 14074 2300 7464 9567 9905 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29016 m0 *1 343.84,1174.32
X$29016 14074 2300 13992 12438 14028 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29019 m0 *1 348.88,1164.24
X$29019 14074 2300 13943 12438 13939 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29021 m0 *1 972.72,337.68
X$29021 14074 2300 2704 2780 2832 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29023 m0 *1 292.32,1174.32
X$29023 14074 2300 11955 12994 14039 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29026 r0 *1 302.4,1174.32
X$29026 14074 2300 13974 12438 13990 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29028 m0 *1 864.64,912.24
X$29028 14074 2300 7630 9567 10806 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29031 r0 *1 652.96,1063.44
X$29031 14074 2300 13003 12454 13126 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29035 m0 *1 768.32,1093.68
X$29035 14074 2300 13201 12454 13444 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29037 r0 *1 751.52,1083.6
X$29037 14074 2300 13199 12454 13391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29039 r0 *1 763.28,1093.68
X$29039 14074 2300 13200 12454 13480 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29041 m0 *1 745.36,1073.52
X$29041 14074 2300 13198 12454 13394 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29043 m0 *1 427.28,1103.76
X$29043 14074 2300 13357 12036 13475 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29045 r0 *1 413.84,1103.76
X$29045 14074 2300 13578 12036 13613 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29047 m0 *1 754.32,1063.44
X$29047 14074 2300 13039 12454 13176 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29049 m0 *1 813.12,821.52
X$29049 14074 2300 9265 8178 9350 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29051 m0 *1 856.24,821.52
X$29051 14074 2300 9465 8178 9497 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29054 r0 *1 785.68,1073.52
X$29054 14074 2300 13273 12454 13202 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29056 r0 *1 786.8,1083.6
X$29056 14074 2300 13274 12454 13360 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29059 m0 *1 805.84,1083.6
X$29059 14074 2300 13205 12454 13335 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29061 r0 *1 796.32,1093.68
X$29061 14074 2300 13203 12454 13512 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29438 m0 *1 871.92,519.12
X$29438 14074 2300 4940 5016 4939 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29440 r0 *1 198.24,1134
X$29440 14074 2300 12032 12994 13867 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $29445 m0 *1 949.76,317.52
X$29445 14074 2624 2504 2302 2434 2565 2321 2301 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $29465 m0 *1 1024.8,488.88
X$29465 14074 14073 4576 4503 2305 4637 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29467 r0 *1 901.6,478.8
X$29467 14074 14073 4496 4163 2305 4497 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29470 r0 *1 957.04,488.88
X$29470 14074 14073 4652 4295 2305 4636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29472 m0 *1 1002.4,398.16
X$29472 14074 14073 3426 2929 2305 3490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29475 m0 *1 1019.76,458.64
X$29475 14074 14073 4239 3739 2305 4165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29477 m0 *1 734.16,488.88
X$29477 14074 14073 4569 4385 2305 4570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29479 m0 *1 861.28,488.88
X$29479 14074 14073 4493 4317 2305 4495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29483 r0 *1 865.2,418.32
X$29483 14074 14073 3748 2984 2305 3732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29565 r0 *1 359.52,297.36
X$29565 14073 2352 14074 2383 2388 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29567 r0 *1 361.76,307.44
X$29567 14073 2484 14074 2522 2485 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29569 m0 *1 400.96,367.92
X$29569 14073 3153 14074 3009 3565 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29571 m0 *1 392,367.92
X$29571 14073 3151 14074 3029 3154 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29573 r0 *1 307.44,418.32
X$29573 14073 3752 4312 2319 3750 3711 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $29579 m0 *1 340.48,428.4
X$29579 14073 3776 14074 3693 3777 2319 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29581 r0 *1 384.16,388.08
X$29581 14073 2542 14074 3451 3448 3452 2319 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $29611 m0 *1 288.96,418.32
X$29611 14073 14074 3560 3650 3023 2319 3691 3749
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $29614 m0 *1 289.52,428.4
X$29614 14073 2319 3650 14074 3771 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29616 m0 *1 322,317.52
X$29616 14074 2319 14073 2721 2545 2583 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29618 r0 *1 375.76,317.52
X$29618 14073 14074 2614 2319 2613 2611 2649 2615
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $29620 m0 *1 306.88,378
X$29620 14074 14073 3344 2319 2911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $29622 m0 *1 207.76,488.88
X$29622 14073 4541 14074 2320 4542 3264 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29625 m0 *1 242.48,458.64
X$29625 14073 4147 14074 2320 4181 3264 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29628 m0 *1 251.44,408.24
X$29628 14074 14073 3579 3620 2320 3580 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29630 m0 *1 236.32,418.32
X$29630 14074 14073 3647 3646 2320 3648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29633 r0 *1 210,438.48
X$29633 14074 14073 3989 3990 2320 4078 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29636 r0 *1 434,357.84
X$29636 14074 14073 3086 2969 2320 3031 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29639 m0 *1 434.56,428.4
X$29639 14074 14073 3779 3715 2320 3839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29642 m0 *1 415.52,418.32
X$29642 14074 14073 3696 3452 2320 3653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29644 r0 *1 411.6,428.4
X$29644 14074 14073 3838 3885 2320 4000 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29650 r0 *1 427.28,448.56
X$29650 14074 14073 4095 2859 2320 4155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29653 m0 *1 408.8,478.8
X$29653 14074 14073 4442 2474 2320 4473 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29655 r0 *1 436.24,468.72
X$29655 14073 4151 14074 2320 4270 4157 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $29658 m0 *1 439.04,448.56
X$29658 14074 14073 4130 3565 2320 4096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29661 r0 *1 432.88,438.48
X$29661 14074 14073 4051 3154 2320 4001 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29665 r0 *1 439.04,398.16
X$29665 14074 14073 3540 3350 2320 3591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29670 m0 *1 416.64,388.08
X$29670 14074 14073 3349 3387 2320 3351 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29673 m0 *1 428.96,378
X$29673 14074 14073 3249 3150 2320 3217 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29675 m0 *1 403.2,408.24
X$29675 14074 14073 3632 3630 2320 3481 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29677 r0 *1 393.68,408.24
X$29677 14074 14073 3631 3589 2320 3590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29679 r0 *1 397.6,398.16
X$29679 14074 14073 3513 3511 2320 3479 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29681 r0 *1 332.08,458.64
X$29681 14074 14073 4241 3346 2320 4204 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29686 r0 *1 411.04,488.88
X$29686 14074 14073 4660 4040 2320 4661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29688 r0 *1 402.64,488.88
X$29688 14074 14073 4659 3809 2320 4615 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29690 m0 *1 412.72,509.04
X$29690 14074 14073 4814 4312 2320 5065 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29693 m0 *1 391.44,509.04
X$29693 14074 14073 4878 3691 2320 4812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29702 r0 *1 365.68,448.56
X$29702 14074 14073 4089 4090 2320 3717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29707 r0 *1 372.4,468.72
X$29707 14074 14073 4345 2414 2320 4268 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29710 m0 *1 382.48,458.64
X$29710 14074 14073 4205 2606 2320 4152 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29712 m0 *1 400.96,458.64
X$29712 14074 14073 4242 2759 2320 4154 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29715 r0 *1 384.72,448.56
X$29715 14074 14073 4091 3837 2320 4092 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29766 r0 *1 245.84,428.4
X$29766 14074 3264 14073 3877 2320 3770 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $29769 m0 *1 391.44,347.76
X$29769 14074 14073 2820 2891 2320 3155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29771 m0 *1 188.72,458.64
X$29771 4141 2320 4196 4142 3264 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $29774 m0 *1 162.96,488.88
X$29774 14074 4538 2320 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $29777 r0 *1 209.44,478.8
X$29777 4398 2320 4400 4141 14074 14073 4543 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $29779 m0 *1 183.68,458.64
X$29779 14073 2320 4141 14074 4076 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $29782 m0 *1 341.04,458.64
X$29782 14074 14073 4148 3997 2320 4149 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29784 m0 *1 375.2,519.12
X$29784 14074 14073 4921 4087 2320 4922 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29818 m0 *1 435.68,337.68
X$29818 14074 2327 2616 2820 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $29828 r0 *1 906.08,680.4
X$29828 14074 14073 7278 5844 6966 2328 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29830 m0 *1 824.32,680.4
X$29830 14074 2328 7205 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $29856 r0 *1 868.56,398.16
X$29856 14074 2332 3089 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $29875 r0 *1 10.08,297.36
X$29875 2341 14073 14074 2337 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $29878 m0 *1 66.08,317.52
X$29878 2533 14073 14074 2338 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $29881 m0 *1 34.16,317.52
X$29881 2531 14073 14074 2339 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $29884 m0 *1 58.24,327.6
X$29884 14074 2598 2340 2597 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29886 r0 *1 5.6,408.24
X$29886 14074 3568 2340 3608 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29888 r0 *1 36.4,357.84
X$29888 2340 14073 14074 14083 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $29912 m0 *1 84,398.16
X$29912 14074 3399 2340 3494 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29914 m0 *1 100.24,388.08
X$29914 14074 3262 2340 3261 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29917 r0 *1 84,408.24
X$29917 14074 3572 2340 3612 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29919 r0 *1 5.6,378
X$29919 14074 3200 2340 3254 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29921 m0 *1 7.84,398.16
X$29921 14074 3397 2340 3396 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29925 r0 *1 54.88,367.92
X$29925 14074 3135 2340 3183 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29928 m0 *1 39.2,357.84
X$29928 14074 2899 2340 2947 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29930 m0 *1 23.52,378
X$29930 14074 3201 2340 3309 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29933 m0 *1 12.32,388.08
X$29933 14074 3333 2340 3373 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29936 m0 *1 70,388.08
X$29936 14074 3259 2340 3256 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29939 r0 *1 58.24,398.16
X$29939 14074 3526 2340 3525 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29942 r0 *1 41.44,398.16
X$29942 14074 3458 2340 3523 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29945 r0 *1 37.52,337.68
X$29945 14074 2801 2340 2800 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29947 r0 *1 73.36,367.92
X$29947 14074 3097 2340 3096 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29950 r0 *1 2.24,307.44
X$29950 14074 2441 2340 2440 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29952 r0 *1 7.84,317.52
X$29952 14074 2529 2340 2527 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29954 r0 *1 12.88,327.6
X$29954 14074 2742 2340 2741 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29957 r0 *1 10.08,357.84
X$29957 14074 2896 2340 3014 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29959 r0 *1 28,367.92
X$29959 14074 3182 2340 3162 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29962 r0 *1 60.48,347.76
X$29962 14074 2902 2340 2900 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29964 m0 *1 7.28,347.76
X$29964 14074 2848 2340 2847 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29967 r0 *1 40.32,327.6
X$29967 14074 2668 2340 2666 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29969 r0 *1 56.56,297.36
X$29969 14074 2403 2340 2375 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29971 m0 *1 16.8,307.44
X$29971 14074 2343 2340 2342 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $29974 r0 *1 16.24,398.16
X$29974 14074 14073 2341 3455 2402 3397 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29976 r0 *1 11.76,388.08
X$29976 14074 14073 3396 3397 2401 2341 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $29988 r0 *1 92.4,307.44
X$29988 14074 14073 2344 2464 2402 2346 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30066 m0 *1 773.92,861.84
X$30066 14073 14074 10055 2356 8236 6798 10056 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $30068 m0 *1 787.36,801.36
X$30068 14074 14073 9106 5152 8602 2356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30071 r0 *1 669.2,529.2
X$30071 14074 14073 5194 4933 2357 5252 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30079 m0 *1 464.24,418.32
X$30079 14074 14073 3633 2357 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $30081 r0 *1 667.52,347.76
X$30081 14074 14073 2975 2768 2357 2692 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30097 m0 *1 690.48,660.24
X$30097 14074 2359 6789 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $30099 r0 *1 854.56,710.64
X$30099 14074 14073 7829 7714 7551 2359 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $30106 m0 *1 747.04,317.52
X$30106 14074 2429 2427 2588 2360 14073 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $30108 m0 *1 763.84,307.44
X$30108 2429 14073 2360 2427 14074 2496 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30147 m0 *1 822.64,650.16
X$30147 14074 2367 6827 6246 6532 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $30171 m0 *1 17.36,317.52
X$30171 14074 14073 2372 2528 2402 2529 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30177 m0 *1 8.96,317.52
X$30177 14074 14073 2527 2529 2401 2372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30179 r0 *1 49.28,458.64
X$30179 14073 14074 4173 2373 4190 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30187 m0 *1 39.76,448.56
X$30187 2373 14074 4064 14073 4109 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $30215 r0 *1 329.84,347.76
X$30215 14073 2966 14074 2753 2913 2915 2380 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $30217 m0 *1 304.08,367.92
X$30217 14073 2474 14074 3144 2860 3106 2380 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $30219 m0 *1 335.44,378
X$30219 14074 14073 3027 2380 3215 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30234 r0 *1 327.04,337.68
X$30234 14074 2476 14073 2841 2816 2380 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30236 r0 *1 291.76,378
X$30236 14074 14073 3322 3215 2474 2380 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30238 m0 *1 306.88,388.08
X$30238 2380 14073 3145 3271 14074 3381 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30240 m0 *1 323.68,398.16
X$30240 14074 14073 2380 3408 3345 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30242 m0 *1 327.6,408.24
X$30242 3537 2542 2380 3584 2414 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $30251 m0 *1 334.88,307.44
X$30251 14074 14073 2382 2414 2452 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30309 m0 *1 95.76,317.52
X$30309 2535 14073 14074 2398 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $30314 m0 *1 82.88,317.52
X$30314 2534 14073 14074 2399 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $30319 m0 *1 15.12,367.92
X$30319 3161 14073 14074 2400 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $30324 r0 *1 71.12,378
X$30324 14074 14073 3256 3259 2401 3095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30329 r0 *1 12.88,337.68
X$30329 14074 14073 2847 2848 2401 2665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30331 m0 *1 40.88,327.6
X$30331 14074 14073 2666 2668 2401 2530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30334 m0 *1 42,337.68
X$30334 14074 14073 2800 2801 2401 2802 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30336 m0 *1 15.68,337.68
X$30336 14074 14073 2741 2742 2401 2463 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30338 m0 *1 58.24,367.92
X$30338 14074 14073 3183 3135 2401 3094 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30340 r0 *1 40.88,347.76
X$30340 14074 14073 2947 2899 2401 2531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30342 m0 *1 62.16,347.76
X$30342 14074 14073 2900 2902 2401 2803 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30344 m0 *1 33.04,367.92
X$30344 14074 14073 3162 3182 2401 3015 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30346 r0 *1 20.16,388.08
X$30346 14074 14073 3373 3333 2401 3134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30351 m0 *1 36.96,398.16
X$30351 14074 3456 3457 14073 2401 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30353 m0 *1 78.96,367.92
X$30353 14074 14073 3096 3097 2401 3067 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30355 m0 *1 82.88,347.76
X$30355 14074 14073 2849 2850 2401 2829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30357 r0 *1 92.4,357.84
X$30357 14074 14073 3068 3016 2401 2805 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30359 m0 *1 101.92,327.6
X$30359 14074 14073 2670 2672 2401 2535 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30361 r0 *1 92.4,347.76
X$30361 14074 14073 2851 2903 2401 2804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30387 r0 *1 33.04,378
X$30387 14074 14073 3309 3201 2401 3161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30389 r0 *1 105.28,378
X$30389 14074 14073 3261 3262 2401 3260 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30392 m0 *1 11.2,357.84
X$30392 14074 14073 3014 2896 2401 2877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30395 m0 *1 84,378
X$30395 14074 14073 3067 3258 2402 3097 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30400 r0 *1 16.8,347.76
X$30400 14074 14073 2877 2946 2402 2896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30403 m0 *1 24.08,347.76
X$30403 14074 14073 2665 2897 2402 2848 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30405 r0 *1 21.28,337.68
X$30405 14074 14073 2463 2878 2402 2742 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30408 m0 *1 49.28,327.6
X$30408 14074 14073 2530 2667 2402 2668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30414 m0 *1 64.4,378
X$30414 14074 14073 3094 3236 2402 3135 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30416 m0 *1 46.48,347.76
X$30416 14074 14073 2802 2898 2402 2801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30419 r0 *1 50.96,347.76
X$30419 14074 14073 2531 2948 2402 2899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30421 r0 *1 44.8,367.92
X$30421 14074 14073 3015 3202 2402 3182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30424 m0 *1 29.12,388.08
X$30424 14074 14073 3134 3334 2402 3333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30426 m0 *1 40.32,378
X$30426 14074 14073 3161 3255 2402 3201 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30429 r0 *1 68.32,327.6
X$30429 14074 14073 2533 2743 2402 2598 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30435 r0 *1 84,347.76
X$30435 14074 14073 2829 2949 2402 2850 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30438 m0 *1 72.24,347.76
X$30438 14074 14073 2803 2901 2402 2902 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30440 r0 *1 102.48,357.84
X$30440 14074 14073 2805 3098 2402 3016 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30442 m0 *1 86.8,327.6
X$30442 14074 14073 2534 2669 2402 2638 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30444 r0 *1 101.92,347.76
X$30444 14074 14073 2804 2950 2402 2903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30446 m0 *1 112,327.6
X$30446 14074 14073 2535 2671 2402 2672 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30479 r0 *1 79.52,378
X$30479 14074 14073 3095 3257 2402 3259 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30481 r0 *1 109.76,398.16
X$30481 14074 14073 2402 3099 3459 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30484 r0 *1 115.36,398.16
X$30484 14074 3456 14073 3460 3459 2402 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30487 r0 *1 122.08,388.08
X$30487 14074 14073 3402 2402 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $30489 m0 *1 128.24,408.24
X$30489 14074 2402 14073 3462 3532 3435 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30497 m0 *1 136.08,438.48
X$30497 3827 14073 2404 2464 14074 3905 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30499 r0 *1 152.88,428.4
X$30499 14074 14073 2404 3828 3264 3829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30506 r0 *1 134.96,428.4
X$30506 3987 14074 14073 3827 2404 3868 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $30538 m0 *1 254.8,307.44
X$30538 14074 14073 2412 2411 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $30556 r0 *1 334.88,307.44
X$30556 14074 14073 2417 2414 2478 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $30559 r0 *1 359.52,418.32
X$30559 2414 14074 3714 3754 14073 3587 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $30562 r0 *1 388.08,408.24
X$30562 14074 2414 2477 14073 3410 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30616 m0 *1 283.92,388.08
X$30616 3380 2759 3341 3342 2414 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $30620 m0 *1 372.96,357.84
X$30620 2414 14073 2606 2474 14074 3080 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $30622 r0 *1 380.24,347.76
X$30622 14073 2414 2890 14074 2942 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30626 r0 *1 330.4,438.48
X$30626 14074 2542 14073 2679 3835 2751 2414 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $30628 r0 *1 362.88,357.84
X$30628 14074 3110 14073 3248 3078 3028 2414 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $30630 m0 *1 349.44,378
X$30630 14074 2414 14073 3246 2679 2606 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30632 r0 *1 365.12,337.68
X$30632 14073 2414 2542 14074 2816 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30634 r0 *1 315.28,388.08
X$30634 14073 2414 2476 14074 3271 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30636 m0 *1 307.44,408.24
X$30636 14074 14073 2414 3710 3272 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30639 r0 *1 366.24,398.16
X$30639 14074 3347 14073 3509 3344 2414 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30641 m0 *1 391.44,418.32
X$30641 14074 2414 14073 3758 2477 2679 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30643 r0 *1 385.84,378
X$30643 14074 2968 14073 3451 2751 2414 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30666 m0 *1 328.72,398.16
X$30666 14074 14073 2416 3447 3408 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30683 r0 *1 487.2,347.76
X$30683 14074 14073 2943 2971 2419 2970 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30685 r0 *1 478.8,347.76
X$30685 14074 14073 2924 2918 2419 2866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30687 r0 *1 491.12,357.84
X$30687 14074 14073 3088 3032 2419 3112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30700 r0 *1 491.68,458.64
X$30700 14074 14073 2419 4349 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $30709 r0 *1 785.68,398.16
X$30709 14074 2504 2421 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $30718 m0 *1 577.92,398.16
X$30718 14074 2421 3284 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $30720 r0 *1 744.24,398.16
X$30720 14074 3563 2421 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $30723 m0 *1 756.56,327.6
X$30723 14074 14073 2421 2428 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $30750 m0 *1 707.28,529.2
X$30750 14074 2424 5102 14073 5076 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30753 m0 *1 664.16,539.28
X$30753 14074 2424 5253 14073 5145 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $30785 m0 *1 748.16,327.6
X$30785 14074 14073 2560 2771 2428 2493 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30838 m0 *1 1155.84,317.52
X$30838 14074 2570 2439 2635 2632 2438 2633 2634 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $30841 m0 *1 1036,327.6
X$30841 14074 14073 2507 2705 2438 2627 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $30850 m0 *1 1121.12,327.6
X$30850 14074 2569 2439 2631 2707 2438 2708 2709 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $30857 r0 *1 1145.76,307.44
X$30857 14074 14073 2506 2439 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $30874 r0 *1 156.8,468.72
X$30874 14074 14073 4398 2442 4305 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $30884 r0 *1 136.08,458.64
X$30884 3986 14074 2442 14073 4193 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $30886 r0 *1 129.92,468.72
X$30886 14073 3704 2442 14074 4304 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $30889 r0 *1 126.56,448.56
X$30889 14074 4070 3986 14073 2671 2442 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $30922 r0 *1 288.96,448.56
X$30922 14074 4126 14073 3995 2449 2479 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $30925 m0 *1 277.76,428.4
X$30925 14074 3878 14073 3708 3645 2450 3747 2479
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $30974 m0 *1 25.76,317.52
X$30974 2530 14073 14074 2460 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $30977 m0 *1 25.76,357.84
X$30977 3015 14073 14074 2461 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $30982 m0 *1 30.24,458.64
X$30982 14073 14074 4172 2462 4890 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $30991 m0 *1 19.6,438.48
X$30991 14073 2462 3949 14074 3896 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $30993 m0 *1 33.04,448.56
X$30993 3984 14073 2462 3897 14074 4064 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31001 r0 *1 134.96,438.48
X$31001 3987 14073 2464 2743 14074 3986 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31009 m0 *1 134.4,448.56
X$31009 3987 14074 2464 14073 4116 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $31012 m0 *1 171.36,448.56
X$31012 14074 4077 14073 2464 3532 4074 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31015 r0 *1 119.84,438.48
X$31015 14074 14073 3957 2465 4031 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31020 r0 *1 121.52,428.4
X$31020 3827 14074 14073 3902 2465 3956 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $31023 m0 *1 131.04,317.52
X$31023 14074 2467 2536 2466 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31038 m0 *1 165.76,317.52
X$31038 14074 2470 2536 2575 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31053 r0 *1 345.52,317.52
X$31053 14074 14073 2610 2608 2474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31059 r0 *1 302.4,357.84
X$31059 14074 14073 2606 2860 2474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31063 r0 *1 346.64,388.08
X$31063 14073 2606 14074 3273 3475 2474 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $31065 m0 *1 342.72,337.68
X$31065 2474 14074 2817 2755 14073 2609 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $31067 r0 *1 334.88,448.56
X$31067 14073 2474 4183 14074 4088 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31100 m0 *1 299.6,337.68
X$31100 14073 2610 2474 14074 2815 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31102 r0 *1 305.76,317.52
X$31102 14073 2541 2474 14074 2476 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31104 m0 *1 315.28,327.6
X$31104 14074 2474 14073 2680 2720 2606 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31110 r0 *1 315.28,357.84
X$31110 14073 2860 14074 3026 2966 2474 3025 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $31113 r0 *1 371.84,408.24
X$31113 14073 2606 2474 14074 2760 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31124 r0 *1 314.72,307.44
X$31124 14074 2476 14073 2478 2475 2477 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31140 r0 *1 290.08,398.16
X$31140 14074 2610 14073 3320 3560 3473 2476 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $31149 r0 *1 307.44,428.4
X$31149 14074 2476 14073 3834 3106 3963 3773 3772
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $31153 m0 *1 385.84,327.6
X$31153 14073 2606 2542 14074 2477 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31172 r0 *1 279.44,438.48
X$31172 2643 2479 4039 3913 3645 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $31177 m0 *1 385.84,438.48
X$31177 14074 2479 3778 14073 3836 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31208 m0 *1 343.28,438.48
X$31208 14073 3915 14074 2758 2479 2679 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $31211 r0 *1 346.08,327.6
X$31211 14073 2609 14074 2756 2480 2757 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $31215 m0 *1 314.16,367.92
X$31215 14073 2543 3025 14074 2481 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31234 m0 *1 306.32,347.76
X$31234 14074 14073 2481 2863 2811 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31242 m0 *1 394.8,398.16
X$31242 14074 14073 2679 3275 2481 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31244 m0 *1 388.08,428.4
X$31244 14073 3344 2481 14074 3778 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31247 r0 *1 394.24,428.4
X$31247 14073 2481 3885 2751 3972 2679 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $31249 r0 *1 350.56,317.52
X$31249 14074 14073 2611 2482 2609 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31252 m0 *1 352.24,317.52
X$31252 2610 14073 2544 2648 14074 2483 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31292 r0 *1 632.24,630
X$31292 14074 14073 2490 6505 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31295 r0 *1 881.44,660.24
X$31295 14074 14073 6902 2934 6883 2490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31299 r0 *1 573.44,670.32
X$31299 14073 7128 14074 2492 7132 7024 7129 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $31303 r0 *1 663.04,670.32
X$31303 14074 6713 14073 6721 7215 6790 7096 2492
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $31333 m0 *1 990.64,720.72
X$31333 14074 7825 14073 7889 7635 2496 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31335 r0 *1 985.6,710.64
X$31335 14074 14073 2496 7718 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31368 r0 *1 877.52,710.64
X$31368 14073 2501 7551 14074 7743 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31370 m0 *1 879.76,720.72
X$31370 14074 2501 7806 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $31384 r0 *1 1005.76,398.16
X$31384 14074 14073 3503 3551 2504 3606 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31389 r0 *1 1033.76,327.6
X$31389 14074 14073 2577 2705 2504 2566 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31391 m0 *1 868,428.4
X$31391 14074 14073 3792 3793 2504 3794 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31433 r0 *1 992.32,398.16
X$31433 14073 2504 3490 14074 3504 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31435 r0 *1 968.8,388.08
X$31435 14074 3550 2504 3301 3297 3425 3298 3300 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31437 r0 *1 981.68,438.48
X$31437 14074 3607 2504 3942 3939 4015 3940 3941 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31439 m0 *1 896,388.08
X$31439 14074 3421 2504 2985 3362 3089 3361 3053 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31442 r0 *1 910,398.16
X$31442 14074 3512 2504 3422 3487 3089 3489 3423 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31444 m0 *1 926.8,388.08
X$31444 14074 3439 2504 3230 3364 3089 3141 3296 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31447 m0 *1 958.16,408.24
X$31447 14074 3558 2504 3605 3548 3425 3549 3604 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31449 m0 *1 1029.84,378
X$31449 14074 3231 2504 3058 3177 3089 3175 3057 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31451 r0 *1 911.12,438.48
X$31451 14074 4043 2504 3961 4012 3089 4103 4013 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31453 r0 *1 1043.84,317.52
X$31453 14073 2504 2627 14074 2576 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31456 m0 *1 1100.4,388.08
X$31456 14074 14073 2504 3234 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31459 r0 *1 1064.56,357.84
X$31459 14074 3059 2504 2994 2991 3089 2992 2993 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31461 r0 *1 1066.24,438.48
X$31461 14074 14073 2504 4016 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31463 m0 *1 1062.88,388.08
X$31463 14074 3313 2504 3304 3314 3089 3367 3303 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31468 r0 *1 946.96,327.6
X$31468 14074 2701 2504 2779 2776 2565 2777 2778 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31471 m0 *1 1018.08,367.92
X$31471 14074 3129 2504 2989 3055 3089 3127 3056 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31474 r0 *1 974.96,327.6
X$31474 14074 2717 2504 2642 2703 2565 2704 2715 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31476 r0 *1 877.52,378
X$31476 14074 3385 2504 3051 3292 3089 3293 3050 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31482 r0 *1 810.32,438.48
X$31482 14074 4052 2504 3937 3936 3089 3851 3852 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31484 m0 *1 838.32,428.4
X$31484 14074 3791 2504 3674 3731 3089 3673 3601 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31486 m0 *1 870.8,438.48
X$31486 14073 2504 3732 14074 3965 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31490 m0 *1 873.6,498.96
X$31490 14074 4288 14073 4494 4723 2505 4573 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $31532 m0 *1 1002.96,428.4
X$31532 14074 14073 2506 3797 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31534 m0 *1 917.28,428.4
X$31534 14074 14073 2506 3676 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31537 r0 *1 1114.96,367.92
X$31537 14074 3310 2506 3179 3178 3308 3131 3062 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31539 r0 *1 1153.6,367.92
X$31539 14074 3180 2506 3065 3132 3308 3064 3181 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31543 r0 *1 1155.84,398.16
X$31543 14074 3305 2506 3372 3432 3308 3369 3371 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31545 r0 *1 1119.44,388.08
X$31545 14074 3306 2506 3368 3428 3308 3429 3430 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $31549 r0 *1 778.96,408.24
X$31549 14074 2506 3221 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $31631 m0 *1 93.52,337.68
X$31631 2805 14073 14074 2525 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31638 m0 *1 2.24,367.92
X$31638 3134 14073 14074 2526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $31645 r0 *1 22.4,408.24
X$31645 14074 14073 3521 2528 3637 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31654 m0 *1 16.24,428.4
X$31654 3895 14073 3700 2528 14074 3698 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31656 r0 *1 27.44,408.24
X$31656 14074 14073 2528 3611 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31683 r0 *1 49.28,478.8
X$31683 14074 14073 2532 4395 3895 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31685 r0 *1 60.48,458.64
X$31685 2532 14074 3984 14073 4235 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $31688 r0 *1 62.72,478.8
X$31688 14074 14073 2532 4458 3264 4254 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $31691 m0 *1 53.76,468.72
X$31691 2532 14073 3984 2948 14074 4301 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31693 r0 *1 49.84,468.72
X$31693 2532 14073 2948 2898 14074 4137 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31713 r0 *1 162.4,327.6
X$31713 14074 2673 2536 2787 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31743 r0 *1 180.32,347.76
X$31743 14074 2854 2536 2958 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31749 m0 *1 147.84,357.84
X$31749 14074 2956 2536 2955 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31751 r0 *1 183.12,317.52
X$31751 14074 2601 2536 2538 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31753 r0 *1 203.84,367.92
X$31753 14074 3167 2536 3206 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31757 r0 *1 147.28,327.6
X$31757 14074 14073 2536 14135 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $31770 m0 *1 120.4,337.68
X$31770 14074 2745 2536 2744 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31772 m0 *1 93.52,357.84
X$31772 14074 3016 2536 3068 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31774 r0 *1 135.52,337.68
X$31774 14074 2807 2536 2806 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31776 r0 *1 143.36,367.92
X$31776 14074 3102 2536 2952 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31778 r0 *1 123.76,347.76
X$31778 14074 2904 2536 2933 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31780 r0 *1 81.76,337.68
X$31780 14074 2850 2536 2849 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31782 r0 *1 101.92,327.6
X$31782 14074 2672 2536 2670 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31784 m0 *1 91.28,347.76
X$31784 14074 2903 2536 2851 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31787 r0 *1 127.68,357.84
X$31787 14074 2954 2536 3069 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $31810 r0 *1 375.2,388.08
X$31810 2541 14074 2755 3450 14073 3588 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $31836 r0 *1 363.44,317.52
X$31836 14073 2541 2542 14074 2612 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31840 m0 *1 382.48,347.76
X$31840 14074 2890 14073 2941 2891 2916 2541 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $31844 m0 *1 300.72,408.24
X$31844 14074 14073 2541 3561 3710 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31846 r0 *1 319.76,408.24
X$31846 14073 2610 2541 14074 2913 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31848 m0 *1 337.12,408.24
X$31848 14074 14073 2541 3537 2679 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31850 m0 *1 378,408.24
X$31850 14074 14073 3538 3410 2751 2541 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $31886 m0 *1 285.6,317.52
X$31886 14074 14073 2580 2542 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $31890 m0 *1 282.8,408.24
X$31890 2542 14073 2679 3536 14074 3341 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31893 r0 *1 316.96,347.76
X$31893 14074 14073 2542 2911 2913 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31898 r0 *1 372.96,347.76
X$31898 14073 2542 2913 14074 2967 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31901 m0 *1 362.32,357.84
X$31901 3145 14073 2542 3027 14074 2818 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31904 m0 *1 349.44,337.68
X$31904 14074 2760 14073 2756 2759 2542 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31906 m0 *1 295.68,378
X$31906 14074 14073 3145 3242 2542 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31908 r0 *1 377.44,418.32
X$31908 14073 2610 2542 14074 3110 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31912 m0 *1 364.56,418.32
X$31912 14073 2606 3110 14074 2543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31934 r0 *1 272.16,438.48
X$31934 14074 3650 14073 4039 3833 2543 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $31941 r0 *1 363.44,378
X$31941 14073 3145 2543 14074 3274 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31944 m0 *1 305.2,327.6
X$31944 14073 2751 2679 14074 2544 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31954 r0 *1 287.28,327.6
X$31954 2610 14073 2544 2678 14074 2750 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $31959 r0 *1 355.6,418.32
X$31959 14074 14073 2544 3714 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $31963 m0 *1 338.24,438.48
X$31963 14074 14073 3410 3915 2544 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $31971 r0 *1 389.2,337.68
X$31971 14074 2816 2546 14073 2547 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $31973 r0 *1 309.12,398.16
X$31973 14073 3271 3473 14074 2546 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $31991 r0 *1 328.16,408.24
X$31991 14074 14073 2546 3585 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32005 r0 *1 407.68,317.52
X$32005 14074 2917 2616 2548 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $32088 r0 *1 786.24,327.6
X$32088 14074 14073 2774 2562 2772 2773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32114 r0 *1 943.6,317.52
X$32114 14074 14073 2827 2565 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $32133 r0 *1 1042.16,327.6
X$32133 14074 14073 2567 2828 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $32216 m0 *1 577.36,680.4
X$32216 14073 7128 14074 2588 7132 7134 5219 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $32224 r0 *1 758.24,680.4
X$32224 14074 6713 14073 7205 7388 6790 7147 2588
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $32242 m0 *1 57.68,337.68
X$32242 2803 14073 14074 2592 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32245 m0 *1 10.08,327.6
X$32245 2665 14073 14074 2593 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32248 m0 *1 49.84,367.92
X$32248 3094 14073 14074 2594 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32253 r0 *1 4.48,337.68
X$32253 2877 14073 14074 2595 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32256 m0 *1 66.64,367.92
X$32256 3095 14073 14074 2596 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32312 r0 *1 283.36,378
X$32312 14073 3321 14074 3322 3380 2606 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $32315 m0 *1 374.64,438.48
X$32315 14074 3971 2606 14073 3110 2859 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $32321 m0 *1 312.48,378
X$32321 14074 2759 14073 3383 3025 2606 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $32324 r0 *1 352.24,408.24
X$32324 14074 2606 3626 14073 3627 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $32360 m0 *1 277.2,347.76
X$32360 14073 2610 2606 14074 2817 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32364 r0 *1 271.6,378
X$32364 14074 14073 2606 3320 3213 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32375 m0 *1 360.08,388.08
X$32375 2606 14073 2758 3273 14074 3347 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $32377 m0 *1 321.44,357.84
X$32377 14074 14073 2610 2966 2606 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32399 m0 *1 346.64,327.6
X$32399 14074 14073 2609 2647 2725 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32404 r0 *1 377.44,428.4
X$32404 14074 3884 2610 2755 3812 3110 2859 3837 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $32406 r0 *1 371.84,337.68
X$32406 14073 2610 14074 2865 2842 2819 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $32450 r0 *1 347.2,337.68
X$32450 14073 2610 2751 14074 2758 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32452 m0 *1 347.76,347.76
X$32452 14074 14073 2610 2757 2751 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32455 m0 *1 358.4,337.68
X$32455 14074 14073 2759 2611 2758 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32457 r0 *1 335.44,327.6
X$32457 14073 2611 14074 2754 2682 2755 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $32467 r0 *1 356.72,327.6
X$32467 14073 2758 14074 2612 2725 2759 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $32475 r0 *1 366.8,327.6
X$32475 14074 14073 2792 2760 2751 2612 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32484 m0 *1 380.24,448.56
X$32484 14074 4092 2616 4091 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $32487 r0 *1 431.76,378
X$32487 14074 3113 2616 3249 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $32505 m0 *1 435.12,357.84
X$32505 14074 2923 2616 3086 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32510 r0 *1 414.4,357.84
X$32510 14074 3030 2616 3084 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $32512 r0 *1 407.12,327.6
X$32512 14074 2763 2616 2728 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32514 m0 *1 361.76,458.64
X$32514 14074 3717 2616 4089 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32518 m0 *1 411.6,408.24
X$32518 14074 2616 14075 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $32522 r0 *1 427.84,388.08
X$32522 14074 3478 2616 3277 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32525 r0 *1 411.04,388.08
X$32525 14074 3351 2616 3349 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32527 r0 *1 376.88,458.64
X$32527 14074 4152 2616 4205 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32529 r0 *1 402.08,408.24
X$32529 14074 3590 2616 3631 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32532 r0 *1 406,398.16
X$32532 14074 3479 2616 3513 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32534 r0 *1 418.88,408.24
X$32534 14074 3481 2616 3632 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32536 r0 *1 435.68,408.24
X$32536 14074 3591 2616 3540 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $32605 m0 *1 1052.8,700.56
X$32605 14073 2628 7551 14074 7561 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32608 r0 *1 1060.08,700.56
X$32608 14074 2628 7640 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $32703 m0 *1 326.48,327.6
X$32703 2722 2681 2646 2721 14073 14074 2723 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $32733 m0 *1 792.4,347.76
X$32733 14073 2772 2654 14074 2935 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32774 m0 *1 72.8,357.84
X$32774 3067 14073 14074 2661 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32779 m0 *1 69.44,337.68
X$32779 2829 14073 14074 2662 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32782 m0 *1 85.12,337.68
X$32782 2804 14073 14074 2663 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32785 m0 *1 29.68,337.68
X$32785 2802 14073 14074 2664 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $32797 m0 *1 56,418.32
X$32797 14074 3641 3255 14073 2667 3202 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $32806 m0 *1 68.88,418.32
X$32806 14073 3643 14074 3682 2667 3532 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $32808 m0 *1 63.84,398.16
X$32808 2667 14074 3554 14073 3398 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $32811 m0 *1 50.96,418.32
X$32811 14073 3704 2667 14074 3640 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32818 m0 *1 98.56,468.72
X$32818 4255 4191 2669 3258 14074 14073 4257 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $32820 r0 *1 101.92,478.8
X$32820 14074 14073 2669 4456 3264 4510 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32828 m0 *1 100.24,458.64
X$32828 14074 14073 2669 4174 4139 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32830 m0 *1 90.16,478.8
X$32830 2949 14073 2669 4256 14074 4396 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $32833 m0 *1 96.32,478.8
X$32833 2669 14074 4256 14073 4455 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $32837 m0 *1 143.92,488.88
X$32837 14074 14073 2671 4462 3532 4610 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32848 m0 *1 124.88,478.8
X$32848 14074 14073 2671 4397 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $32890 m0 *1 374.08,347.76
X$32890 14074 14073 2859 2755 2679 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $32893 m0 *1 329.28,448.56
X$32893 14074 14073 4087 4127 2679 4128 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $32895 r0 *1 346.64,438.48
X$32895 14073 2679 14074 4045 4044 3998 2755 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $32926 r0 *1 282.24,448.56
X$32926 14073 2859 2679 14074 3344 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $32967 m0 *1 528.08,347.76
X$32967 14074 14073 2869 2922 2688 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $32971 r0 *1 586.88,418.32
X$32971 14074 3843 14073 3721 3034 2689 3722 3542
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $32973 r0 *1 552.16,357.84
X$32973 14074 3089 14073 3088 3034 2689 2974 2973
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $32989 m0 *1 580.72,357.84
X$32989 14074 14073 2917 2691 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $33022 r0 *1 746.48,327.6
X$33022 14074 14073 2732 2771 2772 2696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33028 m0 *1 773.92,388.08
X$33028 14074 3360 3357 3356 3355 2697 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $33030 r0 *1 766.08,388.08
X$33030 14074 3446 2697 3356 3357 3355 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $33107 m0 *1 240.24,327.6
X$33107 14074 14073 2714 2747 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33206 r0 *1 882.56,710.64
X$33206 14074 7740 2733 7552 7743 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $33208 r0 *1 589.12,670.32
X$33208 14074 14073 2733 6958 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $33241 m0 *1 92.4,378
X$33241 3260 14073 14074 2739 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33248 r0 *1 3.36,388.08
X$33248 2740 14073 14074 3456 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $33262 r0 *1 126.56,438.48
X$33262 14073 2743 3905 14074 3704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33267 r0 *1 165.2,448.56
X$33267 14074 4120 14073 2743 3532 3988 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33270 m0 *1 143.92,448.56
X$33270 2743 14074 3905 14073 4118 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $33285 r0 *1 222.88,337.68
X$33285 14074 14073 2746 2789 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $33307 m0 *1 310.24,418.32
X$33307 14073 2751 14074 3584 3711 3692 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $33310 m0 *1 389.76,388.08
X$33310 14073 3348 14074 3386 3276 3387 2751 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $33315 r0 *1 358.4,398.16
X$33315 14073 2751 14074 3409 3476 3508 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $33344 r0 *1 283.92,357.84
X$33344 14074 14073 2751 2910 2759 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33346 m0 *1 288.96,337.68
X$33346 14074 14073 2791 2836 2751 2838 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33349 m0 *1 321.44,448.56
X$33349 14074 3996 14073 4127 4086 2751 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33353 r0 *1 380.8,378
X$33353 14073 2751 2759 14074 3171 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33365 m0 *1 319.76,378
X$33365 14074 2913 14073 2754 3272 3271 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33371 r0 *1 340.48,337.68
X$33371 2755 14074 2889 2864 14073 2890 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $33388 m0 *1 390.88,357.84
X$33388 14074 2755 14073 3081 3010 2861 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33391 r0 *1 379.68,337.68
X$33391 14074 14073 2755 2941 2842 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33410 m0 *1 345.52,408.24
X$33410 14074 2757 14073 3625 3475 3537 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33430 m0 *1 273.84,337.68
X$33430 14073 2814 14074 2837 2836 2759 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $33435 m0 *1 366.24,448.56
X$33435 14074 14073 4090 3999 2759 3969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33442 m0 *1 379.68,388.08
X$33442 14074 14073 3386 3274 2759 2913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33474 r0 *1 270.48,327.6
X$33474 14074 14073 2790 2759 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $33479 r0 *1 343.84,448.56
X$33479 14074 14073 2859 3997 2759 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33483 m0 *1 363.44,367.92
X$33483 14073 2859 2759 14074 2968 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33485 r0 *1 355.6,357.84
X$33485 14074 2859 14073 3170 3078 2759 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $33498 m0 *1 347.76,388.08
X$33498 14073 3145 2759 14074 3273 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $33505 r0 *1 344.96,418.32
X$33505 14074 2816 2760 14073 3713 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $33508 m0 *1 379.68,398.16
X$33508 14074 14073 3510 2760 2859 2913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $33522 m0 *1 350.56,418.32
X$33522 14074 14073 2760 3586 3651 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33526 r0 *1 338.24,398.16
X$33526 14074 14073 3474 2816 2760 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $33530 r0 *1 375.76,327.6
X$33530 14074 14073 2793 2761 2795 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $33544 r0 *1 122.64,378
X$33544 14074 2762 3263 3315 14073 gf180mcu_fd_sc_mcu9t5v0__latsnq_1
* cell instance $33557 m0 *1 371.84,378
X$33557 14074 2762 14073 gf180mcu_fd_sc_mcu9t5v0__inv_16
* cell instance $33567 m0 *1 547.68,337.68
X$33567 14074 14073 2923 2764 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $33708 m0 *1 1025.36,378
X$33708 14074 14073 2780 14131 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33717 r0 *1 1028.16,357.84
X$33717 14074 3176 2780 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $33751 m0 *1 1144.08,408.24
X$33751 14074 3176 2782 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $33758 r0 *1 1144.08,398.16
X$33758 14074 14073 2782 14155 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $33841 r0 *1 360.64,347.76
X$33841 14074 2939 2791 14073 2969 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $33917 r0 *1 850.64,367.92
X$33917 14074 14073 2796 14134 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $33925 r0 *1 855.12,367.92
X$33925 14074 3176 2796 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $34002 m0 *1 295.12,357.84
X$34002 14074 14073 2965 3003 2811 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34010 r0 *1 257.6,337.68
X$34010 14074 14073 2812 2813 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34027 m0 *1 326.48,347.76
X$34027 14074 14073 2888 2816 2859 2913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34059 m0 *1 276.64,418.32
X$34059 14074 3649 14073 3709 3472 2817 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $34068 r0 *1 345.52,378
X$34068 14074 14073 2817 3216 3273 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34107 r0 *1 963.76,458.64
X$34107 14074 3281 2827 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $34110 r0 *1 1012.48,478.8
X$34110 14074 2827 4015 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $34112 r0 *1 962.64,398.16
X$34112 14074 14073 2827 3425 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $34116 m0 *1 920.64,670.32
X$34116 14074 14073 7043 2828 6966 5358 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34124 r0 *1 922.32,680.4
X$34124 14074 2828 7383 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $34136 r0 *1 204.96,337.68
X$34136 14074 2883 2831 14073 2884 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34195 r0 *1 521.36,347.76
X$34195 14074 14073 2921 2922 2844 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $34201 m0 *1 134.4,367.92
X$34201 2846 14073 14074 3188 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $34231 m0 *1 191.52,347.76
X$34231 14074 14073 2852 2905 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34241 m0 *1 194.88,347.76
X$34241 14074 14073 2854 2960 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34257 m0 *1 394.24,438.48
X$34257 14074 2859 3410 14073 3972 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34259 r0 *1 421.68,418.32
X$34259 14074 2859 3758 14073 3715 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34262 r0 *1 302.4,388.08
X$34262 14073 3444 14074 3342 3350 2859 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34266 m0 *1 333.76,398.16
X$34266 14074 14073 3506 3474 2859 3410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34269 m0 *1 335.44,388.08
X$34269 14073 3384 14074 3247 3346 2859 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34300 r0 *1 280.56,347.76
X$34300 14073 2859 2911 14074 2909 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $34302 m0 *1 272.72,357.84
X$34302 14074 14073 3074 2859 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $34309 r0 *1 318.64,438.48
X$34309 2859 3808 3774 4041 14074 14073 3996 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $34323 r0 *1 301.28,337.68
X$34323 2911 2860 2861 2862 14074 14073 3024 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $34329 m0 *1 304.64,357.84
X$34329 2909 2861 3004 2863 14074 14073 2912 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $34356 m0 *1 496.16,418.32
X$34356 14074 14073 3590 2867 3717 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34371 m0 *1 501.2,418.32
X$34371 3351 3541 2867 3480 14073 14074 3411 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $34374 r0 *1 521.92,367.92
X$34374 14074 14073 3172 2867 2986 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $34383 m0 *1 485.52,378
X$34383 14074 14073 2922 2868 3250 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $34385 m0 *1 494.48,398.16
X$34385 14074 2868 3480 3351 3413 3481 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $34387 r0 *1 511.84,388.08
X$34387 14074 2869 3351 3413 3412 14073 3414 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $34398 r0 *1 554.96,347.76
X$34398 14073 3013 3012 2974 2894 2870 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $34448 r0 *1 631.68,388.08
X$34448 14074 14073 2871 14169 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $34495 r0 *1 19.04,418.32
X$34495 2878 14074 3698 14073 3519 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $34498 m0 *1 31.36,428.4
X$34498 14073 3767 14074 3264 2878 3699 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34500 m0 *1 1031.52,347.76
X$34500 14074 14073 2879 2930 2927 2932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34521 m0 *1 209.44,398.16
X$34521 14074 14073 2951 3498 2884 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34523 m0 *1 219.52,398.16
X$34523 14074 3168 2884 14073 3468 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34528 r0 *1 220.64,408.24
X$34528 14074 14073 3910 3168 2884 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $34574 m0 *1 515.76,398.16
X$34574 3412 3413 3351 3480 14073 14074 2895 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $34576 m0 *1 521.36,388.08
X$34576 14074 3033 2895 14073 3389 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34578 r0 *1 532,388.08
X$34578 14074 2895 2922 14073 3454 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34590 m0 *1 19.04,468.72
X$34590 2897 14074 4233 14073 4299 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $34595 r0 *1 21.28,478.8
X$34595 14074 14073 4505 2897 4447 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34597 m0 *1 22.96,458.64
X$34597 4137 3455 2946 2897 14074 14073 3700 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $34599 r0 *1 73.36,478.8
X$34599 14074 14073 2898 4452 3264 4333 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34607 m0 *1 59.92,468.72
X$34607 2898 14074 4301 14073 4253 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $34618 r0 *1 75.04,398.16
X$34618 2901 14073 3236 3257 14074 3493 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $34625 r0 *1 85.12,398.16
X$34625 3527 14073 2901 3236 14074 3335 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $34627 m0 *1 92.96,428.4
X$34627 14074 14073 3706 2901 3804 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34629 m0 *1 82.32,418.32
X$34629 3704 14073 3642 2901 14074 3683 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $34663 r0 *1 255.36,347.76
X$34663 14074 14073 2907 2961 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $34678 r0 *1 285.6,347.76
X$34678 14074 14073 2964 2910 3001 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $34681 r0 *1 371.84,357.84
X$34681 14074 14073 3079 2910 3027 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $34686 r0 *1 304.64,347.76
X$34686 14073 14074 2937 2912 3003 2910 3005 2938
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $34704 m0 *1 328.16,357.84
X$34704 14074 14073 2911 2914 3077 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34754 r0 *1 385.28,347.76
X$34754 14074 2968 2942 14073 2916 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34762 m0 *1 575.12,357.84
X$34762 14074 14073 2917 3092 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $34765 r0 *1 581.28,357.84
X$34765 14074 14073 2917 3034 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $34782 r0 *1 488.32,408.24
X$34782 14074 14073 3590 2920 3593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $34796 m0 *1 474.32,408.24
X$34796 14074 3592 3541 3480 2920 3351 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $34798 r0 *1 476.56,398.16
X$34798 14074 14073 2921 2920 3654 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $34800 m0 *1 506.8,408.24
X$34800 14074 2921 3351 3479 3412 14073 3414 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $34813 r0 *1 493.92,408.24
X$34813 14074 3590 3593 14073 2922 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34816 r0 *1 518.56,378
X$34816 14074 3172 2922 14073 3327 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34819 r0 *1 534.24,408.24
X$34819 14074 2922 2972 14073 3635 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34834 r0 *1 486.64,398.16
X$34834 3351 3541 3480 2922 14073 14074 3567 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $34849 m0 *1 893.76,428.4
X$34849 14073 3795 14074 3420 4160 2925 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34852 m0 *1 964.32,589.68
X$34852 14073 4871 14074 5863 5844 2925 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34854 r0 *1 1020.32,529.2
X$34854 14074 2925 5169 14073 5177 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34856 r0 *1 964.88,509.04
X$34856 14073 4868 4871 4705 4764 2925 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $34859 r0 *1 916.72,509.04
X$34859 14073 4839 4875 4656 4874 2925 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $34861 r0 *1 909.44,589.68
X$34861 14073 4875 14074 5949 5921 2925 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $34863 m0 *1 843.36,589.68
X$34863 14074 14073 5954 2925 5872 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $34866 m0 *1 844.48,357.84
X$34866 14074 2925 2981 14073 3006 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $34868 r0 *1 886.48,428.4
X$34868 14073 3879 3795 3854 3881 2925 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $34890 r0 *1 1044.96,468.72
X$34890 14074 14073 4119 4376 2927 4238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34892 m0 *1 1032.64,509.04
X$34892 14074 14073 4847 4864 2927 4862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34894 r0 *1 985.6,418.32
X$34894 14074 14073 3735 3745 2927 3678 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34925 r0 *1 967.12,428.4
X$34925 14074 14073 3733 2929 2986 3604 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34928 m0 *1 985.04,448.56
X$34928 14074 14073 4123 2929 2987 3941 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $34978 m0 *1 931.84,660.24
X$34978 14074 7081 2929 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $35015 m0 *1 877.52,660.24
X$35015 14074 2934 7159 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $35060 r0 *1 16.24,478.8
X$35060 14074 14073 4448 2946 4446 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35067 r0 *1 22.4,458.64
X$35067 3895 14073 4189 2946 14074 4233 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $35079 r0 *1 54.32,478.8
X$35079 14073 4449 14074 4450 2948 3532 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $35082 m0 *1 93.52,468.72
X$35082 14073 4255 4191 14074 2949 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35090 m0 *1 90.72,458.64
X$35090 14073 2949 4174 14074 4176 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $35098 r0 *1 105.84,458.64
X$35098 4192 3098 4257 2950 14074 14073 3642 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $35100 r0 *1 122.64,478.8
X$35100 2950 14074 4334 14073 4589 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $35103 m0 *1 147.28,498.96
X$35103 14073 4678 14074 2950 4735 3532 4736 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $35141 m0 *1 164.64,357.84
X$35141 14074 14073 2956 2957 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35143 r0 *1 182,357.84
X$35143 14074 14073 3017 2957 3019 2960 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35158 m0 *1 224.56,378
X$35158 2959 14073 3101 3210 14074 3211 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $35161 r0 *1 215.04,398.16
X$35161 14074 14073 3469 3499 2959 3102 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35167 r0 *1 184.8,388.08
X$35167 14073 14074 3405 2959 3404 3268 3406 3165
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $35170 r0 *1 210,398.16
X$35170 14074 14073 2959 3534 3498 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35198 r0 *1 341.04,438.48
X$35198 14074 14073 3997 2965 3915 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35237 m0 *1 368.48,367.92
X$35237 14074 3147 14073 3193 3150 3028 2968 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $35260 m0 *1 515.76,408.24
X$35260 14074 2972 3351 3413 3481 14073 3414 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $35283 m0 *1 790.16,811.44
X$35283 14074 14073 9296 2975 9349 6240 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35291 r0 *1 772.24,861.84
X$35291 14073 14074 10055 2975 8236 6829 10236 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $35310 m0 *1 874.72,448.56
X$35310 14074 14073 3938 3793 2980 3732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35347 m0 *1 990.64,418.32
X$35347 14073 2980 3606 14074 3745 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35350 r0 *1 1006.88,408.24
X$35350 14074 14073 3678 3551 2980 3490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35353 m0 *1 978.88,438.48
X$35353 14074 3875 3797 3942 3939 2980 3940 3941 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35357 m0 *1 954.8,418.32
X$35357 14074 3686 3676 3605 3548 2980 3549 3604 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35359 m0 *1 911.12,448.56
X$35359 14074 3855 3676 3961 4012 2980 4103 4013 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35368 r0 *1 837.76,418.32
X$35368 14074 3790 3676 3674 3731 2980 3673 3601 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35377 m0 *1 857.92,367.92
X$35377 14074 14073 2982 3174 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $35394 r0 *1 931.84,438.48
X$35394 14074 14073 4014 2984 2987 4013 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35404 m0 *1 809.2,428.4
X$35404 14074 14073 3813 2984 2986 3852 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35446 r0 *1 792.4,630
X$35446 14074 6730 2984 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $35466 r0 *1 899.36,519.12
X$35466 14074 14073 5037 4163 2986 4836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35469 r0 *1 977.2,529.2
X$35469 14074 14073 5154 4295 2986 5155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35471 r0 *1 1034.32,428.4
X$35471 14074 14073 3874 3739 2986 3798 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35474 r0 *1 1039.92,539.28
X$35474 14074 14073 5365 4503 2986 5159 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35477 r0 *1 757.68,529.2
X$35477 14074 14073 5227 4385 2986 4828 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35479 m0 *1 835.52,519.12
X$35479 14074 14073 4761 4317 2986 4631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35481 r0 *1 617.12,488.88
X$35481 14074 14073 4487 3663 2986 4353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35484 m0 *1 531.44,448.56
X$35484 14074 14073 4133 3036 2986 3975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35488 m0 *1 742,428.4
X$35488 14074 14073 3729 3544 2986 3730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35517 m0 *1 1093.12,458.64
X$35517 14074 14073 4226 3739 2987 4169 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35519 m0 *1 1007.44,529.2
X$35519 14074 14073 5093 4295 2987 4846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35521 r0 *1 946.4,529.2
X$35521 14074 14073 5096 4163 2987 4842 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35523 m0 *1 1092.56,529.2
X$35523 14074 14073 5170 4503 2987 5020 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35529 m0 *1 709.52,448.56
X$35529 14074 14073 4058 3544 2987 3931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35532 m0 *1 851.76,539.28
X$35532 14074 14073 5228 4317 2987 5082 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35551 m0 *1 818.72,519.12
X$35551 14074 14073 5039 4385 2987 4938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35562 r0 *1 978.88,428.4
X$35562 14073 2988 3796 14074 3876 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35680 m0 *1 563.92,357.84
X$35680 14074 14073 3012 3091 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $35707 m0 *1 207.2,367.92
X$35707 14074 14073 3104 3140 3019 3209 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $35714 m0 *1 252,378
X$35714 14074 14073 3142 3020 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35741 m0 *1 320.32,367.92
X$35741 14074 3107 3026 14073 3108 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $35765 m0 *1 358.96,378
X$35765 14074 14073 3410 3109 3028 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35767 m0 *1 327.04,378
X$35767 14074 14073 3028 3245 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $35774 r0 *1 487.2,599.76
X$35774 14073 3031 5740 14074 6063 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $35785 r0 *1 602.56,690.48
X$35785 14074 14073 3031 7528 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $35788 m0 *1 404.32,700.56
X$35788 14074 7585 3031 5341 7291 5533 6776 7519 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $35804 m0 *1 480.48,428.4
X$35804 14074 3590 3717 14073 3033 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $35819 m0 *1 468.72,428.4
X$35819 3716 3816 3033 3541 14073 14074 3817 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $35847 m0 *1 658,549.36
X$35847 14074 5254 3034 5357 5291 3284 5355 5418 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35849 r0 *1 647.92,549.36
X$35849 14074 5255 3034 5417 5356 3284 5256 5440 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35851 r0 *1 635.04,478.8
X$35851 14074 4527 3034 4421 4354 3284 4352 4356 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35854 m0 *1 639.52,478.8
X$35854 14074 4526 3034 4420 4353 3284 4284 4419 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35857 r0 *1 637.28,509.04
X$35857 14074 4788 3034 4827 4824 3284 4823 4825 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35859 m0 *1 638.4,509.04
X$35859 14074 4753 3034 4755 4692 3284 4752 4826 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35862 r0 *1 646.8,378
X$35862 14074 3329 3034 3287 3252 3284 3118 3040 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35864 m0 *1 655.76,398.16
X$35864 14074 3328 3034 3286 3353 3284 3352 3120 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35933 r0 *1 635.6,579.6
X$35933 14074 5748 3036 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $35952 r0 *1 607.6,388.08
X$35952 14074 3416 3284 3282 3117 3330 3331 3037 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35954 m0 *1 607.6,388.08
X$35954 14074 3393 3280 3282 3117 3279 3331 3037 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $35967 m0 *1 659.12,378
X$35967 14074 3156 3280 3287 3040 3279 3120 3286 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36090 m0 *1 1115.52,378
X$36090 14074 3311 3234 3179 3178 3233 3131 3062 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36100 m0 *1 1154.72,378
X$36100 14074 3235 3234 3065 3132 3233 3064 3181 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36164 r0 *1 400.96,357.84
X$36164 3081 14074 3082 3083 14073 3325 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $36220 r0 *1 793.52,478.8
X$36220 14074 4520 3563 4289 4492 3089 4359 4424 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36250 r0 *1 936.88,710.64
X$36250 14073 3091 7635 14074 7827 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36252 m0 *1 579.04,670.32
X$36252 14074 3091 6955 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $36259 m0 *1 104.16,367.92
X$36259 3099 14073 14074 3093 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36288 r0 *1 118.16,488.88
X$36288 14074 4646 14073 3098 3532 4537 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $36291 m0 *1 113.68,468.72
X$36291 4192 3704 3098 4257 14074 14073 4334 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36293 m0 *1 109.2,478.8
X$36293 14073 3098 4258 14074 4459 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $36298 m0 *1 185.92,448.56
X$36298 4075 14074 3099 4121 14073 4033 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $36308 m0 *1 143.92,418.32
X$36308 14074 14073 3099 3613 3573 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36310 m0 *1 164.64,408.24
X$36310 14074 3465 14073 3617 3687 3099 3456 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $36312 m0 *1 147.84,367.92
X$36312 14074 3100 3138 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36346 r0 *1 189.28,378
X$36346 14073 3101 3210 14074 3165 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36349 r0 *1 209.44,388.08
X$36349 14074 14073 3101 3207 3210 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36354 r0 *1 226.24,498.96
X$36354 14074 14073 3101 4740 4261 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36356 m0 *1 259.84,468.72
X$36356 3958 14073 3101 4262 14074 4308 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $36358 m0 *1 132.16,539.28
X$36358 3101 4261 5112 5246 14074 14073 5200 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36360 m0 *1 120.4,539.28
X$36360 3101 4261 5112 5199 14074 14073 5244 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36364 m0 *1 155.68,539.28
X$36364 3101 4261 4987 5202 14074 14073 5203 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36366 m0 *1 188.16,509.04
X$36366 3101 4261 4737 4141 14074 14073 4715 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36369 m0 *1 193.2,519.12
X$36369 3101 4261 4237 4865 14074 14073 4955 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36371 m0 *1 187.04,488.88
X$36371 3101 4261 4539 4141 14074 14073 4513 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36373 r0 *1 154.56,488.88
X$36373 14073 4261 3101 4538 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $36375 r0 *1 183.12,488.88
X$36375 3101 4261 4237 4609 14074 14073 4714 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36377 r0 *1 201.6,478.8
X$36377 4196 3101 4261 4237 14074 14073 4433 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36379 m0 *1 211.68,478.8
X$36379 3101 4261 4237 4400 14074 14073 4401 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $36381 m0 *1 251.44,559.44
X$36381 14074 14073 5574 3101 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $36394 m0 *1 203.84,367.92
X$36394 14074 14073 3102 3140 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36397 m0 *1 226.24,398.16
X$36397 14074 14073 3102 3500 3468 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36417 r0 *1 161.28,388.08
X$36417 14074 14073 3103 3403 3338 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $36429 r0 *1 318.64,367.92
X$36429 14074 14073 3192 3107 3214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36475 m0 *1 542.64,378
X$36475 14074 14073 3113 3221 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $36483 r0 *1 519.68,398.16
X$36483 14074 3114 3351 3479 3481 14073 3414 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $36496 m0 *1 563.36,378
X$36496 14074 3415 3284 3116 3218 3281 3219 3220 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36498 m0 *1 566.16,388.08
X$36498 14074 3392 3280 3116 3218 3279 3219 3220 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36513 m0 *1 643.44,388.08
X$36513 14074 3197 3280 3252 3118 3279 3352 3353 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $36553 r0 *1 1001.28,700.56
X$36553 14074 3125 7582 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $36555 m0 *1 982.8,710.64
X$36555 14073 7551 3125 7643 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $36615 r0 *1 126,367.92
X$36615 14073 3138 3186 14074 3164 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $36665 r0 *1 357.84,367.92
X$36665 14074 3170 3146 14073 3193 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $36718 m0 *1 390.88,458.64
X$36718 14074 14073 4153 4152 4149 3155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36731 m0 *1 645.12,418.32
X$36731 14074 14073 3820 3661 3157 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $36737 r0 *1 90.16,367.92
X$36737 3159 14073 14074 3237 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36742 r0 *1 50.96,378
X$36742 3160 14073 14074 3434 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36754 m0 *1 106.4,378
X$36754 3163 14073 14074 3198 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $36759 m0 *1 189.84,438.48
X$36759 14073 3830 14074 3163 3908 4035 3909 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $36761 r0 *1 118.16,367.92
X$36761 14074 14073 3185 3263 3163 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36769 r0 *1 566.72,660.24
X$36769 14074 3164 4085 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36774 r0 *1 175.28,378
X$36774 14074 14073 3265 3266 3165 3267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36782 m0 *1 211.12,378
X$36782 14073 3269 3238 3207 3166 3208 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $36787 m0 *1 220.64,378
X$36787 14074 14073 3167 3209 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36813 r0 *1 505.12,398.16
X$36813 14074 3172 3480 3351 3479 3412 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $36834 r0 *1 907.2,670.32
X$36834 14074 14073 7160 5921 6883 3174 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $36836 r0 *1 862.96,650.16
X$36836 14074 3174 6726 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $36865 r0 *1 753.2,448.56
X$36865 14074 3176 3670 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36867 m0 *1 871.92,589.68
X$36867 14074 3176 5229 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36869 r0 *1 810.88,509.04
X$36869 14074 3176 4315 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36873 m0 *1 1031.52,468.72
X$36873 14074 3176 3736 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36875 m0 *1 940.8,428.4
X$36875 14074 3176 3365 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36879 m0 *1 1080.8,519.12
X$36879 14074 3176 4708 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36881 m0 *1 963.2,579.6
X$36881 14074 3176 5016 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $36935 m0 *1 100.8,378
X$36935 14074 14073 3237 3185 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $36939 m0 *1 141.12,388.08
X$36939 14074 3186 3204 14073 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $36944 m0 *1 140.56,378
X$36944 14074 3187 3203 14073 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $36946 r0 *1 131.04,367.92
X$36946 14074 3204 3187 14073 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $36950 r0 *1 143.36,398.16
X$36950 14074 3529 14073 3464 3530 3188 3465 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $36953 m0 *1 160.16,398.16
X$36953 14074 14073 3465 3338 3188 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36955 m0 *1 159.6,408.24
X$36955 14074 14073 3531 3617 3188 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $36957 m0 *1 153.44,388.08
X$36957 14074 3188 3264 14073 3337 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $36966 r0 *1 148.4,408.24
X$36966 14074 3531 14073 3613 3614 3188 3465 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $36968 r0 *1 153.44,398.16
X$36968 3465 14073 3188 3464 14074 3463 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37014 r0 *1 15.12,448.56
X$37014 14073 14074 4061 3199 5449 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $37021 m0 *1 25.76,448.56
X$37021 3700 3199 3983 4063 14074 14073 3897 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $37024 r0 *1 23.52,438.48
X$37024 3199 14074 4024 14073 4023 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $37038 r0 *1 58.24,408.24
X$37038 14074 3570 14073 3202 3532 3571 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $37046 m0 *1 49.28,408.24
X$37046 14073 3202 3524 14074 3553 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $37048 r0 *1 43.68,408.24
X$37048 3255 14073 3202 3334 14074 3569 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37052 m0 *1 128.24,378
X$37052 14074 3203 3312 14073 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $37072 m0 *1 175.28,398.16
X$37072 3532 14073 3207 3266 14074 3466 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37077 r0 *1 234.08,428.4
X$37077 14073 3440 14074 3208 4037 3993 3832 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $37100 m0 *1 225.68,438.48
X$37100 14074 3210 3992 3911 3912 3832 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $37111 r0 *1 238.56,438.48
X$37111 14074 3832 3212 14073 3958 3618 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $37116 m0 *1 244.72,428.4
X$37116 14074 14073 3212 3770 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37121 r0 *1 218.4,438.48
X$37121 14073 3212 4036 14074 3991 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37156 m0 *1 480.48,589.68
X$37156 14073 3217 5740 14074 5877 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37158 m0 *1 406,690.48
X$37158 14074 7314 3217 5341 7200 5533 6776 7234 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $37160 r0 *1 551.04,690.48
X$37160 14074 14073 3217 7442 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37191 r0 *1 778.4,458.64
X$37191 14074 14073 3221 4288 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $37193 r0 *1 705.6,388.08
X$37193 14074 14073 3221 3280 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $37262 m0 *1 1074.08,458.64
X$37262 14074 4175 4016 4225 4223 3233 4224 4169 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37264 m0 *1 1120,398.16
X$37264 14074 3375 3234 3368 3428 3233 3429 3430 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37284 r0 *1 1107.68,509.04
X$37284 14074 5022 4852 4850 4709 3233 4584 4640 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37287 m0 *1 1061.76,509.04
X$37287 14074 4848 4575 4582 4639 3233 4580 4581 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37289 m0 *1 1073.52,529.2
X$37289 14074 5171 4575 4849 5019 3233 4945 5020 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37291 m0 *1 1121.12,458.64
X$37291 14074 4170 3234 4230 4227 3233 4228 4229 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37293 m0 *1 1157.52,478.8
X$37293 14074 4171 3234 4298 4369 3233 4232 4297 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37295 m0 *1 1137.92,509.04
X$37295 14074 4851 4852 4770 4711 3233 4586 4712 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37297 m0 *1 1137.36,549.36
X$37297 14074 5163 4852 5166 5235 3233 5164 5165 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37301 m0 *1 1064.56,438.48
X$37301 14074 3955 4016 3858 3799 3233 3743 3857 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37303 r0 *1 1062.32,408.24
X$37303 14074 3281 3233 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $37307 r0 *1 1117.76,428.4
X$37307 14074 3946 3234 3801 3860 3233 3740 3742 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37309 r0 *1 1155.84,438.48
X$37309 14074 4028 3234 4021 3948 3233 3861 3803 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37311 r0 *1 1155.84,388.08
X$37311 14074 3374 3234 3372 3432 3233 3369 3371 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37348 m0 *1 88.48,418.32
X$37348 3236 14074 3683 14073 3644 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $37350 m0 *1 103.04,418.32
X$37350 14074 14073 3685 3236 3684 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37367 m0 *1 890.96,670.32
X$37367 14074 14073 7082 3240 6883 7042 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37375 r0 *1 882.56,670.32
X$37375 14074 14073 3240 7385 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $37431 m0 *1 94.08,438.48
X$37431 14074 3952 3901 14073 3255 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $37443 m0 *1 73.36,408.24
X$37443 3527 14073 3493 3255 14074 3554 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37445 m0 *1 75.04,428.4
X$37445 14073 3255 3705 14074 3768 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $37448 r0 *1 49.28,418.32
X$37448 3255 14073 3639 3640 14074 3524 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $37452 r0 *1 91.28,398.16
X$37452 14074 14073 3257 3528 3264 3399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37459 m0 *1 89.04,388.08
X$37459 3257 14074 3335 14073 3336 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $37462 r0 *1 101.92,488.88
X$37462 14074 14073 3258 4645 3264 4454 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37470 r0 *1 91.28,478.8
X$37470 3258 14074 4396 14073 4509 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $37481 m0 *1 118.16,408.24
X$37481 14073 3400 14074 3260 3825 3401 3904 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $37488 r0 *1 113.68,388.08
X$37488 14074 14073 3401 3400 3262 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37494 m0 *1 293.44,529.2
X$37494 14073 14074 5042 3264 5057 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $37496 r0 *1 33.6,458.64
X$37496 14073 3264 14074 4234 4063 3637 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $37499 m0 *1 211.68,670.32
X$37499 14073 4339 4255 6938 3264 6932 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $37503 r0 *1 95.2,458.64
X$37503 14074 4066 3264 14073 4191 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $37509 r0 *1 204.4,448.56
X$37509 14073 3957 14074 3989 4122 3264 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $37511 m0 *1 234.08,519.12
X$37511 14073 14074 4915 4918 4956 4793 4914 3264
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $37546 r0 *1 133.28,509.04
X$37546 14074 14073 3264 4797 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $37549 m0 *1 128.8,448.56
X$37549 14074 14073 3825 4071 3264 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $37551 m0 *1 248.64,428.4
X$37551 14074 3877 14073 3690 3707 3806 3264 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $37555 m0 *1 236.88,448.56
X$37555 14074 14073 3264 4082 3828 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37558 m0 *1 154.56,418.32
X$37558 14074 3615 14073 3464 3264 3574 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $37560 r0 *1 304.64,730.8
X$37560 3264 5640 8305 8522 14074 14073 4120 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $37562 r0 *1 211.12,488.88
X$37562 14074 4649 14073 4542 4543 4398 4463 3264
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $37566 r0 *1 169.12,458.64
X$37566 14073 3264 4194 14074 3904 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37570 r0 *1 176.4,388.08
X$37570 14074 14073 3379 3266 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37603 m0 *1 312.48,408.24
X$37603 14074 14073 3271 3622 3272 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $37623 r0 *1 304.64,398.16
X$37623 14074 14073 3272 3473 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $37652 r0 *1 393.12,378
X$37652 14073 3348 3275 14074 3276 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37696 m0 *1 660.24,478.8
X$37696 14074 4387 3280 4421 4356 3669 4419 4420 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37699 m0 *1 702.24,438.48
X$37699 14074 3974 3280 3728 3930 3516 3929 3931 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37702 m0 *1 637.84,549.36
X$37702 14074 5369 3280 5356 5256 5475 5355 5291 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37704 m0 *1 657.44,559.44
X$37704 14074 5438 3280 5417 5440 5475 5418 5357 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37706 m0 *1 656.32,458.64
X$37706 14074 4285 3280 3727 4101 3669 4006 4007 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37708 r0 *1 656.32,509.04
X$37708 14074 4979 3280 4827 4825 3516 4826 4755 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37710 r0 *1 621.6,468.72
X$37710 14074 4325 3280 4354 4352 3669 4284 4353 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37712 r0 *1 618.24,509.04
X$37712 14074 4978 3280 4824 4823 3516 4752 4692 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37717 m0 *1 577.36,438.48
X$37717 14073 3280 3842 14074 3979 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37734 m0 *1 870.24,458.64
X$37734 14074 3281 4220 14073 gf180mcu_fd_sc_mcu9t5v0__buf_20
* cell instance $37738 r0 *1 977.2,559.44
X$37738 14074 3281 4943 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $37746 r0 *1 612.64,367.92
X$37746 14074 3281 3330 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $37759 r0 *1 660.24,428.4
X$37759 14074 14073 3849 3665 3284 3786 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37761 m0 *1 663.6,448.56
X$37761 14074 14073 4005 4101 3284 3727 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37763 m0 *1 602,428.4
X$37763 14074 14073 3784 3723 3284 3659 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37765 r0 *1 588,428.4
X$37765 14074 14073 3721 3783 3284 3926 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37767 r0 *1 566.16,418.32
X$37767 14074 14073 3720 3657 3284 3595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37797 r0 *1 649.6,428.4
X$37797 14073 3284 3664 14074 3891 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $37799 r0 *1 663.04,438.48
X$37799 14074 14073 3977 4006 3284 4007 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $37811 r0 *1 541.52,438.48
X$37811 14074 4134 3284 3920 3780 3922 3841 3975 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37813 m0 *1 539.84,438.48
X$37813 14074 3923 3284 3921 3762 3922 3840 3918 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37910 m0 *1 556.08,680.4
X$37910 3302 14074 7129 7131 14073 5281 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $37974 m0 *1 840,509.04
X$37974 14074 4879 3302 4834 4701 3488 4244 4633 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37976 m0 *1 915.6,599.76
X$37976 14074 6024 3302 6022 6008 3488 6009 5572 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37978 r0 *1 851.2,589.68
X$37978 14074 5953 3302 5843 6004 3488 5919 5952 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37980 r0 *1 780.08,509.04
X$37980 14074 5079 3302 4968 4882 3488 4520 4664 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37982 r0 *1 784,569.52
X$37982 14074 5688 3302 5550 5712 3488 5711 5501 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37986 m0 *1 978.88,519.12
X$37986 14074 5017 3302 4954 4942 3488 4844 4778 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37988 m0 *1 895.44,398.16
X$37988 14074 3514 3302 3512 3385 3488 3421 3439 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37990 r0 *1 1057.84,529.2
X$37990 14074 5295 3302 5171 5172 3488 4848 4774 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37992 m0 *1 1108.24,529.2
X$37992 14074 5161 3302 5163 5085 3488 5022 4851 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37996 r0 *1 981.68,579.6
X$37996 14074 5924 3302 5782 5846 3488 5847 5784 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $37999 m0 *1 910,519.12
X$37999 14074 4963 3302 4960 4964 3488 4434 4634 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $38003 m0 *1 409.92,740.88
X$38003 14074 8186 3302 5341 8015 5533 6776 8227 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $38005 r0 *1 841.12,438.48
X$38005 14074 4047 3302 4043 4052 3488 3791 3966 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $38045 r0 *1 1140.16,418.32
X$38045 14074 3308 3944 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $38064 m0 *1 128.8,388.08
X$38064 14074 3312 3315 14073 gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* cell instance $38146 r0 *1 753.2,478.8
X$38146 14074 3330 4759 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $38148 r0 *1 771.12,408.24
X$38148 14074 14073 3330 3354 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $38176 r0 *1 55.44,418.32
X$38176 14074 14073 3703 3334 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $38181 r0 *1 92.4,388.08
X$38181 14074 14073 3494 3399 3520 3336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38184 m0 *1 152.32,398.16
X$38184 14074 3403 14073 3497 3337 3465 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $38187 m0 *1 160.16,388.08
X$38187 14074 3403 3338 14073 3378 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $38210 m0 *1 293.44,388.08
X$38210 14073 3344 14074 3343 3444 3381 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $38254 r0 *1 417.2,458.64
X$38254 14074 14073 4243 3916 4149 3351 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38263 m0 *1 463.12,428.4
X$38263 14074 3653 3351 14073 3816 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $38279 m0 *1 532,640.08
X$38279 14073 3351 6566 14074 6601 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38334 m0 *1 908.32,700.56
X$38334 14074 14073 3360 7384 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $38336 r0 *1 921.2,700.56
X$38336 14074 7641 3360 7552 7553 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $38370 m0 *1 936.32,428.4
X$38370 14074 14073 3365 14140 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $38575 m0 *1 63.84,408.24
X$38575 14074 14073 3525 3526 3520 3398 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38588 m0 *1 112.56,408.24
X$38588 14074 3401 3459 14073 3457 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $38595 r0 *1 118.72,388.08
X$38595 14074 14073 3401 3402 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38612 m0 *1 187.6,408.24
X$38612 14073 3532 3406 14074 3575 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38616 r0 *1 233.52,408.24
X$38616 14073 3407 3469 14074 3646 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38648 r0 *1 511.84,700.56
X$38648 14074 14073 7610 3412 7438 5312 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38661 r0 *1 514.08,690.48
X$38661 14073 7330 14074 7439 7438 3412 7410 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $38663 m0 *1 501.2,408.24
X$38663 14074 14073 3412 3541 3413 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38666 r0 *1 508.48,458.64
X$38666 14074 14073 3481 3412 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38674 m0 *1 495.6,408.24
X$38674 14074 14073 3479 3413 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38680 r0 *1 516.88,408.24
X$38680 14074 14073 3655 3414 3594 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38703 r0 *1 786.24,670.32
X$38703 14074 7149 14073 3419 6963 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $38782 r0 *1 167.44,428.4
X$38782 14074 3830 3434 14073 3871 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $38789 m0 *1 134.4,398.16
X$38789 14074 14073 3461 3435 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38804 r0 *1 939.12,720.72
X$38804 14074 8149 3438 7551 7913 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $38806 r0 *1 952.56,720.72
X$38806 14074 3438 8053 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $38853 r0 *1 762.72,650.16
X$38853 14074 6713 14073 6726 7088 6790 6831 3446
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $38891 r0 *1 28.56,458.64
X$38891 14073 4137 3455 14074 4189 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38897 r0 *1 28.56,488.88
X$38897 14073 4603 14074 4604 3455 3532 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $38912 m0 *1 138.32,398.16
X$38912 14074 14073 3456 3495 3462 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38914 r0 *1 143.36,408.24
X$38914 14073 3465 3456 14074 3573 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38918 m0 *1 19.04,488.88
X$38918 14073 4532 4533 3457 4534 3532 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $38920 r0 *1 22.4,468.72
X$38920 14073 4331 4371 3457 4393 3532 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $38923 m0 *1 32.48,418.32
X$38923 14073 3637 14074 3521 3638 3457 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $38925 m0 *1 62.72,438.48
X$38925 14073 3821 3898 3457 3899 3532 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $38927 m0 *1 119.84,448.56
X$38927 14073 3825 14074 4070 4069 3457 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $38944 m0 *1 109.76,448.56
X$38944 14074 14073 3457 3902 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38947 r0 *1 111.44,428.4
X$38947 14074 14073 3866 3824 3769 3457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $38949 m0 *1 53.2,488.88
X$38949 14073 4395 4507 3457 4535 3532 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $38951 r0 *1 24.64,398.16
X$38951 14073 3532 3457 14074 3520 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $38956 m0 *1 59.92,408.24
X$38956 14074 14073 3458 3571 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $38958 r0 *1 36.4,398.16
X$38958 14074 14073 3458 3522 3520 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38962 r0 *1 197.68,418.32
X$38962 14074 14073 3872 3459 3746 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38983 r0 *1 138.32,408.24
X$38983 14074 14073 3462 3529 3573 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $38985 m0 *1 143.92,398.16
X$38985 14073 3495 14074 3463 3496 3497 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $39015 r0 *1 192.08,428.4
X$39015 14074 14073 3907 3574 3465 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $39035 m0 *1 236.88,408.24
X$39035 14074 14073 3620 3619 3470 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $39053 r0 *1 333.2,408.24
X$39053 3585 14073 3474 3562 14074 3693 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $39056 r0 *1 314.72,408.24
X$39056 14074 14073 3622 3583 3474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39062 m0 *1 361.76,408.24
X$39062 14073 3476 14074 3625 3630 3629 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $39065 r0 *1 376.88,408.24
X$39065 14074 3589 3587 14073 3588 3477 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $39071 r0 *1 453.6,398.16
X$39071 14074 14073 3478 3633 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39090 m0 *1 486.08,710.64
X$39090 14074 7521 3479 7608 8555 7777 14073 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $39092 m0 *1 494.48,720.72
X$39092 14074 7521 7300 7608 3479 7778 14073 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $39100 m0 *1 371.28,488.88
X$39100 14074 14073 4553 4408 4149 3479 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39103 m0 *1 516.88,418.32
X$39103 14073 3655 3594 14074 3480 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39119 m0 *1 525.28,690.48
X$39119 14074 14073 7331 3481 7438 4054 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39142 m0 *1 384.16,529.2
X$39142 14074 14073 5064 4810 4149 3481 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39155 m0 *1 716.8,418.32
X$39155 14074 14073 3694 3545 3669 3484 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39248 r0 *1 60.48,428.4
X$39248 3704 3642 3493 3702 14074 14073 3984 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $39250 m0 *1 60.48,428.4
X$39250 3527 14073 3493 3702 14074 3895 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $39252 m0 *1 55.44,428.4
X$39252 14074 14073 3527 3862 3493 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39254 m0 *1 63.84,418.32
X$39254 14073 3642 3493 14074 3639 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39302 m0 *1 388.08,398.16
X$39302 14074 14073 3539 3511 3507 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39339 m0 *1 919.52,488.88
X$39339 14074 14073 4574 4498 3516 4497 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39341 r0 *1 725.2,408.24
X$39341 14073 3516 3546 14074 3695 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39343 r0 *1 668.64,428.4
X$39343 14073 3516 3786 14074 3976 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39346 r0 *1 764.4,488.88
X$39346 14074 14073 4671 4423 3516 4570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39352 r0 *1 879.76,478.8
X$39352 14074 14073 4494 4360 3516 4495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39383 r0 *1 788.48,488.88
X$39383 14074 4663 4699 4289 4492 3516 4359 4424 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $39385 r0 *1 846.16,529.2
X$39385 14074 5185 5184 5015 5153 3516 5081 5082 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $39388 m0 *1 855.68,559.44
X$39388 14074 5481 5184 5426 5480 3516 5552 5482 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $39392 r0 *1 644,559.44
X$39392 14074 14073 3516 5475 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $39396 r0 *1 928.48,509.04
X$39396 14074 4873 4703 4843 4840 3516 4841 4842 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $39406 m0 *1 16.8,408.24
X$39406 14074 14073 3608 3568 3520 3519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39411 m0 *1 89.6,408.24
X$39411 14074 14073 3612 3572 3520 3644 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39415 m0 *1 78.96,438.48
X$39415 14074 14073 3823 3863 3520 3768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39419 m0 *1 30.24,408.24
X$39419 14074 3610 14073 3609 3521 3520 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39421 r0 *1 14,438.48
X$39421 14074 14073 4022 3982 3520 4023 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39425 m0 *1 40.88,408.24
X$39425 14073 3522 14074 3553 3523 3520 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $39437 r0 *1 39.76,428.4
X$39437 14074 14073 3520 3906 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $39441 m0 *1 24.08,418.32
X$39441 14074 14073 3636 3521 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39459 r0 *1 65.52,408.24
X$39459 14074 14073 3526 3643 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39461 r0 *1 111.44,438.48
X$39461 14073 3986 3642 14074 3527 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39471 m0 *1 104.16,438.48
X$39471 3527 14074 3804 14073 3953 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $39474 m0 *1 113.68,438.48
X$39474 14073 3902 3527 14074 3824 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39488 m0 *1 115.92,710.64
X$39488 14073 7677 14074 3528 7597 7644 4339 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39490 r0 *1 86.8,519.12
X$39490 14074 14073 4797 4895 3528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39497 m0 *1 161.84,418.32
X$39497 14074 14073 3574 3531 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $39506 r0 *1 29.68,498.96
X$39506 14074 3532 4604 14073 4602 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39509 r0 *1 55.44,498.96
X$39509 14074 3532 4450 14073 4429 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39512 r0 *1 49.28,509.04
X$39512 14073 3532 14074 4860 4793 4800 4794 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39514 r0 *1 21.28,509.04
X$39514 14073 3532 14074 4857 4794 4793 4792 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39517 m0 *1 26.88,498.96
X$39517 14074 14073 4534 4603 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39520 m0 *1 58.24,458.64
X$39520 14074 14073 4138 4173 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39522 r0 *1 90.72,509.04
X$39522 14073 3532 14074 4897 4793 4899 4896 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39525 m0 *1 36.4,468.72
X$39525 14074 3532 4252 14073 3767 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39528 m0 *1 49.28,569.52
X$39528 14074 5808 3532 14073 3637 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39531 r0 *1 63.28,569.52
X$39531 14074 3532 5700 14073 4890 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39533 m0 *1 134.4,529.2
X$39533 14074 5271 3532 14073 3950 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39535 m0 *1 119.28,529.2
X$39535 14073 3532 14074 4984 4793 5032 4983 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39537 r0 *1 113.68,549.36
X$39537 14073 3532 14074 5325 5381 4793 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $39540 m0 *1 51.52,549.36
X$39540 14073 3532 14074 5433 4794 4793 5267 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39542 m0 *1 39.2,559.44
X$39542 14073 3532 14074 5515 5320 4793 5377 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39544 m0 *1 46.48,529.2
X$39544 14074 5053 3532 14073 4446 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39546 r0 *1 59.36,519.12
X$39546 14073 3532 14074 5028 4892 4793 4734 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39548 r0 *1 18.48,549.36
X$39548 14073 3532 14074 5429 4793 5262 5320 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39550 m0 *1 57.68,559.44
X$39550 14073 3532 14074 5518 5320 4793 5452 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39552 m0 *1 22.4,549.36
X$39552 14073 3532 14074 5362 4794 4793 5319 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39554 m0 *1 30.24,539.28
X$39554 14073 3532 14074 5264 5241 4793 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $39557 m0 *1 114.8,458.64
X$39557 14074 3532 4177 14073 4067 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39560 m0 *1 153.44,529.2
X$39560 14073 3532 14074 5089 4986 4793 4988 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39562 m0 *1 201.6,509.04
X$39562 14074 4738 14073 4867 4777 3532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39564 m0 *1 215.04,539.28
X$39564 14074 14073 5173 3532 5204 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $39566 r0 *1 206.08,519.12
X$39566 14074 14073 4994 4912 3532 4645 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39568 r0 *1 225.12,488.88
X$39568 14074 14073 4545 4650 3532 4610 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39570 m0 *1 227.36,458.64
X$39570 14073 3532 14074 4081 4146 4197 3645 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39572 m0 *1 76.72,539.28
X$39572 14074 3532 3682 14073 5197 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $39575 m0 *1 83.44,539.28
X$39575 14073 3532 14074 5322 4896 4793 5364 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39578 r0 *1 32.48,519.12
X$39578 14073 3532 14074 5026 4892 4793 4982 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $39580 r0 *1 174.72,468.72
X$39580 14074 3904 14073 4335 4512 3532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39582 r0 *1 168,498.96
X$39582 14074 14073 4607 4608 3532 4456 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39584 m0 *1 154.56,509.04
X$39584 3532 14074 4735 4736 14073 4803 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $39686 r0 *1 235.76,640.08
X$39686 14074 4646 6657 3911 3532 6687 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $39688 m0 *1 106.96,640.08
X$39688 14074 3532 14073 3952 6578 6549 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39691 r0 *1 67.76,650.16
X$39691 14074 3570 3911 6764 3532 6894 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $39695 m0 *1 141.12,498.96
X$39695 14074 14073 4606 4678 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39698 r0 *1 32.48,448.56
X$39698 14074 14073 4062 4172 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39700 m0 *1 132.72,468.72
X$39700 14074 4430 4260 14073 4071 3532 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $39703 r0 *1 28.56,478.8
X$39703 14074 14073 4393 4448 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39706 r0 *1 10.08,448.56
X$39706 14074 14073 3982 4061 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39708 r0 *1 11.2,478.8
X$39708 14074 14073 4392 4505 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39710 m0 *1 89.04,438.48
X$39710 14073 3863 3532 14074 3901 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39713 m0 *1 72.24,438.48
X$39713 14074 14073 3899 3900 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39715 m0 *1 98,418.32
X$39715 14074 14073 3572 3684 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39718 m0 *1 114.8,428.4
X$39718 14074 14073 3769 3706 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39720 r0 *1 102.48,428.4
X$39720 14074 3953 14073 3706 3864 3866 3532 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $39722 m0 *1 119.28,438.48
X$39722 14074 14073 3903 4031 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39725 r0 *1 137.76,549.36
X$39725 14074 14073 5382 5200 3532 5434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39728 r0 *1 74.48,539.28
X$39728 14074 3570 14073 5300 5299 3532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39730 m0 *1 48.16,488.88
X$39730 14074 14073 4535 4449 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39732 m0 *1 27.44,579.6
X$39732 14074 3532 5776 14073 5449 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39734 m0 *1 57.68,579.6
X$39734 14074 3532 5724 14073 4190 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $39739 m0 *1 201.6,428.4
X$39739 14074 3689 3532 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $39746 r0 *1 157.92,519.12
X$39746 14074 4907 4796 3532 4989 14073 4987 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $39748 r0 *1 148.96,509.04
X$39748 14074 14073 4990 4863 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39750 r0 *1 183.68,458.64
X$39750 14073 4196 3532 14074 4195 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $39755 r0 *1 151.76,468.72
X$39755 14074 14073 4260 4305 3532 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $39757 m0 *1 193.2,478.8
X$39757 14074 4120 14073 4336 4432 3532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $39760 r0 *1 174.72,519.12
X$39760 4909 3532 4796 4991 14074 14073 5036 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $39762 r0 *1 301.84,498.96
X$39762 4702 3911 3532 4077 4806 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $39765 r0 *1 227.92,408.24
X$39765 14074 14073 3618 3533 3577 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $39771 m0 *1 248.64,418.32
X$39771 14074 3535 3578 3707 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $39829 r0 *1 691.04,579.6
X$39829 14074 14073 5964 3544 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $39877 m0 *1 730.24,549.36
X$39877 14074 14073 5250 5226 3635 3544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39892 m0 *1 715.12,408.24
X$39892 14074 14073 3624 3545 3563 3546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39980 m0 *1 930.72,488.88
X$39980 14074 14073 4595 4498 3563 4363 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $39984 m0 *1 761.6,498.96
X$39984 14074 14073 4668 4423 3563 4490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40025 r0 *1 873.6,488.88
X$40025 14074 14073 4657 4360 3563 4573 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40027 r0 *1 860.16,488.88
X$40027 14073 3563 4495 14074 4658 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40030 r0 *1 833.28,488.88
X$40030 14074 4701 3563 4632 4630 4220 4629 4631 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40032 r0 *1 772.8,488.88
X$40032 14073 3563 4570 14074 4667 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40037 r0 *1 834.96,458.64
X$40037 14074 4244 3563 4184 4219 4220 4218 4159 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40039 m0 *1 799.68,519.12
X$40039 14074 4968 3563 4831 4936 4759 4937 4938 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40041 m0 *1 784.56,539.28
X$40041 14074 14073 3563 5151 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $40043 r0 *1 882.56,529.2
X$40043 14074 3563 5098 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $40045 r0 *1 702.24,428.4
X$40045 14074 3888 3563 3728 3930 3843 3929 3931 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40050 m0 *1 924,498.96
X$40050 14073 3563 4497 14074 4635 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40053 m0 *1 890.96,519.12
X$40053 14074 4964 3563 4837 4940 4220 4835 4836 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40055 m0 *1 901.04,478.8
X$40055 14074 4434 3563 4162 4361 4220 4292 4293 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40057 m0 *1 963.76,549.36
X$40057 14074 14073 3563 4575 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $40059 r0 *1 956.48,498.96
X$40059 14074 14073 4721 4499 3563 4365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40061 m0 *1 929.04,519.12
X$40061 14074 4960 3563 4843 4840 4220 4841 4842 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40063 m0 *1 948.08,498.96
X$40063 14073 3563 4636 14074 4704 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40089 r0 *1 15.68,418.32
X$40089 14074 14073 3568 3699 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40091 m0 *1 43.12,418.32
X$40091 3639 3640 3569 3700 14074 14073 3680 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40127 r0 *1 245.84,438.48
X$40127 14074 3574 14073 3872 3994 4125 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40141 m0 *1 120.4,458.64
X$40141 14074 4071 3578 4140 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40143 m0 *1 202.16,448.56
X$40143 14074 4144 3578 4122 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40171 m0 *1 124.32,498.96
X$40171 14074 4606 3578 4605 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40173 m0 *1 127.12,488.88
X$40173 14074 4462 3578 4461 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40176 m0 *1 126,519.12
X$40176 14074 5033 3578 5031 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40178 m0 *1 89.04,488.88
X$40178 14074 4510 3578 4536 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40181 m0 *1 105.84,488.88
X$40181 14074 4460 3578 4457 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40184 m0 *1 98,428.4
X$40184 14074 3769 3578 3864 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40186 m0 *1 145.6,438.48
X$40186 14074 3829 3578 3869 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40188 r0 *1 134.96,468.72
X$40188 14074 4260 3578 4259 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40191 m0 *1 122.08,428.4
X$40191 14074 3903 3578 3826 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40193 r0 *1 236.32,458.64
X$40193 14074 4198 3578 4124 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40195 r0 *1 142.24,529.2
X$40195 14074 5056 3578 5090 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40198 r0 *1 249.2,408.24
X$40198 14074 3580 3578 3579 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40200 r0 *1 233.52,418.32
X$40200 14074 3648 3578 3647 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40204 r0 *1 150.64,438.48
X$40204 14074 4073 3578 4032 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40207 m0 *1 156.8,519.12
X$40207 14074 4990 3578 4906 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40209 r0 *1 188.72,458.64
X$40209 14074 4196 3578 4143 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40212 r0 *1 147.84,448.56
X$40212 14074 4072 3578 4117 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40214 r0 *1 164.08,488.88
X$40214 14074 4648 3578 4607 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40216 m0 *1 159.6,468.72
X$40216 14074 14073 3578 14132 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $40218 m0 *1 172.48,478.8
X$40218 14074 4399 3578 4335 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40223 r0 *1 191.52,468.72
X$40223 14074 4337 3578 4336 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40226 r0 *1 216.72,478.8
X$40226 14074 4464 3578 4463 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40237 m0 *1 364.56,529.2
X$40237 14074 14073 4995 5043 3580 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40239 r0 *1 364,549.36
X$40239 14074 14073 5397 5398 3580 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $40241 m0 *1 366.8,559.44
X$40241 14073 4995 3580 14074 5461 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40243 r0 *1 370.16,559.44
X$40243 5534 14073 14074 5579 3580 4923 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $40247 r0 *1 294.56,418.32
X$40247 14074 14073 3749 3581 3582 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $40263 r0 *1 357.84,408.24
X$40263 3586 14073 3627 3628 14074 3629 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $40276 r0 *1 500.64,710.64
X$40276 14074 7871 3590 14073 7608 7300 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $40294 m0 *1 488.32,720.72
X$40294 3590 14073 7608 7777 14074 7847 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $40301 r0 *1 387.52,519.12
X$40301 14074 14073 5001 4811 4149 3590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40304 m0 *1 458.64,488.88
X$40304 14074 14073 4617 3591 4386 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $40317 r0 *1 493.36,418.32
X$40317 14074 14073 3717 3593 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40321 m0 *1 1086.4,660.24
X$40321 14074 6869 6820 6893 3594 14073 6735 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $40336 r0 *1 930.72,670.32
X$40336 14074 3594 14073 6967 6986 7161 8388 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $40339 m0 *1 1085.84,619.92
X$40339 3594 6271 6272 6374 14074 14073 6282 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40341 r0 *1 1100.4,609.84
X$40341 14074 14073 3594 6147 6101 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40343 r0 *1 1113.84,670.32
X$40343 3594 7175 7172 7173 14074 14073 7055 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40345 m0 *1 513.52,619.92
X$40345 14074 6245 3594 5396 5606 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $40374 m0 *1 766.08,438.48
X$40374 14074 3814 3676 4010 3934 3935 3600 3672 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $40429 m0 *1 7.28,418.32
X$40429 14074 3636 3822 3609 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40431 r0 *1 33.6,408.24
X$40431 14074 14073 3610 3638 3680 3611 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40462 m0 *1 242.48,448.56
X$40462 14073 3958 3618 14074 4083 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40537 m0 *1 929.6,630
X$40537 14074 14073 6447 6264 3635 4163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40540 r0 *1 661.36,559.44
X$40540 14074 14073 5547 5357 3635 3663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40560 m0 *1 957.04,619.92
X$40560 14074 14073 6362 6265 3635 4295 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40562 m0 *1 801.92,589.68
X$40562 14074 14073 5841 5842 3635 4571 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40564 m0 *1 865.2,640.08
X$40564 14074 14073 6658 6528 3635 4317 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40570 r0 *1 28.56,418.32
X$40570 14074 14073 3636 3701 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40589 m0 *1 13.44,559.44
X$40589 14074 3637 14073 5429 5493 5450 5262 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $40592 r0 *1 12.88,559.44
X$40592 14074 14073 3637 5514 5320 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40595 m0 *1 22.4,428.4
X$40595 14074 3699 14073 3767 3983 3637 3701 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $40601 r0 *1 72.8,418.32
X$40601 14074 14073 3704 3705 3639 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40614 r0 *1 59.92,418.32
X$40614 14074 14073 3702 3641 3703 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $40618 r0 *1 54.88,428.4
X$40618 14074 3862 3641 14073 3821 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $40656 r0 *1 231.28,498.96
X$40656 14074 14073 4740 3645 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $40660 m0 *1 441.28,468.72
X$40660 14074 4150 14073 4206 3645 4271 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40662 r0 *1 420,498.96
X$40662 14074 3913 14073 4722 3645 4785 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40665 r0 *1 441.84,448.56
X$40665 14074 4048 14073 4131 3645 4132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40667 r0 *1 402.64,498.96
X$40667 14074 3747 14073 4925 3645 4967 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $40676 m0 *1 388.64,579.6
X$40676 14074 14073 5736 5789 3648 5665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40692 m0 *1 351.68,589.68
X$40692 4720 5665 3648 5827 14074 14073 6055 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40694 r0 *1 365.12,579.6
X$40694 5730 5732 3648 5734 14074 14073 5828 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40696 m0 *1 343.28,589.68
X$40696 4720 5665 5730 3648 14074 14073 5826 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $40698 r0 *1 384.72,569.52
X$40698 4720 14074 3648 14073 5709 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $40701 m0 *1 374.08,579.6
X$40701 14074 14073 3648 5735 5734 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $40710 r0 *1 291.2,418.32
X$40710 14074 14073 3650 3651 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $40719 r0 *1 454.16,478.8
X$40719 3652 14073 14074 14084 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $40721 m0 *1 427.28,418.32
X$40721 14074 3653 3652 3696 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $40723 m0 *1 407.68,438.48
X$40723 14074 3916 3652 4049 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40725 r0 *1 435.12,428.4
X$40725 14074 3839 3652 3779 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40728 r0 *1 419.44,488.88
X$40728 14074 4616 3652 4659 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40730 r0 *1 393.68,458.64
X$40730 14074 4154 3652 4242 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40775 m0 *1 454.16,448.56
X$40775 14074 4098 3652 4130 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40777 r0 *1 411.04,509.04
X$40777 14074 4927 3652 4814 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40779 m0 *1 422.24,498.96
X$40779 14074 4686 3652 4660 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40781 r0 *1 427.28,498.96
X$40781 14074 4746 3652 4722 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40790 r0 *1 449.12,448.56
X$40790 14074 4156 3652 4131 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40793 m0 *1 436.24,478.8
X$40793 14074 4444 3652 4270 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $40795 r0 *1 441.28,438.48
X$40795 14074 4097 3652 4051 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40797 r0 *1 440.72,458.64
X$40797 14074 4272 3652 4206 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40799 m0 *1 425.04,458.64
X$40799 14074 4155 3652 4095 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40801 r0 *1 397.6,478.8
X$40801 14074 4473 3652 4442 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40803 r0 *1 402.08,468.72
X$40803 14074 4347 3652 4316 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40805 m0 *1 375.2,478.8
X$40805 14074 4269 3652 4346 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40807 m0 *1 413.28,448.56
X$40807 14074 4094 3652 4093 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40809 r0 *1 408.8,438.48
X$40809 14074 4000 3652 3838 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $40811 r0 *1 459.76,498.96
X$40811 14074 4092 3653 14073 4747 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $40828 r0 *1 453.6,519.12
X$40828 14073 4271 3653 14074 4929 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $40830 r0 *1 471.52,529.2
X$40830 14074 3653 4348 4477 14073 5131 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $40833 r0 *1 461.44,488.88
X$40833 14074 14073 3653 4092 4688 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $40835 r0 *1 536.48,529.2
X$40835 14074 3653 5189 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $40837 m0 *1 410.48,488.88
X$40837 14074 14073 4555 4473 4149 3653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40861 r0 *1 607.04,428.4
X$40861 14074 3845 3660 14073 3658 3724 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $40867 r0 *1 621.04,418.32
X$40867 3660 14073 3658 3724 14074 3763 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $40882 m0 *1 726.32,519.12
X$40882 14074 3661 4697 14073 4935 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $40884 m0 *1 743.68,569.52
X$40884 14074 14073 5686 3661 5643 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $40887 r0 *1 661.92,539.28
X$40887 14074 3661 5011 14073 5311 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $40925 m0 *1 623.28,589.68
X$40925 14074 14073 3663 5747 5835 6515 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40989 m0 *1 661.36,428.4
X$40989 14074 14073 3819 3665 3669 3664 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $40999 r0 *1 743.68,579.6
X$40999 14074 14073 5685 3667 5799 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $41012 r0 *1 901.04,468.72
X$41012 14074 4362 4288 4162 4361 3669 4292 4293 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41016 m0 *1 832.16,498.96
X$41016 14074 4762 4288 4632 4630 3669 4629 4631 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41044 m0 *1 889.28,509.04
X$41044 14074 4763 4288 4837 4940 3669 4835 4836 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41046 r0 *1 830.48,468.72
X$41046 14074 4662 4288 4184 4219 3669 4218 4159 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41048 m0 *1 705.04,519.12
X$41048 14074 3669 4674 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $41052 m0 *1 600.88,438.48
X$41052 14073 3669 3926 14074 3725 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41058 m0 *1 913.92,569.52
X$41058 14074 14073 3669 5553 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41060 m0 *1 955.92,549.36
X$41060 14074 14073 3669 4706 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41062 m0 *1 790.72,438.48
X$41062 14074 14073 3669 3935 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41100 m0 *1 751.52,458.64
X$41100 14074 14073 3670 14133 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $41136 m0 *1 747.04,438.48
X$41136 14074 3973 3676 3933 3932 3935 3671 3730 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41188 m0 *1 801.92,438.48
X$41188 14074 3967 3676 3937 3936 3935 3851 3852 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41214 r0 *1 67.2,700.56
X$41214 14074 3682 5204 7501 7591 7592 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $41228 r0 *1 165.76,539.28
X$41228 14073 3685 14074 5272 5326 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $41234 r0 *1 164.64,619.92
X$41234 14074 3685 4739 6320 6321 4797 14073 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $41245 m0 *1 165.2,418.32
X$41245 14074 14073 3687 3688 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41262 m0 *1 294,519.12
X$41262 14074 3689 4999 4917 4919 4997 4918 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $41287 m0 *1 728,418.32
X$41287 14074 14073 3759 3695 3726 3694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41320 r0 *1 33.04,438.48
X$41320 3984 3700 3983 4063 14074 14073 4024 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $41331 r0 *1 67.76,428.4
X$41331 14073 3950 3900 3703 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $41349 r0 *1 101.92,468.72
X$41349 14073 4192 3704 14074 4256 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41394 m0 *1 328.16,428.4
X$41394 14073 14074 3775 3714 3753 3771 3809 3773
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $41401 r0 *1 454.16,559.44
X$41401 14074 5137 3716 14073 5582 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $41411 m0 *1 457.52,569.52
X$41411 5139 14073 5279 3716 14074 5647 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $41413 m0 *1 512.96,640.08
X$41413 14073 3717 6566 14074 6600 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $41432 r0 *1 358.4,498.96
X$41432 14074 14073 4745 4613 4149 3717 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41508 m0 *1 542.08,448.56
X$41508 14074 14073 3719 3923 3844 4134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41536 m0 *1 669.2,438.48
X$41536 14074 14073 3928 3976 3726 3819 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41541 r0 *1 749.28,498.96
X$41541 14074 14073 4757 4729 3726 4671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $41629 r0 *1 1031.52,458.64
X$41629 14074 3736 14176 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $41667 r0 *1 1029.28,438.48
X$41667 14074 4034 4016 3737 3943 4015 3873 3798 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41669 m0 *1 1030.4,438.48
X$41669 14074 3945 3797 3737 3943 3944 3873 3798 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41728 r0 *1 1006.32,630
X$41728 14074 6531 3739 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $41751 m0 *1 1116.08,438.48
X$41751 14074 3951 3797 3801 3860 3944 3740 3742 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41768 r0 *1 1063.44,428.4
X$41768 14074 3867 3797 3858 3799 3944 3743 3857 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $41853 m0 *1 637.84,851.76
X$41853 14074 6713 14073 3978 9962 3763 10011 6790
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $41870 r0 *1 598.08,428.4
X$41870 3766 14073 14074 3844 3843 3784 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $41881 m0 *1 22.4,478.8
X$41881 14074 14073 3767 4427 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $41894 r0 *1 289.52,438.48
X$41894 14073 3995 14074 3914 4040 3771 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $41901 r0 *1 284.48,428.4
X$41901 14074 14073 3771 3878 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $41958 r0 *1 638.96,650.16
X$41958 14074 6713 14073 3782 6836 6790 6714 6789
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $41960 m0 *1 482.16,630
X$41960 14073 3782 6598 5672 6046 6060 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $41994 r0 *1 688.8,650.16
X$41994 14074 14073 3787 6568 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $42004 m0 *1 728,458.64
X$42004 4247 3887 3789 4187 14074 14073 4628 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $42049 r0 *1 1121.12,458.64
X$42049 14074 4020 3797 4230 4227 3944 4228 4229 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $42051 m0 *1 1157.52,468.72
X$42051 14074 4019 3797 4298 4369 3944 4232 4297 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $42054 r0 *1 1074.64,458.64
X$42054 14074 4113 3797 4225 4223 3944 4224 4169 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $42059 m0 *1 1162.56,438.48
X$42059 14074 4026 3797 4021 3948 3944 3861 3803 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $42101 r0 *1 142.24,519.12
X$42101 14073 3804 14074 4986 4903 4989 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $42115 r0 *1 143.36,619.92
X$42115 14074 6456 4797 3804 6377 6376 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $42120 m0 *1 144.48,529.2
X$42120 14074 3804 14073 5089 5090 4904 5091 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42122 r0 *1 229.04,438.48
X$42122 3992 3911 3912 3805 3831 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $42131 m0 *1 287.84,589.68
X$42131 14074 5821 14073 5335 5731 5122 3806 5868
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $42181 m0 *1 451.36,549.36
X$42181 14073 5344 3817 14074 5404 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42191 m0 *1 631.68,438.48
X$42191 3820 3846 3927 3892 14073 14074 3978 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $42197 r0 *1 627.76,428.4
X$42197 14074 4060 3892 14073 3927 3820 3846 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $42206 r0 *1 73.92,438.48
X$42206 14074 3821 14073 4027 3950 3900 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $42209 m0 *1 76.72,448.56
X$42209 14073 3821 3950 14074 3985 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42212 m0 *1 47.6,498.96
X$42212 14074 4535 3822 4588 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42214 m0 *1 10.08,498.96
X$42214 14074 4534 3822 4601 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42216 m0 *1 41.44,458.64
X$42216 14074 4138 3822 4065 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42218 r0 *1 75.6,448.56
X$42218 14074 4066 3822 4112 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42239 m0 *1 92.96,519.12
X$42239 14074 4900 3822 4898 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42242 m0 *1 82.32,498.96
X$42242 14074 4454 3822 4453 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42244 m0 *1 11.2,519.12
X$42244 14074 4889 3822 4856 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42246 r0 *1 4.48,519.12
X$42246 14074 5025 3822 5024 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42249 m0 *1 70.56,478.8
X$42249 14074 4333 3822 4374 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42251 m0 *1 39.76,478.8
X$42251 14074 4393 3822 4373 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42254 r0 *1 59.92,468.72
X$42254 14074 4254 3822 4302 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42256 r0 *1 5.6,468.72
X$42256 14074 4392 3822 4370 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42259 r0 *1 77.28,428.4
X$42259 14074 3863 3822 3823 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42261 m0 *1 130.48,549.36
X$42261 14074 5245 3822 5383 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42263 r0 *1 81.76,539.28
X$42263 14074 5268 3822 5300 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42265 r0 *1 84,549.36
X$42265 14074 5380 3822 5323 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42268 r0 *1 48.72,488.88
X$42268 14074 14073 3822 14156 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $42273 r0 *1 59.36,509.04
X$42273 14074 4801 3822 4798 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42275 m0 *1 38.08,539.28
X$42275 14074 5242 3822 5196 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42277 m0 *1 70.56,519.12
X$42277 14074 4861 3822 4894 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42280 m0 *1 59.92,448.56
X$42280 14074 3899 3822 4110 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42284 m0 *1 2.8,438.48
X$42284 14074 3982 3822 4022 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42287 m0 *1 8.96,448.56
X$42287 14074 4062 3822 4108 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $42298 m0 *1 124.32,438.48
X$42298 14074 14073 3826 3903 3906 3956 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42315 m0 *1 249.76,660.24
X$42315 14074 3828 6906 14073 5707 6990 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $42319 r0 *1 144.48,428.4
X$42319 14074 14073 3869 3829 3906 3868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42351 r0 *1 484.96,468.72
X$42351 14074 4666 3839 14073 4000 3917 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $42362 m0 *1 467.6,468.72
X$42362 14073 4000 3839 4274 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $42365 m0 *1 484.96,468.72
X$42365 3839 14073 4000 3917 14074 4275 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $42367 r0 *1 449.68,468.72
X$42367 14074 14073 3839 4386 4000 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42370 m0 *1 431.76,468.72
X$42370 14074 14073 4320 4155 4149 3839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42413 m0 *1 647.92,438.48
X$42413 14074 3847 3844 4005 3891 3843 3849 3977 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $42422 m0 *1 438.48,549.36
X$42422 14074 5127 5312 14073 4349 3844 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $42424 m0 *1 505.12,710.64
X$42424 3844 14074 7238 7332 14073 7523 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $42426 r0 *1 587.44,700.56
X$42426 14073 7525 14074 7612 7851 3844 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $42459 m0 *1 621.6,579.6
X$42459 5072 14073 5718 3845 14074 5798 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $42461 r0 *1 619.36,579.6
X$42461 14074 14073 3845 5806 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $42471 r0 *1 656.88,529.2
X$42471 14074 5144 4732 14073 5145 3848 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $42475 m0 *1 660.24,529.2
X$42475 3848 5145 4732 14074 14073 5103 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $42614 r0 *1 907.76,690.48
X$42614 14074 14073 3876 7355 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $42675 m0 *1 605.92,438.48
X$42675 14074 14073 3980 3892 3894 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42706 m0 *1 8.96,478.8
X$42706 14074 14073 3895 4532 4137 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42708 m0 *1 29.12,438.48
X$42708 14074 14073 3895 3949 3897 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42712 r0 *1 24.08,448.56
X$42712 14074 14073 4108 4062 3906 3896 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42720 r0 *1 63.84,438.48
X$42720 14073 3898 14074 4110 4027 3906 3985 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $42736 r0 *1 111.44,448.56
X$42736 14074 14073 3902 4068 4139 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42761 m0 *1 14,478.8
X$42761 14074 14073 4370 4392 3906 4299 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42763 r0 *1 129.36,488.88
X$42763 14074 14073 4605 4606 3906 4589 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42767 r0 *1 46.48,448.56
X$42767 14074 14073 4065 4138 3906 4109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42770 r0 *1 112.56,478.8
X$42770 14074 14073 4457 4460 3906 4459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42773 r0 *1 137.2,478.8
X$42773 14074 14073 4461 4462 3906 4511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42776 m0 *1 140,468.72
X$42776 14074 14073 4259 4260 3906 4193 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42778 r0 *1 139.44,448.56
X$42778 14074 14073 4117 4072 3906 4116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42780 m0 *1 99.12,498.96
X$42780 14074 14073 4536 4510 3906 4455 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42782 r0 *1 92.4,448.56
X$42782 14074 14073 4112 4066 3906 4176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42784 r0 *1 76.72,468.72
X$42784 14074 14073 4374 4333 3906 4253 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42786 m0 *1 69.44,468.72
X$42786 14074 14073 4302 4254 3906 4235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42788 r0 *1 82.88,478.8
X$42788 14074 14073 4453 4454 3906 4509 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42794 m0 *1 154,448.56
X$42794 14074 14073 4032 4073 3906 4118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $42819 r0 *1 31.92,468.72
X$42819 14073 4371 14074 4373 4506 3906 4332 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $42822 r0 *1 18.48,488.88
X$42822 14073 4533 14074 4601 4677 3906 4644 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $42824 m0 *1 62.72,488.88
X$42824 14073 4507 14074 4588 4508 3906 4451 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $42828 m0 *1 192.64,448.56
X$42828 14074 14073 4178 4121 3907 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42845 m0 *1 217.84,730.8
X$42845 14074 14073 7940 3909 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $42847 m0 *1 255.92,720.72
X$42847 14073 3909 7770 14074 5529 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42849 m0 *1 254.8,509.04
X$42849 4742 3909 4743 4741 14073 14074 4744 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $42853 r0 *1 261.52,539.28
X$42853 5121 14073 3909 5389 14074 4262 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $42855 m0 *1 263.2,509.04
X$42855 4611 4742 3909 4743 14073 14074 4780 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $42857 m0 *1 256.48,519.12
X$42857 14073 4202 14074 4805 4742 4961 3909 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $42864 r0 *1 283.92,468.72
X$42864 3992 3911 4381 4266 4382 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $42867 m0 *1 275.52,468.72
X$42867 14073 4308 4311 4201 4265 3911 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $42869 r0 *1 292.32,478.8
X$42869 14073 3911 14074 4265 4468 4438 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $42871 r0 *1 233.52,509.04
X$42871 14073 3911 14074 3992 4957 3993 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $42939 m0 *1 327.04,750.96
X$42939 14074 8456 14073 6586 8305 6240 3911 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42941 m0 *1 178.08,730.8
X$42941 14074 5700 5204 7997 6573 8026 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42945 r0 *1 233.52,730.8
X$42945 14074 5724 5204 8083 6280 8631 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42947 m0 *1 48.72,761.04
X$42947 14074 4450 5204 8459 7473 8586 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42949 m0 *1 156.24,630
X$42949 14073 6457 3911 14074 6456 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42951 r0 *1 266,609.84
X$42951 14074 14073 3911 6203 6137 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42953 m0 *1 45.92,680.4
X$42953 14074 5053 5204 7182 6218 7367 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42955 r0 *1 43.68,650.16
X$42955 14074 4604 5204 6814 6761 6892 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42957 m0 *1 268.24,660.24
X$42957 14074 7015 14073 6586 5599 6059 6906 3911
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $42962 r0 *1 36.96,720.72
X$42962 14074 5776 5204 3911 6313 7855 7901 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42964 r0 *1 134.4,720.72
X$42964 14074 5271 5204 7690 7637 7908 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42966 r0 *1 161.28,690.48
X$42966 14074 4736 3911 7319 5204 7419 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $42969 m0 *1 77.84,619.92
X$42969 14074 5808 5204 6239 6217 6277 3911 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42971 r0 *1 106.4,640.08
X$42971 14074 6577 14073 5204 6578 3911 6579 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $42973 r0 *1 50.96,599.76
X$42973 14074 4252 5204 3911 5978 6102 6065 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $42975 m0 *1 202.16,640.08
X$42975 14074 14073 6584 6650 3911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42977 m0 *1 173.6,750.96
X$42977 14074 14073 8290 8287 3911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42979 r0 *1 235.76,468.72
X$42979 3992 3911 3912 4261 4084 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $42982 m0 *1 249.76,509.04
X$42982 14074 14073 4832 4869 3911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $42986 r0 *1 363.44,660.24
X$42986 6941 14073 6868 3911 14074 5115 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $42988 r0 *1 243.04,529.2
X$42988 14073 5152 3911 14074 5118 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42990 r0 *1 322,519.12
X$42990 14073 3911 5043 14074 4919 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42992 r0 *1 308.56,579.6
X$42992 14073 5737 3911 14074 5731 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $42994 m0 *1 324.8,519.12
X$42994 14074 14073 4807 3911 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $42999 r0 *1 252,478.8
X$42999 14074 14073 4515 3912 4516 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43007 r0 *1 248.08,468.72
X$43007 14074 14073 3912 4379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43027 r0 *1 461.44,529.2
X$43027 14074 4273 3917 14073 5129 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $43031 r0 *1 460.32,438.48
X$43031 14074 4097 3917 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $43040 m0 *1 469.84,438.48
X$43040 14074 14073 3917 4001 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43042 m0 *1 485.52,478.8
X$43042 14074 14073 3917 4476 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43053 m0 *1 501.76,609.84
X$43053 3919 14073 4971 5740 14074 6144 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $43086 r0 *1 602.56,468.72
X$43086 14074 14073 3924 4358 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43215 m0 *1 1041.04,509.04
X$43215 14074 14073 4862 4502 3944 4637 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43217 r0 *1 1037.12,529.2
X$43217 14074 5018 4769 5160 5157 3944 5158 5159 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43219 r0 *1 1138.48,498.96
X$43219 14074 4773 4769 4770 4711 3944 4586 4712 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43221 r0 *1 1035.44,509.04
X$43221 14073 3944 4577 14074 4864 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43224 r0 *1 1136.8,529.2
X$43224 14074 5168 4769 5166 5235 3944 5164 5165 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43244 m0 *1 1032.64,458.64
X$43244 14074 14073 4238 4164 3944 4165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43246 m0 *1 1036.56,478.8
X$43246 14073 3944 4105 14074 4376 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43248 r0 *1 1060.64,498.96
X$43248 14074 4766 4769 4582 4639 3944 4580 4581 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43250 r0 *1 1071.28,519.12
X$43250 14074 5027 4769 4849 5019 3944 4945 5020 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43252 m0 *1 1104.32,539.28
X$43252 14074 5162 4769 5234 5296 3944 5233 5297 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43254 r0 *1 1106,519.12
X$43254 14074 5021 4769 4850 4709 3944 4584 4640 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43295 r0 *1 118.72,519.12
X$43295 14074 5032 14073 4902 5031 4984 3950 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $43298 r0 *1 113.68,519.12
X$43298 14074 14073 3950 4901 4983 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43311 m0 *1 106.96,559.44
X$43311 14073 3952 14074 5495 4796 5496 4797 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $43314 r0 *1 108.64,559.44
X$43314 14074 14073 3952 5569 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43339 m0 *1 220.64,539.28
X$43339 14074 14073 5173 3957 5329 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43341 m0 *1 536.48,630
X$43341 14073 6426 4435 6338 6473 3958 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $43358 m0 *1 229.04,519.12
X$43358 14073 3958 4957 14074 4956 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43363 m0 *1 524.16,569.52
X$43363 14073 5136 14074 5650 3958 5543 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43365 m0 *1 333.76,630
X$43365 14073 3958 5873 14074 6468 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43388 r0 *1 914.48,811.44
X$43388 14074 14073 9675 3964 7887 6968 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43396 r0 *1 642.88,438.48
X$43396 14074 14073 4060 3964 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43398 r0 *1 883.68,811.44
X$43398 14074 14073 3964 9354 5078 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43457 r0 *1 531.44,710.64
X$43457 14073 7782 14074 3978 7872 6425 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43477 m0 *1 757.12,962.64
X$43477 14074 3978 14073 11776 5078 11665 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $43479 r0 *1 731.92,952.56
X$43479 14073 3978 9856 14074 11540 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43514 m0 *1 30.24,468.72
X$43514 14074 14073 3984 4331 4189 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $43533 r0 *1 118.16,458.64
X$43533 14073 3986 4192 14074 4139 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43539 m0 *1 166.32,448.56
X$43539 14074 14073 4073 3988 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43546 r0 *1 212.8,448.56
X$43546 14074 4078 3990 4146 4036 4079 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $43550 m0 *1 219.52,448.56
X$43550 14074 14073 3991 4079 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43552 m0 *1 217.84,458.64
X$43552 4179 14074 14073 4144 3991 4080 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $43570 m0 *1 302.4,529.2
X$43570 14073 5123 5058 3992 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43572 r0 *1 534.8,619.92
X$43572 14073 6473 14074 6426 3993 6338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43584 m0 *1 246.4,478.8
X$43584 14073 4402 14074 4403 3994 4202 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43617 m0 *1 405.44,468.72
X$43617 14074 14073 4318 4154 4149 4000 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43625 r0 *1 414.4,478.8
X$43625 14074 14073 4522 4347 4149 4001 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43651 m0 *1 972.72,509.04
X$43651 14074 14073 4870 4779 4008 5095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43655 m0 *1 908.32,509.04
X$43655 14074 14073 4838 4362 4008 4763 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43660 m0 *1 724.64,498.96
X$43660 14074 14073 4697 4672 4008 4730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43663 r0 *1 666.96,549.36
X$43663 14074 14073 5222 5438 4008 5369 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43665 r0 *1 727.44,529.2
X$43665 14074 14073 5100 5148 4008 5192 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43668 r0 *1 845.04,519.12
X$43668 14074 5014 14073 5099 4723 4008 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $43670 m0 *1 830.48,509.04
X$43670 14074 14073 4833 4662 4008 4762 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43673 r0 *1 661.92,519.12
X$43673 14074 14073 5011 4979 4008 4978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43675 r0 *1 756,579.6
X$43675 14074 14073 5799 5749 4008 5797 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43677 r0 *1 762.16,569.52
X$43677 14074 14073 5643 5548 4008 5551 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43729 r0 *1 899.36,700.56
X$43729 14073 4011 7551 14074 7568 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43732 r0 *1 886.48,700.56
X$43732 14074 14073 4011 7550 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43763 m0 *1 978.88,488.88
X$43763 14074 4844 4575 4366 4296 4015 4500 4425 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $43765 r0 *1 1032.64,448.56
X$43765 14074 14073 4167 4164 4016 4105 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43767 r0 *1 1041.04,448.56
X$43767 14073 4016 4165 14074 4166 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $43777 r0 *1 1047.76,710.64
X$43777 14073 7551 4017 7735 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $43779 m0 *1 1044.4,720.72
X$43779 14074 14073 4017 7804 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $43851 m0 *1 10.08,468.72
X$43851 4251 14073 14074 4035 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $43853 r0 *1 252,529.2
X$43853 14074 4035 5119 14073 4742 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $43865 r0 *1 248.64,529.2
X$43865 14074 14073 4035 5120 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $43876 r0 *1 252,468.72
X$43876 14073 4379 14074 4338 4037 4339 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43878 r0 *1 256.48,458.64
X$43878 14074 14073 4200 4199 4037 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $43949 m0 *1 421.68,539.28
X$43949 4054 14074 5209 5101 14073 5210 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $43954 m0 *1 320.32,559.44
X$43954 14074 14073 5394 5459 4054 5395 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $43956 r0 *1 305.76,549.36
X$43956 14073 4054 14074 5391 5392 4961 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $43979 m0 *1 493.36,690.48
X$43979 4054 14073 5674 5611 14074 7497 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $43982 m0 *1 363.44,710.64
X$43982 14074 7744 4054 5341 7656 5533 6776 7693 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $43986 r0 *1 313.6,549.36
X$43986 4054 14073 5391 5393 14074 4683 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44033 r0 *1 119.84,448.56
X$44033 4067 14073 4068 4069 14074 4140 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44045 r0 *1 123.2,458.64
X$44045 14074 4139 14073 4177 4070 4194 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44058 m0 *1 162.4,448.56
X$44058 14074 14073 4072 4074 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44071 r0 *1 301.28,478.8
X$44071 14073 4075 14074 4469 4382 4470 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44076 r0 *1 258.72,488.88
X$44076 14074 4075 4466 14073 4465 4805 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $44079 r0 *1 187.04,448.56
X$44079 4195 4076 4142 4143 4077 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $44090 m0 *1 214.48,458.64
X$44090 14074 14073 4144 4078 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44101 r0 *1 233.52,448.56
X$44101 14074 4197 14073 4181 4124 4081 4082 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44104 m0 *1 237.44,458.64
X$44104 14074 14073 4146 4147 4082 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44110 r0 *1 243.04,448.56
X$44110 14074 14073 4083 4084 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44131 r0 *1 265.44,720.72
X$44131 14074 4085 6132 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $44135 r0 *1 756.56,882
X$44135 14074 4085 7642 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $44137 r0 *1 353.92,952.56
X$44137 14074 4085 10649 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $44165 m0 *1 453.04,529.2
X$44165 14074 4092 5139 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44167 r0 *1 455.84,509.04
X$44167 4556 14073 4092 4821 14074 4815 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44172 m0 *1 379.68,488.88
X$44172 14074 14073 4596 4268 4149 4092 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44177 r0 *1 423.92,468.72
X$44177 14074 14073 4319 4094 4149 4096 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44185 r0 *1 433.44,559.44
X$44185 14074 5668 4096 14073 5279 5582 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $44187 r0 *1 542.08,539.28
X$44187 14073 4096 5189 14074 5287 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44203 r0 *1 555.52,559.44
X$44203 14073 4096 5189 14074 5509 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $44206 m0 *1 519.68,559.44
X$44206 14073 4096 4688 14074 5544 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44208 r0 *1 470.4,549.36
X$44208 14074 14073 5406 5139 4096 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $44210 r0 *1 524.16,539.28
X$44210 5134 14073 4096 5213 14074 5375 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44212 r0 *1 537.04,559.44
X$44212 14074 14073 4096 5468 4688 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44214 r0 *1 565.04,529.2
X$44214 14074 4096 5218 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44217 r0 *1 557.76,529.2
X$44217 5137 4096 5189 4967 14074 14073 5138 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $44219 r0 *1 563.36,519.12
X$44219 14074 14073 5009 4747 4096 4821 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44222 r0 *1 476,448.56
X$44222 14074 4098 4096 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $44224 m0 *1 564.48,519.12
X$44224 14074 14073 4096 5104 4747 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44229 m0 *1 463.12,458.64
X$44229 14074 14073 4474 4097 4156 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $44238 r0 *1 490.56,448.56
X$44238 14074 14073 4098 4598 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44281 m0 *1 1058.96,710.64
X$44281 14074 14073 4106 7715 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44284 m0 *1 1055.04,720.72
X$44284 14074 8164 4106 7551 7907 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $44318 m0 *1 977.2,730.8
X$44318 14074 14073 7980 4115 7887 7996 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44326 r0 *1 930.16,730.8
X$44326 14074 14073 4115 8076 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44382 m0 *1 262.64,478.8
X$44382 4404 14074 4201 4125 14073 4339 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $44384 r0 *1 256.48,509.04
X$44384 14073 4680 14074 4872 4739 4125 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44394 m0 *1 271.04,509.04
X$44394 14074 14073 4679 4125 4611 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44397 r0 *1 282.24,488.88
X$44397 4202 4125 4405 4655 14073 14074 4407 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $44423 r0 *1 490.56,488.88
X$44423 14073 4132 4274 14074 4619 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44426 m0 *1 488.88,498.96
X$44426 4132 4477 4725 4666 14073 14074 4690 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $44429 m0 *1 477.12,509.04
X$44429 14073 4817 14074 4725 4819 4132 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44431 m0 *1 499.52,529.2
X$44431 14073 4132 14074 5069 4973 4976 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44433 r0 *1 500.64,529.2
X$44433 14074 4725 5134 4132 14073 5135 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $44435 r0 *1 508.48,519.12
X$44435 4132 14074 4666 4931 14073 5106 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $44437 r0 *1 500.64,519.12
X$44437 14073 4132 14074 5068 5050 4976 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44453 r0 *1 465.36,498.96
X$44453 14074 4687 14073 4747 4787 4559 4132 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44456 m0 *1 491.12,468.72
X$44456 14074 14073 4324 4132 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $44495 m0 *1 108.64,468.72
X$44495 14074 14073 4139 4258 4257 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44501 m0 *1 170.8,529.2
X$44501 14074 4986 4909 14073 4910 4141 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $44513 m0 *1 178.08,529.2
X$44513 14073 4910 4141 14074 4991 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44517 r0 *1 200.48,488.88
X$44517 14074 4540 4196 14073 4337 4141 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $44520 r0 *1 216.16,458.64
X$44520 14074 4197 14073 4141 4145 4180 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44531 m0 *1 248.64,579.6
X$44531 14074 14073 5729 4144 4796 5665 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44542 m0 *1 251.44,589.68
X$44542 14074 14073 5819 5665 5455 4144 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44552 r0 *1 223.44,458.64
X$44552 14074 14073 4237 4197 4146 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $44562 m0 *1 333.76,468.72
X$44562 14074 4149 4203 4148 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $44567 m0 *1 497.28,700.56
X$44567 4149 5542 6566 7332 14073 14074 7522 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $44569 r0 *1 508.48,670.32
X$44569 14074 7127 4149 14073 6756 5716 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $44582 m0 *1 362.32,488.88
X$44582 14074 14073 4552 4267 4149 4246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44586 r0 *1 352.24,478.8
X$44586 14074 14073 4472 4471 4149 4204 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44588 m0 *1 391.44,488.88
X$44588 14074 14073 4554 4269 4149 4597 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44619 m0 *1 499.52,690.48
X$44619 4149 14073 6756 5716 14074 7498 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44621 r0 *1 360.64,650.16
X$44621 14074 14073 4149 6833 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44623 m0 *1 360.64,509.04
X$44623 14074 14073 4808 4685 4149 4444 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44642 r0 *1 380.24,630
X$44642 14074 6561 5341 4153 5307 5533 6496 6498 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $44656 r0 *1 463.68,458.64
X$44656 14074 4156 4273 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $44658 m0 *1 458.08,539.28
X$44658 14074 5310 5259 14073 5129 4157 4386 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $44660 r0 *1 474.32,539.28
X$44660 4157 14074 4386 5129 14073 5285 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $44677 r0 *1 468.72,519.12
X$44677 14074 4476 14073 4976 4157 4556 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44680 r0 *1 481.04,539.28
X$44680 14074 5445 4157 5129 4386 5131 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $44682 m0 *1 439.04,488.88
X$44682 14074 14073 4444 4157 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $44684 m0 *1 470.4,458.64
X$44684 14074 4186 14073 4475 4157 4246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44699 r0 *1 889.84,660.24
X$44699 14074 14073 6988 4160 6966 6434 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $44706 r0 *1 869.12,660.24
X$44706 14074 14073 4160 6989 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44783 m0 *1 648.48,640.08
X$44783 14074 6669 4163 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $44854 m0 *1 519.68,468.72
X$44854 14073 4212 4277 14074 4178 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44861 r0 *1 511.84,458.64
X$44861 14074 14073 4209 4210 4178 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $44866 r0 *1 230.16,448.56
X$44866 14074 14073 4179 4180 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $44899 r0 *1 454.72,468.72
X$44899 14073 4204 14074 4246 4322 4186 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $44901 r0 *1 477.68,549.36
X$44901 14074 4816 4556 4186 14073 5407 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $44923 m0 *1 508.48,559.44
X$44923 4599 4816 4186 14074 14073 5469 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $44926 r0 *1 474.88,509.04
X$44926 14074 14073 4186 4818 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44928 m0 *1 459.76,498.96
X$44928 14073 4186 4599 14074 4687 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $44930 m0 *1 464.24,488.88
X$44930 14074 14073 4186 4597 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44932 m0 *1 477.12,468.72
X$44932 14074 14073 4273 4186 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $44934 m0 *1 481.6,498.96
X$44934 14074 4186 14073 4749 4724 4618 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44936 m0 *1 464.8,498.96
X$44936 4186 14073 4599 4688 14074 4665 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44938 m0 *1 532.56,559.44
X$44938 4186 14073 4275 5068 14074 5649 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $44957 r0 *1 53.2,559.44
X$44957 14073 4190 14074 5567 5320 5451 5377 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $44965 m0 *1 59.36,569.52
X$44965 14074 4190 14073 5518 5568 5635 5590 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $44978 m0 *1 128.24,478.8
X$44978 14074 4397 14073 4192 4430 4802 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $44993 r0 *1 207.76,529.2
X$44993 14074 14073 4194 5115 5116 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $44997 m0 *1 325.92,579.6
X$44997 14074 14073 5664 4196 4796 5732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45013 m0 *1 218.96,478.8
X$45013 4196 14073 4337 4464 14074 4400 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45016 m0 *1 323.12,589.68
X$45016 14074 14073 5825 5732 5455 4196 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45023 r0 *1 232.96,458.64
X$45023 14074 14073 4198 4197 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45028 m0 *1 259.84,589.68
X$45028 14074 14073 5865 4198 4796 5730 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45038 m0 *1 268.24,589.68
X$45038 14074 14073 5820 5730 5455 4198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45041 r0 *1 277.76,468.72
X$45041 14074 4199 4341 14073 4265 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45044 r0 *1 272.16,468.72
X$45044 14074 14073 4340 4199 4341 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $45049 m0 *1 254.24,478.8
X$45049 14074 14073 4435 4199 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45051 r0 *1 260.96,468.72
X$45051 4263 14073 14074 4200 4262 4437 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $45054 r0 *1 286.72,478.8
X$45054 14074 4201 4518 14073 4519 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45058 r0 *1 286.72,509.04
X$45058 14074 4202 14073 4872 4917 4201 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45061 m0 *1 297.92,498.96
X$45061 4201 14073 4612 4682 14074 4655 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45078 r0 *1 279.44,509.04
X$45078 4404 4201 4679 4611 14074 14073 4681 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $45081 m0 *1 276.08,509.04
X$45081 14074 14073 4201 4467 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45084 r0 *1 264.32,509.04
X$45084 4201 14073 4679 4611 14074 4916 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45086 r0 *1 267.12,488.88
X$45086 14073 4201 4611 14074 4653 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45088 m0 *1 264.32,498.96
X$45088 14073 4201 4679 14074 4465 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45091 m0 *1 259.84,529.2
X$45091 14073 4958 14074 4742 4996 4202 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45094 m0 *1 266,539.28
X$45094 14073 4916 14074 5063 5249 4202 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45097 m0 *1 252.56,539.28
X$45097 4202 5120 5119 4680 14073 14074 5248 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $45102 m0 *1 275.52,488.88
X$45102 14073 4202 14074 4402 4547 4465 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45104 r0 *1 272.16,488.88
X$45104 4202 14074 4466 4405 14073 4716 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $45108 m0 *1 277.2,519.12
X$45108 14073 4402 14074 4679 4962 4202 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45131 r0 *1 267.68,539.28
X$45131 14074 14073 4202 4404 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45133 m0 *1 261.52,549.36
X$45133 14073 4202 5121 14074 5333 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45136 m0 *1 266.56,519.12
X$45136 14074 14073 4202 4743 5121 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45138 r0 *1 272.16,519.12
X$45138 4202 14073 4467 4517 14074 4807 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45140 r0 *1 368.48,509.04
X$45140 14074 4810 4203 4614 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45142 r0 *1 369.04,519.12
X$45142 14074 5002 4203 4921 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45144 r0 *1 341.6,468.72
X$45144 14074 4267 4203 4314 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45147 m0 *1 324.8,478.8
X$45147 14074 4343 4203 4241 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_4
* cell instance $45175 m0 *1 201.6,529.2
X$45175 14074 4993 4203 4994 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45178 r0 *1 181.44,549.36
X$45178 14074 5384 4203 5327 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45181 r0 *1 182,519.12
X$45181 14074 4909 4203 4992 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45183 r0 *1 196,509.04
X$45183 14074 4804 4203 4867 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45185 m0 *1 165.76,549.36
X$45185 14074 5201 4203 5326 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45190 m0 *1 221.2,488.88
X$45190 14074 4544 4203 4545 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45192 m0 *1 358.4,478.8
X$45192 14074 4408 4203 4344 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45195 r0 *1 366.8,478.8
X$45195 14074 4268 4203 4345 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45198 r0 *1 390.32,509.04
X$45198 14074 4813 4203 4878 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45206 m0 *1 338.8,498.96
X$45206 14074 4685 4203 4684 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45208 r0 *1 334.32,488.88
X$45208 14074 4613 4203 4551 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45211 m0 *1 369.6,509.04
X$45211 14074 4811 4203 4877 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45213 r0 *1 320.88,498.96
X$45213 14074 4720 4203 4719 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45217 r0 *1 322.56,478.8
X$45217 14074 4471 4203 4342 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $45225 r0 *1 341.6,478.8
X$45225 14074 14073 4343 4204 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45233 r0 *1 493.36,478.8
X$45233 14073 4271 4204 14074 4478 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45240 r0 *1 478.24,458.64
X$45240 14073 4274 4322 14074 4207 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45244 m0 *1 472.08,488.88
X$45244 14073 14074 4475 4476 4207 4525 4557 4665
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $45250 m0 *1 519.68,478.8
X$45250 14074 14073 4480 4350 4208 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45252 m0 *1 511.84,468.72
X$45252 14074 14073 4208 4276 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45256 m0 *1 542.64,468.72
X$45256 4391 14073 14074 4209 4279 4390 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $45267 m0 *1 530.88,468.72
X$45267 14073 4211 4209 14074 4278 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45269 m0 *1 536.48,468.72
X$45269 14073 4481 4209 14074 4329 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45271 r0 *1 538.72,478.8
X$45271 14074 14073 4351 4216 4481 4209 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45274 r0 *1 519.12,478.8
X$45274 14073 4209 4249 14074 4409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45278 m0 *1 524.72,559.44
X$45278 14073 5314 14074 4210 5513 5347 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45281 m0 *1 394.24,519.12
X$45281 14074 14073 4923 4210 4528 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $45291 r0 *1 530.88,559.44
X$45291 5136 14073 4210 5314 14074 5545 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45295 r0 *1 394.24,498.96
X$45295 4783 14073 14074 4210 4479 4528 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $45299 m0 *1 528.08,488.88
X$45299 14074 14073 4417 4211 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45302 m0 *1 532,488.88
X$45302 14074 4482 4562 4211 4480 4212 14073 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $45306 m0 *1 525.84,468.72
X$45306 14073 4211 4327 14074 4328 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45310 m0 *1 544.32,478.8
X$45310 14074 14073 4390 4213 4413 4212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45312 m0 *1 515.2,468.72
X$45312 14074 14073 4281 4212 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $45320 m0 *1 553.84,468.72
X$45320 4212 14073 4215 4280 14074 4330 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45323 r0 *1 547.68,458.64
X$45323 14074 14073 4212 4213 4214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45327 m0 *1 551.04,498.96
X$45327 14074 4727 4213 14073 4691 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45335 r0 *1 547.12,478.8
X$45335 14073 4413 14074 4278 4530 4214 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45337 r0 *1 584.64,478.8
X$45337 14074 4214 4486 14073 4485 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45339 m0 *1 558.88,478.8
X$45339 14073 4214 14074 4216 4484 4279 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45346 r0 *1 562.8,458.64
X$45346 14074 14073 4214 4215 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45349 m0 *1 524.72,478.8
X$45349 14073 4214 4388 14074 4410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45354 m0 *1 560,498.96
X$45354 14074 4564 4483 14073 4215 4278 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $45360 r0 *1 562.8,498.96
X$45360 4483 14074 4215 4416 14073 4563 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $45363 r0 *1 569.52,478.8
X$45363 14074 4279 14073 4416 4531 4216 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45367 m0 *1 544.32,579.6
X$45367 14073 5314 5677 14074 4216 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45378 r0 *1 542.64,498.96
X$45378 14074 4623 14073 4727 4216 4481 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45380 m0 *1 534.8,478.8
X$45380 14074 14073 4389 4409 4413 4216 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45383 m0 *1 575.68,468.72
X$45383 14074 14073 4216 4283 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45385 m0 *1 577.36,488.88
X$45385 14074 4483 14073 4486 4566 4216 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45387 r0 *1 715.68,488.88
X$45387 14074 4672 4626 4287 4217 4674 4625 4627 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45411 m0 *1 917.28,559.44
X$45411 14074 5572 5098 5487 5484 4220 5485 5486 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45413 r0 *1 855.12,630
X$45413 14074 5919 5098 6359 6358 4220 6444 6528 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45436 m0 *1 849.52,529.2
X$45436 14074 4834 5098 5015 5153 4220 5081 5082 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45438 m0 *1 856.8,579.6
X$45438 14074 5843 5098 5692 5617 4220 5690 5752 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45440 r0 *1 855.68,559.44
X$45440 14074 5952 5098 5426 5480 4220 5552 5482 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45445 r0 *1 852.88,599.76
X$45445 14074 6004 5098 6080 6077 4220 6078 6079 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $45514 r0 *1 42,468.72
X$45514 14074 14073 4252 4234 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45534 m0 *1 173.6,519.12
X$45534 4909 14073 4237 4910 14074 4987 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45551 m0 *1 285.04,468.72
X$45551 14074 14073 4311 4240 4266 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45565 r0 *1 394.24,630
X$45565 14074 7435 5341 4243 5307 5533 6560 6502 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $45581 m0 *1 456.4,478.8
X$45581 14074 14073 4348 4246 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45599 r0 *1 505.12,478.8
X$45599 14073 4249 4276 14074 4528 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45604 m0 *1 509.6,478.8
X$45604 14073 4249 14074 4412 4328 4445 4276 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $45638 r0 *1 198.8,519.12
X$45638 14074 14073 4255 4738 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $45710 m0 *1 281.12,478.8
X$45710 4262 14073 4405 4406 14074 4381 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45712 m0 *1 259.84,488.88
X$45712 14073 4262 4515 4546 4467 4517 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $45715 m0 *1 268.24,468.72
X$45715 14074 4263 14073 4309 4264 4310 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45718 r0 *1 267.68,498.96
X$45718 4680 4744 4782 4718 14074 14073 4264 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $45720 m0 *1 288.96,478.8
X$45720 14073 4407 14074 4440 4438 4339 4265 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $45745 r0 *1 481.6,488.88
X$45745 14073 4558 14074 4444 4618 4271 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $45748 m0 *1 449.68,468.72
X$45748 14074 14073 4272 4271 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $45750 r0 *1 519.68,519.12
X$45750 14073 4271 4816 14074 5049 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45766 r0 *1 503.44,509.04
X$45766 14074 14073 4271 4930 4477 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45768 m0 *1 497.84,488.88
X$45768 4476 14073 4271 4477 14074 4669 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $45772 m0 *1 453.04,468.72
X$45772 14074 4272 4348 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $45781 r0 *1 477.12,468.72
X$45781 14074 14073 4273 4324 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45799 m0 *1 482.72,549.36
X$45799 14074 5259 4274 4975 5285 4821 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $45801 m0 *1 468.72,529.2
X$45801 14074 14073 4274 5067 4474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45803 m0 *1 477.68,539.28
X$45803 14073 4474 4274 5215 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $45805 m0 *1 474.32,529.2
X$45805 4474 4274 4444 14074 14073 5132 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $45810 r0 *1 484.96,559.44
X$45810 14074 14073 4274 5741 5446 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45814 m0 *1 500.08,569.52
X$45814 14074 5007 5542 5610 5651 5346 4275 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $45832 r0 *1 492.24,509.04
X$45832 4818 4816 4599 4275 14074 14073 4822 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $45835 r0 *1 503.44,559.44
X$45835 14074 5540 5584 4275 5346 5539 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $45838 m0 *1 490.56,569.52
X$45838 5610 4275 5649 5609 5539 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $45851 m0 *1 552.16,488.88
X$45851 14074 14073 4483 4417 4277 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $45853 m0 *1 523.04,488.88
X$45853 14073 4277 4409 14074 4560 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45856 m0 *1 514.08,488.88
X$45856 14073 14074 4277 4600 4282 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $45859 r0 *1 514.08,478.8
X$45859 14073 4282 4277 14074 4621 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $45866 m0 *1 529.76,478.8
X$45866 14074 14073 4278 4412 4411 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $45869 m0 *1 552.72,478.8
X$45869 14074 4279 4351 14073 4280 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $45872 r0 *1 579.04,488.88
X$45872 14074 14073 4566 4279 4531 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $45876 r0 *1 523.04,468.72
X$45876 14074 14073 4388 4350 4279 4389 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45887 r0 *1 576.8,478.8
X$45887 14074 14073 4417 4279 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45894 m0 *1 560.56,468.72
X$45894 14074 14073 4281 4282 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45899 r0 *1 533.68,488.88
X$45899 14074 4620 4624 4623 4481 4282 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $45901 r0 *1 523.04,488.88
X$45901 14074 14073 4622 4560 4282 4410 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45903 r0 *1 531.44,468.72
X$45903 14074 14073 4327 4329 4282 4351 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $45919 r0 *1 524.72,478.8
X$45919 4282 14074 4480 14073 4411 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $45922 m0 *1 562.24,488.88
X$45922 14074 4282 14073 4414 4563 4485 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45924 r0 *1 562.24,488.88
X$45924 14074 4282 14073 4673 4530 4484 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $45965 m0 *1 790.72,498.96
X$45965 14074 14073 4288 4699 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45969 m0 *1 734.16,529.2
X$45969 14074 14073 4288 4626 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45971 m0 *1 864.08,539.28
X$45971 14074 14073 4288 5184 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45973 m0 *1 915.04,539.28
X$45973 14074 14073 4288 5230 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $45975 m0 *1 916.16,498.96
X$45975 14074 14073 4288 4703 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $46057 m0 *1 941.92,670.32
X$46057 14074 7080 4295 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $46078 r0 *1 975.52,488.88
X$46078 14074 4779 4703 4366 4296 4706 4500 4425 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $46124 m0 *1 135.52,478.8
X$46124 14073 4397 4304 14074 4511 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46143 m0 *1 274.4,478.8
X$46143 4339 14074 4438 4340 14073 4310 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $46226 m0 *1 804.16,509.04
X$46226 14074 14073 4315 14154 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $46322 m0 *1 875.84,650.16
X$46322 14074 6824 4317 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $46329 r0 *1 394.24,569.52
X$46329 14074 5790 5341 4318 5307 5533 5709 5666 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $46334 r0 *1 400.96,640.08
X$46334 14074 6914 5341 4319 5307 5533 6750 6668 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $46341 r0 *1 414.96,630
X$46341 14074 4320 14073 5307 6752 5533 6500 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46355 m0 *1 721.28,529.2
X$46355 14074 5044 4628 14073 5076 4323 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $46357 r0 *1 719.04,519.12
X$46357 4628 14073 5076 4323 14074 5040 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $46396 m0 *1 30.24,478.8
X$46396 14073 4331 4394 14074 4332 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46398 r0 *1 33.6,478.8
X$46398 14074 4331 14073 4506 4394 4448 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46414 r0 *1 330.4,589.68
X$46414 14074 14073 5898 5733 5455 4337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46416 m0 *1 332.08,589.68
X$46416 14074 14073 5870 4337 4796 5733 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46420 m0 *1 201.6,478.8
X$46420 14073 4337 4433 14074 4432 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46427 r0 *1 302.4,529.2
X$46427 14074 14073 5058 4338 5123 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46474 m0 *1 173.04,599.76
X$46474 14073 4339 5943 5985 6023 5891 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $46476 r0 *1 45.92,630
X$46476 14073 4339 5321 6545 6576 6546 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $46479 r0 *1 167.44,761.04
X$46479 14073 8594 14074 4452 8556 8543 4339 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $46483 m0 *1 176.96,761.04
X$46483 14074 4339 8447 4458 8448 8461 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $46486 m0 *1 311.92,650.16
X$46486 14073 6589 14074 6823 6697 6692 4339 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $46492 m0 *1 304.08,498.96
X$46492 14074 4341 4683 14073 4682 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $46499 m0 *1 255.92,488.88
X$46499 14074 14073 4546 4341 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46503 r0 *1 276.08,478.8
X$46503 14074 4406 14073 4341 4518 4466 4403 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46505 m0 *1 269.36,488.88
X$46505 14073 4467 4341 14074 4405 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46511 m0 *1 464.24,478.8
X$46511 14074 4343 4477 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $46527 r0 *1 476,498.96
X$46527 14074 4348 4444 14073 4725 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $46544 m0 *1 476.56,549.36
X$46544 14074 14073 4348 5259 4477 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46546 m0 *1 465.92,519.12
X$46546 14074 14073 4348 4817 4444 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46549 m0 *1 470.96,498.96
X$46549 14073 4444 4348 4559 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $46551 r0 *1 462.56,468.72
X$46551 14074 4348 4556 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $46560 r0 *1 421.12,529.2
X$46560 4349 14074 5066 5128 14073 5101 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $46585 r0 *1 494.48,670.32
X$46585 14074 14073 4349 7208 5542 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46587 m0 *1 385.84,730.8
X$46587 14074 7951 4349 5341 7950 5533 6776 8121 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $46590 r0 *1 535.92,720.72
X$46590 14074 14073 4349 7928 7440 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46592 r0 *1 524.16,690.48
X$46592 14073 4349 5542 14074 7499 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46636 m0 *1 705.6,498.96
X$46636 14074 4730 4626 4357 4422 4674 4696 4695 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $46655 r0 *1 854,750.96
X$46655 14074 14073 8416 6005 7887 4358 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46657 r0 *1 831.6,750.96
X$46657 14074 14073 4358 9066 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $46810 m0 *1 782.32,529.2
X$46810 14074 5360 4385 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $46828 m0 *1 469.84,539.28
X$46828 4816 4725 4386 5129 14073 14074 5130 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $46830 m0 *1 483.28,519.12
X$46830 14074 4386 14073 4750 4972 5132 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46865 m0 *1 40.88,519.12
X$46865 14073 4394 14074 4792 4950 4892 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $46867 r0 *1 42.56,519.12
X$46867 14074 14073 4446 4394 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $46877 r0 *1 23.52,519.12
X$46877 14074 4394 14073 5026 5024 4891 5051 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $46884 m0 *1 60.48,478.8
X$46884 14074 4395 14073 4508 4429 4449 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46886 m0 *1 64.4,498.96
X$46886 14073 4395 4429 14074 4451 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46904 m0 *1 218.4,529.2
X$46904 14074 5173 4398 5117 5118 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $46906 m0 *1 202.72,488.88
X$46906 14074 14073 4398 4541 4540 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46910 r0 *1 202.72,559.44
X$46910 14074 14073 5524 5302 5455 4399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46912 r0 *1 201.6,539.28
X$46912 14074 14073 5328 4399 4796 5302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $46916 r0 *1 192.08,488.88
X$46916 14073 4399 4539 14074 4609 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46919 r0 *1 183.12,478.8
X$46919 14073 4399 4513 14074 4512 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $46926 m0 *1 215.6,488.88
X$46926 14073 4544 4400 14074 4539 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46931 m0 *1 217.28,498.96
X$46931 4544 14074 4401 14073 4650 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $46934 m0 *1 278.88,498.96
X$46934 14073 4467 4466 14074 4402 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46951 r0 *1 251.44,509.04
X$46951 14073 4403 4402 14074 4958 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46953 m0 *1 250.32,519.12
X$46953 14074 14073 4679 4959 4402 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46955 r0 *1 274.96,498.96
X$46955 14074 4402 14073 4654 4780 4679 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $46957 r0 *1 262.64,498.96
X$46957 14074 14073 4403 4680 4402 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $46967 r0 *1 253.68,498.96
X$46967 14074 14073 4403 4679 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $46974 m0 *1 273.84,529.2
X$46974 14073 4404 14074 4998 5038 4467 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $46976 m0 *1 278.88,549.36
X$46976 14073 4404 14074 5125 5527 4961 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $46979 r0 *1 257.04,478.8
X$46979 14073 4465 14074 4466 4516 4404 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $46982 m0 *1 269.36,498.96
X$46982 14073 4653 4782 4404 4716 4679 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $46993 r0 *1 270.48,478.8
X$46993 14073 4404 4517 14074 4406 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $46999 m0 *1 256.48,549.36
X$46999 14073 4404 4958 14074 5387 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47001 r0 *1 255.36,549.36
X$47001 14074 14073 4404 5388 4742 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47012 m0 *1 269.36,478.8
X$47012 14074 14073 4405 4437 4406 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47043 m0 *1 537.6,498.96
X$47043 14074 4479 4412 14073 4561 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $47057 r0 *1 554.4,488.88
X$47057 14074 14073 4480 4413 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $47067 m0 *1 590.8,619.92
X$47067 14074 6282 14073 4415 6306 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47080 m0 *1 543.2,498.96
X$47080 14074 14073 4417 4623 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $47145 r0 *1 24.08,539.28
X$47145 14073 4427 14074 5264 5107 5262 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47158 m0 *1 15.68,539.28
X$47158 14074 4427 14073 5362 5195 5240 5318 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47173 m0 *1 60.48,509.04
X$47173 14074 4429 14073 4860 4798 4799 4800 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47175 m0 *1 55.44,509.04
X$47175 14074 14073 4429 4951 4794 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47197 r0 *1 275.52,1002.96
X$47197 14074 14073 12357 4435 9763 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $47201 m0 *1 244.16,1002.96
X$47201 14074 12267 9763 4435 14073 12091 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $47204 r0 *1 321.44,982.8
X$47204 14074 9763 11867 12029 4435 11797 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $47229 m0 *1 244.72,1013.04
X$47229 11797 4435 9763 12200 14073 14074 12203 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $47231 r0 *1 248.08,1002.96
X$47231 14073 12277 14074 12265 9763 4435 12267 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $47234 r0 *1 313.04,1002.96
X$47234 14073 12274 14074 12418 9763 4435 12358 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $47244 m0 *1 341.04,529.2
X$47244 14074 5000 5126 14073 4438 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $47274 m0 *1 453.6,519.12
X$47274 14073 4444 14074 4929 5046 4815 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47276 r0 *1 471.52,488.88
X$47276 14074 14073 4444 4556 4599 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $47313 m0 *1 30.8,529.2
X$47313 14073 4447 14074 4982 5052 4794 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47321 m0 *1 46.48,549.36
X$47321 14074 14073 5321 4447 4797 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47323 r0 *1 36.96,529.2
X$47323 14074 4447 14073 5241 5196 5108 5109 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $47349 m0 *1 75.6,529.2
X$47349 14074 14073 4797 5054 4452 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47363 r0 *1 161.84,589.68
X$47363 14074 14073 4456 5943 4739 5982 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47384 r0 *1 141.12,539.28
X$47384 14073 4797 4458 14074 5301 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47392 m0 *1 122.64,488.88
X$47392 14074 14073 4460 4537 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47407 r0 *1 268.24,589.68
X$47407 14074 14073 5895 4464 4796 5988 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47410 m0 *1 268.24,609.84
X$47410 14074 14073 6134 5988 5455 4464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47422 m0 *1 213.92,498.96
X$47422 14074 14073 4464 4649 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47434 m0 *1 259.28,498.96
X$47434 14074 14073 4466 4741 4465 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47437 r0 *1 278.88,488.88
X$47437 14074 14073 4611 4466 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47460 r0 *1 292.88,488.88
X$47460 14074 4654 14073 4594 4468 4549 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47462 m0 *1 323.12,529.2
X$47462 5059 14074 5060 4917 14073 4469 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $47468 r0 *1 301.28,488.88
X$47468 14074 4548 4612 14073 4550 4469 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $47470 r0 *1 295.12,498.96
X$47470 14074 14073 4550 4718 4469 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47473 m0 *1 303.52,488.88
X$47473 14074 14073 4550 4470 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47482 r0 *1 350,579.6
X$47482 14074 5899 5341 4472 5307 5533 5786 5787 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $47512 r0 *1 464.8,509.04
X$47512 14073 4476 4816 14074 4790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47514 r0 *1 495.6,488.88
X$47514 14074 14073 4476 4558 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $47523 m0 *1 484.4,488.88
X$47523 4558 14074 4477 4559 14073 4525 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $47545 m0 *1 495.04,539.28
X$47545 14074 14073 4477 5134 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $47547 m0 *1 459.76,549.36
X$47547 5371 5046 4477 5536 5067 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $47554 r0 *1 514.08,509.04
X$47554 14074 14073 4477 4816 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $47556 m0 *1 491.12,488.88
X$47556 14074 14073 4477 4724 4599 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47559 r0 *1 577.92,539.28
X$47559 14074 14073 5132 5288 4478 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $47565 m0 *1 573.44,539.28
X$47565 14073 5132 4478 14074 5257 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47568 m0 *1 575.68,529.2
X$47568 5048 4478 5132 14074 14073 5072 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $47583 r0 *1 385.28,509.04
X$47583 14073 4479 4923 14074 4876 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47587 r0 *1 534.24,478.8
X$47587 14074 14073 4480 4481 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $47597 r0 *1 554.96,478.8
X$47597 14074 4483 4480 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $47609 r0 *1 501.2,498.96
X$47609 14073 4690 4977 4688 4600 4482 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $47614 m0 *1 507.92,509.04
X$47614 14073 4600 4482 14074 5007 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47616 m0 *1 512.96,509.04
X$47616 14073 14074 4482 4751 4600 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $47621 m0 *1 569.52,488.88
X$47621 14073 4564 14074 4566 4567 4483 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $47658 r0 *1 744.24,498.96
X$47658 14073 4674 4490 14074 4729 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47711 m0 *1 964.88,498.96
X$47711 14074 14073 4651 4499 4706 4636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47724 r0 *1 1043.84,488.88
X$47724 14074 14073 4578 4502 4575 4577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47795 m0 *1 953.12,660.24
X$47795 14074 6986 4503 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $47865 r0 *1 264.32,519.12
X$47865 14074 4958 14073 5097 5038 4517 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47867 r0 *1 270.48,509.04
X$47867 14073 4679 4611 14074 4517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47882 m0 *1 292.88,488.88
X$47882 4548 14073 4519 4547 14074 4549 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $47895 m0 *1 403.2,599.76
X$47895 14074 6057 5341 4522 5307 5533 5736 5989 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $47931 r0 *1 952.56,670.32
X$47931 14074 14073 4531 7162 5911 7079 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $47944 r0 *1 13.44,488.88
X$47944 14073 4532 4602 14074 4644 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $47951 r0 *1 21.28,498.96
X$47951 14074 4532 14073 4677 4602 4603 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $47975 m0 *1 157.92,498.96
X$47975 14074 4538 4796 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $47991 r0 *1 227.92,539.28
X$47991 14074 14073 5273 4544 4796 5331 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48002 r0 *1 230.72,549.36
X$48002 14074 14073 5386 5331 5455 4544 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48010 m0 *1 252.56,529.2
X$48010 14074 4961 14073 4546 5175 5120 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48022 m0 *1 292.88,498.96
X$48022 14073 4681 4682 14074 4550 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48034 r0 *1 357.84,609.84
X$48034 14074 6290 5341 4552 5307 5533 6206 6138 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48036 r0 *1 367.36,599.76
X$48036 14074 6032 5341 4553 5307 5533 6111 6112 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48039 r0 *1 386.4,579.6
X$48039 14074 6328 5341 4554 5307 5533 5788 5901 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48042 m0 *1 400.96,619.92
X$48042 14074 6293 5341 4555 5307 5533 6295 6329 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48049 r0 *1 463.12,539.28
X$48049 4556 14074 5137 5286 14073 5371 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $48068 m0 *1 579.04,589.68
X$48068 14074 4557 5834 14073 5910 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $48071 r0 *1 577.92,589.68
X$48071 5909 4557 5834 5072 14073 14074 5995 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $48073 r0 *1 579.04,559.44
X$48073 14074 5472 5373 4557 14073 5875 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $48082 r0 *1 490,549.36
X$48082 14073 5407 14074 5409 5446 4558 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $48091 m0 *1 507.36,529.2
X$48091 14073 4559 4816 5068 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48094 r0 *1 509.6,549.36
X$48094 14074 5409 5410 5398 4559 4816 14073 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $48107 m0 *1 519.68,549.36
X$48107 14074 5347 4816 4995 5411 4559 14073 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $48111 m0 *1 510.72,519.12
X$48111 14074 14073 4816 4931 4559 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48120 r0 *1 674.24,559.44
X$48120 14074 14073 4561 5505 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48122 r0 *1 968.24,690.48
X$48122 14073 7164 7477 7478 4562 5911 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $48135 r0 *1 980,680.4
X$48135 7164 14073 4562 5911 14074 7275 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $48137 r0 *1 995.12,690.48
X$48137 14074 7467 14073 7472 7372 4562 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48139 m0 *1 987.28,690.48
X$48139 5911 7371 7373 7258 4562 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $48142 m0 *1 556.64,498.96
X$48142 14074 14073 4562 4624 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48146 r0 *1 570.64,488.88
X$48146 14074 14073 4565 4567 4673 4562 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48169 m0 *1 645.68,498.96
X$48169 4731 4676 4568 4693 14074 14073 4732 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $48187 m0 *1 799.68,549.36
X$48187 14074 14073 5360 4571 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $48240 m0 *1 999.04,519.12
X$48240 14074 4954 4575 4775 4845 4943 4765 4846 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48242 m0 *1 1040.48,498.96
X$48242 14073 4575 4637 14074 4717 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48248 r0 *1 1002.96,579.6
X$48248 14074 5782 4575 5562 5560 4943 5620 5621 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48251 r0 *1 978.88,569.52
X$48251 14074 5784 4575 5490 5558 4943 5489 5618 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48253 r0 *1 970.48,539.28
X$48253 14074 4942 4575 5232 5181 4943 5094 5155 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48257 r0 *1 1070.72,539.28
X$48257 14074 14073 4575 4852 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48315 m0 *1 906.08,498.96
X$48315 4702 14073 14074 4587 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48356 m0 *1 374.64,660.24
X$48356 14074 7197 5341 4596 5307 5533 6912 6913 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48363 m0 *1 586.88,529.2
X$48363 4598 14074 4821 5010 14073 5141 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $48380 m0 *1 522.48,539.28
X$48380 14073 4598 4688 14074 5207 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48382 r0 *1 536.48,539.28
X$48382 14073 4598 4821 14074 5286 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48384 m0 *1 538.72,529.2
X$48384 14074 14073 4598 5008 4688 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48386 r0 *1 572.32,539.28
X$48386 14074 14073 5139 5352 4598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48388 m0 *1 560.56,529.2
X$48388 14074 5138 14073 5105 5140 4598 5139 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48391 r0 *1 588.56,519.12
X$48391 4598 14073 4821 5010 14074 5191 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $48412 m0 *1 514.08,539.28
X$48412 14074 14073 4599 5213 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48436 r0 *1 31.36,509.04
X$48436 14073 4602 14074 4734 4859 4794 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $48444 m0 *1 20.72,509.04
X$48444 14074 4602 14073 4857 4856 4858 4795 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48470 m0 *1 182.56,498.96
X$48470 4648 14074 4714 14073 4608 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $48480 r0 *1 188.16,498.96
X$48480 14073 4648 4609 14074 4737 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48484 m0 *1 236.32,509.04
X$48484 14074 4610 4739 14073 4869 4913 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $48509 m0 *1 306.32,549.36
X$48509 5125 5392 5437 5342 14073 14074 4612 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $48515 r0 *1 310.24,519.12
X$48515 14073 4681 4612 14074 4918 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48547 r0 *1 543.76,519.12
X$48547 14074 5105 4928 14073 4615 4922 4661 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $48552 m0 *1 546,529.2
X$48552 4615 14073 4928 5216 14074 4661 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $48555 m0 *1 545.44,559.44
X$48555 4922 4661 4615 4928 14073 14074 5349 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $48557 r0 *1 397.6,690.48
X$48557 14074 7492 4615 5341 7518 5533 6776 7323 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48559 m0 *1 557.2,690.48
X$48559 14074 14073 4615 7131 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48561 r0 *1 437.36,488.88
X$48561 14074 14073 4616 4615 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48570 r0 *1 444.08,498.96
X$48570 4686 14074 4616 4746 14073 4786 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $48574 m0 *1 464.24,509.04
X$48574 14073 14074 4787 4881 4617 4748 4883 4884
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $48581 r0 *1 483.28,509.04
X$48581 14074 4818 14073 4820 4931 4618 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48584 m0 *1 476,519.12
X$48584 14074 4818 14073 4884 4930 4618 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $48597 m0 *1 480.48,569.52
X$48597 14074 14073 4619 5133 5541 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48599 r0 *1 502.88,488.88
X$48599 14074 4670 4669 4619 4620 4621 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $48602 m0 *1 489.44,589.68
X$48602 14073 4619 5541 14074 5831 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $48607 m0 *1 497.84,509.04
X$48607 4822 4747 4621 4888 4620 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $48619 m0 *1 522.48,498.96
X$48619 14074 14073 4622 5214 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48632 r0 *1 585.76,498.96
X$48632 14074 14073 4624 4941 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48650 r0 *1 706.16,539.28
X$48650 14074 5192 4626 5225 5146 4674 5224 5292 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48653 r0 *1 716.24,549.36
X$48653 14074 5148 4626 5147 5193 4674 5368 5226 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48732 r0 *1 831.04,619.92
X$48732 6442 14073 14074 4638 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48754 m0 *1 820.4,529.2
X$48754 5152 14073 14074 4642 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48761 m0 *1 820.96,509.04
X$48761 4832 14073 14074 4643 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $48772 m0 *1 218.4,650.16
X$48772 14074 14073 4645 6823 4739 6679 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48783 m0 *1 183.12,529.2
X$48783 4992 14073 14074 4911 4646 5036 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $48797 m0 *1 178.08,569.52
X$48797 14074 14073 5521 4648 4796 5522 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48807 m0 *1 186.48,569.52
X$48807 14074 14073 5595 5522 5455 4648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $48876 m0 *1 412.72,730.8
X$48876 14074 8016 4661 5341 8013 5533 6776 7954 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $48878 r0 *1 559.44,700.56
X$48878 14074 14073 4661 7129 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $48882 m0 *1 439.04,498.96
X$48882 14074 14073 4686 4661 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48902 m0 *1 504,579.6
X$48902 14074 5716 5715 4666 5106 5674 14073 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $48904 m0 *1 521.92,579.6
X$48904 14074 14073 5796 4666 5586 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $48916 m0 *1 537.6,579.6
X$48916 5410 14074 4666 5586 14073 5671 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $48919 m0 *1 502.88,589.68
X$48919 14074 6047 5832 4666 5715 5904 5795 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $48921 r0 *1 506.24,589.68
X$48921 14074 5832 14073 5715 6756 5795 4666 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $48947 m0 *1 507.92,650.16
X$48947 14074 14073 4670 6782 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $48949 m0 *1 505.12,700.56
X$48949 14074 14073 4670 7332 6243 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $48951 m0 *1 505.68,690.48
X$48951 14073 6243 4670 7410 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $48965 r0 *1 853.44,579.6
X$48965 14074 5871 5184 5692 5617 4674 5690 5752 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48967 r0 *1 762.72,559.44
X$48967 14074 5548 4699 5421 5420 4674 5477 5549 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48969 m0 *1 854,609.84
X$48969 14074 5951 5184 6080 6077 4674 6078 6079 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48989 r0 *1 763.28,519.12
X$48989 14074 5012 4699 4829 4758 4674 4760 4828 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48994 r0 *1 792.4,529.2
X$48994 14074 4969 4699 4831 4936 4674 4937 4938 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48996 m0 *1 799.68,559.44
X$48996 14074 5551 4699 5425 5478 4674 5422 5479 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $48998 r0 *1 792.4,589.68
X$48998 14074 5749 4699 5751 5750 4674 5840 5842 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49000 r0 *1 758.8,589.68
X$49000 14074 5797 4699 5915 5838 4674 5839 5914 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49008 r0 *1 855.12,619.92
X$49008 14074 5920 5184 6359 6358 4674 6444 6528 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49050 m0 *1 260.96,539.28
X$49050 14074 14073 4680 5332 5249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49063 m0 *1 283.92,690.48
X$49063 14074 5529 14073 7515 7486 5533 4681 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $49065 m0 *1 294,549.36
X$49065 14073 4681 5063 14074 5334 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49070 m0 *1 318.08,539.28
X$49070 14074 14073 4681 5205 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49073 m0 *1 317.52,549.36
X$49073 4681 5274 5337 5125 14074 14073 5335 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $49103 r0 *1 463.68,519.12
X$49103 14073 4790 4687 14074 5003 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49105 m0 *1 470.96,519.12
X$49105 14074 14073 4790 4970 4687 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49109 r0 *1 484.4,498.96
X$49109 14073 4690 14074 4688 4749 4689 4748 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $49130 m0 *1 485.52,579.6
X$49130 14074 6944 5260 14073 4975 5673 4689 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $49135 r0 *1 484.96,579.6
X$49135 14074 6423 5539 4975 4689 5260 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $49144 r0 *1 988.96,660.24
X$49144 14074 14073 6804 6010 4691 5836 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49146 m0 *1 999.6,680.4
X$49146 14074 14073 7167 5763 4691 5737 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49148 r0 *1 990.08,670.32
X$49148 14074 14073 7078 5695 4691 6909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49150 r0 *1 809.2,609.84
X$49150 14074 14073 6261 6170 4691 5448 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49167 r0 *1 882.56,630
X$49167 14074 14073 6529 5944 4691 6043 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49184 r0 *1 721.28,559.44
X$49184 14074 14073 4694 14150 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $49298 m0 *1 883.12,690.48
X$49298 14074 14073 7282 4702 7038 7379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49300 r0 *1 415.52,589.68
X$49300 14074 14073 5959 4702 5214 5787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49303 r0 *1 824.32,791.28
X$49303 14074 14073 9104 4702 8602 9066 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49305 m0 *1 825.44,892.08
X$49305 14074 10581 14073 10398 10482 4702 10583 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $49308 m0 *1 763.84,892.08
X$49308 14074 14073 10580 4702 10395 7153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $49344 r0 *1 662.48,609.84
X$49344 14074 14073 6252 4702 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $49346 r0 *1 549.36,892.08
X$49346 14074 14073 4702 10678 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49363 m0 *1 971.6,569.52
X$49363 14074 5845 4769 5490 5558 4706 5489 5618 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49367 m0 *1 974.96,619.92
X$49367 14074 5947 4769 6365 6266 4706 6364 6265 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49380 r0 *1 991.76,599.76
X$49380 14074 5925 4769 6091 6088 4706 6089 6090 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49382 r0 *1 997.36,509.04
X$49382 14074 4866 4769 4775 4845 4706 4765 4846 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49386 m0 *1 1004.08,589.68
X$49386 14074 5862 4769 5562 5560 4706 5620 5621 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49388 m0 *1 975.52,539.28
X$49388 14074 5095 5230 5232 5181 4706 5094 5155 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49495 r0 *1 1173.2,498.96
X$49495 4713 14073 14074 5769 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49502 r0 *1 194.32,498.96
X$49502 14073 4804 4715 14074 4777 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $49520 m0 *1 486.64,599.76
X$49520 14073 5004 5993 5831 4720 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $49543 m0 *1 379.12,579.6
X$49543 5734 14074 14073 4720 5665 5789 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $49610 r0 *1 39.2,509.04
X$49610 14074 4795 4734 14073 4792 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $49615 r0 *1 79.52,509.04
X$49615 14074 14073 4801 4734 4861 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49624 r0 *1 163.52,509.04
X$49624 14074 14073 4735 4908 4739 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $49637 m0 *1 195.44,509.04
X$49637 14073 4804 4737 14074 4865 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49644 m0 *1 191.52,640.08
X$49644 14074 6321 6582 6648 4739 14073 6650 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $49663 m0 *1 228.48,509.04
X$49663 14074 14073 4740 4793 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $49667 r0 *1 255.92,519.12
X$49667 14074 4915 4995 14073 4741 4996 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $49682 r0 *1 260.4,549.36
X$49682 14074 5390 4742 5387 5529 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $49701 m0 *1 353.36,650.16
X$49701 14074 6775 5341 4745 5307 5533 6749 6940 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $49707 r0 *1 444.64,509.04
X$49707 14074 14073 4746 4928 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $49720 r0 *1 494.48,498.96
X$49720 14073 4790 4819 14074 4748 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $49722 m0 *1 487.2,509.04
X$49722 14073 4749 4971 4748 4750 4888 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $49736 r0 *1 476,519.12
X$49736 14074 5004 4820 5003 5006 4750 14073 gf180mcu_fd_sc_mcu9t5v0__oai211_4
* cell instance $49747 m0 *1 515.76,599.76
X$49747 14074 14073 4751 5904 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $49749 r0 *1 513.52,579.6
X$49749 14074 4751 5539 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $49779 m0 *1 761.04,509.04
X$49779 14074 4882 5151 4829 4758 4759 4760 4828 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49787 r0 *1 800.8,559.44
X$49787 14074 5550 5151 5425 5478 4759 5422 5479 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49796 m0 *1 764.96,559.44
X$49796 14074 5501 5151 5421 5420 4759 5477 5549 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49798 r0 *1 792.4,579.6
X$49798 14074 5711 5151 5751 5750 4759 5840 5842 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49801 m0 *1 763.28,589.68
X$49801 14074 5712 5151 5915 5838 4759 5839 5914 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $49852 m0 *1 983.36,599.76
X$49852 14074 14073 5230 4769 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $49875 r0 *1 1180.48,509.04
X$49875 4771 14073 14074 4854 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49878 r0 *1 1181.6,569.52
X$49878 4772 14073 14074 5699 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $49932 r0 *1 422.24,549.36
X$49932 14074 5370 5403 14073 4785 5343 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $49935 r0 *1 539.28,700.56
X$49935 14074 7524 4785 14073 7525 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $49954 m0 *1 461.44,519.12
X$49954 14074 14073 4928 4785 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $49956 r0 *1 538.72,690.48
X$49956 14074 4785 5716 7440 14073 7443 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $49959 r0 *1 429.52,549.36
X$49959 14074 14073 5403 5283 4785 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49962 m0 *1 532,569.52
X$49962 14074 14073 5613 4786 5675 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $49970 m0 *1 521.36,529.2
X$49970 5048 14073 14074 4786 5070 5066 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $49993 m0 *1 459.2,509.04
X$49993 14074 14073 4790 4881 5005 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $49995 r0 *1 469.84,509.04
X$49995 14074 14073 4790 4885 4819 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50010 m0 *1 20.16,529.2
X$50010 14074 5051 4792 14073 4982 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50061 r0 *1 121.52,529.2
X$50061 5032 14074 5111 4983 14073 4794 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $50067 r0 *1 32.48,539.28
X$50067 14074 4794 5263 14073 5264 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50087 m0 *1 28.56,519.12
X$50087 14074 14073 4889 4795 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50092 m0 *1 325.36,630
X$50092 14074 14073 6383 4993 4796 6386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50094 m0 *1 323.68,640.08
X$50094 14074 14073 6663 4909 4796 6495 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50096 r0 *1 45.92,609.84
X$50096 14074 14073 6219 5242 4796 6316 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50098 m0 *1 29.68,509.04
X$50098 14073 4859 14074 4796 4858 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50100 m0 *1 31.92,519.12
X$50100 14073 4950 14074 4796 4891 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50103 m0 *1 142.8,519.12
X$50103 14073 4903 14074 4796 4904 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50106 m0 *1 115.92,519.12
X$50106 14073 4901 14074 4796 4902 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50108 r0 *1 55.44,569.52
X$50108 14073 5567 14074 4796 5635 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50113 r0 *1 131.04,539.28
X$50113 14073 5301 14074 5114 4796 5270 4797 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $50116 r0 *1 92.4,529.2
X$50116 14073 5110 14074 4796 5243 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50118 r0 *1 101.92,519.12
X$50118 14073 4953 14074 4796 5030 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50121 r0 *1 44.8,549.36
X$50121 14073 5430 14074 4796 5431 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50123 m0 *1 52.64,519.12
X$50123 14073 4951 14074 4796 4799 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50126 m0 *1 62.72,519.12
X$50126 14073 4893 14074 4796 4952 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50129 m0 *1 38.64,529.2
X$50129 14073 5052 14074 4796 5108 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50132 m0 *1 29.12,569.52
X$50132 14073 5565 14074 4796 5634 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50135 r0 *1 17.92,579.6
X$50135 14074 14073 5856 5261 4796 5720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50137 r0 *1 18.48,559.44
X$50137 14073 5514 14074 4796 5450 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50140 r0 *1 21.84,529.2
X$50140 14073 5107 14074 4796 5240 4797 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50142 r0 *1 113.12,650.16
X$50142 14074 14073 6765 4900 4796 6682 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50145 m0 *1 151.2,559.44
X$50145 14074 14073 5497 5056 4796 5453 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50150 m0 *1 183.12,549.36
X$50150 14074 14073 5327 5201 4796 5384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50153 m0 *1 24.64,660.24
X$50153 14074 14073 6889 4889 4796 6928 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50156 r0 *1 215.04,549.36
X$50156 14074 14073 5498 4804 4796 5385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50161 r0 *1 92.4,569.52
X$50161 14074 14073 5702 5517 4796 5592 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50163 r0 *1 117.04,589.68
X$50163 14074 14073 5886 5324 4796 5888 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50165 m0 *1 269.36,710.64
X$50165 14074 14073 7686 5519 4796 7652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50167 r0 *1 178.64,700.56
X$50167 14074 14073 7571 5379 4796 7600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50169 r0 *1 92.4,650.16
X$50169 14074 14073 6852 5268 4796 6853 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50172 m0 *1 161.84,700.56
X$50172 14074 14073 7505 5245 4796 7506 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50174 r0 *1 140.56,690.48
X$50174 14074 14073 7418 4861 4796 7321 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50176 r0 *1 19.04,670.32
X$50176 14074 14073 7180 5025 4796 7104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50178 m0 *1 73.36,690.48
X$50178 14074 14073 7307 4801 4796 7415 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50180 r0 *1 101.92,670.32
X$50180 14074 14073 7068 5380 4796 7010 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50183 m0 *1 133.28,700.56
X$50183 14074 14073 7569 5033 4796 7394 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50242 m0 *1 150.64,640.08
X$50242 14074 14073 6645 4990 4796 6581 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50244 r0 *1 20.72,710.64
X$50244 14074 14073 7730 5652 4796 7589 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50248 m0 *1 180.32,519.12
X$50248 4991 4796 4909 4911 4797 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $50250 m0 *1 151.2,519.12
X$50250 14073 4796 4987 14074 4905 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50326 m0 *1 67.76,529.2
X$50326 14073 5054 14074 4892 4893 4800 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50333 r0 *1 76.16,509.04
X$50333 14074 14073 4801 4800 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50346 m0 *1 67.2,700.56
X$50346 14074 14073 7476 7415 5455 4801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50354 r0 *1 213.36,529.2
X$50354 14073 14074 5115 5116 5173 5118 4802 5117
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $50357 r0 *1 154,509.04
X$50357 14073 4863 4906 4905 4907 4803 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $50369 r0 *1 220.64,559.44
X$50369 14074 14073 5525 5385 5455 4804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50374 r0 *1 308.56,509.04
X$50374 14074 14073 5178 4806 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50382 r0 *1 358.4,549.36
X$50382 14074 14073 4807 5399 5397 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50388 r0 *1 365.68,589.68
X$50388 14074 6040 5341 4808 5307 5533 5955 6140 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $50390 r0 *1 363.44,519.12
X$50390 14074 4809 4920 14073 5062 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50395 m0 *1 356.72,549.36
X$50395 14074 5307 14073 5439 5339 4809 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $50409 m0 *1 525.84,730.8
X$50409 14074 4922 4812 14073 5675 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $50429 m0 *1 546.56,539.28
X$50429 4922 14073 4812 5217 14074 5065 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $50431 r0 *1 393.12,740.88
X$50431 14074 8183 4812 5341 8089 5533 6776 8230 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $50433 m0 *1 546.56,720.72
X$50433 14074 14073 4812 5403 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50435 r0 *1 561.12,740.88
X$50435 4821 14074 4812 8127 14073 8234 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $50437 m0 *1 407.12,529.2
X$50437 14074 14073 4813 4812 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $50444 r0 *1 405.44,519.12
X$50444 5002 14074 4813 4926 14073 5066 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $50477 r0 *1 527.52,549.36
X$50477 4816 4821 5213 5215 14074 14073 5448 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $50483 r0 *1 500.64,539.28
X$50483 14074 5284 5347 4995 5134 4817 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $50505 r0 *1 483.84,529.2
X$50505 14073 4820 5260 5003 5006 5133 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $50508 r0 *1 493.36,529.2
X$50508 14074 14073 4972 4821 5259 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $50512 m0 *1 623.28,740.88
X$50512 14074 8096 4821 14073 8131 8195 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $50516 r0 *1 582.4,549.36
X$50516 4821 14073 5010 5406 14074 5511 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $50518 m0 *1 569.52,579.6
X$50518 14074 5612 4821 14073 5010 5406 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $50520 r0 *1 572.88,569.52
X$50520 4821 14073 4967 5406 14074 5680 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $50522 r0 *1 572.32,559.44
X$50522 5137 14074 5218 4821 14073 5589 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $50524 r0 *1 614.88,569.52
X$50524 14073 5468 14074 4821 5718 5218 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $50548 r0 *1 604.8,579.6
X$50548 14074 14073 4821 5744 5743 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50553 m0 *1 566.16,589.68
X$50553 14073 5218 4821 14074 5907 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50556 r0 *1 583.52,599.76
X$50556 14074 14073 5139 5908 4821 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50565 m0 *1 556.08,730.8
X$50565 14074 5189 4821 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $50573 r0 *1 493.92,519.12
X$50573 14074 14073 4822 5006 5005 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50576 m0 *1 485.52,529.2
X$50576 14074 4822 14073 5005 4975 5050 5408 4970
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $50650 r0 *1 821.52,670.32
X$50650 14074 14073 7203 4832 7038 7237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50652 m0 *1 804.72,821.52
X$50652 14074 14073 9399 5194 9349 4832 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50654 r0 *1 431.2,599.76
X$50654 14074 14073 5990 4832 5214 5957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50657 m0 *1 785.68,882
X$50657 14074 10581 14073 10396 10482 4832 10483 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $50659 r0 *1 800.8,871.92
X$50659 14074 14073 10397 4832 10395 6801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50684 m0 *1 544.88,851.76
X$50684 14074 14073 4832 9946 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $50686 m0 *1 724.64,609.84
X$50686 14074 14073 6352 4832 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $50800 r0 *1 1100.4,539.28
X$50800 14074 5085 4852 5234 5296 4943 5233 5297 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $50803 m0 *1 1043.28,539.28
X$50803 14074 5172 4852 5160 5157 4943 5158 5159 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $50812 m0 *1 1121.12,579.6
X$50812 14074 5629 14073 5854 5761 4854 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $50817 m0 *1 1118.88,569.52
X$50817 14074 14073 5628 5629 5505 4854 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50820 m0 *1 1127.28,569.52
X$50820 14074 14073 5630 5631 5695 4854 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50823 m0 *1 1148.56,569.52
X$50823 4855 14073 14074 5566 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $50856 r0 *1 141.12,700.56
X$50856 14074 14073 7599 7321 5455 4861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50860 r0 *1 78.4,519.12
X$50860 14074 14073 4861 5029 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $50877 m0 *1 195.44,529.2
X$50877 14073 4993 4865 14074 4910 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $50952 m0 *1 463.68,569.52
X$50952 14074 5608 4883 14073 5536 5535 5537 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $50954 r0 *1 463.12,559.44
X$50954 5535 5537 5536 4883 14073 14074 5538 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $50968 m0 *1 490.56,519.12
X$50968 14074 4974 4973 4885 4977 4975 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $50988 r0 *1 27.44,670.32
X$50988 14074 14073 7063 6928 5455 4889 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $50994 r0 *1 35.84,549.36
X$50994 14073 4890 14074 5377 5430 5264 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51000 r0 *1 53.76,549.36
X$51000 14074 4890 14073 5433 5432 5431 5451 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51008 m0 *1 121.52,549.36
X$51008 14074 4892 5112 5245 5033 14073 5113 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $51010 r0 *1 38.08,539.28
X$51010 14074 4892 5263 14073 5320 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $51026 r0 *1 69.44,519.12
X$51026 14074 5054 14073 5028 4894 4952 5029 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51031 m0 *1 87.92,519.12
X$51031 14074 14073 4895 4953 4896 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51033 r0 *1 91.84,519.12
X$51033 14074 4895 14073 4897 4898 5030 4899 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51036 m0 *1 95.2,539.28
X$51036 14073 5197 14074 5198 5110 4896 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51038 m0 *1 113.68,529.2
X$51038 14074 4896 5055 14073 4983 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $51040 r0 *1 151.2,519.12
X$51040 4985 14074 4986 4988 14073 4896 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $51057 m0 *1 109.76,519.12
X$51057 14074 14073 4900 4899 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51061 m0 *1 110.88,549.36
X$51061 14074 5325 4900 14073 5324 5112 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $51064 r0 *1 108.64,549.36
X$51064 14073 4900 5112 14074 5495 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51067 r0 *1 109.76,660.24
X$51067 14074 14073 6981 6682 5455 4900 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51072 r0 *1 111.44,539.28
X$51072 14074 14073 4900 5198 5324 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51090 m0 *1 164.64,670.32
X$51090 14073 7074 14074 5979 5330 7013 4908 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $51093 m0 *1 34.72,660.24
X$51093 6850 14073 14074 4908 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51109 r0 *1 329.28,640.08
X$51109 14074 14073 6693 6495 5455 4909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51126 m0 *1 201.6,519.12
X$51126 4993 14074 4955 14073 4912 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $51128 r0 *1 232.4,569.52
X$51128 14074 5661 14073 5335 4913 5122 5660 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $51139 m0 *1 257.04,730.8
X$51139 14074 8001 7944 14073 4916 5333 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $51147 m0 *1 260.96,720.72
X$51147 4916 14073 5389 5333 14074 7770 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $51150 m0 *1 258.16,569.52
X$51150 14073 4916 5527 14074 5598 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51153 r0 *1 292.88,519.12
X$51153 14074 4997 14073 5057 4918 4917 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51162 r0 *1 333.2,529.2
X$51162 14073 5125 14074 5060 4917 5180 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51179 r0 *1 301.84,519.12
X$51179 14074 14073 4999 5042 4919 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51220 r0 *1 375.76,720.72
X$51220 14074 7919 4922 5341 7921 5533 6776 7868 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $51222 r0 *1 540.96,720.72
X$51222 14074 14073 4922 7852 7440 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51224 m0 *1 528.64,680.4
X$51224 14074 7237 6946 7210 7239 4922 14073 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $51226 r0 *1 515.76,730.8
X$51226 14074 14073 4922 8102 5403 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51231 r0 *1 396.48,519.12
X$51231 14074 14073 5002 4922 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51242 r0 *1 383.6,539.28
X$51242 14074 4923 14073 5280 5337 5208 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51245 r0 *1 372.96,609.84
X$51245 14074 6132 4924 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $51251 m0 *1 400.96,519.12
X$51251 14074 4926 4924 4925 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $51274 r0 *1 320.32,619.92
X$51274 14074 6386 4924 6383 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $51279 r0 *1 304.64,650.16
X$51279 14074 5526 6860 4924 6908 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51282 r0 *1 301.28,660.24
X$51282 14074 5526 6936 4924 6935 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51284 m0 *1 322,650.16
X$51284 14074 5526 6694 4924 6828 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51286 m0 *1 332.08,640.08
X$51286 14074 6495 4924 6663 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $51288 r0 *1 309.12,599.76
X$51288 14074 5526 6053 4924 6051 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51291 r0 *1 329.28,609.84
X$51291 14074 5526 6136 4924 6135 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51293 m0 *1 302.4,599.76
X$51293 14074 5526 5824 4924 5896 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51295 r0 *1 320.32,660.24
X$51295 14074 5526 6859 4924 6937 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $51298 m0 *1 371.28,619.92
X$51298 14074 14073 4924 14163 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $51313 r0 *1 323.68,569.52
X$51313 14074 5732 4924 5664 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $51317 r0 *1 328.72,579.6
X$51317 14074 5733 4924 5870 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $51328 r0 *1 412.16,519.12
X$51328 14074 14073 4926 5010 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51336 r0 *1 516.32,519.12
X$51336 14074 14073 4927 5070 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51338 m0 *1 435.12,519.12
X$51338 14074 14073 4927 5065 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51341 r0 *1 500.64,680.4
X$51341 14074 7330 4928 14073 6782 6243 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $51373 r0 *1 411.04,720.72
X$51373 14074 8014 4928 5341 7840 5533 6776 7870 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $51375 r0 *1 539.28,710.64
X$51375 14074 14073 4928 7757 7128 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51379 m0 *1 549.92,549.36
X$51379 5285 4930 5351 5317 14073 14074 5412 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $51390 r0 *1 547.68,549.36
X$51390 14074 4930 5315 5285 5130 5374 14073 5413
+ gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $51445 m0 *1 964.32,700.56
X$51445 14073 4941 14074 7554 7555 7255 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51450 m0 *1 953.12,690.48
X$51450 7276 14074 14073 4941 7162 7256 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $51460 r0 *1 974.4,619.92
X$51460 14074 5847 5098 6365 6266 4943 6364 6265 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $51486 r0 *1 982.8,609.84
X$51486 14074 5846 5098 6091 6088 4943 6089 6090 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $51488 m0 *1 912.24,619.92
X$51488 14074 6009 5098 6361 6360 4943 6263 6264 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $51490 m0 *1 911.68,609.84
X$51490 14074 6008 5098 6086 6083 4943 6084 6085 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $51495 r0 *1 922.32,579.6
X$51495 14074 6022 5098 5757 5753 4943 5754 5755 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $51516 r0 *1 1165.36,519.12
X$51516 4947 14073 14074 5023 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51519 r0 *1 1158.08,559.44
X$51519 4948 14073 14074 5631 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51522 r0 *1 1170.4,559.44
X$51522 4949 14073 14074 5760 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $51558 m0 *1 260.4,640.08
X$51558 14074 4958 5599 14073 6220 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $51571 r0 *1 258.16,640.08
X$51571 14073 5332 14074 6588 4958 6585 5599 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $51573 m0 *1 261.52,559.44
X$51573 14074 5500 5528 4958 5457 4961 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $51578 m0 *1 253.12,569.52
X$51578 14074 14073 4958 5597 5528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51584 r0 *1 226.8,519.12
X$51584 14074 14073 4959 5330 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51590 r0 *1 321.44,559.44
X$51590 14074 14073 5459 4961 5391 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $51593 m0 *1 324.8,549.36
X$51593 14073 5366 14074 5395 5275 5336 4961 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $51619 r0 *1 374.64,831.6
X$51619 14074 9939 9546 5464 9835 4961 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $51622 m0 *1 289.52,549.36
X$51622 14074 14073 4961 5121 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51626 m0 *1 280,569.52
X$51626 14073 4961 5334 14074 5599 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51630 m0 *1 285.04,519.12
X$51630 14074 14073 5390 4997 4962 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51651 m0 *1 416.08,539.28
X$51651 14074 14073 5010 4967 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $51653 r0 *1 565.04,559.44
X$51653 14074 5588 5139 14073 4967 5509 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $51667 r0 *1 562.24,569.52
X$51667 14073 5065 4967 14074 5679 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51669 r0 *1 547.12,539.28
X$51669 14073 4967 5315 5189 5216 5217 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51673 r0 *1 579.6,529.2
X$51673 14074 14073 4967 5219 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51689 m0 *1 474.32,619.92
X$51689 14073 5672 6331 6297 6142 4971 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51691 m0 *1 468.16,609.84
X$51691 14073 5672 6330 6061 6062 4971 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51693 r0 *1 472.08,609.84
X$51693 14073 5672 6596 6115 6141 4971 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51696 r0 *1 468.16,589.68
X$51696 14073 5672 5960 5874 5961 4971 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51711 m0 *1 499.52,619.92
X$51711 14073 6500 4971 14074 6336 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51727 r0 *1 491.68,619.92
X$51727 14074 14073 4974 6060 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51729 r0 *1 458.08,660.24
X$51729 14074 14073 4974 7019 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $51777 r0 *1 45.92,529.2
X$51777 14074 14073 5265 5109 4982 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $51789 m0 *1 152.32,539.28
X$51789 14074 14073 5201 4985 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51808 r0 *1 157.92,539.28
X$51808 5201 14073 4987 5202 14074 5112 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $51816 m0 *1 163.52,529.2
X$51816 14074 14073 4990 4988 5056 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51824 r0 *1 169.68,519.12
X$51824 14074 14073 4990 4989 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $51835 m0 *1 162.96,660.24
X$51835 14074 14073 6899 6581 5455 4990 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51838 r0 *1 152.88,539.28
X$51838 14073 4990 5056 14074 5202 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51858 r0 *1 327.6,630
X$51858 14074 14073 6494 6386 5455 4993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $51865 m0 *1 374.08,539.28
X$51865 14074 5060 4995 14073 5207 5279 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $51868 r0 *1 369.6,549.36
X$51868 14074 14073 4995 5398 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $51871 m0 *1 438.48,579.6
X$51871 14073 4995 14074 5670 5340 5740 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51897 m0 *1 497.84,589.68
X$51897 14073 4995 5347 14074 5903 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51900 r0 *1 258.72,529.2
X$51900 14074 14073 4995 5175 5119 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $51905 m0 *1 381.92,549.36
X$51905 4995 14073 5207 5279 14074 5337 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $51907 r0 *1 269.92,529.2
X$51907 14073 4996 14074 5122 5176 5121 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51922 r0 *1 330.4,539.28
X$51922 14074 5063 14073 4998 5337 5305 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $51930 r0 *1 454.16,569.52
X$51930 14073 5669 14074 4999 5467 5538 5713 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $51936 m0 *1 342.72,539.28
X$51936 14073 5205 5206 14074 5000 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $51942 m0 *1 383.04,609.84
X$51942 14074 6205 5341 5001 5307 5533 6207 6337 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $51958 r0 *1 468.72,599.76
X$51958 14073 5991 14074 5004 6062 5831 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $51960 m0 *1 483.84,619.92
X$51960 14074 5674 6333 5831 5004 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $51973 r0 *1 476.56,599.76
X$51973 14073 5004 6141 5831 6063 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51975 m0 *1 477.12,599.76
X$51975 14073 5004 5992 5831 5665 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51978 m0 *1 479.36,609.84
X$51978 14073 5004 6142 5831 6143 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51980 m0 *1 467.6,599.76
X$51980 14073 5004 6046 5831 5732 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51983 m0 *1 470.96,589.68
X$51983 14073 5004 5961 5831 5877 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $51986 r0 *1 477.68,589.68
X$51986 14073 5004 5962 5831 5730 5674 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $52001 m0 *1 628.32,579.6
X$52001 14073 5005 5072 14074 5802 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52007 r0 *1 465.92,569.52
X$52007 14074 14073 5005 5606 5279 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $52009 m0 *1 461.44,579.6
X$52009 14073 5279 5005 5740 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $52012 r0 *1 555.52,519.12
X$52012 14074 14073 5008 5005 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52023 r0 *1 504.56,569.52
X$52023 14074 5007 5674 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52032 m0 *1 569.52,529.2
X$52032 5008 14073 5072 5104 14074 5078 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52034 m0 *1 572.88,740.88
X$52034 8127 14074 5009 8036 14073 8201 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $52045 m0 *1 567.28,569.52
X$52045 14073 5009 5648 5010 5588 5612 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $52051 m0 *1 582.4,549.36
X$52051 14074 14073 5372 5010 5352 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $52054 m0 *1 590.8,549.36
X$52054 14074 5010 5352 14073 5289 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $52078 r0 *1 404.88,730.8
X$52078 14074 8082 5010 5341 7953 5533 6776 8032 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $52098 r0 *1 831.6,589.68
X$52098 14074 14073 5013 6003 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52157 r0 *1 965.44,579.6
X$52157 14074 14073 5016 14136 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $52210 m0 *1 1041.04,609.84
X$52210 14074 6195 5695 5494 5693 5763 5927 5023 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $52213 r0 *1 1036.56,599.76
X$52213 14074 6196 5695 5023 5926 5763 5693 5494 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $52215 r0 *1 1044.4,609.84
X$52215 14074 14073 6269 5023 5695 5693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52222 m0 *1 1060.08,609.84
X$52222 14074 14073 6192 6012 5505 5023 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52225 m0 *1 1065.68,589.68
X$52225 14074 14073 5849 5858 5023 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $52240 r0 *1 26.88,690.48
X$52240 14074 14073 7413 7104 5455 5025 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52243 m0 *1 25.76,529.2
X$52243 14074 14073 5025 5051 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52272 r0 *1 128.8,519.12
X$52272 14074 14073 5033 5032 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52288 r0 *1 132.72,700.56
X$52288 14074 14073 7598 7394 5455 5033 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52291 r0 *1 128.24,529.2
X$52291 5033 14073 5112 5113 14074 5114 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52294 r0 *1 124.88,539.28
X$52294 5033 14073 5245 5113 14074 5246 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52328 r0 *1 861.28,700.56
X$52328 14074 7648 5040 7552 7570 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $52330 m0 *1 866.32,700.56
X$52330 14074 14073 5040 7386 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52341 m0 *1 820.4,670.32
X$52341 14074 14073 5041 7026 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52348 r0 *1 367.36,539.28
X$52348 14073 5043 14074 5060 5278 5277 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52353 r0 *1 361.2,539.28
X$52353 14073 5276 5043 14074 5307 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52357 m0 *1 567.28,680.4
X$52357 14073 7128 14074 5044 7132 7133 7131 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $52368 r0 *1 650.16,670.32
X$52368 14074 6713 14073 7026 7037 6790 7098 5044
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52386 r0 *1 602.56,529.2
X$52386 14074 14073 5048 5743 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52396 m0 *1 527.52,539.28
X$52396 14073 5215 5049 14074 5314 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52424 r0 *1 114.8,529.2
X$52424 14074 14073 5113 5055 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52432 r0 *1 159.04,529.2
X$52432 14074 14073 5056 5091 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52436 r0 *1 148.4,569.52
X$52436 14074 14073 5594 5453 5455 5056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52443 m0 *1 402.64,559.44
X$52443 14074 5058 5462 5581 5464 5463 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $52456 r0 *1 319.76,539.28
X$52456 14074 14073 5059 5304 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52458 m0 *1 385.84,539.28
X$52458 14074 14073 5059 5208 5180 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $52460 r0 *1 432.88,539.28
X$52460 5344 5277 5059 5308 14074 14073 5405 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $52469 m0 *1 321.44,539.28
X$52469 14074 5124 5275 5060 5063 5205 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $52472 m0 *1 335.44,529.2
X$52472 14074 5061 5062 14073 5063 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $52475 m0 *1 329.84,529.2
X$52475 14074 14073 5125 5061 5062 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $52493 m0 *1 351.12,559.44
X$52493 5460 14073 5339 5062 14074 5504 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $52495 r0 *1 339.36,549.36
X$52495 14073 5334 14074 5602 5278 5276 5062 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $52508 r0 *1 379.68,589.68
X$52508 14074 5956 5341 5064 5307 5533 5829 5957 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $52529 r0 *1 407.68,680.4
X$52529 14074 7308 5065 5341 7292 5533 6776 7231 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $52543 r0 *1 411.04,529.2
X$52543 14074 5274 5127 14073 5281 5066 5128 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $52568 r0 *1 546,579.6
X$52568 14074 14073 5215 6339 5068 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $52570 r0 *1 523.6,559.44
X$52570 14074 5068 14073 5586 5544 5469 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52573 r0 *1 512.96,529.2
X$52573 14073 5134 5213 14074 5069 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52579 m0 *1 534.8,549.36
X$52579 14073 5069 5215 14074 5348 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52581 r0 *1 563.36,680.4
X$52581 14073 7303 14074 7132 7025 5070 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52583 m0 *1 567.84,710.64
X$52583 14073 7525 14074 7612 7759 5070 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $52598 m0 *1 576.8,579.6
X$52598 5137 5218 5189 5070 14074 14073 5678 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $52600 m0 *1 589.12,589.68
X$52600 14074 5876 14073 5071 5746 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52619 r0 *1 630.56,599.76
X$52619 14074 14073 5072 6153 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52650 m0 *1 891.52,962.64
X$52650 14074 11614 8251 14073 11671 5078 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $52687 r0 *1 1173.76,579.6
X$52687 5087 14073 14074 5768 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52690 r0 *1 1169.28,569.52
X$52690 5088 14073 14074 5927 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $52736 r0 *1 235.2,529.2
X$52736 14074 14073 5097 5204 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52779 m0 *1 830.48,589.68
X$52779 14074 14073 5099 5917 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $52805 r0 *1 1038.24,700.56
X$52805 14074 7561 14073 7723 7635 5103 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52808 r0 *1 680.96,680.4
X$52808 14074 5103 7237 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $52828 r0 *1 49.28,539.28
X$52828 14074 14073 5242 5109 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52841 r0 *1 130.48,549.36
X$52841 14074 5382 14073 5383 5270 5111 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $52843 m0 *1 128.8,539.28
X$52843 14074 14073 5245 5111 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52861 m0 *1 110.88,539.28
X$52861 14073 5268 5199 14074 5113 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $52885 m0 *1 216.72,549.36
X$52885 14074 14073 5596 5116 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $52892 m0 *1 267.12,650.16
X$52892 6774 14074 6689 6690 14073 5117 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $52905 r0 *1 248.08,912.24
X$52905 14074 14073 10775 7603 10121 5119 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $52930 r0 *1 278.32,892.08
X$52930 14074 10747 9437 10778 10377 10269 9329 5119 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $52932 m0 *1 249.76,892.08
X$52932 14074 10621 14073 6413 10622 5387 5119 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $52936 m0 *1 257.04,902.16
X$52936 14074 10776 14073 6413 10941 5387 5119 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $52949 r0 *1 290.08,549.36
X$52949 14074 5502 5121 14073 5334 5436 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $52961 r0 *1 138.32,761.04
X$52961 14074 8541 14073 5122 8593 5204 8594 8069
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52963 m0 *1 303.52,831.6
X$52963 5122 14074 6586 9540 14073 9652 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $52966 r0 *1 41.44,781.2
X$52966 14074 8836 14073 5335 8887 5122 8888 8927
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52968 r0 *1 70.56,771.12
X$52968 14074 8682 14073 5335 7990 5122 8625 8929
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52971 r0 *1 45.36,640.08
X$52971 14074 6574 14073 5335 6681 5122 6576 6483
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52975 r0 *1 183.12,801.36
X$52975 14074 9238 14073 6586 8449 5122 9239 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $52978 r0 *1 246.4,710.64
X$52978 14074 7422 14073 5335 7685 5122 6202 7602
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52980 r0 *1 291.2,831.6
X$52980 5122 14074 6586 9650 14073 9651 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $52983 m0 *1 110.88,630
X$52983 14074 6121 14073 5335 6485 5122 6549 6279
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $52985 r0 *1 155.68,781.2
X$52985 14074 9042 14073 6586 8898 5122 8840 9383
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53062 m0 *1 138.88,619.92
X$53062 14074 5779 14073 5335 6318 5122 6406 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53064 m0 *1 315.28,761.04
X$53064 14074 14073 8906 8522 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53067 r0 *1 282.24,831.6
X$53067 14074 9648 14073 6586 9760 5122 10118 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53070 r0 *1 52.08,821.52
X$53070 14074 9929 14073 5335 7005 5122 9636 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53073 r0 *1 318.08,781.2
X$53073 14074 9048 14073 6586 8633 5122 8733 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53075 r0 *1 167.44,841.68
X$53075 14074 9828 14073 6586 7507 5122 9829 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53077 r0 *1 38.64,821.52
X$53077 14074 9527 14073 5335 7181 5122 9525 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53080 m0 *1 43.68,700.56
X$53080 14074 14073 7590 7366 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53082 m0 *1 40.88,609.84
X$53082 14074 14073 5972 6118 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53085 r0 *1 211.12,599.76
X$53085 14074 5893 14073 5122 6131 5204 5596 6227
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53087 r0 *1 267.68,650.16
X$53087 14073 6773 5122 14074 6689 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53089 m0 *1 253.68,670.32
X$53089 14074 14073 7014 6990 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53091 r0 *1 213.36,670.32
X$53091 14074 7420 14073 5122 7190 5204 6932 7061
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53093 r0 *1 80.08,599.76
X$53093 14074 14073 5810 6120 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53095 r0 *1 310.8,831.6
X$53095 14074 9436 14073 6586 9719 5122 9936 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53097 m0 *1 37.52,740.88
X$53097 14074 7854 14073 5335 8020 5122 8107 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53099 r0 *1 108.08,710.64
X$53099 14074 7736 14073 5122 7676 5204 7677 7672
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53101 m0 *1 271.04,781.2
X$53101 14074 8634 14073 6586 8692 5122 8844 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53103 m0 *1 136.08,740.88
X$53103 14074 14073 10550 7937 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53105 m0 *1 191.52,660.24
X$53105 14074 6857 14073 5335 6582 5122 6855 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53107 m0 *1 302.96,700.56
X$53107 14074 5178 5529 7516 6586 5122 7515 7431 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $53109 r0 *1 319.76,640.08
X$53109 14074 14073 6694 6662 5122 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53112 r0 *1 175.84,589.68
X$53112 14074 5656 14073 5335 5891 5122 5814 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53115 r0 *1 325.36,529.2
X$53115 14074 14073 5124 5122 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $53117 r0 *1 392,549.36
X$53117 14074 5442 14073 5402 5123 5401 5340 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53137 r0 *1 377.44,549.36
X$53137 14074 14073 5401 5278 5126 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $53139 r0 *1 384.16,549.36
X$53139 14073 5280 14074 5441 5126 5400 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53143 m0 *1 416.08,549.36
X$53143 5281 14074 5127 5370 14073 5275 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $53146 r0 *1 414.96,539.28
X$53146 14074 5305 5127 14073 5281 5283 5282 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $53153 r0 *1 407.12,539.28
X$53153 5283 5282 5281 5127 14073 14074 5180 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $53156 r0 *1 425.04,539.28
X$53156 5283 5282 5281 5127 14073 14074 5308 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $53177 m0 *1 560,549.36
X$53177 5350 5287 5286 5373 5130 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $53180 m0 *1 571.2,589.68
X$53180 14074 5130 14073 5834 5470 5908 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53182 r0 *1 560.56,589.68
X$53182 14073 14074 5907 5139 5878 5130 5966 5140
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $53191 m0 *1 487.2,539.28
X$53191 14074 14073 5131 5345 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $53193 m0 *1 502.32,549.36
X$53193 14074 5409 5345 5259 5132 5611 14073 gf180mcu_fd_sc_mcu9t5v0__nand4_4
* cell instance $53195 m0 *1 483.84,559.44
X$53195 14074 5512 5132 14073 5259 5345 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $53222 r0 *1 483.28,569.52
X$53222 14074 5672 5408 5133 5673 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $53237 r0 *1 490,559.44
X$53237 14073 5468 5584 5135 5407 5409 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $53243 m0 *1 491.12,559.44
X$53243 14074 5409 5610 5135 5468 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $53246 r0 *1 449.12,569.52
X$53246 14073 5608 5466 14074 5136 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53259 r0 *1 521.36,609.84
X$53259 14074 5606 14073 5741 5794 5905 6245 5136
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53262 m0 *1 470.96,579.6
X$53262 14074 14073 5136 5670 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53264 r0 *1 442.4,619.92
X$53264 14074 14073 5136 5463 6499 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53266 r0 *1 592.48,529.2
X$53266 14073 5137 14074 5191 5143 5142 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53268 m0 *1 562.24,559.44
X$53268 14074 5470 5137 14073 5349 5287 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $53296 m0 *1 600.32,579.6
X$53296 14073 5137 5218 14074 5803 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53298 r0 *1 595.28,579.6
X$53298 14074 14073 5137 5911 5314 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53302 r0 *1 532,529.2
X$53302 14074 14073 5139 5137 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $53304 m0 *1 580.72,559.44
X$53304 14074 14073 5137 5471 5218 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53307 m0 *1 544.88,549.36
X$53307 14074 14073 5137 5350 5349 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53313 m0 *1 566.16,599.76
X$53313 14074 14073 6045 5139 5907 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $53316 r0 *1 536.48,549.36
X$53316 14073 5375 5447 5411 5139 5215 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $53320 r0 *1 609.84,579.6
X$53320 14073 5744 14074 5403 5745 5139 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53352 m0 *1 609.84,579.6
X$53352 14074 5218 14073 5745 5288 5743 5805 5139
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53354 m0 *1 614.32,690.48
X$53354 14074 14073 5139 7336 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53359 r0 *1 559.44,539.28
X$53359 14074 14073 5139 5317 5287 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53362 r0 *1 594.16,559.44
X$53362 5139 14073 5219 5509 14074 5510 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $53367 m0 *1 585.2,539.28
X$53367 14074 5139 14073 5220 5258 5141 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53378 m0 *1 592.48,539.28
X$53378 5218 14073 5189 5219 14074 5142 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $53381 r0 *1 594.72,539.28
X$53381 5289 5143 5288 5353 5313 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $53384 r0 *1 547.12,720.72
X$53384 7128 14074 6958 5144 14073 7929 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $53393 r0 *1 653.52,650.16
X$53393 14074 6713 14073 6346 6799 6790 6842 5144
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53449 r0 *1 418.88,609.84
X$53449 14074 14073 6238 5152 5214 6138 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53452 r0 *1 793.52,670.32
X$53452 14074 14073 7090 5152 7038 6958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53454 r0 *1 780.08,871.92
X$53454 14074 14073 10396 5152 10395 6798 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53456 m0 *1 772.24,892.08
X$53456 14074 10581 14073 10692 10482 5152 10625 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $53485 r0 *1 551.04,871.92
X$53485 14074 10445 14073 10537 6343 5152 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53489 r0 *1 670.32,609.84
X$53489 14074 14073 6214 5152 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $53513 r0 *1 1010.24,720.72
X$53513 14074 14073 5156 7911 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $53516 m0 *1 1018.08,730.8
X$53516 14074 14073 8394 5156 7887 7557 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $53586 r0 *1 1173.76,539.28
X$53586 5167 14073 14074 5694 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $53691 m0 *1 541.52,539.28
X$53691 14073 5216 5217 14074 5187 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53693 r0 *1 582.96,539.28
X$53693 14073 5372 5415 5220 5257 5187 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $53695 m0 *1 586.32,559.44
X$53695 14073 5187 14074 5510 5473 5511 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53705 m0 *1 576.8,569.52
X$53705 14074 5646 5648 5613 5187 5288 5645 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $53715 r0 *1 559.44,609.84
X$53715 14073 6147 14074 6303 5188 5835 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $53718 m0 *1 578.48,539.28
X$53718 5218 14074 5189 5219 14073 5258 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $53721 r0 *1 588.56,549.36
X$53721 5189 14074 5352 5351 14073 5416 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $53724 r0 *1 635.04,892.08
X$53724 14074 10686 5189 14073 5743 5805 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $53756 m0 *1 637.28,700.56
X$53756 14074 14073 5189 7530 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53758 m0 *1 613.2,750.96
X$53758 5189 14073 5403 8131 14074 8235 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $53760 m0 *1 636.72,892.08
X$53760 5189 14073 5743 5805 14074 10636 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $53765 m0 *1 539.84,549.36
X$53765 14073 5189 5349 14074 5374 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53773 m0 *1 571.76,549.36
X$53773 14074 14073 5189 5444 5219 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53815 m0 *1 799.68,861.84
X$53815 14073 14074 10055 5194 8236 6801 10232 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $53819 r0 *1 5.6,539.28
X$53819 14074 5261 5378 5195 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $53829 m0 *1 85.12,549.36
X$53829 14074 5197 14073 5322 5323 5243 5269 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $53834 m0 *1 96.32,549.36
X$53834 14074 5269 5198 14073 5364 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $53838 m0 *1 103.6,539.28
X$53838 14074 14073 5199 5269 5198 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $53857 m0 *1 162.96,539.28
X$53857 14073 5201 5203 14074 5272 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $53861 r0 *1 190.96,559.44
X$53861 14074 14073 5523 5384 5455 5201 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $53878 m0 *1 45.36,670.32
X$53878 14074 14073 7004 7064 5204 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53921 r0 *1 133.28,619.92
X$53921 14073 6317 5204 14074 6376 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53925 r0 *1 56.56,630
X$53925 14074 14073 6484 6546 5204 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53928 m0 *1 231.84,771.12
X$53928 14074 14073 6890 8691 5204 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $53934 m0 *1 163.52,761.04
X$53934 14074 8542 14073 8447 5204 7414 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $53948 m0 *1 348.88,539.28
X$53948 14073 5205 5251 14074 5306 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $53952 m0 *1 344.4,549.36
X$53952 14073 5396 5206 5340 5338 5339 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $53962 r0 *1 375.2,539.28
X$53962 14074 5342 5207 14073 5279 5212 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $53964 m0 *1 374.08,549.36
X$53964 14074 5458 5207 14073 5279 5212 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $53977 r0 *1 797.44,740.88
X$53977 5207 7976 8146 8135 8251 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $53983 m0 *1 416.08,569.52
X$53983 5605 14074 14073 5647 5668 5209 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $53986 m0 *1 425.04,559.44
X$53986 14074 14073 5209 5506 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $53989 r0 *1 417.2,549.36
X$53989 14073 5210 5507 14074 5443 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54000 m0 *1 365.12,549.36
X$54000 14074 5341 14073 5339 5337 5212 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54019 r0 *1 468.16,771.12
X$54019 14074 14073 8707 8738 5214 7868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54021 r0 *1 476.56,771.12
X$54021 14074 14073 8739 8740 5214 8230 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54023 m0 *1 484.96,750.96
X$54023 14074 14073 8430 7784 5214 8227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54025 m0 *1 410.48,750.96
X$54025 14074 14073 8424 8362 5214 8032 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54027 r0 *1 404.88,761.04
X$54027 14074 14073 8458 8459 5214 8122 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54030 r0 *1 434.56,761.04
X$54030 14074 14073 8613 7803 5214 7693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54033 r0 *1 418.32,761.04
X$54033 14074 14073 8553 8290 5214 8121 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54036 r0 *1 431.2,730.8
X$54036 14074 14073 8091 8033 5214 7954 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54040 r0 *1 403.2,579.6
X$54040 14074 14073 5791 5737 5214 5666 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54042 m0 *1 439.6,619.92
X$54042 14074 14073 6139 6240 5214 6140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54044 r0 *1 439.6,599.76
X$54044 14074 14073 5900 6059 5214 5901 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54047 m0 *1 407.12,609.84
X$54047 14074 14073 6058 6137 5214 5989 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54050 r0 *1 408.8,619.92
X$54050 14074 14073 6474 6418 5214 6329 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54054 m0 *1 400.96,670.32
X$54054 14074 14073 6996 6764 5214 6942 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54056 r0 *1 541.52,660.24
X$54056 14074 14073 6925 6909 5214 6500 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54058 m0 *1 521.92,640.08
X$54058 14074 14073 6506 6602 5214 6502 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54060 m0 *1 425.6,660.24
X$54060 14074 14073 6778 6916 5214 6779 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54063 m0 *1 435.12,660.24
X$54063 14074 14073 6699 6917 5214 6668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54066 m0 *1 521.36,630
X$54066 14074 14073 6475 6431 5214 6337 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54068 r0 *1 434.56,640.08
X$54068 14074 14073 6592 6584 5214 6498 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54070 m0 *1 400.96,650.16
X$54070 14074 14073 6751 6777 5214 6698 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54072 r0 *1 465.36,730.8
X$54072 14074 14073 8098 8036 5214 7870 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54074 r0 *1 548.24,680.4
X$54074 14074 14073 7022 7240 5214 6112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54076 r0 *1 484.4,720.72
X$54076 14074 14073 7842 7832 5214 7234 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54078 m0 *1 547.68,680.4
X$54078 14074 14073 7212 7213 5214 6940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54080 m0 *1 458.64,690.48
X$54080 14074 14073 7326 7319 5214 6913 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54082 r0 *1 429.52,680.4
X$54082 14074 14073 7120 7182 5214 7231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54084 m0 *1 420,690.48
X$54084 14074 14073 7322 7403 5214 7323 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54086 r0 *1 421.68,700.56
X$54086 14074 14073 7586 7501 5214 7519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54138 m0 *1 556.64,569.52
X$54138 14074 5546 5215 14073 5411 5509 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $54160 m0 *1 561.12,589.68
X$54160 14074 14073 5215 5878 5411 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54163 r0 *1 572.88,589.68
X$54163 14073 5215 5411 14074 5909 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54168 m0 *1 573.44,559.44
X$54168 5215 5471 5411 5589 14074 14073 5472 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $54171 m0 *1 526.96,589.68
X$54171 5411 5544 5215 14074 14073 5968 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $54176 r0 *1 501.2,589.68
X$54176 14074 14073 5215 6243 5541 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54179 r0 *1 564.48,539.28
X$54179 14074 5351 5219 14073 5216 5217 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $54186 m0 *1 565.6,539.28
X$54186 14074 14073 5216 5313 5217 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54203 m0 *1 981.12,690.48
X$54203 14074 5218 5911 14073 7372 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $54225 m0 *1 963.2,670.32
X$54225 14073 5218 7044 14074 7079 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54227 m0 *1 955.92,700.56
X$54227 14074 14073 7277 7377 5218 7255 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54230 r0 *1 985.6,690.48
X$54230 7478 5218 7164 7467 5911 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $54232 m0 *1 999.04,690.48
X$54232 14074 5911 14073 7373 7259 5218 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54238 m0 *1 642.32,700.56
X$54238 14074 14073 5218 7662 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54245 m0 *1 600.32,720.72
X$54245 14073 7783 14074 7612 7848 5219 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54351 r0 *1 871.92,589.68
X$54351 14074 14073 5229 14168 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $54392 r0 *1 918.96,619.92
X$54392 14074 5922 5230 6361 6360 5553 6263 6264 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54394 r0 *1 913.36,599.76
X$54394 14074 5948 5230 6086 6083 5553 6084 6085 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54397 m0 *1 916.72,589.68
X$54397 14074 5950 5230 5757 5753 5553 5754 5755 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54399 r0 *1 915.04,559.44
X$54399 14074 5554 5230 5487 5484 5553 5485 5486 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $54443 r0 *1 1162.56,549.36
X$54443 5238 14073 14074 5693 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54446 r0 *1 1174.88,549.36
X$54446 5239 14073 14074 5494 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $54460 r0 *1 42,619.92
X$54460 14074 14073 6315 6316 5455 5242 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54475 r0 *1 101.92,539.28
X$54475 14073 5268 5244 14074 5299 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $54478 m0 *1 160.72,710.64
X$54478 14074 14073 7681 7506 5455 5245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54502 m0 *1 246.4,559.44
X$54502 14074 14073 5456 5499 5248 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54514 r0 *1 349.44,549.36
X$54514 14073 5338 14074 5396 5251 5340 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $54545 r0 *1 623.84,569.52
X$54545 14073 14074 5743 5683 5257 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $54552 m0 *1 590.8,579.6
X$54552 5257 14073 5681 5473 14074 5742 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $54556 r0 *1 590.24,569.52
X$54556 5257 5681 5473 5474 14074 14073 5535 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $54586 m0 *1 19.04,549.36
X$54586 14074 14073 5261 5318 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54588 r0 *1 27.44,579.6
X$54588 14074 14073 5719 5720 5455 5261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54591 r0 *1 33.04,569.52
X$54591 14074 14073 5517 5376 5261 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54600 r0 *1 40.32,559.44
X$54600 14074 14073 5517 5262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54606 m0 *1 32.48,549.36
X$54606 14074 5263 5376 14073 5319 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $54609 r0 *1 44.8,539.28
X$54609 14074 14073 5265 5263 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54624 r0 *1 52.64,539.28
X$54624 14074 14073 5265 5267 5266 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54629 m0 *1 67.76,559.44
X$54629 14074 14073 5519 5452 5266 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54632 m0 *1 52.08,559.44
X$54632 14074 14073 5266 5451 5377 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $54637 r0 *1 92.4,660.24
X$54637 14074 14073 6930 6853 5455 5268 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $54650 r0 *1 101.92,549.36
X$54650 14074 14073 5380 5269 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54662 m0 *1 224,549.36
X$54662 14074 5331 5454 5273 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $54667 r0 *1 323.12,539.28
X$54667 14074 5274 14073 5366 5304 5603 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $54685 m0 *1 347.2,559.44
X$54685 14074 14073 5276 5460 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54714 r0 *1 454.72,539.28
X$54714 14074 14073 5310 5279 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $54716 r0 *1 458.08,549.36
X$54716 14073 5406 5279 14074 5344 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54727 r0 *1 408.24,549.36
X$54727 5398 5281 5399 5443 14073 14074 5441 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $54747 m0 *1 423.92,549.36
X$54747 14074 14073 5282 5343 5309 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $54765 r0 *1 501.76,549.36
X$54765 14074 14073 5284 5541 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $54767 r0 *1 519.12,569.52
X$54767 14074 5715 5469 5544 5284 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $54781 m0 *1 504,539.28
X$54781 14074 14073 5345 5285 5346 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $54806 r0 *1 599.76,569.52
X$54806 14074 5682 5403 5416 5288 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $54834 r0 *1 1062.32,720.72
X$54834 14074 9274 5294 7551 7814 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $54836 m0 *1 1063.44,730.8
X$54836 14074 14073 5294 8043 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $54869 r0 *1 198.24,549.36
X$54869 14074 5302 5454 5328 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $54889 r0 *1 478.8,619.92
X$54889 14074 14073 5302 6332 6060 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $54891 m0 *1 358.96,599.76
X$54891 14074 14073 5302 5986 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $54893 m0 *1 358.4,619.92
X$54893 5988 5331 5302 5522 14074 14073 6236 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $54895 r0 *1 371.84,619.92
X$54895 5988 5331 5302 5987 14074 14073 6292 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $54940 r0 *1 364.56,650.16
X$54940 14073 6833 5307 14074 6776 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $54981 m0 *1 600.88,710.64
X$54981 14073 7525 14074 7612 7703 5312 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55000 m0 *1 333.2,569.52
X$55000 14074 14073 5312 5601 5334 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55019 m0 *1 600.32,589.68
X$55019 14073 5406 5314 14074 5836 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55022 m0 *1 600.32,599.76
X$55022 14073 5803 5314 14074 6043 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55025 r0 *1 534.24,589.68
X$55025 14074 5906 5967 14073 5905 5796 5314 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $55037 m0 *1 548.24,569.52
X$55037 5803 14073 5348 5315 14074 5537 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $55045 m0 *1 556.08,650.16
X$55045 14074 6847 14073 5316 6703 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55059 r0 *1 26.88,559.44
X$55059 14073 5449 14074 5376 5565 5320 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55087 m0 *1 117.6,569.52
X$55087 14074 5324 5593 5520 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55089 r0 *1 121.52,559.44
X$55089 14074 14073 5324 5571 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55092 r0 *1 125.44,589.68
X$55092 14074 14073 5887 5888 5455 5324 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55106 r0 *1 248.08,609.84
X$55106 14074 14073 6203 5329 6202 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55113 m0 *1 221.76,771.12
X$55113 14073 8547 14074 5979 5330 8630 6280 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55115 r0 *1 166.88,630
X$55115 14073 6488 14074 5979 5330 6553 6320 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55118 m0 *1 51.52,640.08
X$55118 14073 6575 14074 5979 5330 6638 6484 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55120 r0 *1 222.88,650.16
X$55120 14073 6771 14074 5979 5330 6770 6679 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55122 m0 *1 94.64,640.08
X$55122 14073 6405 14074 5979 5330 6403 6577 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55124 m0 *1 73.36,630
X$55124 14073 5980 14074 5979 5330 6400 6217 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55174 r0 *1 176.96,730.8
X$55174 14074 14073 8077 6573 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55176 m0 *1 133.28,619.92
X$55176 14074 14073 6124 6317 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55179 m0 *1 42.56,761.04
X$55179 14074 14073 8680 7473 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55181 m0 *1 209.44,619.92
X$55181 14073 6025 14074 5979 5330 6228 6227 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55183 r0 *1 50.4,670.32
X$55183 14074 14073 7065 7004 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55186 r0 *1 157.36,761.04
X$55186 14074 14073 8804 7414 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55189 r0 *1 164.64,599.76
X$55189 14074 14073 6107 5982 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55191 r0 *1 61.6,700.56
X$55191 14074 14073 7734 7591 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55193 r0 *1 56,670.32
X$55193 14074 14073 7306 6218 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55196 m0 *1 49.84,650.16
X$55196 14074 14073 6813 6761 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55198 r0 *1 216.16,771.12
X$55198 14073 8732 14074 5979 5330 8629 6890 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55200 r0 *1 206.08,680.4
X$55200 14074 14073 7380 7061 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55202 r0 *1 73.36,599.76
X$55202 14073 5330 5979 14074 6049 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55204 r0 *1 134.96,710.64
X$55204 14074 14073 7680 7637 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55206 m0 *1 45.36,730.8
X$55206 14074 14073 7988 6313 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55208 m0 *1 53.76,599.76
X$55208 14073 5971 14074 5979 5330 5977 5978 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $55213 m0 *1 98.56,710.64
X$55213 14074 14073 7566 7672 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55216 m0 *1 133.28,761.04
X$55216 14074 14073 8504 8069 5330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55219 r0 *1 351.68,599.76
X$55219 5988 14073 5331 6055 14074 6056 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $55237 r0 *1 453.6,619.92
X$55237 14074 14073 5331 6395 6060 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55243 m0 *1 372.96,589.68
X$55243 14073 5331 6041 14074 5829 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $55245 r0 *1 104.72,700.56
X$55245 14073 5332 14074 6220 7502 7417 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55263 r0 *1 58.8,690.48
X$55263 14074 7268 14073 5332 7475 5335 7217 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55265 m0 *1 83.44,630
X$55265 14074 6186 14073 5332 6402 5335 5722 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55267 m0 *1 63.84,599.76
X$55267 14074 6276 14073 5332 5975 5335 5885 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55269 m0 *1 142.8,730.8
X$55269 14074 7738 14073 5332 7994 6586 8343 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55283 r0 *1 262.08,559.44
X$55283 14074 14073 5391 5576 5333 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55297 m0 *1 298.48,559.44
X$55297 14074 5529 14073 5457 5334 5503 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $55343 r0 *1 103.04,710.64
X$55343 14074 14073 7860 7595 5335 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55351 m0 *1 221.2,609.84
X$55351 14074 6229 14073 5598 6200 5335 5659 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55353 m0 *1 249.2,640.08
X$55353 14074 14073 5335 6586 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $55363 m0 *1 308,660.24
X$55363 14074 14073 6859 6858 5335 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55372 m0 *1 336.56,549.36
X$55372 14074 14073 5336 5338 5337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55413 m0 *1 341.04,569.52
X$55413 14074 14073 5604 5341 5533 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55490 m0 *1 373.52,559.44
X$55490 14074 14073 5461 5341 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $55526 r0 *1 539.84,569.52
X$55526 14073 5347 5644 14074 5677 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55538 r0 *1 540.96,579.6
X$55538 14074 14073 5347 5833 5644 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55540 m0 *1 537.6,569.52
X$55540 14074 14073 5410 5347 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $55549 m0 *1 571.76,599.76
X$55549 14074 5909 14073 6045 6064 5414 5348 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55559 r0 *1 571.76,549.36
X$55559 14073 5352 14074 5414 5444 5471 5349 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $55571 m0 *1 600.32,559.44
X$55571 14074 5509 5351 14073 5474 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $55588 m0 *1 618.24,609.84
X$55588 14073 6148 14074 5966 6067 5353 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55594 r0 *1 610.4,609.84
X$55594 14073 5966 6305 5353 6148 6309 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $55633 r0 *1 656.88,619.92
X$55633 14074 14073 5358 6346 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $55642 m0 *1 799.68,640.08
X$55642 14074 5360 5615 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $55645 r0 *1 800.8,640.08
X$55645 14074 5360 6659 6246 6744 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $55704 r0 *1 34.72,559.44
X$55704 14074 5516 5376 14073 5377 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $55722 m0 *1 52.08,609.84
X$55722 14074 6132 5378 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $55726 r0 *1 25.76,630
X$55726 14074 5526 6483 5378 6399 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55748 r0 *1 6.16,630
X$55748 14074 5526 6481 5378 6544 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55750 m0 *1 22.96,599.76
X$55750 14074 5526 5972 5378 5970 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55752 r0 *1 46.48,599.76
X$55752 14074 14073 5378 14147 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $55754 m0 *1 41.44,619.92
X$55754 14074 6316 5378 6219 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55756 m0 *1 61.04,660.24
X$55756 14074 5526 6851 5378 6763 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55759 r0 *1 59.92,640.08
X$55759 14074 5526 6642 5378 6639 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55761 r0 *1 24.08,660.24
X$55761 14074 6928 5378 6889 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55763 r0 *1 16.8,640.08
X$55763 14074 5526 6574 5378 6636 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55765 m0 *1 106.96,650.16
X$55765 14074 6682 5378 6765 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55767 m0 *1 91.84,660.24
X$55767 14074 6853 5378 6852 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55770 r0 *1 76.16,619.92
X$55770 14074 5526 6221 5378 6371 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55773 r0 *1 101.92,630
X$55773 14074 5526 6404 5378 6548 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55775 r0 *1 64.4,609.84
X$55775 14074 5526 6119 5378 6184 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55777 m0 *1 94.64,579.6
X$55777 14074 5592 5378 5702 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55779 m0 *1 86.8,589.68
X$55779 14074 5526 5722 5378 5811 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55782 r0 *1 73.36,569.52
X$55782 14074 5526 5653 5378 5701 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55784 m0 *1 22.4,559.44
X$55784 14074 5517 5378 5493 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55787 r0 *1 63.84,549.36
X$55787 14074 5379 5378 5432 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55790 m0 *1 44.8,589.68
X$55790 14074 5526 5885 5378 5934 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55793 m0 *1 67.76,589.68
X$55793 14074 5526 5810 5378 5721 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55796 r0 *1 11.2,569.52
X$55796 14074 5652 5378 5633 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55798 r0 *1 13.44,589.68
X$55798 14074 5526 5883 5378 5932 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $55800 m0 *1 8.96,589.68
X$55800 14074 5720 5378 5856 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55802 r0 *1 63.28,559.44
X$55802 14074 5519 5378 5568 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55812 r0 *1 180.32,710.64
X$55812 14074 14073 7682 7600 5455 5379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55814 m0 *1 77.84,559.44
X$55814 14074 14073 5379 5451 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $55823 r0 *1 92.4,670.32
X$55823 14074 14073 7008 7010 5455 5380 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55827 m0 *1 117.04,559.44
X$55827 14074 5569 14073 5381 5520 5496 5571 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55851 m0 *1 451.36,670.32
X$55851 14074 14073 5384 7097 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55853 m0 *1 365.12,670.32
X$55853 5453 5384 6682 5888 14074 14073 7117 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $55855 m0 *1 389.76,670.32
X$55855 5453 14073 5384 6417 14074 7199 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $55857 m0 *1 374.64,640.08
X$55857 14073 5384 6591 14074 6496 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $55859 r0 *1 374.08,650.16
X$55859 5453 5384 6682 6590 14074 14073 6695 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $55878 m0 *1 463.12,660.24
X$55878 14074 14073 5385 6921 6593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55880 r0 *1 361.76,619.92
X$55880 14073 5385 6236 14074 6327 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55882 m0 *1 351.68,640.08
X$55882 14073 5385 6664 14074 6749 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $55884 m0 *1 205.52,559.44
X$55884 14074 5385 5454 5498 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $55886 m0 *1 224.56,589.68
X$55886 14074 14073 5728 5818 5597 5386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $55890 m0 *1 239.68,589.68
X$55890 14074 5662 14073 5727 5864 5654 5386 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $55915 r0 *1 257.04,559.44
X$55915 14074 14073 5576 5528 5388 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55918 r0 *1 274.96,730.8
X$55918 14073 7943 8004 14074 5389 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55927 r0 *1 277.76,549.36
X$55927 14074 14073 5390 5455 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $55940 r0 *1 320.32,841.68
X$55940 14073 9834 14074 9904 5391 9539 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $55948 m0 *1 306.32,559.44
X$55948 5392 14074 5437 5458 14073 5503 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $55955 r0 *1 319.76,549.36
X$55955 14074 14073 5393 5531 5394 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55958 m0 *1 313.6,559.44
X$55958 14074 14073 5393 5437 5458 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $55963 m0 *1 322,841.68
X$55963 14073 9541 9539 14074 5395 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $55968 r0 *1 315.28,841.68
X$55968 14074 14073 9903 9834 5395 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $55975 r0 *1 515.2,630
X$55975 14074 5606 5396 14073 6497 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $55978 r0 *1 417.2,619.92
X$55978 14074 5396 5581 6393 5463 5464 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $55995 r0 *1 334.32,549.36
X$55995 14074 14073 5460 5437 5397 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56001 m0 *1 538.72,559.44
X$56001 14074 14073 5543 5398 5513 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $56011 r0 *1 422.8,569.52
X$56011 14074 5465 5399 14073 5667 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $56014 r0 *1 479.36,579.6
X$56014 14074 5670 5399 14073 5794 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $56016 m0 *1 478.24,579.6
X$56016 14074 5399 5671 14073 5713 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $56027 m0 *1 527.52,579.6
X$56027 14073 5410 14074 5880 5905 5399 5545 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $56029 r0 *1 532.56,569.52
X$56029 14074 5399 14073 5650 5676 5671 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56033 m0 *1 458.64,932.4
X$56033 8466 14074 8949 5400 14073 11343 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $56035 r0 *1 423.36,801.36
X$56035 9246 14074 5667 5400 14073 9247 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $56037 m0 *1 410.48,932.4
X$56037 14074 5400 11098 14073 11253 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $56041 r0 *1 442.4,569.52
X$56041 5606 14074 5538 5467 14073 5400 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $56074 m0 *1 462.56,831.6
X$56074 9663 9551 7241 5400 14073 14074 9549 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $56076 m0 *1 378,892.08
X$56076 14074 14073 10559 7333 5400 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $56078 m0 *1 400.96,841.68
X$56078 14074 5400 14073 9835 7003 9659 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56080 m0 *1 453.04,841.68
X$56080 14074 5400 14073 9662 9842 7333 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56085 m0 *1 388.64,559.44
X$56085 14074 14073 5401 5462 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56089 m0 *1 392,559.44
X$56089 5402 14073 14074 5464 5463 5462 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $56097 m0 *1 591.36,720.72
X$56097 14073 7783 14074 7612 8018 5403 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56119 m0 *1 536.48,730.8
X$56119 14074 7524 7958 6844 7239 5403 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $56125 r0 *1 445.76,549.36
X$56125 14074 14073 5466 5404 5405 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $56127 m0 *1 445.76,559.44
X$56127 14074 5404 5405 14073 5467 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $56160 r0 *1 500.64,579.6
X$56160 14073 5407 5445 5832 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $56162 m0 *1 485.52,569.52
X$56162 14074 14073 5445 5651 5407 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56207 m0 *1 553.28,559.44
X$56207 14074 5994 5447 14073 5546 5412 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $56210 m0 *1 567.28,609.84
X$56210 14073 5803 5413 14074 6149 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $56216 m0 *1 569.52,619.92
X$56216 14074 14073 5803 6788 5413 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56218 r0 *1 570.64,599.76
X$56218 14074 5968 14073 6148 5413 5803 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $56233 r0 *1 570.64,609.84
X$56233 14073 5415 6064 14074 6247 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $56235 m0 *1 572.32,609.84
X$56235 14074 6152 6064 5415 5968 6149 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $56237 m0 *1 574.56,619.92
X$56237 14074 14073 5415 6304 6064 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56329 m0 *1 168.56,750.96
X$56329 14073 8287 8447 14074 5434 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $56343 m0 *1 330.4,559.44
X$56343 14074 14073 5460 5436 5604 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56345 m0 *1 304.08,569.52
X$56345 14073 5640 14074 5641 5458 5437 5601 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $56364 r0 *1 329.28,559.44
X$56364 14073 5531 5439 14074 5532 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $56382 m0 *1 414.96,892.08
X$56382 14074 5442 10667 14073 10565 10566 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $56403 m0 *1 496.16,579.6
X$56403 14074 14073 5445 5795 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $56426 m0 *1 20.16,569.52
X$56426 14074 5449 14073 5515 5633 5634 5516 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $56444 r0 *1 145.04,559.44
X$56444 14074 5453 5593 5497 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $56462 m0 *1 435.68,670.32
X$56462 14074 14073 5453 7324 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56466 r0 *1 385.84,619.92
X$56466 14074 14073 5453 6388 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56471 r0 *1 375.76,640.08
X$56471 14074 14073 5453 6591 6590 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56474 r0 *1 244.72,579.6
X$56474 14074 5665 5454 5729 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $56476 r0 *1 264.32,579.6
X$56476 14074 5730 5454 5865 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $56478 r0 *1 245.84,599.76
X$56478 14074 6132 5454 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $56509 r0 *1 255.36,619.92
X$56509 14074 5526 6323 5454 6463 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56512 r0 *1 236.32,619.92
X$56512 14074 5526 6322 5454 6557 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56514 m0 *1 294.56,609.84
X$56514 14074 5526 5897 5454 6204 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56516 r0 *1 281.12,630
X$56516 14074 5526 5868 5454 6411 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56518 m0 *1 265.44,599.76
X$56518 14074 5988 5454 5895 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $56520 r0 *1 274.4,619.92
X$56520 14074 5526 6325 5454 6324 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56523 m0 *1 244.72,609.84
X$56523 14074 5526 6133 5454 6201 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56525 r0 *1 241.36,599.76
X$56525 14074 14073 5454 14138 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $56527 m0 *1 283.92,640.08
X$56527 14074 5526 6491 5454 6587 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56529 r0 *1 281.12,660.24
X$56529 14074 5526 6934 5454 6933 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56531 r0 *1 262.08,660.24
X$56531 14074 5526 6993 5454 6992 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56533 r0 *1 248.64,650.16
X$56533 14074 5526 6773 5454 6772 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56535 m0 *1 237.44,650.16
X$56535 14074 5526 6585 5454 6686 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56540 r0 *1 174.16,559.44
X$56540 14074 5522 5454 5521 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $56542 r0 *1 202.72,579.6
X$56542 14074 5526 5659 5454 5861 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56545 r0 *1 195.44,569.52
X$56545 14074 5526 5658 5454 5703 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56547 m0 *1 227.36,579.6
X$56547 14074 5526 5662 5454 5706 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56549 r0 *1 235.2,559.44
X$56549 14074 5526 5573 5454 5499 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56552 r0 *1 221.76,579.6
X$56552 14074 5526 5660 5454 5728 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56555 r0 *1 226.8,589.68
X$56555 14074 5526 5661 5454 6027 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56557 r0 *1 281.12,589.68
X$56557 14074 5526 5821 5454 6034 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56560 m0 *1 276.64,579.6
X$56560 14074 5526 5663 5454 5783 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $56583 m0 *1 91.84,569.52
X$56583 14074 14073 5591 5592 5455 5517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56586 r0 *1 269.36,700.56
X$56586 14074 14073 7651 7652 5455 5519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56649 r0 *1 29.12,710.64
X$56649 14074 14073 7934 7589 5455 5652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56653 m0 *1 245.84,569.52
X$56653 14074 14073 5573 5456 5597 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56660 m0 *1 292.88,750.96
X$56660 14074 14073 6413 8355 5457 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56675 m0 *1 371.28,569.52
X$56675 5644 14073 5458 5534 14074 5873 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $56697 m0 *1 461.44,619.92
X$56697 14073 5741 14074 6241 6244 5463 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56699 m0 *1 430.64,630
X$56699 14073 5740 14074 6241 6469 5463 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $56713 m0 *1 423.92,821.52
X$56713 5581 6393 9442 9441 5464 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $56715 m0 *1 400.96,912.24
X$56715 5464 14074 10890 9247 14073 11095 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $56731 m0 *1 385.84,922.32
X$56731 14074 14073 5464 11065 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $56739 m0 *1 420,579.6
X$56739 5465 14074 14073 5793 5668 14092 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $56746 m0 *1 450.24,811.44
X$56746 5740 14073 5608 5466 14074 9337 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $56748 m0 *1 444.08,811.44
X$56748 5740 14073 5608 5466 14074 9249 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $56753 m0 *1 441.84,569.52
X$56753 5606 14074 5538 5467 14073 5607 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $56799 r0 *1 641.2,690.48
X$56799 14074 14073 5475 7448 7337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $56895 r0 *1 1181.6,599.76
X$56895 5491 14073 14074 6095 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $56900 r0 *1 1163.12,599.76
X$56900 5492 14073 14074 6177 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $56908 m0 *1 1047.2,579.6
X$56908 14074 14073 5781 5623 5695 5494 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56911 m0 *1 1044.96,599.76
X$56911 14074 6103 5763 5693 5926 5695 5494 6012 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $56913 r0 *1 1055.6,599.76
X$56913 14074 14073 6011 5494 5695 5927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56943 r0 *1 268.8,559.44
X$56943 14074 5654 5500 14073 gf180mcu_fd_sc_mcu9t5v0__buf_16
* cell instance $56953 m0 *1 289.52,559.44
X$56953 14074 14073 5502 5600 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $56962 m0 *1 357.28,559.44
X$56962 14074 14073 5504 5533 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $56964 m0 *1 1032.64,589.68
X$56964 14074 14073 5848 5926 5505 5927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56966 r0 *1 1080.24,579.6
X$56966 14074 14073 5780 5759 5505 5760 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56968 m0 *1 1089.76,569.52
X$56968 14074 14073 5626 5627 5505 5566 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56973 m0 *1 1156.4,589.68
X$56973 14074 14073 5697 5698 5505 5769 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56975 r0 *1 1039.92,569.52
X$56975 14074 14073 5637 5624 5505 5693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56977 r0 *1 1070.16,569.52
X$56977 14074 14073 5625 5636 5505 5694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56979 m0 *1 1127.28,640.08
X$56979 14074 14073 6643 6630 5505 6537 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56981 m0 *1 1158.08,640.08
X$56981 14074 14073 6633 6632 5505 6631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56983 r0 *1 1158.08,619.92
X$56983 14074 14073 6273 6274 5505 6095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56985 m0 *1 1116.64,630
X$56985 14074 14073 6278 6175 5505 5931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56987 r0 *1 1120,680.4
X$56987 14074 14073 7360 7174 5505 7058 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56990 r0 *1 1098.72,680.4
X$56990 14074 14073 7370 7262 5505 6732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56993 r0 *1 1080.24,680.4
X$56993 14074 14073 7270 7261 5505 7048 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56996 r0 *1 1072.4,630
X$56996 14074 14073 6551 6534 5505 6536 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $56998 r0 *1 1155.28,670.32
X$56998 14074 14073 7178 7177 5505 7056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57000 r0 *1 1150.8,680.4
X$57000 14074 14073 7266 7263 5505 6976 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57003 r0 *1 1063.44,680.4
X$57003 14074 14073 7359 7170 5505 6888 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57005 r0 *1 1052.8,680.4
X$57005 14074 14073 7274 6982 5505 6887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57036 m0 *1 1158.64,619.92
X$57036 14074 14073 6180 6181 5505 6177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57039 r0 *1 1159.76,650.16
X$57039 14074 14073 6812 6810 5505 6540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57041 m0 *1 1089.76,670.32
X$57041 14074 14073 7069 6733 5505 6734 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57043 r0 *1 1158.64,579.6
X$57043 14074 14073 5777 5771 5505 5699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57075 m0 *1 505.12,660.24
X$57075 14073 5512 6782 14074 7002 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $57080 r0 *1 505.12,650.16
X$57080 14074 14073 5512 6783 6782 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $57099 r0 *1 29.68,569.52
X$57099 14074 14073 5652 5516 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57125 m0 *1 68.32,569.52
X$57125 14074 14073 5519 5590 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $57142 r0 *1 494.48,630
X$57142 14074 14073 5522 6477 6060 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $57145 m0 *1 373.52,609.84
X$57145 5522 14074 6292 14073 6207 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $57153 m0 *1 183.68,670.32
X$57153 14074 14073 6984 6854 5597 5523 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57155 m0 *1 203.84,660.24
X$57155 14074 6856 14073 5727 6769 5654 5523 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57161 m0 *1 192.08,589.68
X$57161 14074 14073 5817 5892 5597 5524 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57163 m0 *1 204.96,579.6
X$57163 14074 5658 14073 5727 5705 5654 5524 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57168 r0 *1 216.16,700.56
X$57168 14074 7509 14073 5727 7510 5654 5525 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $57170 m0 *1 211.68,720.72
X$57170 14074 14073 7684 7828 6413 5525 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $57173 m0 *1 96.32,720.72
X$57173 14074 5526 7822 7009 7904 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57175 r0 *1 258.72,771.12
X$57175 14074 5526 8548 7111 8693 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57177 m0 *1 94.08,1073.52
X$57177 14074 5526 13111 12477 13288 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57179 r0 *1 119.28,892.08
X$57179 14074 5526 10550 9428 10547 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57181 m0 *1 122.64,912.24
X$57181 14074 5526 8541 9428 10932 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57183 m0 *1 109.2,750.96
X$57183 14074 5526 8339 7009 8210 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57186 r0 *1 47.6,861.84
X$57186 14074 5526 9983 8931 10108 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57189 m0 *1 82.88,1103.76
X$57189 14074 5526 13522 12477 13548 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57191 m0 *1 99.12,902.16
X$57191 14074 5526 9749 8931 10770 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57193 m0 *1 39.2,831.6
X$57193 14074 5526 9636 8931 9313 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57195 r0 *1 115.36,720.72
X$57195 14074 5526 7765 7009 7905 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57197 r0 *1 127.12,1093.68
X$57197 14074 5526 13349 12477 13497 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57199 r0 *1 279.44,771.12
X$57199 14074 5526 8634 7111 8694 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57201 m0 *1 20.16,831.6
X$57201 14074 5526 9525 8931 9591 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57203 m0 *1 66.08,710.64
X$57203 14074 5526 7594 7009 7674 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57205 r0 *1 231.28,781.2
X$57205 14074 5526 8842 7111 9005 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57207 r0 *1 81.76,1033.2
X$57207 14074 5526 12647 12477 12770 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57210 m0 *1 62.16,720.72
X$57210 14074 5526 7856 7009 7902 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57213 r0 *1 13.44,831.6
X$57213 14074 5526 9527 8931 9797 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57215 m0 *1 123.2,1023.12
X$57215 14074 5526 12510 11176 12620 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57217 r0 *1 118.72,992.88
X$57217 14074 5526 12193 11176 12109 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57219 m0 *1 100.24,992.88
X$57219 14074 5526 12106 11176 12107 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57221 m0 *1 91.28,982.8
X$57221 14074 5526 11647 11176 11710 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57224 m0 *1 297.92,771.12
X$57224 14074 5526 8420 7427 8550 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57226 m0 *1 296.24,761.04
X$57226 14074 5526 8357 7427 8421 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57228 r0 *1 17.36,841.68
X$57228 14074 5526 9745 8931 9744 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57230 m0 *1 93.52,1013.04
X$57230 14074 5526 12344 11176 12482 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57232 m0 *1 65.52,972.72
X$57232 14074 5526 11787 11176 11834 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57234 m0 *1 61.6,1002.96
X$57234 14074 5526 12105 12477 12320 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57236 m0 *1 132.16,720.72
X$57236 14074 5526 7678 7009 7823 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57238 r0 *1 107.52,1053.36
X$57238 14074 5526 13054 12477 13154 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57241 m0 *1 132.72,1053.36
X$57241 14074 5526 12720 12477 12975 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57244 r0 *1 31.36,851.76
X$57244 14074 5526 9929 8931 10107 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57246 m0 *1 224.56,781.2
X$57246 14074 5526 8729 7111 8902 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57248 m0 *1 32.48,1023.12
X$57248 14074 5526 12505 12477 12612 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57250 m0 *1 34.72,1013.04
X$57250 14074 5526 12342 11176 12473 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57252 m0 *1 113.68,1033.2
X$57252 14074 5526 12646 12477 12619 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57254 r0 *1 226.24,1002.96
X$57254 14074 5526 12199 11275 12352 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57256 m0 *1 294,791.28
X$57256 14074 5526 8937 7111 9103 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57259 r0 *1 122.64,861.84
X$57259 14074 5526 8343 9428 10330 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57261 r0 *1 81.76,1144.08
X$57261 14074 5526 13109 12477 13874 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57263 r0 *1 57.12,972.72
X$57263 14074 5526 11857 11176 11916 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57265 m0 *1 83.44,1123.92
X$57265 14074 5526 13561 12477 13717 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57267 m0 *1 26.32,962.64
X$57267 14074 5526 11645 11176 11688 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57269 r0 *1 141.68,1063.44
X$57269 14074 5526 13059 12477 13113 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57271 m0 *1 26.32,952.56
X$57271 14074 5526 11518 11176 11561 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57273 r0 *1 128.24,801.36
X$57273 14074 5526 9038 9428 9235 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57276 m0 *1 33.04,902.16
X$57276 14074 5526 10643 8931 10831 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57279 m0 *1 89.04,882
X$57279 14074 5526 10372 8931 10450 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57281 m0 *1 147.28,1103.76
X$57281 14074 5526 13406 12477 13455 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57284 m0 *1 28.56,932.4
X$57284 14074 5526 11177 11176 11231 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57286 m0 *1 56.56,952.56
X$57286 14074 5526 11519 11176 11563 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57288 r0 *1 39.76,912.24
X$57288 14074 5526 10975 8931 11032 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57290 m0 *1 10.08,791.28
X$57290 14074 5526 8925 7103 8924 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57292 m0 *1 99.68,1134
X$57292 14074 5526 13563 12477 13722 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57294 r0 *1 101.92,1123.92
X$57294 14074 5526 13565 12477 13752 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57296 r0 *1 35.84,972.72
X$57296 14074 5526 11856 11176 11915 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57298 m0 *1 32.48,972.72
X$57298 14074 5526 11785 11176 11784 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57300 r0 *1 59.92,811.44
X$57300 14074 5526 8891 8931 9370 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57303 r0 *1 7.28,781.2
X$57303 14074 5526 8836 7103 8885 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57305 m0 *1 35.84,1002.96
X$57305 14074 5526 12341 11176 12187 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57307 r0 *1 105.84,962.64
X$57307 14074 5526 11649 11176 11757 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57310 m0 *1 98,791.28
X$57310 14074 5526 7860 7103 8795 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57312 m0 *1 127.68,962.64
X$57312 14074 5526 11522 11176 11592 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57314 r0 *1 117.6,1144.08
X$57314 14074 5526 13771 12477 13900 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57317 r0 *1 127.68,1134
X$57317 14074 5526 13770 12477 13901 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57319 m0 *1 103.04,871.92
X$57319 14074 5526 10261 9428 10329 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57321 m0 *1 117.04,791.28
X$57321 14074 5526 8932 8931 8989 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57324 m0 *1 125.44,801.36
X$57324 14074 5526 9039 8931 9095 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57326 m0 *1 103.04,962.64
X$57326 14074 5526 11648 11176 11837 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57328 m0 *1 67.76,841.68
X$57328 14074 5526 9747 8931 9746 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57330 m0 *1 45.36,781.2
X$57330 14074 5526 8720 7103 8791 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57332 r0 *1 64.4,851.76
X$57332 14074 5526 8682 8931 10023 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57334 r0 *1 21.28,952.56
X$57334 14074 5526 11516 11176 11625 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57336 m0 *1 131.6,841.68
X$57336 14074 5526 9425 9428 9751 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57338 r0 *1 40.32,892.08
X$57338 14074 5526 10542 8931 10726 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57340 r0 *1 118.72,851.76
X$57340 14074 5526 9932 9428 9989 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57343 r0 *1 21.84,761.04
X$57343 14074 5526 8438 7103 8500 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57346 r0 *1 66.64,861.84
X$57346 14074 5526 10109 8931 10326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57348 m0 *1 27.44,750.96
X$57348 14074 5526 8203 7103 8404 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57350 m0 *1 285.6,730.8
X$57350 14074 5526 8008 7427 7946 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57352 m0 *1 91.28,912.24
X$57352 14074 5526 10546 8931 10929 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57354 m0 *1 65.52,902.16
X$57354 14074 5526 9697 8931 10644 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57357 m0 *1 113.68,781.2
X$57357 14074 5526 8839 7103 8798 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57359 m0 *1 285.6,710.64
X$57359 14074 5526 7425 7427 7604 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57361 m0 *1 111.44,932.4
X$57361 14074 5526 11180 11176 11323 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57364 m0 *1 48.16,821.52
X$57364 14074 5526 9422 8931 9593 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57366 m0 *1 24.08,892.08
X$57366 14074 5526 10541 8931 10718 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57368 m0 *1 128.24,821.52
X$57368 14074 5526 9233 9428 9429 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57371 m0 *1 24.64,801.36
X$57371 14074 5526 8927 8931 9087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57373 m0 *1 90.16,750.96
X$57373 14074 5526 8209 7103 8208 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57376 m0 *1 69.44,912.24
X$57376 14074 5526 8929 8931 10924 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57378 m0 *1 54.32,1083.6
X$57378 14074 5526 13259 12477 13256 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57381 m0 *1 35.28,1083.6
X$57381 14074 5526 13180 12477 13253 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57384 r0 *1 61.6,902.16
X$57384 14074 5526 10768 8931 10922 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57387 m0 *1 38.08,1063.44
X$57387 14074 5526 12987 12477 13148 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57389 m0 *1 26.32,861.84
X$57389 14074 5526 10022 8931 10193 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57391 m0 *1 35.84,1053.36
X$57391 14074 5526 12800 12477 13020 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57393 m0 *1 252,761.04
X$57393 14074 5526 8453 7111 8352 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57395 r0 *1 101.92,932.4
X$57395 14074 5526 11179 11176 11178 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57400 m0 *1 98.56,892.08
X$57400 14074 5526 9531 8931 10545 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57404 r0 *1 132.16,831.6
X$57404 14074 5526 9644 9428 9643 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57406 r0 *1 103.04,942.48
X$57406 14074 5526 11418 11176 11417 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57408 m0 *1 73.92,801.36
X$57408 14074 5526 9126 8931 9191 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57411 m0 *1 60.48,791.28
X$57411 14074 5526 8722 7103 9090 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57414 r0 *1 67.76,750.96
X$57414 14074 5526 8336 7103 8205 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57416 m0 *1 52.64,1123.92
X$57416 14074 5526 13521 12477 13677 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57419 m0 *1 61.04,932.4
X$57419 14074 5526 11269 11176 11315 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57421 r0 *1 59.36,922.32
X$57421 14074 5526 11084 11176 11083 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57423 m0 *1 333.2,690.48
X$57423 14074 5526 7318 6424 7391 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57425 r0 *1 41.44,1103.76
X$57425 14074 5526 13404 12477 13588 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57427 m0 *1 95.76,922.32
X$57427 14074 5526 7736 9428 11036 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57429 m0 *1 72.24,962.64
X$57429 14074 5526 11521 11176 11591 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57432 r0 *1 40.88,791.28
X$57432 14074 5526 9036 7103 9035 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57434 r0 *1 61.04,761.04
X$57434 14074 5526 8440 7103 8587 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57438 m0 *1 96.32,841.68
X$57438 14074 5526 9641 8931 9884 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57441 r0 *1 161.28,640.08
X$57441 14074 5526 6683 5593 6818 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57445 r0 *1 155.12,609.84
X$57445 14074 5526 6225 5593 6128 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57448 m0 *1 168.56,609.84
X$57448 14074 5526 6129 5593 6194 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57452 r0 *1 134.96,609.84
X$57452 14074 5526 6127 5593 6125 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57454 r0 *1 192.08,630
X$57454 14074 5526 6489 5593 6458 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57456 m0 *1 213.36,952.56
X$57456 14074 5526 11525 10555 11575 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57461 r0 *1 194.32,650.16
X$57461 14074 5526 6856 5593 6768 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57463 r0 *1 177.52,660.24
X$57463 14074 5526 6855 5593 6984 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57465 r0 *1 203.84,660.24
X$57465 14074 5526 6857 5593 6904 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57467 m0 *1 132.72,650.16
X$57467 14074 5526 6406 5593 6644 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57469 m0 *1 124.32,660.24
X$57469 14074 5526 6766 5593 6896 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57471 m0 *1 118.16,670.32
X$57471 14074 5526 7011 7009 7071 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57474 r0 *1 221.76,902.16
X$57474 14074 5526 10653 10555 10842 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57476 m0 *1 96.32,609.84
X$57476 14074 5526 6121 5593 6188 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57478 m0 *1 210.56,932.4
X$57478 14074 5526 11183 10555 11326 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57480 r0 *1 180.32,640.08
X$57480 14074 5526 6684 5593 6743 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57483 r0 *1 198.8,841.68
X$57483 14074 5526 9647 9428 9832 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57485 m0 *1 203.28,841.68
X$57485 14074 5526 9752 9132 9646 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57487 r0 *1 237.44,892.08
X$57487 14074 5526 10621 10555 10743 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57489 m0 *1 136.08,589.68
X$57489 14074 5526 5779 5593 6019 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57491 m0 *1 165.76,579.6
X$57491 14074 5526 5656 5593 5655 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57493 r0 *1 160.16,579.6
X$57493 14074 5526 5814 5593 5726 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57496 m0 *1 141.68,912.24
X$57496 14074 5526 10976 9428 11041 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57498 r0 *1 156.8,569.52
X$57498 14074 5526 5657 5593 5638 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57500 m0 *1 232.4,619.92
X$57500 14074 5526 6231 5593 6230 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57505 r0 *1 190.4,589.68
X$57505 14074 5526 5893 5593 5817 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57508 m0 *1 166.32,902.16
X$57508 14074 5526 10773 9428 10837 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57512 r0 *1 163.52,922.32
X$57512 14074 5526 11089 10555 11238 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57515 r0 *1 162.4,912.24
X$57515 14074 5526 10978 9428 11151 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57523 r0 *1 211.12,630
X$57523 14074 5526 6490 5593 6556 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57527 r0 *1 218.96,609.84
X$57527 14074 5526 6229 5593 6285 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57530 r0 *1 144.48,922.32
X$57530 14074 5526 11088 11176 11087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57533 m0 *1 175.28,811.44
X$57533 14074 5526 9238 9132 9289 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57542 m0 *1 177.52,630
X$57542 14074 5526 6408 5593 6552 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57544 r0 *1 130.48,579.6
X$57544 14074 5526 5725 5593 5778 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57547 m0 *1 255.36,952.56
X$57547 14074 5526 11186 10555 11580 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57550 r0 *1 175.84,811.44
X$57550 14074 5526 9388 9132 9320 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57555 r0 *1 192.08,912.24
X$57555 14074 5526 10877 9428 11049 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57557 m0 *1 176.96,922.32
X$57557 14074 5526 11090 9428 11152 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57559 r0 *1 192.08,599.76
X$57559 14074 5526 6050 5593 6197 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57561 r0 *1 203.84,892.08
X$57561 14074 5526 10652 9428 10651 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57564 r0 *1 202.16,791.28
X$57564 14074 5526 9044 7111 9001 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57567 r0 *1 261.52,670.32
X$57567 14074 5526 7015 7111 7194 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57569 m0 *1 250.32,700.56
X$57569 14074 5526 7422 7111 7513 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57572 m0 *1 103.04,599.76
X$57572 14074 5526 5983 5593 6105 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57574 r0 *1 242.48,670.32
X$57574 14074 5526 7014 7111 7192 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57577 r0 *1 255.92,730.8
X$57577 14074 5526 8029 7111 8002 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57579 r0 *1 254.24,740.88
X$57579 14074 5526 8118 7111 8303 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57581 m0 *1 273.28,700.56
X$57581 14074 5526 7426 7111 7424 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57583 m0 *1 138.88,882
X$57583 14074 5526 10452 9428 10451 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57585 r0 *1 221.2,841.68
X$57585 14074 5526 9755 9132 9754 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57587 m0 *1 218.96,831.6
X$57587 14074 5526 8545 9132 9432 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57590 m0 *1 181.44,720.72
X$57590 14074 5526 7766 7009 7912 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57592 r0 *1 141.68,861.84
X$57592 14074 5526 9383 9428 10207 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57594 m0 *1 114.24,619.92
X$57594 14074 5526 6279 5593 6222 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57596 r0 *1 234.64,831.6
X$57596 14074 5526 5603 9132 9536 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57599 m0 *1 202.16,740.88
X$57599 14074 5526 8028 7009 8115 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57601 m0 *1 180.88,740.88
X$57601 14074 5526 8114 7009 8078 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57603 r0 *1 160.72,861.84
X$57603 14074 5526 9829 9428 10209 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57605 r0 *1 190.4,882
X$57605 14074 5526 10455 9428 10553 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57607 m0 *1 181.44,871.92
X$57607 14074 5526 10262 9428 10519 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57610 m0 *1 281.12,720.72
X$57610 14074 5526 7864 7111 8005 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57612 m0 *1 236.88,690.48
X$57612 14074 5526 7313 7111 7312 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57614 r0 *1 231.84,700.56
X$57614 14074 5526 7602 7111 7574 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57617 m0 *1 158.48,892.08
X$57617 14074 5526 10552 9428 10551 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57619 r0 *1 215.6,680.4
X$57619 14074 5526 7225 7111 7224 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57622 m0 *1 208.32,861.84
X$57622 14074 5526 10028 9428 10027 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57625 m0 *1 165.76,680.4
X$57625 14074 5526 7222 7009 7075 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57628 r0 *1 251.44,882
X$57628 14074 5526 10457 10555 10456 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57630 m0 *1 204.4,700.56
X$57630 14074 5526 7509 7111 7508 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57632 m0 *1 203.28,680.4
X$57632 14074 5526 7113 7111 7112 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57634 m0 *1 201.6,821.52
X$57634 14074 5526 9241 9132 9498 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57636 m0 *1 171.36,821.52
X$57636 14074 5526 9239 9428 9431 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57639 r0 *1 173.6,680.4
X$57639 14074 5526 7223 7009 7376 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57641 m0 *1 151.76,730.8
X$57641 14074 5526 7862 7009 7767 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57643 r0 *1 143.92,730.8
X$57643 14074 5526 8024 7009 8075 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57645 r0 *1 220.64,882
X$57645 14074 5526 9903 9428 10554 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57647 m0 *1 151.76,720.72
X$57647 14074 5526 7861 7009 7909 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57650 r0 *1 148.96,851.76
X$57650 14074 5526 9828 9428 9994 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57652 m0 *1 224,882
X$57652 14074 5526 10264 9428 10427 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57654 r0 *1 221.76,861.84
X$57654 14074 5526 10116 9428 10336 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57656 r0 *1 206.64,710.64
X$57656 14074 5526 7420 7111 7684 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57658 m0 *1 203.28,710.64
X$57658 14074 5526 7482 7111 7649 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57660 m0 *1 153.44,851.76
X$57660 14074 5526 9933 9428 9892 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57663 m0 *1 251.44,871.92
X$57663 14074 5526 10266 9132 10265 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57667 m0 *1 10.64,730.8
X$57667 14074 5526 7932 7103 7931 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57670 m0 *1 253.12,811.44
X$57670 14074 9045 9132 9295 5526 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $57673 r0 *1 5.04,720.72
X$57673 14074 5526 7854 7103 7853 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57675 r0 *1 191.52,771.12
X$57675 14074 5526 8728 7111 8809 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57677 m0 *1 140,972.72
X$57677 14074 5526 11711 11176 11789 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57679 m0 *1 273.84,791.28
X$57679 14074 5526 8844 7111 8843 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57682 m0 *1 114.24,700.56
X$57682 14074 5526 7504 7009 7567 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57684 r0 *1 175.28,982.8
X$57684 14074 5526 11944 10555 12019 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57686 r0 *1 10.08,680.4
X$57686 14074 5526 7218 7103 7363 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57689 m0 *1 279.44,801.36
X$57689 14074 5526 7945 7427 9209 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57691 r0 *1 137.76,750.96
X$57691 14074 5526 8344 7009 8505 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57693 m0 *1 173.04,1013.04
X$57693 14074 5526 12197 10555 12405 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57695 r0 *1 149.52,1023.12
X$57695 14074 5526 12506 11176 12700 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57697 m0 *1 97.44,680.4
X$57697 14074 5526 7107 7009 7269 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57699 m0 *1 202.72,1023.12
X$57699 14074 5526 12271 11275 12628 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57701 r0 *1 125.44,680.4
X$57701 14074 5526 7220 7009 7271 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57703 r0 *1 52.64,730.8
X$57703 14074 5526 8021 7103 8022 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57705 m0 *1 181.44,771.12
X$57705 14074 5526 8346 7111 8807 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57708 m0 *1 14.56,740.88
X$57708 14074 5526 8107 7103 8162 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57710 r0 *1 138.88,992.88
X$57710 14074 5526 12194 10555 12242 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57712 r0 *1 179.76,761.04
X$57712 14074 5526 8345 7111 8512 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57714 m0 *1 98,690.48
X$57714 14074 5526 7417 7009 7565 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57716 m0 *1 43.12,720.72
X$57716 14074 5526 7762 7103 7732 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57719 r0 *1 63.28,670.32
X$57719 14074 5526 6978 7103 7183 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57722 r0 *1 59.92,680.4
X$57722 14074 5526 7106 7103 7368 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57725 r0 *1 154,791.28
X$57725 14074 5526 9042 7111 9040 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57727 r0 *1 158.48,771.12
X$57727 14074 5526 8627 7009 8724 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57729 m0 *1 204.4,942.48
X$57729 14074 5526 11349 10555 11348 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57731 r0 *1 176.96,942.48
X$57731 14074 5526 11347 10555 11423 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57735 r0 *1 210.56,972.72
X$57735 14074 5526 11862 10555 11921 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57740 m0 *1 140.56,952.56
X$57740 14074 5526 11420 11176 11419 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57742 m0 *1 164.64,952.56
X$57742 14074 5526 11422 10555 11421 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57744 r0 *1 151.2,962.64
X$57744 14074 5526 11651 10555 11696 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57746 m0 *1 148.96,791.28
X$57746 14074 5526 8934 7009 8933 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57749 r0 *1 218.4,801.36
X$57749 14074 5526 8600 9132 9204 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57751 r0 *1 198.24,982.8
X$57751 14074 5526 11947 10555 12087 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57753 r0 *1 28,700.56
X$57753 14074 5526 7590 7103 7560 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57755 r0 *1 29.12,680.4
X$57755 14074 5526 7217 7103 7105 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $57758 m0 *1 181.44,962.64
X$57758 14074 5526 11523 10555 11638 14073 gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* cell instance $58115 r0 *1 237.44,801.36
X$58115 14074 9134 9132 9242 5526 14073 gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* cell instance $58127 m0 *1 234.08,750.96
X$58127 14073 5529 14074 8299 5640 8351 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58129 r0 *1 293.44,750.96
X$58129 5529 14074 8354 8419 14073 8356 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $58152 m0 *1 234.08,730.8
X$58152 14074 14073 5529 5707 7999 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58154 r0 *1 248.08,720.72
X$58154 14073 5529 7914 14074 7685 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58166 m0 *1 289.52,630
X$58166 14074 14073 6411 6412 6413 5530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58168 m0 *1 295.68,579.6
X$58168 14074 5663 14073 5727 5867 5654 5530 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58174 m0 *1 322.56,569.52
X$58174 14074 5602 14073 6052 5531 5604 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $58177 r0 *1 314.72,569.52
X$58177 14073 5707 14074 5532 5785 5602 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58306 r0 *1 516.88,599.76
X$58306 14074 14073 5539 6114 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $58316 r0 *1 519.68,670.32
X$58316 14074 6786 7132 7002 5540 6566 14073 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $58318 m0 *1 517.44,700.56
X$58318 14074 7524 6566 7410 5540 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $58338 m0 *1 510.16,700.56
X$58338 14074 7608 14073 7663 7410 5542 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $58341 r0 *1 504.56,700.56
X$58341 5542 5716 7410 7497 14074 14073 7665 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $58427 r0 *1 1172.08,589.68
X$58427 5564 14073 14074 5931 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $58434 m0 *1 1070.72,589.68
X$58434 14074 6017 5763 5566 5636 5695 5768 5759 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $58438 m0 *1 1071.28,599.76
X$58438 14074 6093 5695 5760 5636 5763 5566 5768 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $58447 m0 *1 1098.72,589.68
X$58447 5851 14073 5695 5566 14074 5852 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $58449 r0 *1 1083.04,589.68
X$58449 14074 14073 5941 5760 5695 5566 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58484 m0 *1 239.12,871.92
X$58484 14074 10264 14073 10377 10338 10269 5573
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58488 m0 *1 292.32,1033.2
X$58488 14074 6497 5574 12115 11948 6468 14073 gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $58490 r0 *1 548.8,640.08
X$58490 14074 6677 5574 6472 6146 6676 14073 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $58493 r0 *1 249.76,1063.44
X$58493 14074 12941 5574 14073 6497 6468 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $58495 m0 *1 229.6,1073.52
X$58495 14074 13267 6497 12115 5574 14073 6468 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $58507 r0 *1 228.48,1063.44
X$58507 5574 6497 6468 13168 14074 14073 13116 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $58535 m0 *1 367.92,942.48
X$58535 14074 11715 14073 11430 10655 8220 5579 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58537 r0 *1 364.56,962.64
X$58537 14074 14073 11428 7603 11497 5579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58545 r0 *1 423.92,912.24
X$58545 14074 5581 10991 10100 10465 10992 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $58600 r0 *1 73.36,579.6
X$58600 14074 14073 5721 5809 5597 5591 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58603 r0 *1 89.04,579.6
X$58603 14074 5653 14073 5727 5723 5654 5591 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58606 m0 *1 381.92,700.56
X$58606 14073 5592 7434 14074 7517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58625 m0 *1 376.32,720.72
X$58625 14073 5592 7775 14074 7921 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $58628 m0 *1 455.84,730.8
X$58628 14074 14073 5592 8017 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58630 m0 *1 162.4,619.92
X$58630 14074 6132 5593 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $58688 r0 *1 143.36,640.08
X$58688 14074 6581 5593 6645 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $58693 m0 *1 114.8,589.68
X$58693 14074 5888 5593 5886 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $58703 m0 *1 141.68,640.08
X$58703 14074 14073 6644 6580 5597 5594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58705 r0 *1 142.24,589.68
X$58705 14074 5725 14073 5727 5940 5654 5594 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58709 m0 *1 161.84,589.68
X$58709 14074 14073 5726 5890 5597 5595 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58711 r0 *1 179.2,579.6
X$58711 14074 5657 14073 5727 5813 5654 5595 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58716 r0 *1 22.4,821.52
X$58716 14074 14073 9591 9524 5597 7063 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58718 r0 *1 45.36,811.44
X$58718 14074 14073 9313 9314 5597 6930 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58721 r0 *1 32.48,791.28
X$58721 14074 14073 9087 8926 5597 7476 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58727 r0 *1 26.88,599.76
X$58727 14074 14073 5970 6100 5597 5719 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58729 m0 *1 36.96,630
X$58729 14074 14073 6399 6482 5597 6315 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58737 r0 *1 117.6,619.92
X$58737 14074 14073 6222 6375 5597 5887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58739 r0 *1 21.84,740.88
X$58739 14074 14073 8162 8277 5597 7934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58770 m0 *1 31.36,700.56
X$58770 14074 14073 7560 7500 5597 7413 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $58773 r0 *1 89.6,630
X$58773 14074 14073 5597 6413 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $58776 r0 *1 53.2,781.2
X$58776 14073 8720 5598 14074 8887 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58779 m0 *1 143.92,609.84
X$58779 14074 14073 6127 6281 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58829 m0 *1 73.36,730.8
X$58829 14073 7594 5598 14074 7990 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58831 r0 *1 187.6,740.88
X$58831 14074 14073 8114 8291 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58833 m0 *1 249.76,781.2
X$58833 14074 14073 8842 8730 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58835 m0 *1 182.56,599.76
X$58835 14074 14073 6129 6023 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58837 m0 *1 141.68,771.12
X$58837 14074 8344 14073 5598 8685 6586 9038 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58839 r0 *1 59.36,660.24
X$58839 14074 14073 6978 7066 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58842 r0 *1 150.64,781.2
X$58842 14073 8627 5598 14074 8898 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58844 m0 *1 53.76,660.24
X$58844 14074 14073 6851 6891 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58847 r0 *1 217.28,690.48
X$58847 14074 7225 14073 5598 7421 6586 7482 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $58849 m0 *1 71.68,650.16
X$58849 14073 6642 5598 14074 6681 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58851 r0 *1 47.6,730.8
X$58851 14074 14073 8021 8072 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58853 m0 *1 170.8,690.48
X$58853 14074 14073 7222 7309 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58855 r0 *1 240.8,771.12
X$58855 14074 14073 8729 8632 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58857 m0 *1 186.48,640.08
X$58857 14074 14073 6408 6648 5598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $58859 m0 *1 114.24,640.08
X$58859 14073 6404 5598 14074 6485 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $58870 r0 *1 381.92,690.48
X$58870 14074 14073 7490 5600 7492 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $58872 r0 *1 376.32,670.32
X$58872 14073 7197 14074 5600 5654 7092 7198 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58874 r0 *1 370.16,720.72
X$58874 14074 14073 8011 5600 7919 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $58876 r0 *1 375.76,740.88
X$58876 14073 5600 14074 6752 5654 8120 8223 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58878 r0 *1 376.32,730.8
X$58878 14073 6328 14074 5600 5654 8031 7283 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58880 m0 *1 381.36,740.88
X$58880 14073 8184 14074 8183 7939 5600 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $58882 r0 *1 402.64,781.2
X$58882 14073 14074 9113 8942 5654 8014 8908 5600
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $58884 m0 *1 371.84,771.12
X$58884 14073 6040 14074 5600 5654 8703 8551 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58886 r0 *1 388.08,761.04
X$58886 14073 7435 14074 5600 5654 8552 7115 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58888 m0 *1 385.84,589.68
X$58888 14073 5790 14074 5600 5654 5830 5823 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58890 r0 *1 388.08,781.2
X$58890 14073 6914 14074 5600 5654 8849 8941 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58892 m0 *1 379.12,619.92
X$58892 14073 6293 14074 5600 5654 6237 5889 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58894 m0 *1 353.92,720.72
X$58894 14073 6057 14074 5600 5654 7774 7837 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58896 r0 *1 333.2,710.64
X$58896 14073 7744 14074 5600 5654 7688 7771 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58898 m0 *1 354.48,609.84
X$58898 14073 6205 14074 5600 5654 6198 5816 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58900 r0 *1 333.76,599.76
X$58900 14073 5956 14074 5600 5654 6054 6031 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58903 m0 *1 348.32,619.92
X$58903 14073 6290 14074 5600 5654 6234 6235 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58905 r0 *1 356.72,680.4
X$58905 14073 6775 14074 5600 5654 7229 7230 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58907 r0 *1 350,670.32
X$58907 14073 5899 14074 5600 5654 7016 7085 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58909 r0 *1 154,650.16
X$58909 14073 6817 14074 5600 5654 6816 6680 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58912 r0 *1 178.08,650.16
X$58912 14073 6821 14074 5600 5654 6767 6123 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58915 r0 *1 217.84,640.08
X$58915 14073 6561 14074 5600 5654 6583 6685 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58917 m0 *1 255.36,599.76
X$58917 14073 6032 14074 5600 5654 6033 5894 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58919 r0 *1 213.36,781.2
X$58919 14073 7951 14074 5600 5654 8841 8805 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58921 m0 *1 190.4,710.64
X$58921 14073 7585 14074 5600 5654 7683 7596 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58923 r0 *1 213.92,730.8
X$58923 14073 8082 14074 5600 5654 8080 8027 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58925 r0 *1 157.92,670.32
X$58925 14073 7012 14074 5600 5654 7073 7006 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58927 m0 *1 175.84,690.48
X$58927 14073 7314 14074 5600 5654 7310 7311 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58929 r0 *1 162.96,730.8
X$58929 14073 8016 14074 5600 5654 8025 7935 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58932 r0 *1 157.36,680.4
X$58932 14073 7308 14074 5600 5654 7273 7221 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58934 m0 *1 201.6,761.04
X$58934 14073 8186 14074 5600 5654 8414 8446 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58936 r0 *1 148.4,771.12
X$58936 14073 8222 14074 5600 5654 8683 8719 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $58993 m0 *1 238,831.6
X$58993 14074 8220 14073 9707 8219 5603 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $59005 r0 *1 235.76,821.52
X$59005 14074 14073 9536 9433 9137 5603 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59014 r0 *1 414.4,569.52
X$59014 14074 14073 5605 5958 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $59016 m0 *1 593.6,811.44
X$59016 14074 14073 7000 5606 9305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $59022 r0 *1 603.68,740.88
X$59022 14073 8329 8129 8127 8332 5606 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $59056 m0 *1 588.56,771.12
X$59056 14074 14073 6659 9230 5606 8285 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $59058 m0 *1 556.64,811.44
X$59058 14074 14073 5606 9339 8127 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $59060 r0 *1 558.32,791.28
X$59060 14073 5606 8127 14074 9061 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59062 r0 *1 618.24,680.4
X$59062 5606 6450 7244 7293 14074 14073 6754 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $59064 m0 *1 610.96,640.08
X$59064 14073 5606 6245 14074 6513 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59068 r0 *1 437.36,750.96
X$59068 8226 8366 5606 5667 14073 14074 6499 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $59070 m0 *1 428.96,811.44
X$59070 9246 14074 5667 5607 14073 9442 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $59072 r0 *1 433.44,922.32
X$59072 14074 14073 11166 5607 11098 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $59074 r0 *1 427.84,851.76
X$59074 14073 10100 14074 10101 9770 5607 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $59092 r0 *1 439.04,791.28
X$59092 7003 7957 8226 9443 5607 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $59094 m0 *1 430.64,922.32
X$59094 14073 14074 5607 9842 11100 11167 10991 11166
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $59096 r0 *1 444.64,912.24
X$59096 14074 14073 10568 7333 5607 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $59112 r0 *1 503.44,609.84
X$59112 14074 14073 5609 6566 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $59120 m0 *1 510.16,660.24
X$59120 14074 6114 5611 14073 6786 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59130 r0 *1 503.44,670.32
X$59130 14074 14073 5674 7021 5611 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $59133 r0 *1 500.64,690.48
X$59133 14074 14073 7609 6114 5611 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $59137 m0 *1 486.08,700.56
X$59137 14073 5674 5611 14074 7521 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59143 r0 *1 580.16,569.52
X$59143 14073 5613 14074 5681 5680 5679 5678 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $59151 r0 *1 743.68,569.52
X$59151 5687 14074 5685 5686 14073 5614 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $59156 r0 *1 729.12,821.52
X$59156 14074 9613 14073 9459 5614 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $59160 m0 *1 726.32,1002.96
X$59160 14074 12223 14073 12498 12010 9856 5614 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59163 r0 *1 439.04,710.64
X$59163 14073 14074 7751 6501 7750 7121 7694 5614
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $59254 m0 *1 1093.12,619.92
X$59254 14074 5622 14181 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $59259 m0 *1 1093.12,609.84
X$59259 14074 6132 5622 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $59276 r0 *1 1048.32,569.52
X$59276 14074 14073 5623 5624 5758 5693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59292 r0 *1 1088.64,579.6
X$59292 14074 5759 14073 5770 5850 5767 5627 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59298 m0 *1 1134.56,579.6
X$59298 14074 5765 5763 5699 5629 5695 5631 5698 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $59300 r0 *1 1130.08,579.6
X$59300 14074 5764 5695 5769 5629 5763 5699 5631 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $59310 r0 *1 1116.64,589.68
X$59310 14074 14073 6014 5930 5763 5630 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59312 m0 *1 1112.16,589.68
X$59312 14074 14073 5853 5930 5851 5630 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59317 m0 *1 1128.4,589.68
X$59317 14074 14073 5857 5762 5695 5631 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59327 r0 *1 1148.56,589.68
X$59327 5632 14073 14074 6176 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $59350 r0 *1 1078.56,599.76
X$59350 14074 5636 14073 5854 6190 5694 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59354 r0 *1 175.84,569.52
X$59354 14074 14073 5638 5656 5654 5657 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59377 r0 *1 301.28,720.72
X$59377 14074 5654 14073 5641 7947 5727 7864 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59406 r0 *1 700,912.24
X$59406 14074 14073 5794 5644 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59409 r0 *1 781.2,942.48
X$59409 14073 5644 8236 14074 11372 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59411 r0 *1 786.24,952.56
X$59411 14074 14073 5644 11610 8236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $59413 m0 *1 529.76,609.84
X$59413 14073 5644 5676 14074 6145 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59419 m0 *1 584.08,579.6
X$59419 5679 14074 5680 5678 14073 5645 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $59424 m0 *1 600.32,609.84
X$59424 14074 6307 5646 14073 5682 5910 5994 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $59426 r0 *1 585.76,609.84
X$59426 14074 6342 5646 14073 5682 5909 5910 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $59435 m0 *1 613.2,599.76
X$59435 5682 14074 5646 5995 14073 6070 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $59437 r0 *1 612.64,599.76
X$59437 5646 14073 5682 6068 14074 5995 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $59439 r0 *1 595.84,609.84
X$59439 14074 6308 5646 5682 5910 5909 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $59443 r0 *1 457.52,932.4
X$59443 14074 14073 11416 5647 6594 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59445 m0 *1 458.64,942.48
X$59445 14074 14073 11415 5647 8231 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59447 m0 *1 469.28,932.4
X$59447 14074 14073 11258 5647 6867 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59449 m0 *1 464.24,922.32
X$59449 14074 14073 11169 5647 6784 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59451 m0 *1 472.64,791.28
X$59451 14074 14073 8851 5647 8464 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59454 m0 *1 418.88,811.44
X$59454 14074 14073 9406 5647 8644 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59456 r0 *1 475.44,801.36
X$59456 14074 14073 9220 5647 7125 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59459 m0 *1 470.4,801.36
X$59459 14074 14073 9115 5647 8125 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59462 m0 *1 458.08,791.28
X$59462 14074 14073 8947 5647 7437 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59465 m0 *1 437.92,791.28
X$59465 14074 14073 8945 5647 7126 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59468 m0 *1 377.44,791.28
X$59468 14074 14073 9019 5647 8527 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59470 m0 *1 391.44,871.92
X$59470 14074 14073 10273 5647 6866 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59473 r0 *1 373.52,871.92
X$59473 14074 14073 10380 5647 8364 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59476 r0 *1 467.6,861.84
X$59476 14074 14073 10241 5647 9734 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59478 m0 *1 467.6,871.92
X$59478 14074 14073 10354 5647 7409 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59480 m0 *1 470.96,841.68
X$59480 14074 14073 9817 5647 6780 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59483 r0 *1 452.48,841.68
X$59483 14074 14073 9911 5647 8229 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59485 m0 *1 473.2,892.08
X$59485 14074 14073 10670 5647 7236 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59488 m0 *1 405.44,942.48
X$59488 14074 14073 11501 5647 8856 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59490 r0 *1 377.44,932.4
X$59490 14074 14073 11338 5647 8363 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59492 m0 *1 379.68,942.48
X$59492 14074 14073 11429 5647 7334 8940 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59530 r0 *1 399.84,791.28
X$59530 14074 14073 9052 8940 9053 5647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59533 m0 *1 410.48,589.68
X$59533 14074 14073 5647 5793 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59535 r0 *1 430.08,579.6
X$59535 5738 14074 14073 5647 5739 14113 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $59561 m0 *1 84,579.6
X$59561 14074 14073 5701 5722 5654 5653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59563 m0 *1 267.68,771.12
X$59563 14074 14073 8693 8634 5654 8548 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59568 r0 *1 315.84,791.28
X$59568 14074 14073 9011 9048 5654 8846 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59570 r0 *1 303.52,750.96
X$59570 14074 14073 8421 8420 5654 8357 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59572 m0 *1 325.36,761.04
X$59572 14074 14073 8455 8456 5654 8358 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59574 r0 *1 290.08,579.6
X$59574 14074 14073 5783 5821 5654 5663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59576 r0 *1 302.96,589.68
X$59576 14074 14073 5896 5897 5654 5824 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59578 m0 *1 17.36,841.68
X$59578 14074 14073 9744 9527 5654 9745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59583 r0 *1 311.92,801.36
X$59583 14074 5654 9047 14073 9138 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $59585 m0 *1 127.12,851.76
X$59585 14074 14073 9989 8343 5654 9932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59587 r0 *1 12.88,791.28
X$59587 14074 14073 8924 8836 5654 8925 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59590 r0 *1 113.12,791.28
X$59590 14074 14073 8989 7860 5654 8932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59592 r0 *1 132.72,791.28
X$59592 14074 14073 9095 9038 5654 9039 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59594 m0 *1 87.36,871.92
X$59594 14074 14073 10326 8682 5654 10109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59598 m0 *1 320.88,740.88
X$59598 14074 14073 8087 8088 5654 7948 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59600 r0 *1 30.8,861.84
X$59600 14074 14073 10193 9929 5654 10022 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59609 m0 *1 299.04,821.52
X$59609 14074 14073 9397 9436 5654 9398 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59615 m0 *1 313.04,660.24
X$59615 14074 14073 6908 6859 5654 6860 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59618 r0 *1 205.52,831.6
X$59618 14074 14073 9646 9647 5654 9752 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59621 m0 *1 29.12,589.68
X$59621 14074 5883 14073 5727 5807 5654 5719 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59623 r0 *1 32.48,589.68
X$59623 14074 14073 5932 5885 5654 5883 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59625 m0 *1 201.6,670.32
X$59625 14074 14073 6768 6857 5654 6856 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59628 r0 *1 214.48,569.52
X$59628 14074 14073 5703 5659 5654 5658 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59631 r0 *1 241.36,569.52
X$59631 14074 14073 5706 5661 5654 5662 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59634 m0 *1 138.32,579.6
X$59634 14074 14073 5778 5779 5654 5725 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59637 m0 *1 20.16,640.08
X$59637 14074 14073 6544 6574 5654 6481 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59639 m0 *1 266,680.4
X$59639 14074 14073 6992 7015 5654 6993 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59642 r0 *1 111.44,599.76
X$59642 14074 14073 6105 6121 5654 5983 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59644 m0 *1 288.96,740.88
X$59644 14074 14073 8005 8008 5654 7864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59646 r0 *1 159.04,841.68
X$59646 14074 14073 9892 9828 5654 9933 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59648 r0 *1 283.36,670.32
X$59648 14074 14073 6933 6936 5654 6934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59651 r0 *1 261.52,841.68
X$59651 14074 14073 9757 9648 5654 9759 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59653 r0 *1 240.8,690.48
X$59653 14074 14073 7312 7422 5654 7313 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59655 r0 *1 204.4,700.56
X$59655 14074 14073 7508 7482 5654 7509 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59661 m0 *1 192.08,821.52
X$59661 14074 14073 9320 9238 5654 9388 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59665 r0 *1 13.44,730.8
X$59665 14074 14073 7931 7854 5654 7932 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59667 m0 *1 260.4,801.36
X$59667 14074 6586 14073 9135 9136 5654 9206 7945
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $59669 m0 *1 19.04,690.48
X$59669 14074 14073 7363 7217 5654 7218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59671 m0 *1 236.88,811.44
X$59671 14074 14073 9242 9045 5654 9134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59673 m0 *1 148.96,801.36
X$59673 14074 14073 8933 9042 5654 8934 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59675 m0 *1 267.12,630
X$59675 14074 14073 6463 6325 5654 6323 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59826 r0 *1 277.2,690.48
X$59826 14074 14073 7424 7425 5654 7426 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59828 m0 *1 278.88,841.68
X$59828 14074 9759 14073 5727 9806 5654 9539 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59830 m0 *1 43.68,851.76
X$59830 14074 10022 14073 5727 9980 5654 6930 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59833 r0 *1 264.32,811.44
X$59833 14074 14073 9325 6586 5654 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $59836 m0 *1 172.48,851.76
X$59836 14074 9933 14073 5727 9830 5654 6899 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59839 r0 *1 327.04,781.2
X$59839 14074 8846 14073 5727 8847 5654 6693 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59841 r0 *1 249.2,690.48
X$59841 14074 7313 14073 5727 7483 5654 5819 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59844 m0 *1 24.08,821.52
X$59844 14074 9745 14073 5727 9421 5654 7063 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59847 m0 *1 296.8,811.44
X$59847 8941 7115 5654 9327 6586 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $59850 r0 *1 119.84,599.76
X$59850 14074 5983 14073 5727 6122 5654 5887 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59852 m0 *1 104.72,781.2
X$59852 14074 8932 14073 5727 8838 5654 6981 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59854 m0 *1 28,630
X$59854 14074 6481 14073 5727 6398 5654 6315 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59856 m0 *1 136.64,811.44
X$59856 14074 9039 14073 5727 9130 5654 7599 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59859 r0 *1 85.68,861.84
X$59859 14074 10109 14073 5727 9930 5654 7008 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59861 m0 *1 27.44,690.48
X$59861 14074 7218 14073 5727 7364 5654 7413 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59865 m0 *1 270.48,619.92
X$59865 14074 6323 14073 5727 6287 5654 6134 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59867 m0 *1 272.72,670.32
X$59867 14074 6993 14073 5727 7114 5654 5820 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59870 m0 *1 132.16,861.84
X$59870 14074 9932 14073 5727 10026 5654 7598 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59873 r0 *1 167.44,781.2
X$59873 14074 8934 14073 5727 8995 5654 7681 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59878 m0 *1 29.12,791.28
X$59878 14074 8925 14073 5727 8837 5654 7476 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59880 r0 *1 306.88,821.52
X$59880 14074 9398 14073 5727 9504 5654 9541 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59885 r0 *1 183.12,821.52
X$59885 14074 9388 14073 5727 9291 5654 7682 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59888 r0 *1 273.28,761.04
X$59888 14073 7651 5654 14074 8603 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $59890 r0 *1 24.64,730.8
X$59890 14074 7932 14073 5727 7933 5654 7934 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59898 m0 *1 346.08,710.64
X$59898 14074 14073 5654 7430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $59900 r0 *1 327.6,700.56
X$59900 14074 14073 7580 7516 5654 7429 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59902 r0 *1 319.2,720.72
X$59902 14074 5654 14073 7687 7866 5727 7948 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59904 m0 *1 323.68,690.48
X$59904 14074 7429 14073 5727 7316 5654 5825 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59907 m0 *1 329.84,771.12
X$59907 14074 8358 14073 5727 8699 5654 5898 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59914 m0 *1 322,660.24
X$59914 14074 6860 14073 5727 6861 5654 6494 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59925 m0 *1 309.68,589.68
X$59925 14074 5654 14073 5785 5822 5727 5824 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $59928 m0 *1 170.24,589.68
X$59928 14074 14073 5655 5656 5812 5860 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59940 r0 *1 186.48,609.84
X$59940 14074 7189 6129 5656 6223 6224 6226 6050 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $59956 m0 *1 208.88,589.68
X$59956 14074 14073 5861 5659 5812 5946 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59968 r0 *1 240.8,861.84
X$59968 14074 9764 14073 10117 6223 5659 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $59976 m0 *1 227.36,861.84
X$59976 14074 10094 10114 5660 10115 10113 10020 10116 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $59978 m0 *1 227.36,599.76
X$59978 14074 14073 5818 6026 5984 5660 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59982 m0 *1 239.12,599.76
X$59982 14074 14073 6027 5661 5812 6029 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $59989 r0 *1 234.08,791.28
X$59989 14074 9323 8600 9045 8219 6223 8295 5661 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $60030 m0 *1 434,589.68
X$60030 14074 14073 5666 5874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60052 m0 *1 431.2,579.6
X$60052 14074 14073 5668 5739 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60057 r0 *1 466.48,579.6
X$60057 14074 14073 5902 5669 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60073 r0 *1 481.6,640.08
X$60073 14073 6726 6923 5672 5962 6060 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $60087 m0 *1 490.56,650.16
X$60087 14074 14073 5672 6781 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60093 m0 *1 480.48,670.32
X$60093 14073 6945 7124 5672 5992 6060 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $60098 m0 *1 471.52,750.96
X$60098 14074 14073 8230 8193 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60103 m0 *1 444.08,690.48
X$60103 14074 14073 7231 7325 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60141 m0 *1 454.16,750.96
X$60141 14074 14073 8227 8313 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60143 r0 *1 484.96,660.24
X$60143 14074 6114 5673 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $60145 r0 *1 479.36,700.56
X$60145 14074 14073 6913 7754 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60147 r0 *1 445.2,630
X$60147 14074 14073 6138 6562 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60149 r0 *1 458.64,619.92
X$60149 14074 14073 6140 6476 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60151 r0 *1 461.44,609.84
X$60151 14074 14073 5957 6242 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60153 r0 *1 459.76,650.16
X$60153 14074 14073 6668 6839 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60156 r0 *1 449.68,650.16
X$60156 14074 14073 6498 6837 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60159 r0 *1 445.2,660.24
X$60159 14074 14073 6779 6999 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60162 r0 *1 426.72,670.32
X$60162 14074 14073 6942 7202 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60164 r0 *1 431.76,700.56
X$60164 14074 14073 7323 7750 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60167 r0 *1 436.8,700.56
X$60167 14074 14073 7519 7520 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60170 m0 *1 426.16,740.88
X$60170 14074 14073 8032 8187 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60172 m0 *1 434,750.96
X$60172 14074 14073 8121 8311 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60174 r0 *1 422.24,740.88
X$60174 14074 14073 8122 8310 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60176 m0 *1 465.92,740.88
X$60176 14074 14073 7868 8192 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60179 r0 *1 455.28,720.72
X$60179 14074 14073 7693 7926 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60181 r0 *1 473.76,730.8
X$60181 14074 7695 14073 6781 7782 5673 7870 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $60185 r0 *1 450.24,730.8
X$60185 14074 14073 7954 8035 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60187 r0 *1 437.36,630
X$60187 14074 14073 6329 6700 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60189 r0 *1 436.8,660.24
X$60189 14074 14073 6698 6997 5673 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60232 r0 *1 536.48,740.88
X$60232 14074 14073 5675 8233 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60238 r0 *1 529.76,599.76
X$60238 14074 14073 5905 5676 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60249 m0 *1 547.12,609.84
X$60249 14073 5968 5677 14074 6146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60251 r0 *1 538.72,599.76
X$60251 14073 5677 5967 14074 6113 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60291 m0 *1 726.32,650.16
X$60291 14073 6795 14074 6748 6617 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60293 m0 *1 659.68,771.12
X$60293 14073 8713 14074 8566 8562 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60296 r0 *1 637.84,730.8
X$60296 14073 8044 14074 8007 8133 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60298 r0 *1 627.2,882
X$60298 14073 10637 14074 10472 10962 10478 5683
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $60300 r0 *1 712.88,761.04
X$60300 14073 8615 14074 8614 8384 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60302 m0 *1 733.04,861.84
X$60302 14074 14073 9780 5683 10361 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $60304 m0 *1 721.84,861.84
X$60304 14074 5683 10240 14073 9410 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60306 m0 *1 647.92,882
X$60306 14074 14073 10536 5683 10530 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $60308 m0 *1 703.36,831.6
X$60308 14073 9452 14074 9566 9810 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60310 r0 *1 704.48,821.52
X$60310 14073 9453 14074 9459 9460 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60312 m0 *1 705.6,841.68
X$60312 14073 9513 14074 9785 9853 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60314 m0 *1 695.52,871.92
X$60314 14074 5683 10358 14073 10288 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60316 m0 *1 734.16,740.88
X$60316 14073 8048 14074 8143 7968 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60319 m0 *1 735.28,720.72
X$60319 14073 7836 14074 7833 7795 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60321 r0 *1 720.16,730.8
X$60321 14073 8050 14074 8084 8049 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60323 r0 *1 710.64,720.72
X$60323 14073 7881 14074 7923 7924 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60325 m0 *1 637.28,650.16
X$60325 14073 6753 14074 6843 6516 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60327 r0 *1 700.56,801.36
X$60327 14073 9156 14074 9263 9214 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60330 m0 *1 654.64,650.16
X$60330 14073 6716 14074 6842 6611 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60332 m0 *1 660.24,670.32
X$60332 14073 6947 14074 7096 7095 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60334 r0 *1 638.96,640.08
X$60334 14073 6672 14074 6714 6519 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60336 m0 *1 712.88,791.28
X$60336 14073 9016 14074 9013 8866 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60338 r0 *1 705.04,811.44
X$60338 14073 9110 14074 9407 9345 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60340 r0 *1 636.72,670.32
X$60340 14073 7136 14074 7098 7027 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60343 r0 *1 753.76,650.16
X$60343 14074 5683 6831 14073 6834 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60345 m0 *1 742.56,740.88
X$60345 14073 8051 14074 8144 7798 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60348 m0 *1 771.68,740.88
X$60348 14074 5683 8145 14073 8181 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60350 m0 *1 758.24,690.48
X$60350 14074 5683 7352 14073 7293 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60352 m0 *1 759.36,680.4
X$60352 14073 7211 14074 7147 7209 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60354 r0 *1 770,680.4
X$60354 14073 7251 14074 7288 6621 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60356 r0 *1 758.8,861.84
X$60356 14074 5683 10157 14073 10052 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $60359 m0 *1 758.8,700.56
X$60359 14073 7460 14074 7575 6725 5683 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60411 m0 *1 698.88,932.4
X$60411 14074 11371 11259 8236 5683 5794 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $60413 m0 *1 628.32,912.24
X$60413 14074 14073 5683 8127 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60415 r0 *1 640.64,831.6
X$60415 14073 9734 5683 14074 9347 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60421 m0 *1 743.12,579.6
X$60421 5685 14073 5686 5714 14074 5687 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $60440 m0 *1 902.72,710.64
X$60440 14073 7551 5689 7742 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $60443 m0 *1 875.84,710.64
X$60443 14074 14073 5689 7633 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60481 m0 *1 1083.04,609.84
X$60481 14074 14073 6173 5768 5695 5694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60491 r0 *1 1057.84,589.68
X$60491 14074 5942 14073 5929 5926 5695 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60496 r0 *1 1121.12,650.16
X$60496 14074 14073 6808 6452 5695 6537 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60498 m0 *1 1135.68,640.08
X$60498 14074 6641 5763 6540 6630 5695 6452 6632 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60500 r0 *1 1130.64,650.16
X$60500 14074 14073 6807 6631 5695 6540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60502 r0 *1 1125.6,619.92
X$60502 14074 14073 6367 6176 5695 5931 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60505 r0 *1 1017.52,670.32
X$60505 14074 14073 7046 5695 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60510 r0 *1 1076.32,650.16
X$60510 14074 14073 6805 6734 5695 6732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60512 r0 *1 1052.8,660.24
X$60512 14074 14073 6969 6811 5695 6887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60518 r0 *1 1080.8,630
X$60518 14074 14073 6550 6535 5695 6536 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60520 m0 *1 1087.52,630
X$60520 14073 5851 5695 14074 5767 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60522 m0 *1 1052.8,680.4
X$60522 14074 14073 7047 6888 5695 7048 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60567 r0 *1 1132.32,640.08
X$60567 14074 6628 5695 6631 6630 5763 6540 6452 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60569 r0 *1 1141.28,650.16
X$60569 5851 14073 5695 6540 14074 6809 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60572 r0 *1 1140.72,660.24
X$60572 5851 14073 5695 6976 14074 7060 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60574 m0 *1 1127.28,650.16
X$60574 14074 14073 5695 5849 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60576 m0 *1 1141.28,619.92
X$60576 5851 14073 5695 6095 14074 6178 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60578 m0 *1 1130.08,609.84
X$60578 14074 6099 5763 6095 6175 5695 6176 6181 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60580 r0 *1 1126.72,609.84
X$60580 14074 6185 5695 6177 6175 5763 6095 6176 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60582 m0 *1 1131.76,619.92
X$60582 14074 14073 6015 6177 5695 6095 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60584 r0 *1 1123.36,670.32
X$60584 14074 7184 5695 7058 6451 5763 7056 6976 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60586 m0 *1 1122.24,680.4
X$60586 14074 7185 5695 7056 7174 5763 6976 6451 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60592 r0 *1 1071.28,640.08
X$60592 14074 14073 5763 6174 5695 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60594 r0 *1 1078,640.08
X$60594 14074 6626 5763 6732 6534 5695 6535 6733 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60596 m0 *1 1108.8,680.4
X$60596 14074 14073 5695 7054 6451 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60600 r0 *1 1099.28,670.32
X$60600 5851 14073 5695 6732 14074 6975 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60603 r0 *1 1075.2,670.32
X$60603 5851 14073 5695 7048 14074 7171 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60606 r0 *1 1050,670.32
X$60606 14074 7076 5763 7048 6982 5695 6811 7170 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60608 m0 *1 1051.12,670.32
X$60608 14074 6970 5695 6888 6982 5763 7048 6811 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60610 m0 *1 1076.32,650.16
X$60610 14074 6740 5695 6734 6534 5763 6732 6535 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $60613 r0 *1 1134,589.68
X$60613 14074 14073 5930 5769 5695 5699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $60619 r0 *1 1149.68,579.6
X$60619 14074 5698 14073 5770 5696 5767 5771 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $60623 r0 *1 1141.28,569.52
X$60623 14074 5766 14073 5762 5696 5758 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60639 m0 *1 1139.6,589.68
X$60639 5767 5699 5935 5766 5758 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $60673 r0 *1 213.36,589.68
X$60673 14073 5705 14074 5815 5946 5894 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $60726 m0 *1 854,811.44
X$60726 14074 14073 9353 5714 7887 8868 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $60729 m0 *1 776.16,821.52
X$60729 14074 14073 5714 9500 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60743 m0 *1 518.56,680.4
X$60743 14073 6756 14074 7021 6783 7210 5716 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $60789 r0 *1 399.28,700.56
X$60789 14073 5720 7658 14074 7518 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $60791 m0 *1 394.8,700.56
X$60791 14073 5720 7517 14074 7583 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60793 r0 *1 432.88,710.64
X$60793 14074 14073 5720 7751 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60804 m0 *1 101.92,730.8
X$60804 14074 8169 5722 7822 7936 6326 6223 7765 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $60807 r0 *1 90.72,589.68
X$60807 14074 14073 5722 5937 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60810 r0 *1 94.08,589.68
X$60810 14074 14073 5723 6018 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $60830 r0 *1 295.12,690.48
X$60830 14074 14073 7426 7487 5727 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $60903 r0 *1 311.92,750.96
X$60903 14073 8357 5727 14074 8419 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60908 m0 *1 310.8,801.36
X$60908 14074 14073 9047 5727 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $60921 m0 *1 282.24,670.32
X$60921 14074 6774 14073 7083 5727 6934 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $60932 m0 *1 276.08,771.12
X$60932 14073 8548 5727 14074 8549 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $60937 m0 *1 205.52,851.76
X$60937 14074 9647 14073 5812 10001 5727 9752 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $60971 r0 *1 350,589.68
X$60971 5730 14073 5732 5733 14074 5827 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $60973 r0 *1 374.08,579.6
X$60973 14073 5730 5735 14074 5788 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $60990 m0 *1 345.52,579.6
X$60990 5732 14074 5826 14073 5786 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $61005 r0 *1 456.96,599.76
X$61005 14074 14073 5733 6419 6060 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $61007 m0 *1 366.8,599.76
X$61007 14073 5733 5828 14074 5987 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $61011 m0 *1 363.44,589.68
X$61011 5733 14074 5828 14073 5955 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $61028 m0 *1 813.68,932.4
X$61028 14074 10581 14073 11210 10482 5737 11119 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $61030 m0 *1 806.4,922.32
X$61030 14074 14073 11118 5737 10395 6959 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61032 r0 *1 967.68,680.4
X$61032 14074 7044 14087 5737 6909 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $61034 m0 *1 986.16,700.56
X$61034 14074 7556 14086 5737 7148 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $61036 m0 *1 927.92,650.16
X$61036 14074 14073 6623 5737 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $61039 r0 *1 784.56,700.56
X$61039 14074 14073 7542 5737 7038 7390 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61067 r0 *1 561.68,851.76
X$61067 14074 9846 14073 7101 10103 6343 5737 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61070 r0 *1 995.12,680.4
X$61070 7371 14074 14073 5737 6909 7259 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $61073 m0 *1 987.28,680.4
X$61073 7165 14074 14073 5737 7148 14089 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $61075 r0 *1 819.84,821.52
X$61075 14074 14073 9462 9609 9349 5737 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61093 m0 *1 353.36,801.36
X$61093 14074 14073 9050 5793 8921 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61096 m0 *1 352.24,811.44
X$61096 14074 14073 9330 5793 9218 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61098 r0 *1 357.84,801.36
X$61098 14074 14073 9243 5793 8190 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61101 r0 *1 353.36,710.64
X$61101 14074 14073 7689 5793 7607 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61103 m0 *1 355.6,730.8
X$61103 14074 14073 7949 5793 7436 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61105 r0 *1 416.08,801.36
X$61105 14074 14073 5738 8940 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61107 m0 *1 410.48,811.44
X$61107 14074 14073 9244 5793 9245 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61109 m0 *1 352.8,761.04
X$61109 14074 14073 8360 5793 8422 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61111 m0 *1 422.24,791.28
X$61111 14074 14073 8943 5793 8946 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61113 m0 *1 407.12,771.12
X$61113 14074 14073 8639 5793 8093 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61115 r0 *1 376.88,801.36
X$61115 14074 14073 9140 5793 7606 5738 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61153 r0 *1 570.64,821.52
X$61153 14074 6788 14073 9415 9628 9404 9449 5740
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $61165 m0 *1 564.48,690.48
X$61165 5740 14073 7302 6246 14074 7207 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61177 m0 *1 592.48,609.84
X$61177 14074 5875 5742 14073 6150 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $61180 r0 *1 591.36,599.76
X$61180 14074 6151 5994 5910 5742 5875 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $61183 r0 *1 591.36,589.68
X$61183 14074 6044 5742 5910 5994 5875 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $61205 r0 *1 1120,579.6
X$61205 14073 5763 14074 5857 5855 5746 5762 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $61210 m0 *1 1042.16,589.68
X$61210 14074 14073 5747 5781 5851 5859 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61216 r0 *1 635.04,619.92
X$61216 14073 6394 6380 5748 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $61277 m0 *1 1089.76,589.68
X$61277 14074 14073 6271 5850 5758 5938 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61279 m0 *1 1050.56,589.68
X$61279 14074 5928 5849 5858 5758 6010 5929 5859 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $61282 r0 *1 1140.72,619.92
X$61282 14074 14073 6098 6369 5758 6370 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61284 r0 *1 1031.52,619.92
X$61284 14073 5758 6378 14074 6379 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $61286 m0 *1 1042.72,630
X$61286 14074 6171 14073 6454 6172 5758 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $61309 r0 *1 1037.12,619.92
X$61309 6103 5758 6268 6286 6094 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $61311 r0 *1 1030.96,630
X$61311 6196 5758 6171 6555 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $61313 r0 *1 1040.48,630
X$61313 6093 5758 6171 6532 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $61315 m0 *1 1029.84,599.76
X$61315 14074 6171 14073 6037 5764 5758 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $61317 r0 *1 1050,630
X$61317 14074 14073 5758 6533 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $61319 m0 *1 1070.72,619.92
X$61319 14074 5758 14073 6017 6094 6270 6453 5944
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $61321 m0 *1 1095.92,630
X$61321 14074 14073 6010 5944 5758 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $61323 r0 *1 1104.32,599.76
X$61323 14074 6099 14073 5758 6094 6016 5945 5944
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $61329 r0 *1 1104.88,589.68
X$61329 14074 5758 14073 5765 6094 5853 5837 5944
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $61345 r0 *1 1091.44,589.68
X$61345 5763 14073 5849 5760 14074 5939 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61349 m0 *1 1120.56,589.68
X$61349 14073 5763 14074 5761 5855 5849 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61361 r0 *1 1142.4,589.68
X$61361 5763 14073 5849 5769 14074 5935 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61363 m0 *1 1029.28,619.92
X$61363 14074 14073 6378 6269 5763 6011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61365 m0 *1 1013.04,680.4
X$61365 14074 14073 7168 5763 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $61370 m0 *1 1040.48,670.32
X$61370 14074 14073 6983 7047 5763 6969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61373 r0 *1 1103.2,650.16
X$61373 14074 14073 6806 6807 5763 6808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61375 m0 *1 1074.64,609.84
X$61375 14074 14073 6172 5941 5763 6173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61377 r0 *1 1108.24,619.92
X$61377 14074 14073 6373 6015 5763 6367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61379 m0 *1 1065.68,650.16
X$61379 14074 14073 6741 6805 5763 6550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61417 m0 *1 1138.48,670.32
X$61417 5763 14073 5849 7056 14074 7059 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61420 r0 *1 1135.68,660.24
X$61420 14073 5763 5849 14074 5770 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $61422 r0 *1 1138.48,630
X$61422 5763 14073 5849 6631 14074 6538 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61425 r0 *1 1145.76,609.84
X$61425 5763 14073 5849 6177 14074 6179 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61429 r0 *1 1116.08,599.76
X$61429 14073 14074 6174 6372 6098 5763 6101 6187
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $61440 r0 *1 1069.04,670.32
X$61440 5763 14073 5849 6888 14074 7051 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61444 r0 *1 1111.6,660.24
X$61444 14074 14073 5763 5851 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61447 m0 *1 1098.16,670.32
X$61447 5763 14073 5849 6734 14074 6974 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $61466 m0 *1 1135.68,690.48
X$61466 14074 7174 14073 5770 7365 5767 7177 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61480 r0 *1 1148.56,650.16
X$61480 14074 6632 14073 5770 6738 5767 6810 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61482 m0 *1 1128.4,670.32
X$61482 14074 5767 14073 7056 7057 7058 5849 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61484 r0 *1 1149.12,619.92
X$61484 14074 6181 14073 5770 6369 5767 6274 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61486 r0 *1 1144.64,670.32
X$61486 14074 7177 14073 5770 7062 5767 7263 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61489 r0 *1 1088.64,680.4
X$61489 14074 6733 14073 5770 6973 5767 7262 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61491 r0 *1 1081.36,670.32
X$61491 14074 7170 14073 5770 7070 5767 7261 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $61509 r0 *1 1098.72,619.92
X$61509 14074 14073 5768 6374 6366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $61547 m0 *1 1173.2,630
X$61547 5772 14073 14074 6537 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61550 r0 *1 1178.24,619.92
X$61550 5773 14073 14074 6631 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61553 r0 *1 1181.6,630
X$61553 5774 14073 14074 6540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61558 m0 *1 1181.6,630
X$61558 5775 14073 14074 6452 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $61574 m0 *1 141.68,599.76
X$61574 14074 14073 6019 5779 5812 6020 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61581 m0 *1 148.4,619.92
X$61581 14074 6319 6127 5779 6223 6224 6226 6225 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61619 r0 *1 459.2,589.68
X$61619 14074 14073 5787 6061 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61697 m0 *1 891.52,740.88
X$61697 14073 14074 8250 8079 5798 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $61709 m0 *1 882,680.4
X$61709 14074 14073 5798 7038 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $61726 m0 *1 669.76,589.68
X$61726 14074 5802 6262 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $61767 m0 *1 682.08,982.8
X$61767 14074 14073 10482 11890 5805 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $61789 r0 *1 1079.12,730.8
X$61789 14074 8062 5806 7478 7640 7548 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61791 r0 *1 1062.88,730.8
X$61791 14074 8074 5806 7551 7906 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $61794 m0 *1 1084.72,720.72
X$61794 14074 7815 7478 7164 7640 7237 5806 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61796 m0 *1 1075.76,710.64
X$61796 14074 7724 7554 7164 5806 7237 7548 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61798 m0 *1 1098.16,740.88
X$61798 14074 14073 8071 8165 7162 5806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61802 m0 *1 584.64,740.88
X$61802 14073 5806 8201 14074 8199 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $61804 r0 *1 577.92,720.72
X$61804 14074 7756 14073 7875 5806 7239 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $61806 m0 *1 38.64,589.68
X$61806 14074 14073 5807 5933 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $61813 m0 *1 74.48,599.76
X$61813 14074 14073 5809 5980 5973 5810 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61816 m0 *1 65.52,942.48
X$61816 14074 11483 10114 5810 10115 11143 11028 11084 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61829 r0 *1 83.44,589.68
X$61829 14074 5981 14073 5811 5976 5937 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $61831 r0 *1 328.72,801.36
X$61831 14074 14073 9212 9048 5812 9139 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61834 m0 *1 283.92,771.12
X$61834 14074 14073 8694 8634 5812 8605 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61837 m0 *1 338.8,771.12
X$61837 14074 14073 8457 8456 5812 8700 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61839 r0 *1 312.48,700.56
X$61839 14074 14073 7605 7516 5812 7579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61841 m0 *1 292.32,599.76
X$61841 14074 14073 6034 5821 5812 6035 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61843 m0 *1 323.12,670.32
X$61843 14074 14073 6937 6859 5812 7086 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61846 m0 *1 212.8,660.24
X$61846 14074 14073 6904 6857 5812 6905 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61851 r0 *1 254.24,700.56
X$61851 14074 14073 7513 7422 5812 7514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61854 m0 *1 274.4,680.4
X$61854 14074 14073 7194 7015 5812 7227 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61856 m0 *1 115.92,609.84
X$61856 14074 14073 6188 6121 5812 6189 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61858 m0 *1 277.76,630
X$61858 14074 14073 6324 6325 5812 6465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61901 m0 *1 222.32,710.64
X$61901 14074 14073 7649 7482 5812 7511 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61903 r0 *1 333.76,821.52
X$61903 14074 5812 9543 9653 9138 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $61905 m0 *1 150.08,599.76
X$61905 14074 14073 5812 5976 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $61911 m0 *1 179.2,589.68
X$61911 14073 5813 14074 5815 5860 5816 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61925 m0 *1 164.64,599.76
X$61925 14074 14073 5890 6021 5984 5814 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $61927 r0 *1 169.68,892.08
X$61927 14074 10774 10114 5814 10260 10113 10716 10773 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $61930 m0 *1 330.4,811.44
X$61930 14073 8847 14074 5815 9139 8941 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61932 m0 *1 322,771.12
X$61932 14073 8699 14074 5815 8700 8551 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61934 r0 *1 311.36,589.68
X$61934 14073 5822 14074 5815 6036 5823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61936 m0 *1 301.84,589.68
X$61936 14073 5867 14074 5815 6035 5823 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61938 r0 *1 50.4,851.76
X$61938 14073 9980 14074 5815 10196 7006 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61941 r0 *1 30.8,821.52
X$61941 14073 9421 14074 5815 9693 6680 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61943 r0 *1 107.52,781.2
X$61943 14073 8838 14074 5815 8894 7311 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61945 m0 *1 31.36,781.2
X$61945 14073 8837 14074 5815 8886 8719 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61947 m0 *1 75.04,851.76
X$61947 14073 9930 14074 5815 10086 7596 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61950 r0 *1 137.76,851.76
X$61950 14073 10026 14074 5815 10111 7771 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61952 m0 *1 304.64,730.8
X$61952 14073 7947 14074 5815 8009 7283 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61954 r0 *1 320.88,690.48
X$61954 14073 7316 14074 5815 7579 7085 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61956 r0 *1 320.88,740.88
X$61956 14073 7866 14074 5815 8182 8223 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61958 r0 *1 325.36,670.32
X$61958 14073 6861 14074 5815 7086 7115 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61960 m0 *1 309.68,670.32
X$61960 14073 7083 14074 5815 7084 7085 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61962 r0 *1 213.36,650.16
X$61962 14073 6769 14074 5815 6905 6685 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61965 r0 *1 151.2,589.68
X$61965 14073 5940 14074 5815 6020 5889 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61969 r0 *1 147.28,801.36
X$61969 14073 9130 14074 5815 9236 8446 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61973 m0 *1 247.52,599.76
X$61973 14073 5864 14074 5815 6029 6031 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61975 r0 *1 192.08,801.36
X$61975 14073 9291 14074 5815 9290 8027 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61978 r0 *1 277.2,680.4
X$61978 14073 7114 14074 5815 7227 7283 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61981 m0 *1 124.32,609.84
X$61981 14073 6122 14074 5815 6189 6123 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61983 m0 *1 181.44,851.76
X$61983 14073 9830 14074 5815 9997 7198 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61985 m0 *1 223.44,700.56
X$61985 14073 7510 14074 5815 7511 7230 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61987 m0 *1 29.68,730.8
X$61987 14073 7933 14074 5815 7900 7935 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61990 m0 *1 168,791.28
X$61990 14073 8995 14074 5815 9199 8805 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61992 m0 *1 281.68,619.92
X$61992 14073 6287 14074 5815 6465 6235 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $61994 m0 *1 36.96,690.48
X$61994 14073 7364 14074 5815 7267 7221 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $62037 r0 *1 330.96,811.44
X$62037 14074 14073 9138 5815 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62039 r0 *1 309.68,761.04
X$62039 14074 5815 14073 6232 6492 8696 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62041 r0 *1 50.96,589.68
X$62041 14074 14073 5815 5974 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62044 r0 *1 428.96,791.28
X$62044 14074 14073 9055 5816 8944 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62048 r0 *1 170.24,599.76
X$62048 14074 6193 14073 6049 6107 6126 6194 5816
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $62080 m0 *1 239.68,700.56
X$62080 14074 14073 7574 7512 6413 5819 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62090 m0 *1 253.68,680.4
X$62090 14074 14073 7192 7281 6413 5820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62104 m0 *1 305.76,619.92
X$62104 14074 5821 14073 6223 6414 6326 6053 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62113 m0 *1 330.96,982.8
X$62113 14074 14073 12100 5823 11867 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $62126 r0 *1 393.68,861.84
X$62126 14073 10125 14074 10102 5823 6866 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $62128 r0 *1 308.56,861.84
X$62128 8223 14073 5823 10121 14074 10119 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $62138 r0 *1 331.52,690.48
X$62138 14074 14073 7428 7489 6413 5825 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62157 m0 *1 314.72,609.84
X$62157 14074 14073 6051 5830 6130 6053 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62189 m0 *1 538.16,589.68
X$62189 14073 5880 14074 5906 5879 5833 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $62194 m0 *1 546,630
X$62194 5968 5833 6339 6427 14073 14074 6426 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $62196 m0 *1 553.84,630
X$62196 14074 6472 6427 14073 6339 5968 5833 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $62204 m0 *1 717.92,599.76
X$62204 14074 6001 14073 6038 6037 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62208 r0 *1 629.44,650.16
X$62208 14074 14073 6711 6737 5835 6918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62210 r0 *1 558.88,902.16
X$62210 10972 5835 10791 11174 14073 14074 6924 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $62212 r0 *1 569.52,750.96
X$62212 7161 14073 14074 5835 8359 9031 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $62215 r0 *1 688.8,589.68
X$62215 14074 5963 14073 5964 5945 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62218 r0 *1 633.36,589.68
X$62218 14074 7340 14073 5965 5837 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62221 m0 *1 954.8,650.16
X$62221 14074 6731 14073 6803 6453 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62225 m0 *1 557.76,851.76
X$62225 6847 14073 14074 5835 9836 10014 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $62229 m0 *1 581.84,861.84
X$62229 10039 10052 10102 5876 5835 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $62277 r0 *1 582.4,821.52
X$62277 14074 5835 14073 9516 9449 9666 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62279 r0 *1 963.2,640.08
X$62279 14074 6655 14073 6656 6286 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62281 m0 *1 990.64,670.32
X$62281 14074 7045 14073 6985 6971 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62283 m0 *1 999.04,640.08
X$62283 14074 6625 14073 6531 6454 5835 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62285 m0 *1 616,902.16
X$62285 14074 6394 10870 5835 10786 8845 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $62287 r0 *1 623.28,912.24
X$62287 14074 7253 11105 11002 5835 10935 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $62291 m0 *1 555.52,619.92
X$62291 14074 14073 6300 5835 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62297 m0 *1 962.64,690.48
X$62297 14074 14073 7378 7375 5836 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62312 m0 *1 968.8,690.48
X$62312 14073 7555 7374 5836 7477 7375 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $62314 m0 *1 982.24,680.4
X$62314 14073 7165 5836 14074 7257 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62364 m0 *1 904.4,690.48
X$62364 14074 14073 5844 7280 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62412 m0 *1 1126.16,630
X$62412 14074 14073 5849 6187 6176 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62415 r0 *1 1092.56,619.92
X$62415 14073 5851 5849 14074 6366 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62417 r0 *1 1070.16,660.24
X$62417 5851 14073 5849 6811 14074 7050 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $62419 m0 *1 1106,670.32
X$62419 14073 14074 7053 5851 6977 5849 6979 7052
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $62425 r0 *1 1065.12,589.68
X$62425 5849 14073 6013 6012 14074 5942 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $62433 m0 *1 1116.64,599.76
X$62433 14074 14073 6016 6015 5851 6367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62435 r0 *1 1067.92,650.16
X$62435 14074 14073 6627 6805 5851 6550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62437 r0 *1 1111.6,650.16
X$62437 14074 14073 6736 6807 5851 6808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62439 r0 *1 1076.88,609.84
X$62439 14074 14073 6270 5941 5851 6173 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62441 m0 *1 1046.08,619.92
X$62441 14074 14073 6283 6269 5851 6011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62443 m0 *1 1042.72,680.4
X$62443 14074 14073 7191 7047 5851 6969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62483 r0 *1 1098.72,589.68
X$62483 14074 14073 5938 5939 5852 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $62487 m0 *1 1064,599.76
X$62487 14074 14073 6013 5854 6010 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62499 m0 *1 1118.32,670.32
X$62499 14074 7174 14073 5854 7186 7058 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62501 m0 *1 1118.32,640.08
X$62501 14074 6630 14073 5854 6629 6537 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62504 r0 *1 1116.64,619.92
X$62504 14074 6175 14073 5854 6372 5931 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62507 m0 *1 1062.88,660.24
X$62507 14074 6982 14073 5854 6895 6887 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62510 m0 *1 1081.92,640.08
X$62510 14074 6534 14073 5854 6819 6536 6010 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62512 m0 *1 1082.48,670.32
X$62512 14074 6094 14073 6971 5854 6979 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62567 m0 *1 290.64,650.16
X$62567 14074 14073 6412 6691 5984 5868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62574 m0 *1 287.28,871.92
X$62574 14074 10341 10114 5868 10115 10113 10320 10268 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $62600 m0 *1 341.6,630
X$62600 14074 14073 5873 9763 6469 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62645 r0 *1 2.24,599.76
X$62645 5881 14073 14074 6573 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62648 m0 *1 29.12,609.84
X$62648 5882 14073 14074 6313 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $62656 m0 *1 42,599.76
X$62656 5974 5971 5976 5884 5933 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $62658 r0 *1 43.68,589.68
X$62658 14074 5884 14073 5934 5976 5936 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62668 r0 *1 74.48,730.8
X$62668 14074 8283 5885 7856 7936 7989 6223 8073 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $62671 r0 *1 54.32,589.68
X$62671 14074 14073 5885 5936 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62691 m0 *1 430.64,670.32
X$62691 14074 14073 5888 7020 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62693 m0 *1 378,650.16
X$62693 14074 14073 5888 6696 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62695 r0 *1 398.72,771.12
X$62695 14073 8093 14074 8628 8639 5889 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $62700 m0 *1 132.16,609.84
X$62700 14074 6191 14073 6049 6124 6126 6125 5889
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $62715 m0 *1 400.96,1002.96
X$62715 5889 12210 12256 12338 12339 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $62721 m0 *1 201.6,599.76
X$62721 14074 14073 5892 6025 5984 5893 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62731 r0 *1 197.68,871.92
X$62731 14074 10375 10114 5893 10260 10113 10370 10455 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $62739 m0 *1 459.2,1053.36
X$62739 5894 11713 12954 13096 13097 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $62742 m0 *1 460.88,861.84
X$62742 14074 10034 10132 14073 5894 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $62769 m0 *1 276.08,1063.44
X$62769 12349 5894 13172 13118 13173 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $62776 r0 *1 303.52,609.84
X$62776 14074 14073 6204 5897 6232 6036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62781 r0 *1 301.84,630
X$62781 14074 6491 14073 6410 6558 6492 5897 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $62783 m0 *1 337.68,791.28
X$62783 14074 14073 9049 9015 6413 5898 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62798 r0 *1 453.6,599.76
X$62798 14074 14073 5901 6115 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62807 m0 *1 505.68,932.4
X$62807 14074 14073 11193 8949 5903 11194 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62809 m0 *1 504,942.48
X$62809 14074 14073 11361 9411 5903 11345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62823 r0 *1 491.68,922.32
X$62823 14074 5903 14073 11175 9615 9659 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $62825 r0 *1 491.12,932.4
X$62825 14074 14073 5903 11289 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62833 r0 *1 582.4,740.88
X$62833 14073 8131 8135 14074 5905 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62861 r0 *1 575.68,609.84
X$62861 14073 5909 5908 14074 6248 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62863 r0 *1 580.72,609.84
X$62863 14074 14073 5909 6249 5908 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $62900 m0 *1 959.28,680.4
X$62900 14074 14073 7260 7256 5911 7277 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $62947 r0 *1 846.72,589.68
X$62947 14074 14073 5954 5918 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $62949 m0 *1 848.96,599.76
X$62949 14073 5918 6028 14074 6005 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62952 m0 *1 840.56,599.76
X$62952 14074 14073 5918 6030 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62968 r0 *1 890.4,670.32
X$62968 14074 14073 5921 7150 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62977 m0 *1 986.16,730.8
X$62977 14074 14073 5923 7969 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $62979 m0 *1 982.8,720.72
X$62979 14073 5923 7551 14074 7825 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $62996 r0 *1 1048.32,589.68
X$62996 14074 6010 14073 5927 5928 5926 5944 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $63075 r0 *1 1107.12,680.4
X$63075 14074 14073 7052 7057 5944 7365 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63077 r0 *1 1058.96,640.08
X$63077 14074 6533 14073 6626 6094 6627 6742 5944
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $63098 m0 *1 1037.68,619.92
X$63098 14073 5944 6283 14074 6268 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63100 r0 *1 1037.68,670.32
X$63100 14074 5944 14073 7191 6094 7076 6963 6533
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $63102 r0 *1 1064,599.76
X$63102 14074 14073 5944 6013 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63108 m0 *1 1106,650.16
X$63108 14074 5944 14073 6736 6094 6641 6703 6533
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $63171 m0 *1 342.16,811.44
X$63171 14073 8190 14074 9292 9243 8027 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63173 m0 *1 347.76,801.36
X$63173 14074 14073 9109 5958 9050 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63176 r0 *1 352.24,811.44
X$63176 14073 9218 14074 9331 9330 8446 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63178 r0 *1 346.64,811.44
X$63178 14074 14073 9319 5958 9330 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63180 m0 *1 361.76,811.44
X$63180 14074 14073 9401 5958 9243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63183 r0 *1 348.88,791.28
X$63183 14073 8921 14074 9041 9050 8719 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63185 r0 *1 419.44,781.2
X$63185 14074 14073 8910 5958 8943 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63187 r0 *1 346.64,750.96
X$63187 14073 8422 14074 8359 8360 7935 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63189 m0 *1 347.2,771.12
X$63189 14074 14073 8698 5958 8360 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63192 r0 *1 408.8,771.12
X$63192 14074 14073 8736 5958 8639 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63194 m0 *1 380.24,811.44
X$63194 14074 14073 9333 5958 9140 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63198 r0 *1 370.72,821.52
X$63198 14073 7606 14074 9545 9140 6123 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63200 r0 *1 406,821.52
X$63200 14073 9245 14074 9548 9244 8941 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63202 r0 *1 346.08,720.72
X$63202 14073 7607 14074 7764 7689 7221 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63204 r0 *1 347.76,710.64
X$63204 14074 14073 7773 5958 7689 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63206 r0 *1 357.28,730.8
X$63206 14074 14073 8119 5958 7949 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63208 m0 *1 345.52,730.8
X$63208 14073 7436 14074 7830 7949 7230 5958 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63210 m0 *1 416.64,821.52
X$63210 14074 14073 9515 5958 9244 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63234 m0 *1 418.88,791.28
X$63234 14074 14073 5958 8914 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63244 m0 *1 485.52,660.24
X$63244 14073 6865 5960 6866 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $63247 r0 *1 477.68,660.24
X$63247 14074 6701 14073 7123 6865 5960 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63276 r0 *1 630,871.92
X$63276 10267 6246 10391 10440 14074 14073 5963 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $63291 r0 *1 552.16,619.92
X$63291 14074 6339 14073 5967 6396 6571 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63300 r0 *1 552.16,630
X$63300 5968 14074 6427 6338 14073 6571 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $63302 m0 *1 561.12,640.08
X$63302 14073 5968 14074 6507 6396 6508 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $63304 r0 *1 574,640.08
X$63304 14074 14073 6705 5968 6342 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63306 m0 *1 574.56,650.16
X$63306 14074 5968 6604 14073 6706 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $63308 r0 *1 568.4,630
X$63308 5968 14074 6342 6427 14073 6509 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $63333 r0 *1 26.88,609.84
X$63333 5969 14073 14074 6218 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63343 r0 *1 73.36,720.72
X$63343 14074 14073 7902 5971 7763 7856 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63345 r0 *1 92.4,740.88
X$63345 14074 14073 8208 5971 8110 8209 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63347 m0 *1 58.8,982.8
X$63347 14074 14073 11916 5971 10371 11857 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63351 r0 *1 35.28,922.32
X$63351 14074 14073 11231 5971 10345 11177 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63354 r0 *1 35.28,599.76
X$63354 14074 14073 6100 5971 5973 5972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63385 r0 *1 180.32,1073.52
X$63385 14074 11952 14073 13407 13265 12349 5971
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $63387 m0 *1 106.96,1103.76
X$63387 14074 12115 14073 13590 13551 12116 5971
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $63389 m0 *1 430.64,781.2
X$63389 14074 14073 8912 5971 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63392 r0 *1 353.36,690.48
X$63392 14074 7490 14073 7187 7430 5971 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63394 r0 *1 55.44,1093.68
X$63394 14074 13404 14073 12104 13489 5971 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $63397 r0 *1 432.88,1103.76
X$63397 14074 14073 11794 13478 5971 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63408 m0 *1 34.16,922.32
X$63408 14074 11082 10114 5972 10115 11143 11142 11177 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $63412 r0 *1 110.88,912.24
X$63412 14074 14073 11038 10875 5973 7736 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63414 m0 *1 136.64,902.16
X$63414 14074 14073 10771 9532 5973 8541 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63416 r0 *1 33.04,831.6
X$63416 14074 14073 9524 9423 5973 9525 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63419 r0 *1 46.48,831.6
X$63419 14074 14073 9314 9514 5973 9636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63422 r0 *1 76.16,912.24
X$63422 14074 14073 10769 10645 5973 8929 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63424 m0 *1 126.56,892.08
X$63424 14074 14073 10548 10549 5973 10550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63428 m0 *1 258.72,922.32
X$63428 14074 14073 6907 11091 5973 6773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63430 m0 *1 180.32,831.6
X$63430 14074 14073 9604 8726 5973 9239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63432 m0 *1 39.76,640.08
X$63432 14074 14073 6482 6575 5973 6483 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63434 r0 *1 152.32,871.92
X$63434 14074 14073 10112 9433 5973 9383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63436 r0 *1 255.36,680.4
X$63436 14074 14073 7281 7226 5973 7014 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63438 m0 *1 165.76,861.84
X$63438 14074 14073 10210 7074 5973 9829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63441 r0 *1 218.4,720.72
X$63441 14074 14073 7828 7941 5973 7420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63444 r0 *1 277.2,781.2
X$63444 14074 14073 8904 8547 5973 8844 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63446 m0 *1 341.6,922.32
X$63446 14073 9543 11093 14074 5973 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63448 m0 *1 337.12,912.24
X$63448 14074 14073 9015 11058 5973 8906 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63450 r0 *1 30.24,740.88
X$63450 14074 14073 8277 8202 5973 8107 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63453 m0 *1 34.72,710.64
X$63453 14074 14073 7500 7673 5973 7590 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63501 r0 *1 184.24,599.76
X$63501 14074 14073 5973 5984 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63503 m0 *1 38.08,791.28
X$63503 14074 14073 8926 8980 5973 8927 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63523 m0 *1 259.84,710.64
X$63523 14074 14073 7603 7423 5974 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63525 m0 *1 30.24,640.08
X$63525 5974 6575 5976 6637 6314 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $63527 m0 *1 84.56,599.76
X$63527 5974 5980 5976 5981 6018 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $63531 r0 *1 265.44,761.04
X$63531 14073 8547 5974 14074 8354 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63537 m0 *1 45.92,609.84
X$63537 14074 14073 5975 6102 6118 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63539 m0 *1 26.88,841.68
X$63539 14074 14073 9797 9527 5976 9693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63541 m0 *1 131.04,871.92
X$63541 14074 14073 10330 8343 5976 10111 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63544 r0 *1 26.32,781.2
X$63544 14074 14073 8885 8836 5976 8886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63547 r0 *1 105.28,771.12
X$63547 14074 14073 8795 7860 5976 8894 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63549 r0 *1 39.2,861.84
X$63549 14074 14073 10107 9929 5976 10196 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63551 m0 *1 145.6,811.44
X$63551 14074 14073 9235 9038 5976 9236 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63554 r0 *1 25.76,720.72
X$63554 14074 14073 7853 7854 5976 7900 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63556 m0 *1 33.04,680.4
X$63556 14074 14073 7105 7217 5976 7267 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63558 m0 *1 157.36,801.36
X$63558 14074 14073 9040 9042 5976 9199 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63605 r0 *1 168,851.76
X$63605 14074 14073 9994 9828 5976 9997 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63608 m0 *1 64.96,871.92
X$63608 14074 14073 10023 8682 5976 10086 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63613 r0 *1 35.84,640.08
X$63613 14074 6637 14073 6636 5976 6678 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63615 m0 *1 166.88,811.44
X$63615 14074 14073 9289 9238 5976 9290 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63622 r0 *1 57.12,609.84
X$63622 14074 5977 14073 6184 6049 6104 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63625 m0 *1 20.72,609.84
X$63625 6116 14073 14074 5978 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63641 r0 *1 211.12,771.12
X$63641 14074 14073 8696 5979 8211 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63666 r0 *1 101.92,720.72
X$63666 14074 14073 7904 5980 7763 7822 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63668 m0 *1 68.32,922.32
X$63668 14074 14073 11083 5980 10345 11084 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63671 r0 *1 61.6,1083.6
X$63671 14074 13259 14073 12104 13255 5980 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $63673 m0 *1 338.24,730.8
X$63673 14074 8011 14073 7938 7430 5980 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63676 m0 *1 72.8,750.96
X$63676 14074 14073 8205 5980 8110 8336 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63678 r0 *1 75.6,952.56
X$63678 14074 14073 11591 5980 10371 11521 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63682 r0 *1 459.76,781.2
X$63682 14074 14073 8915 5980 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63717 m0 *1 184.24,1053.36
X$63717 14073 5980 12349 14074 12978 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63719 r0 *1 127.68,1083.6
X$63719 14074 13378 14073 13435 12116 5980 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63721 r0 *1 358.4,1063.44
X$63721 14074 14073 13346 12209 5980 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $63726 r0 *1 11.76,599.76
X$63726 6048 14073 14074 5982 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $63736 r0 *1 334.32,771.12
X$63736 14074 14073 8701 8732 5984 8733 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63739 m0 *1 329.84,710.64
X$63739 14074 14073 7489 7317 5984 7431 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63743 r0 *1 332.64,650.16
X$63743 14074 14073 6830 6771 5984 6694 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63745 m0 *1 143.36,660.24
X$63745 14074 14073 6580 6898 5984 6406 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63749 m0 *1 183.12,660.24
X$63749 14074 14073 6854 6488 5984 6855 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63753 m0 *1 240.8,710.64
X$63753 14074 14073 7512 7603 5984 7602 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63755 m0 *1 122.64,630
X$63755 14074 14073 6375 6405 5984 6279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $63784 m0 *1 670.88,660.24
X$63784 6871 14074 6874 14073 5985 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $63786 r0 *1 589.68,821.52
X$63786 14073 9447 14074 7023 7214 9451 5985 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $63798 m0 *1 658.56,630
X$63798 14074 14073 5985 6430 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63802 r0 *1 357.84,599.76
X$63802 14073 5986 6056 14074 6111 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $63808 r0 *1 366.8,619.92
X$63808 14073 5987 6327 14074 6415 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63811 m0 *1 371.84,599.76
X$63811 14074 14073 5988 6041 5987 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63825 m0 *1 450.8,630
X$63825 14074 14073 5988 6563 6060 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63830 r0 *1 348.32,609.84
X$63830 5988 14074 6055 14073 6206 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $63841 r0 *1 449.12,609.84
X$63841 14074 14073 5989 6297 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63855 r0 *1 483.28,650.16
X$63855 14073 6712 6865 6781 5993 6060 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $63872 m0 *1 689.92,599.76
X$63872 5996 5998 5997 5999 14073 14074 6000 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $63875 r0 *1 700,599.76
X$63875 14073 5996 14074 6039 6160 5998 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $63877 m0 *1 692.16,619.92
X$63877 5996 14074 5998 6072 14073 6161 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $63880 r0 *1 671.44,630
X$63880 14074 6349 5996 6569 6516 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $63883 m0 *1 687.12,609.84
X$63883 5996 14074 5998 5997 14073 6071 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $63891 r0 *1 693.84,640.08
X$63891 14073 5996 6348 14074 6613 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63893 r0 *1 686,619.92
X$63893 14074 14073 5996 6435 6348 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $63895 m0 *1 700,619.92
X$63895 14074 14073 5996 6350 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63898 m0 *1 683.76,599.76
X$63898 5996 14073 6072 5999 14074 6042 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $63902 r0 *1 707.84,599.76
X$63902 14073 6072 14074 5999 6073 5997 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $63912 m0 *1 707.84,599.76
X$63912 14073 6072 5997 14074 6039 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63915 r0 *1 684.32,599.76
X$63915 14074 14073 6163 5997 6069 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $63919 r0 *1 763.28,619.92
X$63919 14074 6357 6356 14073 5997 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $63921 r0 *1 750.96,609.84
X$63921 14074 5997 14073 6167 5999 6168 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $63931 r0 *1 710.08,609.84
X$63931 14074 14073 6163 5998 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63936 m0 *1 780.08,640.08
X$63936 14073 6622 6661 5999 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $63945 r0 *1 715.68,599.76
X$63945 14073 6165 5999 14074 6066 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63951 m0 *1 694.4,609.84
X$63951 14074 6210 6161 14073 6000 6160 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $63957 m0 *1 591.36,821.52
X$63957 14074 14073 9516 6001 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63971 m0 *1 848.96,761.04
X$63971 14074 14073 6005 8483 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63974 m0 *1 847.84,710.64
X$63974 14074 14073 6006 7613 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63977 m0 *1 855.68,710.64
X$63977 14074 14073 6006 7714 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $63986 m0 *1 926.8,700.56
X$63986 14073 6007 7551 14074 7553 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $63989 r0 *1 913.36,700.56
X$63989 14074 14073 6007 7646 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $63995 m0 *1 1034.88,609.84
X$63995 6010 14073 6170 6195 14074 6094 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $64049 m0 *1 1019.2,670.32
X$64049 6014 6533 6171 7077 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $64077 m0 *1 431.76,801.36
X$64077 14073 9055 8944 14074 6021 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $64081 r0 *1 173.04,902.16
X$64081 14074 14073 10837 6021 10345 10773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64085 m0 *1 168.56,922.32
X$64085 14074 14073 11151 6021 7763 10978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64087 m0 *1 170.8,932.4
X$64087 14074 14073 11238 6021 10371 11089 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64106 m0 *1 280,1103.76
X$64106 14074 11952 14073 13619 13609 12349 6021
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64108 r0 *1 238,1134
X$64108 14074 12115 14073 13803 13831 12327 6021
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64110 m0 *1 273.28,1164.24
X$64110 14074 12189 14073 6021 13988 12104 13971
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64112 r0 *1 440.72,1093.68
X$64112 14074 11795 14073 13515 13533 6021 11794
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64129 m0 *1 227.92,902.16
X$64129 14074 14073 10842 6025 10371 10653 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64131 m0 *1 232.96,630
X$64131 14074 14073 6230 6025 6409 6231 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64134 m0 *1 201.6,892.08
X$64134 14074 14073 10553 6025 10345 10455 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64158 r0 *1 460.88,871.92
X$64158 14074 14073 6025 10034 10132 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $64160 r0 *1 264.88,1134
X$64160 14074 12115 14073 13765 13696 12116 6025
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64162 r0 *1 244.72,1154.16
X$64162 14074 12189 14073 6025 14009 12104 13934
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64164 m0 *1 225.12,801.36
X$64164 14074 14073 9204 6026 8110 8600 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64166 r0 *1 246.96,630
X$64166 14074 14073 6557 6026 6409 6322 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64170 r0 *1 230.16,871.92
X$64170 14074 14073 10427 6026 10371 10264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64172 m0 *1 228.48,871.92
X$64172 14074 14073 10336 6026 10345 10116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64174 r0 *1 462.56,841.68
X$64174 14073 9772 9773 14074 6026 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $64177 r0 *1 256.48,811.44
X$64177 14073 9325 14074 9324 9394 6026 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $64199 m0 *1 300.72,1164.24
X$64199 14074 12189 14073 6026 14029 12104 13974
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64201 m0 *1 300.72,1144.08
X$64201 14074 12274 14073 13826 13871 12116 6026
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64239 m0 *1 460.32,841.68
X$64239 14074 14073 9772 6031 9773 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64241 m0 *1 257.04,1053.36
X$64241 14073 11860 13040 6031 12982 12995 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $64244 m0 *1 460.88,1043.28
X$64244 14074 12815 14073 12816 12864 6031 12210
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64250 r0 *1 253.68,609.84
X$64250 14074 14073 6201 6033 6130 6133 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64290 m0 *1 677.6,609.84
X$64290 6042 6168 6213 6214 6210 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $64298 r0 *1 628.88,609.84
X$64298 14074 6211 6154 6068 6305 6044 14073 6344
+ gf180mcu_fd_sc_mcu9t5v0__oai32_4
* cell instance $64300 r0 *1 591.92,650.16
X$64300 6706 14074 6308 6044 14073 7214 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $64302 m0 *1 621.04,619.92
X$64302 14074 6068 6311 6067 6044 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $64314 m0 *1 647.36,619.92
X$64314 14073 6044 6155 6067 6251 6068 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $64316 r0 *1 650.16,599.76
X$64316 14073 6044 6110 6067 6069 6068 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $64328 r0 *1 515.76,680.4
X$64328 14073 7410 6047 14074 7300 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $64335 r0 *1 526.4,680.4
X$64335 14074 14073 6047 7238 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $64340 m0 *1 102.48,700.56
X$64340 14074 7416 14073 6049 7566 6126 7565 7311
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64347 r0 *1 234.64,650.16
X$64347 14074 6770 14073 6686 6049 6688 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64394 r0 *1 224,781.2
X$64394 14074 8629 14073 8902 6049 8936 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64396 m0 *1 134.96,710.64
X$64396 14074 7679 14073 6049 7680 6126 7823 7771
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64399 m0 *1 231.28,791.28
X$64399 14074 8630 14073 9005 6049 8935 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64402 r0 *1 182.56,730.8
X$64402 14074 8293 14073 6049 8077 6126 8078 8027
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64405 m0 *1 156.24,781.2
X$64405 14074 8803 14073 6049 8804 6126 8724 8805
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64407 r0 *1 177.52,630
X$64407 14074 6553 14073 6552 6049 6554 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64409 r0 *1 47.04,771.12
X$64409 14074 8681 14073 6049 8680 6126 8791 8719
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64412 m0 *1 219.52,619.92
X$64412 14074 6228 14073 6285 6049 6284 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64414 m0 *1 56,650.16
X$64414 14074 6762 14073 6049 6813 6126 6763 6680
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64417 m0 *1 59.92,670.32
X$64417 14074 7067 14073 6049 7065 6126 7183 7006
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64419 m0 *1 61.6,640.08
X$64419 14074 6638 14073 6639 6049 6640 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64421 m0 *1 56.56,690.48
X$64421 14074 7369 14073 6049 7306 6126 7368 7221
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64423 m0 *1 212.24,690.48
X$64423 14074 7381 14073 6049 7380 6126 7224 7230
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64426 r0 *1 68.88,710.64
X$64426 14074 7675 14073 6049 7734 6126 7674 7596
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64429 m0 *1 50.96,730.8
X$64429 14074 7987 14073 6049 7988 6126 8022 7935
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64431 r0 *1 170.24,670.32
X$64431 14074 7013 14073 7075 6049 7188 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64433 m0 *1 101.36,630
X$64433 14074 6403 14073 6548 6049 6455 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64435 r0 *1 79.52,630
X$64435 14074 6400 14073 6371 6049 6401 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64438 m0 *1 138.88,761.04
X$64438 14074 8506 14073 6049 8504 6126 8505 8446
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64444 m0 *1 201.6,609.84
X$64444 14074 14073 6197 6198 6130 6050 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64448 r0 *1 316.96,710.64
X$64448 14074 7685 6052 14073 7687 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $64461 m0 *1 329.84,609.84
X$64461 14074 14073 6135 6054 6130 6136 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64472 m0 *1 366.8,630
X$64472 14073 6055 6327 14074 6416 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $64474 r0 *1 356.72,619.92
X$64474 14074 14073 6055 6664 6236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64491 r0 *1 884.24,680.4
X$64491 14074 14073 7157 6059 7038 7384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64494 r0 *1 738.08,609.84
X$64494 14074 14073 6260 6059 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $64498 r0 *1 810.88,892.08
X$64498 14074 10581 14073 10582 10482 6059 10802 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64500 r0 *1 1178.8,771.12
X$64500 6059 14073 14074 8679 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64504 r0 *1 817.04,871.92
X$64504 14074 14073 10398 6059 10395 7089 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64544 r0 *1 866.88,821.52
X$64544 14074 14073 9608 9576 9349 6059 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64546 m0 *1 570.08,902.16
X$64546 14074 10675 14073 7101 8131 6343 10893 6059
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $64567 m0 *1 455.84,630
X$64567 14074 14073 6060 6593 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $64597 m0 *1 669.76,851.76
X$64597 14074 14073 6065 7403 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $64599 r0 *1 660.8,841.68
X$64599 14074 9849 6065 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $64606 r0 *1 638.96,599.76
X$64606 14074 14073 6066 6211 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64611 m0 *1 635.6,619.92
X$64611 14073 6066 6429 14074 6309 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $64616 m0 *1 602.56,619.92
X$64616 14074 14073 6250 6067 6307 6304 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $64641 r0 *1 680.4,609.84
X$64641 14074 6069 6302 6567 6159 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $64643 r0 *1 667.52,599.76
X$64643 14074 14073 6069 6158 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64647 m0 *1 669.76,619.92
X$64647 14074 6253 6157 6152 6302 6070 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $64654 r0 *1 670.88,599.76
X$64654 6157 6152 6071 6213 6070 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $64656 m0 *1 657.44,609.84
X$64656 14074 6717 6157 6152 6070 6158 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $64665 r0 *1 717.92,609.84
X$64665 6257 14073 6164 6165 14074 6072 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $64680 m0 *1 703.36,619.92
X$64680 14073 6254 6517 6256 6073 6255 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $64682 r0 *1 720.72,599.76
X$64682 14074 14073 6166 6075 6074 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64686 r0 *1 729.68,640.08
X$64686 14074 14073 6074 6387 6437 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $64689 m0 *1 717.36,619.92
X$64689 14074 6521 6165 6524 6075 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $64806 r0 *1 1038.24,609.84
X$64806 14074 6094 6199 14073 6171 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $64845 r0 *1 1156.96,660.24
X$64845 6096 14073 14074 7058 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64848 r0 *1 1165.36,660.24
X$64848 6097 14073 14074 7056 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64877 r0 *1 85.12,599.76
X$64877 14074 14073 6119 6104 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $64913 m0 *1 691.6,781.2
X$64913 14074 8827 6110 8755 8826 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $64915 r0 *1 702.24,761.04
X$64915 14074 8477 14073 8563 8564 6110 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $64931 r0 *1 501.2,660.24
X$64931 14074 14073 6112 7001 6114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64955 r0 *1 510.16,630
X$64955 14074 14073 6337 6565 6114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64957 m0 *1 484.96,690.48
X$64957 14074 14073 7234 7407 6114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64960 m0 *1 480.48,640.08
X$64960 14074 14073 6502 6595 6114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64963 m0 *1 475.44,670.32
X$64963 14074 14073 6940 7122 6114 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64972 r0 *1 19.6,619.92
X$64972 6117 14073 14074 6280 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $64977 m0 *1 71.68,619.92
X$64977 14074 6119 6220 14073 6276 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $64984 m0 *1 79.52,680.4
X$64984 14074 6119 14073 7007 7593 6326 7107 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $64988 r0 *1 83.44,609.84
X$64988 14074 14073 6402 6277 6120 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $64997 r0 *1 120.96,630
X$64997 14074 6404 14073 6226 6486 6223 6121 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $65019 m0 *1 373.52,1023.12
X$65019 6123 12210 12521 12577 12658 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65028 r0 *1 420.56,831.6
X$65028 14073 9543 9813 14074 6126 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $65077 m0 *1 150.08,609.84
X$65077 14074 14073 6127 6191 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65079 m0 *1 166.88,630
X$65079 14074 14073 6128 6237 6407 6225 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65088 r0 *1 180.32,609.84
X$65088 14074 14073 6129 6193 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65091 m0 *1 363.44,771.12
X$65091 14074 14073 8702 8703 6130 8636 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65094 m0 *1 358.4,750.96
X$65094 14074 14073 8308 8031 6130 8361 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65096 r0 *1 374.08,750.96
X$65096 14074 14073 8423 8120 6130 8224 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65099 m0 *1 385.84,791.28
X$65099 14074 14073 8939 8849 6130 9051 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65101 m0 *1 384.16,771.12
X$65101 14074 14073 8637 8552 6130 8638 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65103 r0 *1 337.68,720.72
X$65103 14074 14073 7835 7774 6130 7772 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65107 r0 *1 337.12,619.92
X$65107 14074 14073 6385 6234 6130 6233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65109 m0 *1 367.36,791.28
X$65109 14074 14073 7430 6130 8938 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65112 m0 *1 352.24,690.48
X$65112 14074 14073 7391 7229 6130 7318 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65114 m0 *1 221.2,640.08
X$65114 14074 14073 6556 6583 6130 6490 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65117 r0 *1 204.96,670.32
X$65117 14074 14073 7112 7092 6130 7113 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65152 r0 *1 203.84,619.92
X$65152 14074 14073 6130 6407 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65155 m0 *1 210,791.28
X$65155 14074 14073 9001 8841 6130 9044 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65157 r0 *1 370.16,781.2
X$65157 14074 14073 8907 8908 6130 8734 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65159 r0 *1 341.6,670.32
X$65159 14074 14073 7195 7016 6130 7116 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65162 m0 *1 214.48,609.84
X$65162 14074 14073 6200 6131 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65183 m0 *1 260.4,851.76
X$65183 14074 6132 9132 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65185 m0 *1 236.88,740.88
X$65185 14074 6132 7111 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65190 m0 *1 62.16,861.84
X$65190 14074 6132 8931 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65195 r0 *1 330.96,761.04
X$65195 14074 6132 7427 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65200 r0 *1 43.68,740.88
X$65200 14074 6132 7103 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65203 r0 *1 140.56,710.64
X$65203 14074 6132 7009 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65210 m0 *1 451.36,710.64
X$65210 14074 6132 6424 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $65221 m0 *1 241.36,630
X$65221 14074 6462 6229 6231 6410 6224 6226 6133 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $65232 m0 *1 257.04,660.24
X$65232 14074 14073 6772 6907 6413 6134 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65239 m0 *1 255.36,630
X$65239 14074 6322 14073 6410 6464 6224 6136 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $65243 m0 *1 677.6,630
X$65243 6137 6466 6392 6433 14073 14074 6718 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $65247 m0 *1 748.72,619.92
X$65247 14073 6354 6167 14074 6137 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $65256 m0 *1 755.44,630
X$65256 14074 14073 6137 6442 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65284 r0 *1 500.64,619.92
X$65284 14074 14073 6335 6336 6333 6144 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65290 m0 *1 540.96,619.92
X$65290 14073 6244 6145 14074 6301 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $65292 m0 *1 535.92,619.92
X$65292 14074 14073 6244 6300 6145 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65294 m0 *1 553.28,640.08
X$65294 14073 6146 14074 6507 6473 6508 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $65318 r0 *1 597.52,619.92
X$65318 6148 14073 6342 6151 14074 6343 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $65320 r0 *1 575.12,630
X$65320 14074 14073 6148 6675 6150 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65328 m0 *1 579.6,619.92
X$65328 14074 14073 6149 6604 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65331 r0 *1 599.76,630
X$65331 14074 6150 6307 14073 6512 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $65334 m0 *1 579.04,922.32
X$65334 6304 14074 6788 6150 14073 11362 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $65337 r0 *1 573.44,619.92
X$65337 14073 6247 6150 14074 6340 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $65339 r0 *1 599.2,932.4
X$65339 14073 11368 8197 6150 11292 6604 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $65342 r0 *1 611.52,932.4
X$65342 14073 11445 10013 6150 11341 6604 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $65365 m0 *1 611.52,942.48
X$65365 14074 14073 6150 11341 11444 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65367 m0 *1 600.88,942.48
X$65367 14074 14073 6150 11292 11369 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65369 r0 *1 596.96,670.32
X$65369 14074 14073 6706 7446 6150 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65371 m0 *1 602,690.48
X$65371 14074 14073 6150 7242 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65373 m0 *1 590.24,650.16
X$65373 14074 6706 14073 6708 6307 6150 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $65376 m0 *1 583.52,650.16
X$65376 14073 6304 6150 14074 6707 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $65380 r0 *1 591.36,630
X$65380 14074 14073 6150 6428 6307 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65383 m0 *1 572.88,660.24
X$65383 14073 6706 6150 14074 6701 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $65385 r0 *1 574,932.4
X$65385 14074 11263 11199 11367 11291 6150 11342 11198 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $65387 r0 *1 603.68,619.92
X$65387 14074 6514 6151 6152 6308 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $65391 m0 *1 606.48,630
X$65391 14074 14073 6151 6470 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65397 m0 *1 610.4,609.84
X$65397 14074 14073 6151 6157 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65411 r0 *1 611.52,650.16
X$65411 14074 6308 14073 6673 6152 6470 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $65417 m0 *1 726.88,640.08
X$65417 14074 14073 6522 6618 6153 6504 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65419 m0 *1 714,650.16
X$65419 14074 14073 6520 6794 6153 6784 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65421 r0 *1 660.8,771.12
X$65421 14074 14073 8561 8709 6153 8644 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65423 r0 *1 674.8,640.08
X$65423 14074 14073 6609 6610 6153 6597 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65425 r0 *1 679.84,650.16
X$65425 14074 14073 6569 6791 6153 6594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65427 m0 *1 641.2,740.88
X$65427 14074 14073 8134 8191 6153 8037 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65429 m0 *1 715.68,851.76
X$65429 14074 14073 9959 9908 6153 8190 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65431 m0 *1 714,841.68
X$65431 14074 14073 9809 9808 6153 8946 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65433 r0 *1 734.16,730.8
X$65433 14074 14073 7970 7971 6153 7334 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65435 m0 *1 725.76,740.88
X$65435 14074 14073 8052 8142 6153 7696 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65437 m0 *1 714.56,720.72
X$65437 14074 14073 7789 7790 6153 6840 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65439 m0 *1 667.52,680.4
X$65439 14074 14073 7029 7298 6153 6599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65442 r0 *1 715.12,740.88
X$65442 14074 14073 8141 8316 6153 8124 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65444 m0 *1 702.8,811.44
X$65444 14074 14073 9300 9346 6153 8527 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65447 m0 *1 710.08,821.52
X$65447 14074 14073 9506 9502 6153 8464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65449 m0 *1 641.76,680.4
X$65449 14074 14073 7028 7287 6153 7100 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65452 r0 *1 700,781.2
X$65452 14074 14073 8865 8909 6153 8856 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65454 m0 *1 749.84,660.24
X$65454 14074 14073 6620 6878 6153 6864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65457 m0 *1 768.32,660.24
X$65457 14074 14073 6728 6877 6153 6866 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65460 m0 *1 759.36,710.64
X$65460 14074 14073 7626 7711 6153 7125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65462 r0 *1 742.56,730.8
X$65462 14074 14073 7797 8054 6153 8093 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65464 m0 *1 770.56,700.56
X$65464 14073 6153 14074 7573 7541 7035 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $65466 r0 *1 749.28,680.4
X$65466 14074 14073 6724 7285 6153 7236 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65468 m0 *1 749.28,690.48
X$65468 14074 14073 7249 7392 6153 7235 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65512 r0 *1 718.48,841.68
X$65512 14074 14073 9910 9907 6153 8422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65515 m0 *1 718.48,771.12
X$65515 14074 14073 8385 8706 6153 7606 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65518 r0 *1 771.68,761.04
X$65518 14074 6153 8131 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $65520 m0 *1 769.44,821.52
X$65520 8387 14073 6153 6796 14074 9501 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $65522 r0 *1 646.24,619.92
X$65522 14073 6390 14074 6154 6345 6251 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $65528 m0 *1 640.64,630
X$65528 14074 14073 6429 6154 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65530 m0 *1 649.04,609.84
X$65530 14074 14073 6212 6156 6155 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65533 r0 *1 652.96,609.84
X$65533 14073 6162 6156 14074 6252 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $65548 m0 *1 688.8,690.48
X$65548 14073 6159 14074 7342 7138 6564 7454 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $65550 m0 *1 698.88,771.12
X$65550 14074 14073 8708 6159 6567 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $65558 m0 *1 704.48,730.8
X$65558 14074 14073 7838 6159 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65566 r0 *1 701.12,609.84
X$65566 14073 14074 6164 6254 6162 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $65571 m0 *1 716.8,609.84
X$65571 14074 14073 6257 6162 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65579 m0 *1 702.24,609.84
X$65579 14074 6255 6163 6256 6254 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $65588 r0 *1 714.56,619.92
X$65588 14074 6255 6164 6387 6437 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $65590 m0 *1 714,630
X$65590 14074 6616 6299 6164 6437 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $65592 r0 *1 724.64,630
X$65592 14074 6164 6522 6617 6437 14073 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $65596 r0 *1 724.64,609.84
X$65596 14073 6164 6665 14074 6258 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $65604 m0 *1 732.48,609.84
X$65604 14074 14073 6259 6209 6165 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65609 r0 *1 746.48,619.92
X$65609 14073 6439 6353 6165 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $65614 r0 *1 731.92,619.92
X$65614 14074 14073 6166 6256 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $65617 r0 *1 745.92,630
X$65617 14074 6166 6355 6439 6523 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $65621 r0 *1 599.76,821.52
X$65621 14074 14073 9452 6168 8099 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65624 m0 *1 651.28,771.12
X$65624 14074 14073 8713 6168 7963 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65627 m0 *1 610.4,821.52
X$65627 14074 14073 9453 6168 7701 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65629 r0 *1 608.16,821.52
X$65629 14074 14073 9513 6168 7877 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65631 m0 *1 600.88,811.44
X$65631 14074 14073 9304 6168 8019 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65633 r0 *1 597.52,791.28
X$65633 14074 14073 9110 6168 8104 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65635 r0 *1 605.36,761.04
X$65635 14074 14073 8621 6168 8130 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65637 m0 *1 645.12,720.72
X$65637 14074 14073 7836 6168 7447 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65639 r0 *1 654.64,730.8
X$65639 14074 14073 8051 6168 7878 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65641 m0 *1 586.32,730.8
X$65641 14074 14073 7960 6168 7700 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65643 r0 *1 672.56,720.72
X$65643 14074 14073 7881 6168 7787 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65645 m0 *1 703.36,801.36
X$65645 14074 14073 9156 6168 7964 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65647 m0 *1 700,791.28
X$65647 14074 14073 9016 6168 8380 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65649 r0 *1 661.92,700.56
X$65649 14074 14073 7576 6168 7617 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $65698 m0 *1 654.08,740.88
X$65698 14074 6310 6168 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $65701 r0 *1 759.36,650.16
X$65701 14074 14073 6168 6832 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $65712 r0 *1 1032.64,609.84
X$65712 14073 6170 6268 14074 6199 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $65717 m0 *1 1030.96,680.4
X$65717 6450 14074 6171 7169 14073 7193 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $65732 r0 *1 1023.12,619.92
X$65732 6450 14074 6171 6379 14073 6380 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $65734 m0 *1 1032.08,650.16
X$65734 6740 6533 6171 6822 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65738 r0 *1 1033.2,640.08
X$65738 6373 6533 6171 6651 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65740 m0 *1 1019.2,650.16
X$65740 6741 6533 6171 6744 6246 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65743 m0 *1 1027.04,660.24
X$65743 14074 6171 14073 6897 6628 6533 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $65745 m0 *1 1034.32,660.24
X$65745 6806 6533 6171 6885 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65747 r0 *1 1027.6,660.24
X$65747 6970 6533 6171 6886 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65749 m0 *1 1028.72,670.32
X$65749 6983 6533 6171 7163 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65752 r0 *1 1025.36,670.32
X$65752 14074 6171 14073 6967 7184 6533 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $65754 m0 *1 1038.24,640.08
X$65754 6185 6533 6171 6649 6450 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $65767 m0 *1 1117.76,650.16
X$65767 14073 6629 6737 6174 6547 6739 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $65770 r0 *1 1087.52,650.16
X$65770 14074 6174 6819 14073 6820 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $65773 m0 *1 1071.84,660.24
X$65773 14074 14073 7072 6174 6895 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $65775 m0 *1 1113.84,680.4
X$65775 14074 6174 7186 14073 7172 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $65777 r0 *1 1086.96,609.84
X$65777 14074 6174 6190 14073 6272 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $65818 m0 *1 1149.12,609.84
X$65818 14074 14073 6370 6179 6178 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $65833 r0 *1 1174.88,609.84
X$65833 6182 14073 14074 6976 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $65836 r0 *1 1168.16,619.92
X$65836 6183 14073 14074 6451 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $65849 r0 *1 89.6,609.84
X$65849 14074 6221 6220 14073 6186 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $65951 m0 *1 727.44,630
X$65951 14074 14073 6209 6438 6256 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65962 m0 *1 640.64,619.92
X$65962 14074 14073 6251 6212 6211 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $65973 r0 *1 669.76,619.92
X$65973 6214 14074 6467 6252 14073 6392 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $65979 m0 *1 33.04,619.92
X$65979 6215 14073 14074 6227 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $65982 m0 *1 18.48,619.92
X$65982 6216 14073 14074 6217 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66002 m0 *1 146.72,710.64
X$66002 14074 7678 6220 14073 7738 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $66005 m0 *1 68.32,680.4
X$66005 14074 7106 6220 14073 7268 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $66031 r0 *1 90.72,730.8
X$66031 14074 6221 14073 7007 8023 7989 8109 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66033 m0 *1 94.64,630
X$66033 14074 14073 6221 6401 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $66037 r0 *1 282.8,730.8
X$66037 14074 14073 7865 6223 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66111 m0 *1 233.52,710.64
X$66111 14073 7482 6223 14074 7601 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66114 m0 *1 60.48,851.76
X$66114 14074 10084 9929 9983 7936 7989 6223 9638 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66118 m0 *1 309.68,781.2
X$66118 14074 8634 14073 6223 8731 6224 8734 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66120 r0 *1 64.4,821.52
X$66120 14074 9528 9527 9422 7936 7989 6223 9037 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66123 r0 *1 196.56,811.44
X$66123 14074 9764 14073 9294 6223 9238 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66125 m0 *1 73.36,871.92
X$66125 14074 10615 8682 10768 7936 7989 6223 9931 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66128 r0 *1 47.04,761.04
X$66128 14074 8718 6574 8438 7936 7989 6223 8439 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66131 r0 *1 104.72,851.76
X$66131 14074 10373 7860 10546 7936 7989 6223 9420 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66133 m0 *1 268.24,750.96
X$66133 14074 7945 14073 8219 8417 6223 7015 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66135 m0 *1 46.48,750.96
X$66135 14074 8342 7854 8203 7936 7989 6223 8112 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66138 m0 *1 212.24,801.36
X$66138 14074 8220 14073 9131 6223 6857 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66140 m0 *1 144.48,871.92
X$66140 14074 10515 8343 10452 7936 6326 6223 7861 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66142 m0 *1 165.76,801.36
X$66142 14074 8627 14073 8211 9201 6223 9042 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66144 r0 *1 140.56,821.52
X$66144 14074 9430 9038 9644 7936 7989 6223 9315 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66146 r0 *1 59.36,720.72
X$66146 14074 7857 7217 7762 7936 7989 6223 8204 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66148 m0 *1 55.44,801.36
X$66148 14074 9127 8836 9036 7936 7989 6223 9125 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66150 r0 *1 185.36,851.76
X$66150 14074 8220 14073 9998 6223 9828 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66152 r0 *1 210.56,851.76
X$66152 14074 9647 14073 6223 10002 7936 10028 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66156 r0 *1 309.68,619.92
X$66156 14074 6325 14073 6223 6382 6326 6233 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66158 r0 *1 322.56,902.16
X$66158 14074 7516 14073 6223 10848 10883 11056 10784
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $66160 r0 *1 272.16,750.96
X$66160 14074 8453 14073 8295 8418 6224 8361 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66162 m0 *1 207.2,640.08
X$66162 14074 6931 6408 6489 6410 6224 6226 6490 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66166 r0 *1 197.68,740.88
X$66166 14074 8727 8346 8114 8211 6224 8295 8028 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66197 m0 *1 255.92,690.48
X$66197 14073 7318 6224 14074 7315 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66201 m0 *1 173.04,640.08
X$66201 14074 6683 14073 6410 6646 6224 6684 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66205 m0 *1 184.8,680.4
X$66205 14074 7110 7222 7223 6410 6224 6226 7113 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66207 r0 *1 301.84,619.92
X$66207 14074 14073 6326 6224 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66248 r0 *1 232.96,710.64
X$66248 14073 7225 6226 14074 7768 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66250 m0 *1 365.12,821.52
X$66250 14074 14073 6226 9332 9400 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $66258 r0 *1 120.4,660.24
X$66258 14074 14073 6226 7007 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66261 r0 *1 220.64,912.24
X$66261 14074 10980 14073 10113 6226 10114 11092 10830
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $66263 r0 *1 167.44,750.96
X$66263 14074 14073 6226 8211 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66267 r0 *1 306.32,902.16
X$66267 14074 8220 14073 10944 6226 8842 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66269 r0 *1 313.6,902.16
X$66269 14074 14073 8842 10945 6226 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $66286 m0 *1 226.8,619.92
X$66286 14074 14073 6229 6284 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $66299 r0 *1 301.28,761.04
X$66299 14074 14073 8550 8420 6232 8356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66301 r0 *1 291.76,730.8
X$66301 14074 14073 7946 8008 6232 8009 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66303 r0 *1 290.64,700.56
X$66303 14074 14073 7604 7425 6232 7577 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66306 m0 *1 301.28,670.32
X$66306 14074 14073 6935 6936 6232 7084 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66319 m0 *1 312.48,740.88
X$66319 14074 14073 8086 8088 6232 8182 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66331 r0 *1 453.6,942.48
X$66331 14074 14073 11432 6235 11433 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $66350 r0 *1 301.84,1043.28
X$66350 14074 11948 14073 12943 12918 12349 12917 6235
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $66352 r0 *1 456.96,1043.28
X$66352 14074 13001 14073 12924 6235 11713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66369 m0 *1 665.28,821.52
X$66369 14074 6239 9454 9455 14073 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $66379 m0 *1 512.96,781.2
X$66379 14074 14073 6239 8738 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66385 r0 *1 830.48,670.32
X$66385 14074 14073 7039 6240 7038 6955 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66388 m0 *1 734.16,619.92
X$66388 14074 14073 6258 6240 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66395 r0 *1 761.04,892.08
X$66395 14074 10581 14073 10580 10482 6240 10753 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $66397 m0 *1 890.96,771.12
X$66397 6240 14073 14074 8580 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66399 m0 *1 769.44,902.16
X$66399 14074 14073 10692 6240 10395 6829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66407 m0 *1 594.16,902.16
X$66407 14074 14073 6240 10869 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $66431 m0 *1 394.24,962.64
X$66431 14074 14073 8696 6241 9247 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $66444 m0 *1 389.76,912.24
X$66444 14073 11065 14074 6241 9764 10126 11066 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $66446 r0 *1 393.68,972.72
X$66446 14074 12177 11873 14073 9247 11875 6241 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $66448 r0 *1 463.68,619.92
X$66448 14073 14074 6395 6420 6242 6422 6421 6346
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $66468 m0 *1 605.92,640.08
X$66468 14073 6497 6245 14074 6450 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66478 r0 *1 621.04,660.24
X$66478 14074 14073 6919 7000 6246 6897 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66480 m0 *1 611.52,882
X$66480 14073 10477 7338 10536 10569 6246 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $66483 r0 *1 941.92,660.24
X$66483 14074 6886 14073 6901 6987 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66531 m0 *1 579.6,781.2
X$66531 8737 14073 6246 8922 14074 6731 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $66534 r0 *1 566.16,771.12
X$66534 8445 6246 8716 9032 14074 14073 7196 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $66536 r0 *1 1020.32,640.08
X$66536 14074 6555 14073 6652 7358 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66538 r0 *1 1006.88,640.08
X$66538 14074 6649 14073 6653 6654 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66541 r0 *1 627.2,670.32
X$66541 14074 7055 14073 6312 7216 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66543 m0 *1 603.68,740.88
X$66543 7769 6246 8197 8129 14074 14073 7149 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $66545 m0 *1 614.88,851.76
X$66545 9621 6246 9921 10013 14074 14073 7045 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $66548 m0 *1 602,871.92
X$66548 6246 14073 10285 10365 14074 7340 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $66550 r0 *1 627.2,811.44
X$66550 9248 6246 9623 9418 14074 14073 6655 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $66552 r0 *1 877.52,650.16
X$66552 14074 6822 14073 6824 6802 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66554 r0 *1 868.56,841.68
X$66554 9322 6246 9902 9858 14074 14073 6625 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $66557 r0 *1 828.8,650.16
X$66557 14074 6651 14073 6826 6825 6246 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66560 m0 *1 546,619.92
X$66560 14074 14073 6301 6246 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66570 m0 *1 550.48,932.4
X$66570 14074 8852 14073 11193 11440 9925 6247 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $66576 m0 *1 581.84,630
X$66576 14074 6342 14073 6511 6471 6248 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66578 r0 *1 582.96,619.92
X$66578 14073 6248 6340 14074 6341 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66580 m0 *1 588,640.08
X$66580 14073 6308 14074 6605 6603 6249 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $66583 r0 *1 593.6,640.08
X$66583 14073 6249 14074 6708 6512 6606 6342 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $66589 m0 *1 601.44,680.4
X$66589 7242 14074 6308 6250 14073 7135 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $66593 m0 *1 749.28,650.16
X$66593 14074 6523 14073 6251 6745 6439 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66608 m0 *1 683.2,791.28
X$66608 14074 9018 9017 6253 8954 8955 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $66610 m0 *1 675.36,791.28
X$66610 14073 9021 14074 6253 9020 8954 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $66621 m0 *1 694.4,630
X$66621 14074 14073 6429 6254 6435 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $66627 r0 *1 691.04,619.92
X$66627 14073 6351 14074 6255 6389 6350 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $66645 r0 *1 712.88,630
X$66645 14074 6387 6257 6519 6520 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $66648 r0 *1 739.76,619.92
X$66648 14074 6257 6387 14073 6299 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $66655 r0 *1 722.4,640.08
X$66655 14074 6387 14073 6665 6438 6257 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66660 m0 *1 732.48,630
X$66660 6381 6352 6258 6260 14073 14074 6461 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $66667 r0 *1 756,619.92
X$66667 14074 6355 14073 6384 6259 6354 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66669 m0 *1 759.36,640.08
X$66669 14074 14073 6524 6259 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66671 m0 *1 740.32,630
X$66671 14073 6439 6384 14074 6260 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $66680 m0 *1 876.96,791.28
X$66680 14074 14073 9006 6801 6262 8957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66682 r0 *1 871.92,740.88
X$66682 14074 14073 8175 7354 6262 8045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66684 m0 *1 874.72,761.04
X$66684 14074 14073 8518 7464 6262 8486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66686 r0 *1 888.16,882
X$66686 14074 14073 10525 8386 6262 9787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66688 r0 *1 903.28,761.04
X$66688 8251 14074 8255 6262 14073 8484 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $66690 m0 *1 867.44,861.84
X$66690 14074 14073 10228 6959 6262 8650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66692 r0 *1 879.2,821.52
X$66692 14074 14073 9496 8147 6262 9348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66694 r0 *1 859.04,851.76
X$66694 14074 14073 9990 7545 6262 8867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66697 r0 *1 875.84,831.6
X$66697 14074 14073 9674 7089 6262 8654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66699 m0 *1 883.68,831.6
X$66699 14074 14073 9717 7153 6262 8003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66701 r0 *1 846.16,841.68
X$66701 14074 14073 9900 7967 6262 9569 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66703 m0 *1 877.52,821.52
X$66703 14074 14073 9466 6829 6262 8520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66705 m0 *1 875.28,882
X$66705 14074 14073 10401 8387 6262 7972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66707 m0 *1 871.92,892.08
X$66707 14074 14073 10620 8245 6262 9786 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66735 r0 *1 902.16,771.12
X$66735 14073 7976 6262 14074 8660 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66737 m0 *1 892.64,750.96
X$66737 14074 14073 6262 8307 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $66739 m0 *1 879.2,781.2
X$66739 14074 14073 8819 6798 6262 8568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66742 m0 *1 882.56,771.12
X$66742 14074 14073 8601 7154 6262 8480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66745 m0 *1 887.04,892.08
X$66745 14074 14073 10742 7630 6262 10238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66805 r0 *1 1148.56,630
X$66805 6275 14073 14074 6535 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $66818 r0 *1 107.52,861.84
X$66818 14074 10204 10114 6279 10260 10113 10019 10261 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $66842 r0 *1 138.32,619.92
X$66842 14074 14073 6281 6377 6318 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $66894 r0 *1 389.2,619.92
X$66894 14073 6388 6417 14074 6295 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $66902 r0 *1 822.08,630
X$66902 14074 14073 6296 6965 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $66908 m0 *1 766.08,619.92
X$66908 14074 14073 6356 6298 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $66912 r0 *1 772.8,630
X$66912 14074 6298 6524 6527 6441 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $66934 m0 *1 560.56,791.28
X$66934 14074 9061 14073 7130 9030 9012 6303 8131
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $66938 m0 *1 590.8,630
X$66938 14074 14073 6471 6428 6304 6512 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $66958 r0 *1 605.92,851.76
X$66958 14074 9053 14073 9948 6606 6304 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $66960 m0 *1 603.12,861.84
X$66960 6304 14073 9053 6606 14074 10252 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $66969 r0 *1 588,882
X$66969 10642 6604 10539 6306 10641 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $66974 r0 *1 583.52,670.32
X$66974 14074 6308 6307 14073 7099 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $66986 m0 *1 589.12,680.4
X$66986 14074 14073 6307 6308 7301 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $66992 m0 *1 577.36,640.08
X$66992 14073 6307 6675 14074 6510 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $66995 r0 *1 584.08,640.08
X$66995 14073 6307 6707 14074 6605 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $67027 r0 *1 621.04,609.84
X$67027 14074 14073 6311 6310 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67030 m0 *1 626.64,609.84
X$67030 14074 6311 6607 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $67046 r0 *1 33.6,619.92
X$67046 14074 14073 6398 6314 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67068 m0 *1 374.64,700.56
X$67068 7321 6928 7104 6316 14074 14073 7434 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $67070 m0 *1 382.48,730.8
X$67070 14074 14073 6316 7922 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67072 m0 *1 448,730.8
X$67072 14074 14073 6316 7955 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67074 m0 *1 18.48,630
X$67074 6480 14073 14074 6317 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67085 r0 *1 163.52,630
X$67085 14074 14073 6319 6647 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67089 m0 *1 6.72,650.16
X$67089 6759 14073 14074 6320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67115 r0 *1 269.36,640.08
X$67115 14073 6325 6586 14074 6690 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67118 m0 *1 313.6,680.4
X$67118 14074 7286 7228 6936 6492 6326 6410 7116 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $67122 m0 *1 321.44,871.92
X$67122 14073 9435 10379 14074 6326 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67125 r0 *1 79.52,660.24
X$67125 14074 6851 14073 7007 6929 6326 6766 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67155 r0 *1 114.24,700.56
X$67155 14074 7417 14073 7007 7503 6326 7504 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67157 m0 *1 318.08,750.96
X$67157 14074 8088 14073 6492 8609 6326 8224 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67162 r0 *1 82.32,670.32
X$67162 14074 6978 14073 7007 7108 6326 7011 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67165 m0 *1 83.44,720.72
X$67165 14074 7594 14073 7007 7821 6326 7766 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67167 m0 *1 83.44,730.8
X$67167 14074 6642 14073 7007 8338 6326 7862 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67169 r0 *1 85.12,680.4
X$67169 14074 7106 14073 7007 7219 6326 7220 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67172 r0 *1 206.08,801.36
X$67172 14074 9241 14073 7936 9200 6326 9044 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67174 r0 *1 120.96,781.2
X$67174 14074 8720 14073 8211 9094 6326 8839 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67176 m0 *1 151.2,771.12
X$67176 14074 8344 14073 8211 8723 6326 8345 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67180 m0 *1 124.88,740.88
X$67180 14074 8021 14073 8211 8113 6326 8024 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67182 m0 *1 300.16,720.72
X$67182 14074 8030 7422 7425 6492 6326 7865 7772 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $67210 m0 *1 465.92,650.16
X$67210 14074 6701 14073 6943 6598 6330 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67212 m0 *1 481.04,650.16
X$67212 14073 6598 6330 6784 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $67220 m0 *1 485.52,680.4
X$67220 14073 7124 6331 7236 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $67223 m0 *1 478.24,680.4
X$67223 14074 6701 14073 7327 7124 6331 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67228 m0 *1 499.52,670.32
X$67228 14074 7001 7100 6332 6397 6425 7026 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $67233 r0 *1 483.84,619.92
X$67233 14074 14073 6333 6334 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67240 m0 *1 504.56,619.92
X$67240 14074 14073 6334 6397 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67244 r0 *1 467.6,630
X$67244 14074 6334 6501 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $67246 m0 *1 466.48,630
X$67246 14074 14073 6334 6420 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67250 r0 *1 510.72,861.84
X$67250 6335 14074 8367 10134 14073 10281 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $67252 r0 *1 507.36,851.76
X$67252 14074 8367 6335 14073 9734 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $67266 m0 *1 498.4,871.92
X$67266 14073 8852 14074 10279 8367 6335 6701 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $67280 r0 *1 558.32,650.16
X$67280 14073 6509 7130 6338 6848 6396 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $67291 r0 *1 567.84,650.16
X$67291 14074 6787 14073 6338 6755 6704 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67303 r0 *1 580.16,630
X$67303 14074 14073 6427 6511 6572 6341 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67319 r0 *1 553.84,811.44
X$67319 14074 9307 14073 7101 9339 6343 9415 6777
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $67323 m0 *1 558.88,841.68
X$67323 14074 9925 14073 9775 9145 6343 9776 9777
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $67325 r0 *1 589.12,861.84
X$67325 14074 14073 7182 10142 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67370 r0 *1 554.4,882
X$67370 14073 9259 6343 14074 10469 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67372 r0 *1 568.4,861.84
X$67372 14073 6602 6343 14074 10138 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67374 m0 *1 558.32,871.92
X$67374 14074 10038 14073 7101 10362 6343 7240 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67378 r0 *1 551.6,771.12
X$67378 14074 8711 14073 7101 8714 6343 8738 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67382 r0 *1 571.76,841.68
X$67382 14074 9736 14073 7101 9924 6343 7319 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67384 r0 *1 543.2,831.6
X$67384 14074 14073 8362 9664 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67386 m0 *1 585.2,831.6
X$67386 14074 14073 7403 9561 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67388 r0 *1 572.32,801.36
X$67388 14074 9118 14073 7101 9517 6343 6584 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67391 r0 *1 556.08,831.6
X$67391 14074 9558 14073 7101 9735 6343 6917 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67394 r0 *1 571.76,791.28
X$67394 14074 14073 8459 9122 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67397 r0 *1 566.16,791.28
X$67397 14074 14073 6418 9227 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67399 r0 *1 637.84,912.24
X$67399 14074 14073 6764 11072 6343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67402 r0 *1 627.76,892.08
X$67402 14074 10573 14073 10685 6343 8036 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67406 m0 *1 552.16,912.24
X$67406 14074 10677 14073 11079 6343 7803 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67408 m0 *1 581.84,902.16
X$67408 14074 10762 14073 7101 10868 6343 6442 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67411 r0 *1 670.32,700.56
X$67411 14073 7618 14074 6344 7619 6345 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $67413 r0 *1 667.52,690.48
X$67413 14074 14073 7493 7451 6344 7491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67415 m0 *1 644,660.24
X$67415 6870 14074 6345 6344 14073 6868 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $67417 r0 *1 642.88,660.24
X$67417 14073 6870 14074 6344 6941 6345 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $67422 r0 *1 678.16,700.56
X$67422 14074 14073 7491 6345 7659 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $67437 r0 *1 665.84,680.4
X$67437 7451 6345 7404 7299 7493 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $67452 r0 *1 700,630
X$67452 14074 14073 6347 6721 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67454 m0 *1 501.2,630
X$67454 14073 14074 6477 6397 6565 6425 6503 6347
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $67456 r0 *1 678.72,619.92
X$67456 14074 6391 14073 6390 6389 6348 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67462 r0 *1 683.2,640.08
X$67462 14074 14073 6612 6348 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67468 r0 *1 704.48,619.92
X$67468 6348 14074 6436 14073 6352 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $67473 m0 *1 684.88,640.08
X$67473 14074 6719 6612 6349 6391 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $67476 r0 *1 700,619.92
X$67476 14074 14073 6349 6351 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67482 m0 *1 700,630
X$67482 14073 6351 14074 6436 6518 6350 6614 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $67497 r0 *1 748.72,640.08
X$67497 14074 6355 6353 6724 6725 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $67501 r0 *1 759.36,630
X$67501 14074 14073 6353 6354 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $67511 m0 *1 749.84,630
X$67511 14074 14073 6354 6460 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67520 r0 *1 760.48,640.08
X$67520 14074 14073 6355 6440 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67523 r0 *1 764.96,640.08
X$67523 14074 6356 6526 6621 6728 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $67526 m0 *1 771.12,630
X$67526 14074 14073 6459 6356 6357 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $67531 r0 *1 767.76,630
X$67531 14073 6526 6525 14074 6357 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67585 r0 *1 1123.92,630
X$67585 14074 14073 6452 6547 6366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67587 m0 *1 1095.36,650.16
X$67587 14074 14073 6535 6735 6366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67596 r0 *1 1120,660.24
X$67596 14074 14073 6976 6977 6366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67600 r0 *1 1114.96,660.24
X$67600 14074 14073 6451 7173 6366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67608 r0 *1 1165.36,630
X$67608 6368 14073 14074 6536 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $67660 m0 *1 945.84,680.4
X$67660 14074 14073 7255 6381 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $67664 r0 *1 946.96,680.4
X$67664 14074 6381 7162 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $67669 r0 *1 309.68,932.4
X$67669 14074 10641 11352 11407 6382 14073 11333
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $67696 r0 *1 455.84,640.08
X$67696 14074 14073 6386 6671 6593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67699 r0 *1 362.32,640.08
X$67699 6495 14073 6386 6415 14074 6666 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $67701 m0 *1 367.36,640.08
X$67701 6495 6386 6581 6416 14074 14073 6417 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $67703 r0 *1 368.48,640.08
X$67703 6495 6386 6581 6415 14074 14073 6590 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $67705 r0 *1 370.72,630
X$67705 6386 14074 6415 14073 6560 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $67708 m0 *1 386.96,640.08
X$67708 14074 14073 6386 6667 6416 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $67736 m0 *1 673.12,640.08
X$67736 14074 6391 6612 6611 6609 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $67750 m0 *1 422.24,892.08
X$67750 10667 14073 10565 10566 14074 6393 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $67780 r0 *1 477.12,670.32
X$67780 14073 14074 6921 6397 7122 6425 7297 7205
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $67783 m0 *1 472.64,690.48
X$67783 14073 14074 7406 6397 7407 6425 7328 7329
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $67808 r0 *1 107.52,619.92
X$67808 14074 14073 6404 6455 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67811 r0 *1 108.64,871.92
X$67811 14074 14073 10329 6405 10345 10261 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67814 r0 *1 102.48,841.68
X$67814 14074 14073 9884 6405 8110 9641 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67816 r0 *1 92.4,871.92
X$67816 14074 14073 10450 6405 10371 10372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67819 r0 *1 169.68,650.16
X$67819 14074 14073 6818 6405 6409 6683 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67821 m0 *1 222.88,841.68
X$67821 14074 14073 9754 6405 9137 9755 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67854 r0 *1 146.16,1073.52
X$67854 14074 12115 14073 13263 13058 12327 6405
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67857 r0 *1 384.72,811.44
X$67857 14074 9333 14073 6405 9404 9251 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67859 m0 *1 244.16,1063.44
X$67859 14074 11948 14073 12993 13117 12349 6405
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67861 r0 *1 84.56,1134
X$67861 14074 13109 14073 12104 13851 6405 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $67872 m0 *1 141.68,942.48
X$67872 14074 11488 10114 6406 10115 11143 11389 11420 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $67875 m0 *1 125.44,730.8
X$67875 14074 7993 14073 7905 7938 6407 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67877 r0 *1 122.08,771.12
X$67877 14074 14073 8798 8683 6407 8839 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67881 r0 *1 134.96,650.16
X$67881 14074 14073 6896 6816 6407 6766 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67883 m0 *1 182.56,650.16
X$67883 14074 14073 6743 6767 6407 6684 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67885 r0 *1 192.08,720.72
X$67885 14074 14073 7912 7683 6407 7766 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67887 r0 *1 144.48,680.4
X$67887 14074 14073 7271 7273 6407 7220 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67889 r0 *1 170.8,720.72
X$67889 14074 14073 7767 7939 6407 7862 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67892 r0 *1 160.16,720.72
X$67892 14074 14073 7909 7688 6407 7861 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67895 m0 *1 122.08,680.4
X$67895 14074 7109 14073 7269 7187 6407 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $67897 r0 *1 129.36,670.32
X$67897 14074 14073 7071 7073 6407 7011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67900 r0 *1 125.44,690.48
X$67900 14074 14073 7567 7310 6407 7504 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67924 m0 *1 154,740.88
X$67924 14074 14073 8075 8025 6407 8024 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67926 r0 *1 203.28,730.8
X$67926 14074 14073 8115 8080 6407 8028 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67928 m0 *1 116.48,680.4
X$67928 14074 14073 7109 7107 6407 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $67931 r0 *1 188.16,750.96
X$67931 14074 14073 8512 8414 6407 8345 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67933 m0 *1 123.2,720.72
X$67933 14074 14073 7993 7765 6407 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $67939 r0 *1 184.8,630
X$67939 14074 14073 6408 6554 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $67944 m0 *1 310.24,690.48
X$67944 14074 14073 7389 7317 6409 7228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67946 m0 *1 259.84,750.96
X$67946 14074 14073 8303 7226 6409 8118 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67948 r0 *1 343.28,831.6
X$67948 14074 14073 9542 8732 6409 9654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67950 r0 *1 291.76,640.08
X$67950 14074 14073 6587 6691 6409 6491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67953 m0 *1 204.96,630
X$67953 14074 14073 6458 6488 6409 6489 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67958 m0 *1 283.92,942.48
X$67958 14074 14073 11276 11091 6409 11351 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67960 r0 *1 267.68,932.4
X$67960 14074 14073 11405 7603 6409 11274 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67962 m0 *1 246.4,841.68
X$67962 14074 14073 9756 6771 6409 9833 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67964 r0 *1 211.12,861.84
X$67964 14074 14073 10027 10263 6409 10028 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67967 m0 *1 185.92,690.48
X$67967 14074 14073 7376 7074 6409 7223 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $67969 m0 *1 348.88,912.24
X$67969 14073 9543 10987 14074 6409 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $67972 m0 *1 348.88,942.48
X$67972 14074 14073 11410 11058 6409 11280 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68014 r0 *1 301.28,791.28
X$68014 14074 14073 9103 8547 6409 8937 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68016 m0 *1 192.64,942.48
X$68016 14074 14073 6409 7763 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68019 m0 *1 271.6,922.32
X$68019 14074 14073 11274 10878 6410 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $68022 r0 *1 280,851.76
X$68022 14073 9435 9537 14074 6410 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68055 r0 *1 304.08,781.2
X$68055 14074 8937 14073 6410 8905 6492 8420 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $68058 r0 *1 177.52,851.76
X$68058 14074 14073 6410 7936 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68062 m0 *1 223.44,942.48
X$68062 14074 8220 14073 11272 6410 11349 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68064 m0 *1 277.2,750.96
X$68064 14074 8220 14073 8221 6410 8118 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68070 m0 *1 168,942.48
X$68070 14074 8220 14073 11595 6410 11422 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68072 r0 *1 182,912.24
X$68072 14074 8220 14073 11046 6410 10978 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68079 r0 *1 292.88,942.48
X$68079 14074 8220 14073 11407 6410 11351 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68087 r0 *1 137.76,902.16
X$68087 14074 14073 10932 10771 6413 7599 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68091 r0 *1 325.92,771.12
X$68091 14074 14073 8821 8701 6413 6693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68093 r0 *1 80.64,902.16
X$68093 14074 14073 10924 10769 6413 7008 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68096 m0 *1 290.64,861.84
X$68096 14074 14073 10223 10225 6413 9539 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68099 r0 *1 124.32,882
X$68099 14074 14073 10547 10548 6413 7598 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68102 r0 *1 102.48,912.24
X$68102 14074 14073 11036 11038 6413 6981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68106 m0 *1 306.32,851.76
X$68106 14074 14073 9934 9935 6413 9541 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68108 r0 *1 323.68,650.16
X$68108 14074 14073 6828 6830 6413 6494 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68112 m0 *1 148.4,861.84
X$68112 14074 14073 10207 10112 6413 7681 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68115 m0 *1 157.36,861.84
X$68115 14074 14073 10209 10210 6413 6899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68119 r0 *1 268.8,781.2
X$68119 14074 14073 8843 8904 6413 7651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68178 r0 *1 174.72,821.52
X$68178 14074 14073 9431 9604 6413 7682 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68184 r0 *1 310.8,630
X$68184 14073 6414 6558 14074 6493 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68197 m0 *1 371.28,690.48
X$68197 14073 6417 7290 14074 7320 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68206 r0 *1 371.84,680.4
X$68206 14073 6417 7117 14074 7289 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68210 m0 *1 859.04,750.96
X$68210 14074 14073 8248 6418 7038 7982 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68212 r0 *1 918.96,771.12
X$68212 6418 14073 14074 8677 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68215 r0 *1 735.28,912.24
X$68215 14074 14073 11005 6418 10395 8245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68217 m0 *1 714,912.24
X$68217 14074 10581 14073 10689 10482 6418 11004 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $68253 r0 *1 888.16,781.2
X$68253 14074 14073 6418 8869 8602 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $68255 m0 *1 692.72,710.64
X$68255 14074 14073 6457 6418 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68258 m0 *1 468.16,640.08
X$68258 14073 14074 6419 6501 6476 6422 6504 6568
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $68268 m0 *1 474.32,630
X$68268 14074 14073 6421 6597 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68279 m0 *1 493.36,630
X$68279 14074 14073 6423 6422 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68281 r0 *1 455.28,630
X$68281 14073 14074 6563 6501 6562 6422 6670 6505
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $68285 r0 *1 465.36,650.16
X$68285 14073 14074 6838 6501 6839 6841 6840 6422
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $68287 m0 *1 459.2,670.32
X$68287 14073 14074 7097 6501 6837 6422 7204 6884
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $68301 m0 *1 513.52,630
X$68301 14074 14073 6423 6425 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68303 m0 *1 471.52,700.56
X$68303 14074 6423 7121 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $68329 r0 *1 451.36,700.56
X$68329 14074 6424 14159 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* cell instance $68353 r0 *1 471.52,710.64
X$68353 14074 7754 7696 7660 6501 7710 6425 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $68399 m0 *1 669.76,630
X$68399 6430 6570 6432 6461 14073 14074 6466 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $68403 m0 *1 661.92,630
X$68403 14074 14073 6430 6431 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68408 r0 *1 882,690.48
X$68408 14074 14073 7480 6431 7038 7466 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68413 r0 *1 828.8,922.32
X$68413 14074 10581 14073 10695 11212 6431 11156 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $68415 r0 *1 817.6,912.24
X$68415 14074 14073 11007 6431 10395 7354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68418 r0 *1 1164.8,761.04
X$68418 6431 14073 14074 8497 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68441 r0 *1 836.08,801.36
X$68441 14074 14073 9068 9166 9349 6431 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68443 m0 *1 694.96,730.8
X$68443 14073 7966 7965 14074 6432 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $68451 m0 *1 678.16,650.16
X$68451 14074 6432 6579 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $68456 m0 *1 679.84,700.56
X$68456 7453 14074 7535 7534 14073 6433 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $68466 r0 *1 703.92,650.16
X$68466 14074 6952 6616 6435 6792 6521 14073 gf180mcu_fd_sc_mcu9t5v0__nor4_4
* cell instance $68469 r0 *1 700,640.08
X$68469 14073 6719 14074 6911 6614 6518 6435 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $68478 m0 *1 715.12,660.24
X$68478 6518 6615 6435 6792 14073 14074 6995 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $68492 m0 *1 744.8,640.08
X$68492 14074 6523 6439 6620 6619 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $68502 m0 *1 763.28,630
X$68502 14073 6440 14074 6459 6745 6460 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $68504 m0 *1 776.72,630
X$68504 14074 14073 6526 6441 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $68507 r0 *1 804.72,912.24
X$68507 14074 10581 14073 11118 10482 6442 10947 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $68512 r0 *1 812.56,882
X$68512 14074 14073 10582 6442 10395 7545 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68514 m0 *1 822.64,841.68
X$68514 14074 14073 9721 6442 8602 9805 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68517 r0 *1 810.88,710.64
X$68517 14074 14073 7749 6442 7038 7712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68556 m0 *1 1070.16,670.32
X$68556 6450 7049 7050 7072 14073 14074 6972 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $68570 r0 *1 940.8,670.32
X$68570 14074 7163 14073 7080 6450 7357 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $68634 r0 *1 683.76,700.56
X$68634 14074 7535 6457 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $68657 r0 *1 246.96,871.92
X$68657 6462 10376 10429 10117 14074 14073 10267 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $68671 m0 *1 245.28,761.04
X$68671 14073 6464 8516 14074 8517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68681 m0 *1 660.24,750.96
X$68681 14073 8239 8376 14074 6467 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $68694 r0 *1 665.28,650.16
X$68694 14074 6467 6764 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $68751 m0 *1 10.08,640.08
X$68751 6478 14073 14074 6484 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68754 r0 *1 8.4,640.08
X$68754 6479 14073 14074 6761 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $68767 r0 *1 36.96,882
X$68767 14074 10612 10114 6483 10260 10113 10611 10643 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $68789 m0 *1 167.44,640.08
X$68789 14073 6486 6646 14074 6487 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $68793 r0 *1 169.68,831.6
X$68793 14074 9545 9709 9645 6487 14073 9535 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $68799 m0 *1 171.92,831.6
X$68799 6487 9645 9709 9535 14074 14073 9404 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $68803 r0 *1 222.88,892.08
X$68803 14074 14073 10554 6488 10121 9903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68806 m0 *1 208.32,902.16
X$68806 14074 14073 10651 6488 10371 10652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68808 m0 *1 191.52,882
X$68808 14074 14073 10519 6488 10345 10262 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $68836 r0 *1 452.48,801.36
X$68836 14074 14073 9217 6488 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $68839 m0 *1 215.04,650.16
X$68839 14074 14073 6488 6685 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $68842 m0 *1 162.96,1134
X$68842 14074 12115 14073 13792 13774 12327 6488
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $68844 r0 *1 156.8,1164.24
X$68844 14074 13966 14073 12104 14016 6488 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $68847 r0 *1 278.32,1083.6
X$68847 14074 11952 14073 13389 13308 12349 6488
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $68849 r0 *1 440.16,1083.6
X$68849 14074 14073 11713 13403 6488 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $68869 r0 *1 320.32,871.92
X$68869 10378 14073 9435 10431 14074 6492 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $68889 m0 *1 273.28,761.04
X$68889 14074 8008 14073 6492 8519 7989 8452 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $68893 m0 *1 311.36,871.92
X$68893 14074 10102 10341 10781 6493 14073 10430
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $68915 r0 *1 454.72,650.16
X$68915 14074 14073 6495 6838 6593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $68920 r0 *1 383.04,640.08
X$68920 14073 6495 6667 14074 6750 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $68968 m0 *1 445.2,700.56
X$68968 14074 7325 7607 7587 6501 6989 7121 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $68993 m0 *1 459.2,750.96
X$68993 14073 14074 8228 6501 8313 7121 8850 7383
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $68996 r0 *1 450.24,680.4
X$68996 14073 14074 7232 6501 6999 7121 7753 7233
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69003 m0 *1 439.04,710.64
X$69003 14073 14074 7324 6501 6700 7121 7841 7752
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69006 r0 *1 436.8,670.32
X$69006 14074 6997 7606 7020 6501 7091 7121 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $69008 r0 *1 437.92,680.4
X$69008 14073 14074 7295 6501 7202 7121 7405 7150
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69010 r0 *1 440.72,690.48
X$69010 14073 14074 7495 6501 7520 7121 8092 7385
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69012 m0 *1 436.8,740.88
X$69012 14073 14074 8034 6501 8187 7121 8190 8076
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69015 r0 *1 439.04,740.88
X$69015 14073 14074 8123 6501 8310 7121 8460 7159
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69017 m0 *1 441.84,750.96
X$69017 14073 14074 7869 6501 8311 7121 8426 8249
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69019 m0 *1 470.96,740.88
X$69019 14074 8193 8527 7955 6501 7280 7121 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $69021 r0 *1 473.2,740.88
X$69021 14074 8192 8464 8017 6501 7355 7121 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $69023 m0 *1 449.12,740.88
X$69023 14073 14074 8094 6501 8035 7121 8314 7911
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $69026 r0 *1 460.32,720.72
X$69026 14074 7926 8037 7925 6501 7121 7956 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai221_4
* cell instance $69039 m0 *1 505.12,640.08
X$69039 14074 14073 6503 6599 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69047 r0 *1 510.16,650.16
X$69047 14074 14073 6504 6867 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69054 m0 *1 645.12,650.16
X$69054 14074 6715 14073 6843 6505 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69062 r0 *1 566.16,640.08
X$69062 14073 6603 14074 6507 6676 6508 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $69082 r0 *1 650.16,851.76
X$69082 14073 9949 14074 6507 10046 10044 10045 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $69086 r0 *1 659.12,710.64
X$69086 7784 6718 7785 7786 14073 14074 6508 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $69103 m0 *1 573.44,670.32
X$69103 14074 6510 6705 14073 7023 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $69105 m0 *1 577.92,660.24
X$69105 14074 14073 7101 6510 6705 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $69122 r0 *1 627.2,730.8
X$69122 6513 8096 8095 8435 14074 14073 7206 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $69124 m0 *1 621.6,660.24
X$69124 14074 6919 14073 6669 6513 7614 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69126 m0 *1 608.72,660.24
X$69126 14074 14073 6716 6514 6946 6607 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69128 r0 *1 600.88,680.4
X$69128 14074 14073 7211 6607 7241 6514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69135 r0 *1 609.84,700.56
X$69135 14074 6514 7532 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $69137 m0 *1 601.44,700.56
X$69137 14074 14073 7460 6607 7584 6514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69140 r0 *1 602,670.32
X$69140 14074 14073 6947 6607 7024 6514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69143 m0 *1 612.08,700.56
X$69143 14074 14073 6514 7846 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69146 m0 *1 608.72,680.4
X$69146 14074 14073 7136 6607 7133 6514 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69150 r0 *1 610.96,861.84
X$69150 14074 14073 10364 6515 10041 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $69169 m0 *1 701.68,640.08
X$69169 14073 6517 6613 7031 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $69171 r0 *1 707.84,630
X$69171 14074 14073 6613 6564 6517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $69181 m0 *1 719.04,640.08
X$69181 14074 14073 6616 6518 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69194 m0 *1 711.2,640.08
X$69194 14074 14073 6521 6615 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69212 m0 *1 767.2,640.08
X$69212 6525 14074 14073 6727 6660 6661 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $69223 m0 *1 780.08,650.16
X$69223 14074 14073 6526 6622 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69225 m0 *1 761.04,650.16
X$69225 14074 6746 6797 6729 6832 6527 14073 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $69229 r0 *1 782.32,640.08
X$69229 14073 6527 6622 14074 6623 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $69250 m0 *1 1133.44,650.16
X$69250 14074 14073 6739 6738 6533 6815 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69260 r0 *1 1087.52,660.24
X$69260 14074 14073 6893 6973 6533 6980 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69263 r0 *1 1135.68,680.4
X$69263 14074 14073 7175 7062 6533 7176 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69266 m0 *1 1069.6,680.4
X$69266 7272 14073 14074 7051 6533 7171 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $69294 r0 *1 1032.64,670.32
X$69294 14073 6533 7185 14074 7169 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $69297 r0 *1 1071.84,680.4
X$69297 14074 7272 14073 7049 7070 6533 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69339 m0 *1 1141.84,650.16
X$69339 14074 14073 6815 6538 6809 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $69342 r0 *1 1178.8,650.16
X$69342 6539 14073 14074 7048 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69357 r0 *1 1173.76,660.24
X$69357 6541 14073 14074 6888 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69360 m0 *1 1156.4,660.24
X$69360 6542 14073 14074 6887 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69363 r0 *1 1173.76,640.08
X$69363 6543 14073 14074 6732 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69378 m0 *1 673.68,801.36
X$69378 14074 9216 6545 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $69382 r0 *1 687.68,811.44
X$69382 14074 14073 6545 9409 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69457 r0 *1 688.8,660.24
X$69457 14073 6875 14074 6950 6564 6792 7138 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $69479 m0 *1 534.8,690.48
X$69479 7238 14074 6566 7332 14073 7411 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $69483 r0 *1 522.48,700.56
X$69483 14074 14073 6566 7608 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69485 m0 *1 703.92,740.88
X$69485 14073 14074 8318 6567 7966 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $69504 r0 *1 682.64,771.12
X$69504 7838 14074 6567 8647 14073 8754 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $69507 r0 *1 688.8,761.04
X$69507 14074 14073 7454 6567 8648 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $69509 r0 *1 700.56,730.8
X$69509 14074 7343 8185 8477 7537 6567 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $69517 r0 *1 732.48,650.16
X$69517 6568 6713 6800 6748 6994 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $69530 m0 *1 662.48,650.16
X$69530 14074 14073 6570 6692 6697 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $69532 r0 *1 666.96,640.08
X$69532 14074 14073 6570 6602 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69542 m0 *1 621.04,871.92
X$69542 14073 10251 14074 6572 10293 10144 10479
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $69562 m0 *1 41.44,650.16
X$69562 14074 14073 6574 6678 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $69565 m0 *1 32.48,761.04
X$69565 14074 14073 8500 6575 7763 8438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69567 m0 *1 380.8,781.2
X$69567 14073 8735 8848 14074 6575 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $69570 r0 *1 38.08,902.16
X$69570 14074 14073 10831 6575 10345 10643 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69573 m0 *1 35.84,982.8
X$69573 14074 14073 11784 6575 10371 11785 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69575 m0 *1 67.2,771.12
X$69575 14074 14073 8587 6575 8110 8440 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69578 r0 *1 43.68,1073.52
X$69578 14074 13180 14073 12104 13281 6575 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $69613 m0 *1 201.6,1063.44
X$69613 14074 11952 14073 13114 13166 12349 6575
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $69616 m0 *1 109.2,1083.6
X$69616 14074 12115 14073 13304 13303 12327 6575
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $69618 m0 *1 385.28,1093.68
X$69618 14074 11795 14073 13470 13414 6575 11794
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $69622 m0 *1 23.52,650.16
X$69622 6760 14073 14074 6577 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69639 m0 *1 682.64,660.24
X$69639 14074 14073 6579 6777 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69660 r0 *1 445.2,700.56
X$69660 14074 14073 6581 7660 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $69665 m0 *1 367.36,650.16
X$69665 6581 14074 6666 14073 6912 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $69673 r0 *1 889.84,801.36
X$69673 14074 14073 9203 6584 8602 9171 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69675 r0 *1 831.6,700.56
X$69675 14074 14073 7650 6584 7038 7548 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69679 m0 *1 945.28,781.2
X$69679 6584 14073 14074 8779 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69682 r0 *1 748.16,912.24
X$69682 14074 14073 11006 6584 10395 7630 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69684 m0 *1 733.6,922.32
X$69684 14074 10581 14073 11005 10482 6584 11162 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $69716 r0 *1 734.72,690.48
X$69716 14074 7349 6584 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $69721 m0 *1 262.08,650.16
X$69721 14074 14073 6585 6688 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $69776 m0 *1 246.4,730.8
X$69776 14074 6586 14073 8002 8001 7943 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69778 r0 *1 272.72,791.28
X$69778 14073 8029 6586 14074 9047 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $69780 r0 *1 264.88,791.28
X$69780 14073 9045 6586 14074 9046 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $69799 r0 *1 309.68,640.08
X$69799 6588 14073 6858 6662 14074 6589 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $69804 m0 *1 376.32,690.48
X$69804 7394 14073 6590 7290 14074 7396 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $69812 r0 *1 374.64,690.48
X$69812 7415 6590 7290 7432 14074 14073 7433 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $69814 r0 *1 371.28,670.32
X$69814 14074 14073 6590 6939 7017 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $69831 r0 *1 458.64,942.48
X$69831 14074 6594 10641 14073 11433 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $69848 m0 *1 543.2,861.84
X$69848 10037 14074 14073 6594 6844 10248 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $69851 m0 *1 524.72,871.92
X$69851 14074 14073 6594 10360 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $69855 m0 *1 459.76,640.08
X$69855 14074 14073 6670 6594 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69857 r0 *1 529.76,942.48
X$69857 14074 14073 11505 7607 10134 6594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69859 m0 *1 479.92,942.48
X$69859 14074 14073 11503 7607 6701 6594 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69867 r0 *1 470.4,660.24
X$69867 14074 6701 14073 6920 6923 6596 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69869 m0 *1 476,660.24
X$69869 14073 6923 6596 6864 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $69877 m0 *1 473.2,650.16
X$69877 14074 14073 6597 6780 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69891 m0 *1 510.16,680.4
X$69891 14074 14073 6599 7126 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $69895 r0 *1 511.84,640.08
X$69895 14074 6674 14073 6785 6600 6702 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69898 m0 *1 531.44,650.16
X$69898 14074 6845 14073 6709 6601 6702 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $69906 r0 *1 735.28,871.92
X$69906 14074 14073 10394 6602 10395 8147 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69908 r0 *1 749.28,892.08
X$69908 14074 10581 14073 10532 10482 6602 10627 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $69910 m0 *1 855.12,771.12
X$69910 14074 14073 8658 6602 8602 8820 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69913 m0 *1 906.08,801.36
X$69913 6602 14073 14074 9072 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $69915 m0 *1 808.08,720.72
X$69915 14074 14073 7801 6602 7038 7802 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $69949 m0 *1 566.16,650.16
X$69949 14074 14073 6603 6787 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $69953 r0 *1 565.6,912.24
X$69953 14073 10998 9032 7446 11080 6604 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $69957 r0 *1 614.32,902.16
X$69957 14073 10792 10871 10139 10793 6604 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $69992 r0 *1 560.56,871.92
X$69992 10388 7101 10138 10473 6604 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $69996 m0 *1 579.04,801.36
X$69996 14074 6827 9667 6604 9041 9146 14073 gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $69999 m0 *1 607.04,922.32
X$69999 14073 6604 14074 11104 9779 10139 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $70001 m0 *1 640.08,902.16
X$70001 10874 6604 10796 10687 9213 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $70003 m0 *1 628.88,932.4
X$70003 14074 14073 6604 10391 11340 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70005 r0 *1 625.52,922.32
X$70005 14074 11264 14073 7614 11165 6604 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70007 m0 *1 629.44,942.48
X$70007 14074 14073 6604 9623 11513 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70009 r0 *1 650.16,932.4
X$70009 11448 6604 11265 11337 11284 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $70012 m0 *1 634.48,942.48
X$70012 11370 6604 11204 11514 11281 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $70014 r0 *1 633.92,932.4
X$70014 11412 6604 11266 11339 9331 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $70017 m0 *1 612.08,892.08
X$70017 14073 6604 7446 14074 10250 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70021 r0 *1 587.44,902.16
X$70021 14074 9230 11263 8127 6604 10954 9778 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $70023 m0 *1 591.36,922.32
X$70023 14074 14073 6604 11168 7242 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70038 r0 *1 626.64,761.04
X$70038 14074 14073 8615 6607 7615 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70040 r0 *1 601.44,750.96
X$70040 14074 14073 8372 6607 8042 8198 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70042 m0 *1 589.68,740.88
X$70042 14074 14073 7962 6607 8040 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70046 r0 *1 604.8,730.8
X$70046 14074 14073 8044 6607 7927 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70048 m0 *1 613.2,740.88
X$70048 14074 14073 8048 6607 8097 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70050 m0 *1 585.76,781.2
X$70050 14074 14073 8746 6607 7876 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70052 m0 *1 603.68,650.16
X$70052 14074 14073 6753 6607 6844 6673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70054 m0 *1 602,670.32
X$70054 14074 14073 6795 6607 7025 6673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70056 m0 *1 605.36,690.48
X$70056 14074 14073 7251 6607 7408 6673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70058 m0 *1 590.24,750.96
X$70058 14074 14073 8050 6607 8232 7532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70095 r0 *1 609.84,640.08
X$70095 14074 14073 6672 6673 6709 6607 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70098 m0 *1 612.08,650.16
X$70098 14074 14073 6747 6673 6785 6607 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70100 r0 *1 1044.96,640.08
X$70100 14074 14073 6742 6608 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70112 r0 *1 780.08,650.16
X$70112 14073 6801 6796 14074 6610 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70139 r0 *1 710.08,640.08
X$70139 14074 14073 6615 6614 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70155 r0 *1 744.24,650.16
X$70155 14073 6829 6796 14074 6618 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70158 m0 *1 744.24,650.16
X$70158 14074 14073 6834 6619 6747 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70179 r0 *1 935.76,660.24
X$70179 14074 14073 6623 7254 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70233 m0 *1 1173.76,650.16
X$70233 6634 14073 14074 6734 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $70236 r0 *1 1168.16,650.16
X$70236 6635 14073 14074 6811 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $70254 m0 *1 68.88,640.08
X$70254 14074 14073 6642 6640 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70287 r0 *1 180.32,771.12
X$70287 14074 6647 8725 14073 8628 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $70290 m0 *1 177.52,781.2
X$70290 14074 14073 8737 6647 8725 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $70321 r0 *1 666.96,922.32
X$70321 14074 14073 11514 6654 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70340 m0 *1 658,690.48
X$70340 14074 7299 6657 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $70343 m0 *1 667.52,700.56
X$70343 14074 14073 6657 6917 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70357 r0 *1 777.84,640.08
X$70357 14074 14073 6729 6660 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70438 m0 *1 569.52,650.16
X$70438 14074 14073 6704 6677 6755 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70447 m0 *1 32.48,650.16
X$70447 6758 14073 14074 6679 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $70459 r0 *1 358.4,992.88
X$70459 14073 12208 14074 6680 12254 12209 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $70476 m0 *1 360.64,882
X$70476 14074 14073 10460 6680 10461 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70501 r0 *1 460.88,670.32
X$70501 14074 14073 6682 7406 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70504 r0 *1 398.16,670.32
X$70504 6682 14074 7199 14073 7200 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $70534 m0 *1 241.36,771.12
X$70534 14074 6687 8632 14073 8633 8691 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $70546 m0 *1 370.72,821.52
X$70546 14074 6688 9400 9332 9403 9402 9142 14073 9510
+ gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $70554 m0 *1 394.8,861.84
X$70554 14073 10125 10098 14074 6691 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70560 m0 *1 288.96,882
X$70560 14074 14073 10526 6691 10345 10268 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70562 r0 *1 291.76,882
X$70562 14074 14073 10623 6691 10371 10556 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70564 r0 *1 413.84,1053.36
X$70564 14073 6691 14074 12038 12809 13048 13104
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $70589 m0 *1 324.8,1083.6
X$70589 14074 6691 14073 12349 13309 11948 13188
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $70592 m0 *1 411.04,1123.92
X$70592 14074 13743 14073 12104 13732 6691 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $70606 m0 *1 707.84,660.24
X$70606 14074 6722 14073 6692 6876 6723 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70620 r0 *1 349.44,650.16
X$70620 14074 14073 6694 6910 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70625 m0 *1 381.36,650.16
X$70625 14073 6696 6695 14074 6835 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $70632 m0 *1 707.28,650.16
X$70632 6722 14073 6723 6876 14074 6697 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $70656 r0 *1 476.56,942.48
X$70656 14074 14073 11434 8364 6701 6780 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70658 r0 *1 465.92,982.8
X$70658 14074 14073 12040 7334 6701 7125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70661 m0 *1 471.52,982.8
X$70661 14074 14073 11959 8856 6701 8125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70664 r0 *1 462,972.72
X$70664 14073 8852 6701 14074 11855 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $70667 r0 *1 481.6,932.4
X$70667 14074 14073 11358 8527 6701 6867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70669 r0 *1 491.12,982.8
X$70669 14074 14073 11961 8363 6701 7436 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70671 m0 *1 477.12,972.72
X$70671 14074 14073 11723 9218 6701 7409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70674 m0 *1 479.92,982.8
X$70674 14074 14073 11960 8921 6701 7126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70677 m0 *1 476.56,992.88
X$70677 14074 14073 12042 8644 6701 9245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70679 m0 *1 468.16,992.88
X$70679 14074 14073 12120 7606 6701 8093 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70714 m0 *1 573.44,871.92
X$70714 14074 14073 6701 10139 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70719 r0 *1 492.24,871.92
X$70719 14073 9053 6701 14074 10357 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70727 m0 *1 493.36,992.88
X$70727 14074 14073 12121 8231 6701 8229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70734 m0 *1 517.44,690.48
X$70734 14074 14073 7300 6702 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70744 r0 *1 664.16,730.8
X$70744 14073 6704 6755 14074 8046 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70754 m0 *1 658.56,720.72
X$70754 14074 6704 7786 14073 7785 7784 6718 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $70784 r0 *1 534.24,650.16
X$70784 14074 14073 6709 6846 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70791 m0 *1 617.12,841.68
X$70791 14073 9617 14074 6710 9918 10145 9780 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $70812 r0 *1 818.72,922.32
X$70812 14074 11119 14073 11256 9856 6712 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70815 m0 *1 814.8,831.6
X$70815 14074 14073 6712 9609 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $70817 r0 *1 778.4,680.4
X$70817 14074 7252 14073 7288 6712 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70821 m0 *1 751.52,811.44
X$70821 14074 9298 14073 9299 7383 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70823 r0 *1 771.12,771.12
X$70823 14074 8704 14073 8566 7150 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70825 m0 *1 740.88,750.96
X$70825 14074 8244 14073 8143 7710 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70830 m0 *1 719.6,811.44
X$70830 14074 9107 14073 9263 7280 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70832 r0 *1 824.88,962.64
X$70832 14074 14073 11667 11458 11610 6713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $70834 m0 *1 772.24,1023.12
X$70834 14073 6713 11372 14074 12588 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70902 r0 *1 829.36,1013.04
X$70902 14074 14073 6713 12494 11372 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $70904 r0 *1 764.96,922.32
X$70904 14074 14073 11206 6713 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70907 m0 *1 815.92,962.64
X$70907 11704 14073 14074 11458 6713 11296 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $70913 m0 *1 799.68,761.04
X$70913 14074 8521 14073 8523 8249 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70918 m0 *1 732.48,791.28
X$70918 14074 9014 14073 9013 7385 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70921 m0 *1 729.12,841.68
X$70921 14074 9807 14073 9785 8076 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70923 m0 *1 733.04,771.12
X$70923 14074 8705 14073 8614 7091 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70925 r0 *1 722.96,720.72
X$70925 14074 7883 14073 7923 6841 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70928 m0 *1 739.76,761.04
X$70928 14074 8524 14073 8470 7233 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70931 r0 *1 790.16,740.88
X$70931 14074 8312 14073 8144 7752 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70935 r0 *1 766.08,700.56
X$70935 14074 6713 14073 6945 7544 6790 7575 7628
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $70938 m0 *1 768.32,831.6
X$70938 14074 9726 14073 9566 7911 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70940 r0 *1 775.6,740.88
X$70940 14074 8085 14073 8315 6989 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70942 r0 *1 747.6,720.72
X$70942 14074 8012 14073 7833 7329 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70945 m0 *1 785.12,781.2
X$70945 14074 8611 14073 8756 7159 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70947 m0 *1 819.84,740.88
X$70947 14074 8177 14073 8145 8176 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70949 m0 *1 817.6,730.8
X$70949 14074 6713 14073 6965 8006 7885 8007 6790
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $70951 r0 *1 756.56,811.44
X$70951 14074 9405 14073 9407 7355 6713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $70953 r0 *1 771.12,670.32
X$70953 14073 6713 6884 14074 7035 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $70965 r0 *1 765.52,660.24
X$70965 14074 6957 6958 6962 6879 6880 6798 6715 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $70975 m0 *1 680.96,670.32
X$70975 14074 14073 6717 7030 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70978 m0 *1 691.04,680.4
X$70978 14074 14073 6717 7138 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $70988 m0 *1 692.72,650.16
X$70988 14074 6793 6720 6792 6719 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $70992 r0 *1 700.56,670.32
X$70992 14074 14073 6951 6719 6792 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $70998 r0 *1 708.96,660.24
X$70998 14073 6953 14074 6720 6876 6952 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $71000 r0 *1 707.28,680.4
X$71000 14074 7343 6720 7143 7139 7398 7140 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $71025 r0 *1 832.72,801.36
X$71025 14074 14073 6721 9166 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71027 r0 *1 843.36,902.16
X$71027 14074 14073 6721 11059 8236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $71032 m0 *1 720.16,670.32
X$71032 14074 14073 7143 6722 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71036 r0 *1 706.72,670.32
X$71036 14073 6723 14074 6793 7032 6954 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $71043 r0 *1 729.68,680.4
X$71043 14074 14073 6723 7248 7034 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $71047 r0 *1 728,660.24
X$71047 14073 6723 7034 14074 6956 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71049 m0 *1 726.32,670.32
X$71049 14074 7033 14073 7458 7093 6723 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $71051 r0 *1 744.24,680.4
X$71051 14074 14073 7140 6723 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71061 r0 *1 822.08,841.68
X$71061 14074 9731 14073 9996 9856 6726 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $71071 m0 *1 869.12,831.6
X$71071 14074 14073 6726 9576 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71081 r0 *1 763.84,811.44
X$71081 14074 9501 9347 14073 6727 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $71084 m0 *1 757.68,650.16
X$71084 14074 14073 6727 6746 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71088 m0 *1 766.64,740.88
X$71088 14073 8181 7962 14074 6729 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71094 r0 *1 778.4,670.32
X$71094 6730 14073 14074 7207 7077 7206 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $71239 r0 *1 660.24,851.76
X$71239 14074 9950 14073 6755 10010 10047 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $71257 r0 *1 2.24,660.24
X$71257 6757 14073 14074 7061 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71272 r0 *1 56,660.24
X$71272 14074 14073 6851 6762 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71279 r0 *1 786.8,771.12
X$71279 14074 14073 8656 6764 7038 7646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71282 r0 *1 700,972.72
X$71282 14074 14073 11811 6764 10395 8654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71285 r0 *1 463.68,1174.32
X$71285 6764 14073 14074 14062 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71287 m0 *1 703.92,962.64
X$71287 14074 10581 14073 11609 10482 6764 11709 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $71289 r0 *1 828.24,972.72
X$71289 14074 14073 11846 6764 8602 11737 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71341 r0 *1 339.92,861.84
X$71341 14074 14073 10229 6771 10121 10031 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71343 r0 *1 345.52,871.92
X$71343 14074 14073 10432 6771 10345 10459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71346 r0 *1 223.44,821.52
X$71346 14074 14073 9432 6771 8110 8545 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71349 m0 *1 449.68,851.76
X$71349 14073 9941 9912 14074 6771 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71351 r0 *1 336.56,952.56
X$71351 14074 14073 11584 6771 11188 10662 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71397 m0 *1 216.72,1134
X$71397 14074 12115 14073 13776 13777 12327 6771
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $71400 m0 *1 287.28,1164.24
X$71400 14074 11955 14073 12104 13989 12189 6771
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $71402 r0 *1 445.2,1013.04
X$71402 14074 12501 14073 12441 6771 11794 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $71408 m0 *1 254.8,932.4
X$71408 14074 11187 10114 6773 10115 10113 11144 11186 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $71423 r0 *1 259.84,720.72
X$71423 14073 7770 8000 14074 6774 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71479 r0 *1 757.68,761.04
X$71479 14074 14073 8567 6777 7038 7540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71482 r0 *1 734.72,972.72
X$71482 14074 10581 14073 11733 10482 6777 11848 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $71484 r0 *1 455.28,1174.32
X$71484 6777 14073 14074 14049 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $71486 m0 *1 721.84,962.64
X$71486 14074 14073 11663 6777 10395 8650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71526 m0 *1 767.2,982.8
X$71526 14074 14073 6777 11939 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71542 m0 *1 473.76,851.76
X$71542 14074 6780 9942 14073 9773 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $71563 r0 *1 496.16,841.68
X$71563 14074 14073 6780 9914 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71565 r0 *1 490,851.76
X$71565 10015 14074 14073 6780 10035 9943 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $71569 r0 *1 538.16,942.48
X$71569 14074 14073 11437 8364 10134 6780 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71599 m0 *1 501.76,680.4
X$71599 14074 6783 14073 7779 7208 7127 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $71606 m0 *1 465.36,912.24
X$71606 14074 6784 10972 14073 10994 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $71608 m0 *1 529.2,922.32
X$71608 14074 11197 10134 6784 8464 8852 8527 6867 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $71610 m0 *1 533.12,912.24
X$71610 14074 11077 10134 7437 8946 8852 8464 6784 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $71622 r0 *1 507.36,902.16
X$71622 10970 14074 14073 6784 10564 10860 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $71624 r0 *1 510.72,912.24
X$71624 14074 14073 6784 11075 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71631 m0 *1 515.76,660.24
X$71631 14074 14073 6785 6926 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $71638 m0 *1 527.52,670.32
X$71638 14074 6786 7128 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $71644 r0 *1 580.72,902.16
X$71644 6788 14074 10895 10964 14073 10681 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $71648 r0 *1 579.6,851.76
X$71648 14073 10140 10039 6788 10103 8127 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $71660 r0 *1 603.68,922.32
X$71660 11202 7242 11414 11105 6788 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $71663 r0 *1 568.4,922.32
X$71663 11200 10139 11262 11174 6788 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $71666 r0 *1 973.84,720.72
X$71666 14074 14073 7995 7721 7162 6789 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71668 m0 *1 974.4,720.72
X$71668 14073 7826 14074 6789 7811 7810 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $71682 m0 *1 949.76,700.56
X$71682 14074 14073 6789 7379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $71693 r0 *1 776.72,851.76
X$71693 10054 14073 7152 7151 14074 6790 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $71725 r0 *1 774.48,650.16
X$71725 14073 6798 6796 14074 6791 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71729 r0 *1 679.84,660.24
X$71729 14073 14074 6871 6792 6998 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $71748 r0 *1 683.76,670.32
X$71748 14074 6793 6871 6872 6949 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $71752 r0 *1 759.92,660.24
X$71752 14073 7153 6796 14074 6794 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71760 m0 *1 645.68,771.12
X$71760 14073 8520 6796 14074 8715 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71762 r0 *1 817.04,942.48
X$71762 10579 14074 11458 6796 14073 11211 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $71767 r0 *1 754.32,690.48
X$71767 14073 7464 6796 14074 7392 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71825 r0 *1 766.64,942.48
X$71825 14074 14073 11295 6796 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $71827 m0 *1 668.64,740.88
X$71827 14073 8003 6796 14074 8191 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71829 r0 *1 713.44,781.2
X$71829 14073 8867 6796 14074 8909 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71831 m0 *1 718.48,821.52
X$71831 14073 9348 6796 14074 9502 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71833 r0 *1 700,811.44
X$71833 14073 8486 6796 14074 9346 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71835 r0 *1 679.84,811.44
X$71835 14073 8957 6796 14074 9255 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71837 m0 *1 636.16,791.28
X$71837 14073 8480 6796 14074 9114 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71840 m0 *1 646.8,781.2
X$71840 14073 8568 6796 14074 8832 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71842 m0 *1 635.04,831.6
X$71842 14073 8045 6796 14074 9622 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71844 m0 *1 722.4,841.68
X$71844 14073 9569 6796 14074 9808 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71846 m0 *1 724.08,851.76
X$71846 14073 9786 6796 14074 9908 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71848 r0 *1 648.48,871.92
X$71848 14073 10238 6796 14074 10146 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71851 m0 *1 726.88,771.12
X$71851 14073 8650 6796 14074 8706 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71853 r0 *1 677.6,771.12
X$71853 14073 8654 6796 14074 8709 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71856 m0 *1 712.32,730.8
X$71856 14073 7967 6796 14074 7790 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71858 r0 *1 730.24,740.88
X$71858 14073 8147 6796 14074 8316 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71860 r0 *1 724.08,750.96
X$71860 14073 8386 6796 14074 8142 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71862 r0 *1 737.52,740.88
X$71862 14073 8245 6796 14074 8054 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71866 m0 *1 819.84,952.56
X$71866 11458 14073 6796 11642 14074 10579 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $71868 m0 *1 747.04,730.8
X$71868 14073 7972 6796 14074 7971 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71871 r0 *1 749.28,841.68
X$71871 14073 9787 6796 14074 9907 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71873 r0 *1 757.68,710.64
X$71873 14073 7630 6796 14074 7711 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71875 r0 *1 818.72,680.4
X$71875 14073 7154 6796 14074 7287 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71878 r0 *1 813.68,680.4
X$71878 14073 7545 6796 14074 7285 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71881 r0 *1 805.28,660.24
X$71881 14073 7089 6796 14074 6878 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71883 r0 *1 793.52,680.4
X$71883 14073 7354 6796 14074 7298 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71886 r0 *1 780.64,660.24
X$71886 14073 6959 6796 14074 6877 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $71891 m0 *1 759.92,660.24
X$71891 14074 14073 6797 7148 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $71917 m0 *1 765.52,871.92
X$71917 14074 14073 10356 10297 9964 6798 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71920 r0 *1 769.44,871.92
X$71920 14074 10297 14073 10057 10234 10053 6798
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $71926 m0 *1 808.64,660.24
X$71926 14073 6879 14074 6881 6801 6799 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $71931 m0 *1 828.8,660.24
X$71931 14073 6879 14074 6882 6829 6800 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $71959 r0 *1 788.48,871.92
X$71959 14074 10155 14073 10057 10156 10053 6801
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $71962 m0 *1 786.8,861.84
X$71962 14074 14073 10050 10155 9964 6801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $71976 m0 *1 697.2,892.08
X$71976 14074 14073 10759 6802 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72039 m0 *1 641.2,791.28
X$72039 14074 14073 6814 6916 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72042 r0 *1 637.28,781.2
X$72042 14074 6814 9022 8916 8833 8862 14073 gf180mcu_fd_sc_mcu9t5v0__or4_4
* cell instance $72089 m0 *1 632.24,882
X$72089 14074 14073 10478 6825 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72133 r0 *1 748.16,902.16
X$72133 14074 14073 10952 10800 9964 6829 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72135 m0 *1 759.36,902.16
X$72135 14074 10800 14073 10057 10854 10053 6829
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $72166 m0 *1 801.36,680.4
X$72166 14073 7151 14074 7041 7153 6836 7152 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72198 r0 *1 486.64,801.36
X$72198 14074 14073 6840 9245 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72205 r0 *1 720.16,861.84
X$72205 14074 9731 14073 10295 9856 6841 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72242 r0 *1 528.08,861.84
X$72242 14074 14073 6844 10135 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $72244 m0 *1 437.92,861.84
X$72244 9842 14073 6844 9249 14074 10129 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $72247 r0 *1 439.6,871.92
X$72247 9842 14073 6844 9337 14074 10384 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $72249 r0 *1 438.48,841.68
X$72249 9842 6844 7611 9249 14074 14073 9840 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $72259 r0 *1 529.76,660.24
X$72259 14074 14073 6846 7333 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72273 r0 *1 602,892.08
X$72273 14074 10139 14073 10792 9848 10684 6848 10250
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $72278 r0 *1 15.68,660.24
X$72278 6849 14073 14074 6890 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $72304 m0 *1 371.84,680.4
X$72304 14073 6853 7017 14074 7290 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $72306 r0 *1 431.76,670.32
X$72306 14074 14073 6853 7295 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $72308 r0 *1 370.72,660.24
X$72308 14073 6853 6939 14074 7018 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $72320 r0 *1 188.72,861.84
X$72320 14074 10216 10114 6855 10115 10113 10214 10262 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $72346 m0 *1 338.8,821.52
X$72346 6859 14073 9435 9329 14074 9610 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $72368 m0 *1 404.88,660.24
X$72368 14073 6863 6862 14074 6915 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $72370 m0 *1 400.96,690.48
X$72370 14073 7321 7400 14074 6862 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $72372 m0 *1 409.36,670.32
X$72372 14074 14073 6928 6863 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $72379 m0 *1 490,670.32
X$72379 14074 14073 6864 7437 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72390 m0 *1 400.96,861.84
X$72390 14074 6866 10102 14073 10098 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72392 r0 *1 532,871.92
X$72392 14074 10997 10134 6866 8190 8852 8422 7236 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $72394 r0 *1 538.16,861.84
X$72394 14074 11438 10134 6866 8190 8466 7872 9734 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $72415 r0 *1 503.44,841.68
X$72415 9916 14074 14073 6866 9411 9917 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $72418 m0 *1 516.88,851.76
X$72418 14074 14073 6866 9945 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $72436 m0 *1 532.56,932.4
X$72436 14074 14073 11196 8527 10134 6867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72438 r0 *1 472.64,922.32
X$72438 14074 14073 6867 11101 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $72440 r0 *1 500.64,912.24
X$72440 10971 14074 14073 6867 8917 10995 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $72451 r0 *1 650.72,660.24
X$72451 14073 6941 6868 14074 6948 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $72470 r0 *1 672.56,660.24
X$72470 14074 6872 14073 6874 6911 6870 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72472 m0 *1 650.16,680.4
X$72472 14074 14073 6998 6870 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72474 m0 *1 684.88,680.4
X$72474 6870 14073 6871 7139 14074 7137 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $72476 m0 *1 668.08,670.32
X$72476 14074 6949 6871 7029 7095 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $72488 m0 *1 665.84,660.24
X$72488 14073 6871 6872 14074 6873 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $72493 m0 *1 639.52,670.32
X$72493 14074 6872 6998 7027 7028 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $72502 r0 *1 700.56,660.24
X$72502 6875 14073 14074 6951 6949 6873 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $72510 m0 *1 700.56,670.32
X$72510 14074 6952 7296 7094 6951 6873 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $72517 r0 *1 716.8,660.24
X$72517 14074 6954 14073 7141 6875 6995 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72525 r0 *1 730.24,670.32
X$72525 14074 6876 14073 6956 7145 7033 7034 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $72538 m0 *1 812.56,761.04
X$72538 14074 6957 8090 8570 6879 6880 8520 8521 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72540 m0 *1 804.72,740.88
X$72540 14074 6957 7802 8056 6879 6880 8147 8179 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72542 m0 *1 776.16,841.68
X$72542 14074 6957 8043 9673 6879 7152 9787 9726 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72544 r0 *1 775.6,811.44
X$72544 14074 6957 7804 9163 6879 7152 9348 9405 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72546 m0 *1 779.52,771.12
X$72546 14074 6957 7646 8655 6879 7152 8654 8704 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72548 r0 *1 738.64,791.28
X$72548 14074 6957 7969 9160 6879 7152 8486 9107 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72550 r0 *1 749.84,801.36
X$72550 14074 6957 7640 9161 6879 7152 8957 9298 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72552 m0 *1 829.36,730.8
X$72552 14073 6879 14074 7974 8003 8006 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72554 r0 *1 764.4,750.96
X$72554 14074 6957 8194 8482 6879 6880 8386 8244 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72556 r0 *1 792.96,761.04
X$72556 14074 6957 7806 8610 6879 6880 8568 8611 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72558 m0 *1 747.04,761.04
X$72558 14074 6957 7713 8479 6879 6880 8480 8524 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72561 m0 *1 752.08,771.12
X$72561 14074 6957 7540 8652 6879 6880 8650 8705 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72563 r0 *1 736.4,821.52
X$72563 14074 6957 7633 9568 6879 7152 9569 9613 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72565 r0 *1 735.28,781.2
X$72565 14074 6957 8053 8758 6879 7152 8867 9014 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72567 m0 *1 778.96,690.48
X$72567 14074 6957 7390 7353 6879 6880 6959 7252 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72572 m0 *1 748.16,841.68
X$72572 14074 6957 7715 9672 6879 7152 9786 9807 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72574 m0 *1 764.4,730.8
X$72574 14074 6957 7582 7918 6879 6880 7972 8012 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72613 m0 *1 739.76,851.76
X$72613 14073 6879 14074 9961 10238 9962 7152 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72615 r0 *1 809.2,781.2
X$72615 14074 14073 7151 6879 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72619 m0 *1 807.52,700.56
X$72619 14073 6879 14074 7543 7545 7544 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72621 m0 *1 814.24,680.4
X$72621 14073 7151 14074 7155 7154 7037 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72630 m0 *1 815.36,750.96
X$72630 14074 6957 7726 8246 7151 6880 8387 8177 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72636 r0 *1 806.96,690.48
X$72636 14073 7151 14074 7465 7464 7388 6880 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $72642 r0 *1 797.44,720.72
X$72642 14074 6957 7632 7805 7151 6880 7967 7883 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72667 r0 *1 778.4,730.8
X$72667 14074 6957 7550 7973 7151 6880 8045 8085 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72671 r0 *1 809.2,740.88
X$72671 14074 6957 7809 8148 7151 6880 8245 8312 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72675 r0 *1 816.48,700.56
X$72675 14074 6957 7546 7547 7151 6880 7630 7573 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $72677 m0 *1 799.68,700.56
X$72677 14074 14073 7152 6880 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72679 r0 *1 813.12,670.32
X$72679 14074 14073 7087 7203 7036 6881 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72688 m0 *1 828.24,670.32
X$72688 14074 14073 6964 7039 7036 6882 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72693 m0 *1 907.2,730.8
X$72693 14074 7975 7977 14073 6883 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72707 r0 *1 915.6,670.32
X$72707 14074 14073 6883 6966 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72711 r0 *1 908.88,720.72
X$72711 14074 14073 6883 7887 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72731 r0 *1 923.44,670.32
X$72731 14074 6885 14073 7081 7196 7279 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72772 m0 *1 45.92,660.24
X$72772 14074 14073 6891 6892 7181 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $72786 m0 *1 50.4,670.32
X$72786 14074 6894 7066 14073 7005 7064 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $72808 m0 *1 146.72,1154.16
X$72808 14074 13931 14073 13829 12116 6898 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72812 r0 *1 147.84,942.48
X$72812 14074 14073 11419 6898 10345 11420 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72815 r0 *1 168.56,942.48
X$72815 14074 14073 11421 6898 7763 11422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72818 m0 *1 159.6,962.64
X$72818 14074 14073 11696 6898 10371 11651 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72838 m0 *1 410.48,781.2
X$72838 14074 8736 14073 6898 8737 8741 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $72843 m0 *1 260.96,1023.12
X$72843 14073 6898 12349 14074 12517 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $72845 r0 *1 160.72,1154.16
X$72845 14074 13932 14073 12104 14067 6898 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $72855 m0 *1 1078,902.16
X$72855 14074 6900 8399 14073 10818 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72857 r0 *1 1109.36,912.24
X$72857 14074 6900 7891 14073 11021 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72859 m0 *1 1004.64,740.88
X$72859 14074 8170 6900 14073 8154 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72861 r0 *1 1033.2,730.8
X$72861 14074 6900 8060 14073 8061 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72863 r0 *1 1098.72,861.84
X$72863 14074 8392 6900 14073 10316 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72882 r0 *1 907.76,660.24
X$72882 14074 6988 6900 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $72884 m0 *1 1046.64,871.92
X$72884 14074 14073 10335 7829 6900 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $72887 m0 *1 1055.6,761.04
X$72887 14074 14073 8397 8396 6900 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $72890 r0 *1 1058.4,811.44
X$72890 14074 14073 9359 9270 6900 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $72892 r0 *1 1115.52,932.4
X$72892 14074 14073 6900 11471 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72896 r0 *1 933.52,771.12
X$72896 14074 8294 6902 14073 8763 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72899 m0 *1 931.28,791.28
X$72899 14074 6902 8960 14073 9003 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72902 m0 *1 1118.88,831.6
X$72902 14074 6902 7648 14073 9695 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $72914 m0 *1 1105.44,831.6
X$72914 14074 14073 6902 9595 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $72917 m0 *1 1069.04,750.96
X$72917 14074 6902 8266 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $72924 r0 *1 866.32,730.8
X$72924 14074 6903 8153 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $72946 r0 *1 853.44,730.8
X$72946 14074 14073 8081 6909 7038 7726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72949 r0 *1 818.16,932.4
X$72949 14074 14073 11210 6909 10395 8387 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72954 m0 *1 941.36,690.48
X$72954 14074 7382 14085 7254 6909 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $72978 r0 *1 953.12,690.48
X$72978 7378 14074 14073 7254 6909 14118 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $72983 m0 *1 978.32,710.64
X$72983 14074 14073 7148 6909 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $72986 r0 *1 827.68,952.56
X$72986 14074 11542 10581 11458 11612 6909 11705 10579 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $72988 m0 *1 860.72,831.6
X$72988 14074 14073 9720 8369 9349 6909 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $72995 m0 *1 361.76,851.76
X$72995 14074 6910 9939 10009 9940 9837 9831 14073 10097
+ gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $73027 r0 *1 729.68,761.04
X$73027 14074 14073 8612 6916 7038 7713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73040 m0 *1 649.04,791.28
X$73040 14074 14073 6916 9259 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73047 m0 *1 864.64,811.44
X$73047 14074 14073 9396 6917 8602 8868 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73049 r0 *1 857.92,720.72
X$73049 14074 14073 7915 6917 7038 7720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73053 r0 *1 727.44,882
X$73053 14074 10581 14073 10394 10482 6917 10630 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $73057 r0 *1 708.96,882
X$73057 14074 14073 10574 6917 10395 7967 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73060 r0 *1 1173.2,670.32
X$73060 6917 14073 14074 7179 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $73085 r0 *1 458.64,761.04
X$73085 14074 7437 6918 14073 8554 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $73087 r0 *1 285.04,761.04
X$73087 8454 8353 8607 8606 14073 14074 6918 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $73103 r0 *1 477.12,892.08
X$73103 14073 6920 14074 10671 10855 10672 7327 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $73106 r0 *1 476.56,902.16
X$73106 14073 6943 14074 10891 10966 10788 6920 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $73124 m0 *1 468.16,660.24
X$73124 14074 14073 6922 8124 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73151 r0 *1 512.96,660.24
X$73151 14074 14073 6926 7003 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73155 m0 *1 29.12,670.32
X$73155 6927 14073 14074 7004 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $73174 m0 *1 449.12,690.48
X$73174 14074 14073 6928 7232 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73176 m0 *1 386.96,700.56
X$73176 7321 6928 7104 7400 14074 14073 7657 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $73178 r0 *1 391.44,690.48
X$73178 7321 14073 6928 7433 14074 7399 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $73185 m0 *1 79.52,821.52
X$73185 14073 6929 9489 14074 9424 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73194 m0 *1 213.36,811.44
X$73194 6931 9753 9391 9131 14074 14073 9248 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $73225 m0 *1 688.8,670.32
X$73225 14074 6938 6950 6953 14073 gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* cell instance $73238 r0 *1 591.36,740.88
X$73238 14073 14074 7023 8200 8127 6938 8332 7214
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $73240 r0 *1 676.48,690.48
X$73240 14074 14073 6938 7453 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $73272 m0 *1 474.88,922.32
X$73272 14073 14074 11171 8852 11170 11172 11173 6943
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $73293 r0 *1 503.44,750.96
X$73293 14073 6944 8369 14074 8367 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73312 r0 *1 814.8,841.68
X$73312 14074 9731 14073 10059 9856 6945 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $73314 m0 *1 818.72,841.68
X$73314 14074 14073 6945 9805 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $73323 r0 *1 538.72,680.4
X$73323 14074 14073 6946 7611 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73331 r0 *1 659.12,690.48
X$73331 6948 7452 7299 7349 14073 14074 7494 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $73335 r0 *1 651.28,680.4
X$73335 14074 14073 6948 7240 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73341 r0 *1 724.08,670.32
X$73341 14074 14073 6953 7093 6949 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73371 m0 *1 714,680.4
X$73371 14074 14073 6953 6954 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $73373 m0 *1 720.72,690.48
X$73373 14074 14073 7144 6953 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73383 r0 *1 735.28,660.24
X$73383 14074 14073 6994 6955 6957 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $73385 m0 *1 1117.2,761.04
X$73385 14074 8401 7478 7164 8090 6955 8043 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73401 r0 *1 1116.64,750.96
X$73401 14074 8407 7554 7164 8043 6955 8400 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73403 r0 *1 1130.64,771.12
X$73403 14074 14073 8675 8674 7162 6955 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73405 m0 *1 1118.88,771.12
X$73405 14074 8796 8090 7478 8400 6955 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73411 r0 *1 571.2,680.4
X$73411 14074 14073 7239 7303 6955 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73415 m0 *1 763.28,932.4
X$73415 11206 14074 11207 11295 14073 6957 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $73484 m0 *1 531.44,730.8
X$73484 14074 14073 7239 7958 6958 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73486 m0 *1 529.2,750.96
X$73486 14073 7239 14074 7237 8323 6958 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $73488 r0 *1 1101.52,750.96
X$73488 14074 8588 7806 7478 7982 6958 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73509 m0 *1 1098.72,720.72
X$73509 14074 7991 7478 7164 7806 6958 7715 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73511 m0 *1 1094.24,730.8
X$73511 14074 8063 7554 7164 7715 6958 7982 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $73514 m0 *1 1105.44,761.04
X$73514 14074 14073 8495 8503 7162 6958 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73520 m0 *1 844.48,912.24
X$73520 14073 10300 14074 10587 9854 10906 6959 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $73542 m0 *1 843.92,871.92
X$73542 14074 14073 10157 10300 9964 6959 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73544 m0 *1 812.56,710.64
X$73544 14074 7642 6960 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $73580 m0 *1 802.48,720.72
X$73580 14074 14073 6960 14153 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $73603 m0 *1 790.16,670.32
X$73603 14074 14073 6961 7090 7036 6962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $73624 r0 *1 820.96,730.8
X$73624 14074 6965 7956 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $73651 r0 *1 903.84,801.36
X$73651 14074 14073 6968 9171 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73680 r0 *1 1098.72,660.24
X$73680 14074 14073 6980 6974 6975 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $73712 m0 *1 71.68,670.32
X$73712 14074 14073 6978 7067 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $73767 m0 *1 691.04,932.4
X$73767 14074 14073 11337 6987 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73780 r0 *1 843.36,1002.96
X$73780 14073 12419 14074 8602 12299 6989 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $73791 r0 *1 650.16,1002.96
X$73791 14074 12333 14073 12425 12129 9856 6989 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $73803 m0 *1 975.52,761.04
X$73803 14074 8170 6991 14073 8511 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $73805 m0 *1 1015.28,740.88
X$73805 14074 6991 8060 14073 8297 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $73820 r0 *1 1065.12,821.52
X$73820 14074 14073 6991 9796 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $73822 m0 *1 1055.6,750.96
X$73822 14074 14073 8267 8396 6991 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $73825 m0 *1 1062.32,750.96
X$73825 14074 14073 8398 8155 6991 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $73827 m0 *1 1044.4,821.52
X$73827 14074 14073 9488 7829 6991 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $73873 r0 *1 506.24,690.48
X$73873 14073 7002 14074 7499 8462 7498 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $73884 r0 *1 525.28,710.64
X$73884 14073 7608 7002 14074 7698 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73886 m0 *1 519.68,720.72
X$73886 14074 14073 7608 7849 7002 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73888 r0 *1 439.04,932.4
X$73888 14073 7003 9337 14074 11191 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73914 m0 *1 400.96,831.6
X$73914 14074 9440 9546 7003 9659 14073 9615 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $73916 r0 *1 400.4,821.52
X$73916 14074 14073 7003 9547 9249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73920 m0 *1 431.76,841.68
X$73920 14074 14073 7003 9771 9337 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73924 m0 *1 512.4,902.16
X$73924 10763 14074 14073 10859 7003 14096 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $73926 m0 *1 512.96,922.32
X$73926 14074 14073 7003 9550 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $73930 m0 *1 402.64,932.4
X$73930 14073 7003 9249 14074 10663 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73932 m0 *1 424.48,922.32
X$73932 14073 7003 7333 14074 11099 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $73935 m0 *1 418.32,922.32
X$73935 7003 14073 7333 9842 14074 11098 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $73938 m0 *1 513.52,942.48
X$73938 14073 7003 11175 14074 11439 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $73948 r0 *1 408.8,811.44
X$73948 14074 14073 9334 7006 9335 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $73972 m0 *1 221.76,1023.12
X$73972 14073 14074 12574 12513 12631 7006 12628 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $74004 r0 *1 130.48,710.64
X$74004 7009 14073 14074 14082 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $74011 m0 *1 141.68,700.56
X$74011 14074 7394 7009 7569 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74054 r0 *1 70.56,690.48
X$74054 14074 7415 7009 7307 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74058 r0 *1 187.6,700.56
X$74058 14074 7600 7009 7571 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74063 m0 *1 92.4,670.32
X$74063 14074 7010 7009 7068 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74066 r0 *1 159.6,700.56
X$74066 14074 7506 7009 7505 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74070 m0 *1 138.32,690.48
X$74070 14074 7321 7009 7418 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $74091 m0 *1 380.8,680.4
X$74091 14074 14073 7010 7118 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $74093 m0 *1 434,690.48
X$74093 14074 14073 7010 7495 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74095 m0 *1 366.8,680.4
X$74095 14073 7010 7117 14074 7017 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $74119 r0 *1 254.24,861.84
X$74119 14074 10222 10114 7014 10115 10113 10110 10266 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $74143 r0 *1 432.32,720.72
X$74143 14074 14073 7600 8034 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74145 r0 *1 456.96,730.8
X$74145 14074 14073 7321 8228 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74175 m0 *1 439.04,700.56
X$74175 14074 14073 7104 7587 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74177 r0 *1 442.4,720.72
X$74177 14074 14073 7506 7869 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74180 r0 *1 437.36,720.72
X$74180 14074 14073 7415 8123 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74183 r0 *1 460.88,710.64
X$74183 14073 7652 7019 14074 7695 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $74185 r0 *1 451.92,710.64
X$74185 14074 14073 7394 7925 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74188 r0 *1 445.2,730.8
X$74188 14074 14073 7589 8094 7019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74207 r0 *1 556.08,801.36
X$74207 14074 14073 9145 7023 9029 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74209 r0 *1 603.12,841.68
X$74209 14073 9847 14074 7023 7214 9848 7148 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $74212 m0 *1 571.2,801.36
X$74212 14073 9122 14074 9222 9228 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74214 m0 *1 561.68,801.36
X$74214 14073 9226 9252 7023 9227 8127 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $74216 r0 *1 593.04,761.04
X$74216 14073 14074 8448 8461 7214 8534 8622 7023
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $74218 r0 *1 632.8,710.64
X$74218 14073 14074 7597 7644 7214 7843 7844 7023
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $74221 r0 *1 542.64,892.08
X$74221 14074 14073 10677 7023 10765 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74223 r0 *1 550.48,902.16
X$74223 14073 10678 14074 10973 10865 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74225 m0 *1 621.6,892.08
X$74225 14073 8127 14074 10572 10573 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74227 m0 *1 562.24,771.12
X$74227 14073 8127 14074 8468 8717 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74229 m0 *1 674.8,912.24
X$74229 14073 10957 14074 7023 7214 10899 9409 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $74231 m0 *1 674.8,922.32
X$74231 14073 11111 14074 7023 7214 11112 9461 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $74233 m0 *1 663.6,922.32
X$74233 14073 9845 14074 7023 7214 11109 11164 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $74235 r0 *1 647.92,912.24
X$74235 14073 11072 14074 11003 11107 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74238 m0 *1 600.32,902.16
X$74238 14073 10682 10683 7023 10869 8127 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $74241 m0 *1 590.24,831.6
X$74241 14073 9561 14074 9562 9778 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74243 m0 *1 549.92,851.76
X$74243 14073 9946 14074 9915 10104 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74245 r0 *1 548.24,831.6
X$74245 14073 9664 14074 9665 9923 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74247 m0 *1 548.24,871.92
X$74247 14074 14073 10445 7023 10136 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74250 m0 *1 591.36,861.84
X$74250 14073 10142 14074 8128 10253 7023 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74296 m0 *1 577.36,690.48
X$74296 14074 14073 7024 7670 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $74309 r0 *1 503.44,781.2
X$74309 14074 14073 7025 8917 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $74313 m0 *1 823.76,781.2
X$74313 14074 14073 8823 8824 8602 7026 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74324 r0 *1 821.52,882
X$74324 14074 10624 14073 10484 9856 7026 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $74336 m0 *1 673.68,740.88
X$74336 7030 14074 8047 8137 14073 8188 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $74338 r0 *1 680.4,740.88
X$74338 14073 8327 14074 8047 8139 7030 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74340 r0 *1 683.76,781.2
X$74340 14073 8863 14074 8913 9301 7030 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74342 m0 *1 673.12,761.04
X$74342 14073 8241 14074 8047 8475 7030 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $74351 m0 *1 691.04,740.88
X$74351 14074 8047 7347 7621 7031 14073 8243 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $74353 r0 *1 691.6,781.2
X$74353 14074 8913 7031 14073 8648 8649 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $74355 r0 *1 692.16,771.12
X$74355 7031 14073 8648 8649 14074 8755 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $74365 r0 *1 708.4,781.2
X$74365 14073 7031 8648 14074 8564 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $74368 r0 *1 700,771.12
X$74368 14074 8708 14073 8954 8648 7031 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $74370 r0 *1 707.84,690.48
X$74370 14074 7344 14073 7456 7032 7143 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $74373 m0 *1 719.04,680.4
X$74373 14074 7488 7247 7033 7143 14073 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $74376 r0 *1 739.2,670.32
X$74376 14074 14073 7034 7146 7033 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74389 m0 *1 736.4,690.48
X$74389 14074 14073 7034 7350 7395 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74396 m0 *1 734.72,811.44
X$74396 14074 14073 9157 9158 7036 9160 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74399 r0 *1 847.28,680.4
X$74399 14074 14073 7284 7387 7036 7155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74401 r0 *1 876.96,700.56
X$74401 14074 14073 7549 7631 7036 7465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74404 r0 *1 778.4,831.6
X$74404 14074 14073 9571 9724 7036 9673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74407 m0 *1 809.2,730.8
X$74407 14074 14073 8010 7801 7036 8056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74409 r0 *1 785.68,720.72
X$74409 14074 14073 7884 7800 7036 7973 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74411 r0 *1 866.32,690.48
X$74411 14074 14073 7481 7480 7036 7356 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74413 m0 *1 871.36,680.4
X$74413 14074 14073 7201 7157 7036 7158 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74415 r0 *1 855.12,740.88
X$74415 14074 14073 8309 8248 7036 8148 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74418 m0 *1 743.12,811.44
X$74418 14074 14073 9159 9108 7036 9161 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74421 m0 *1 770,771.12
X$74421 14074 14073 8481 8653 7036 8482 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74423 r0 *1 823.2,710.64
X$74423 14074 14073 7747 7650 7036 7547 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74425 r0 *1 782.32,781.2
X$74425 14074 14073 8825 8656 7036 8655 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74428 r0 *1 848.96,720.72
X$74428 14074 14073 7916 7915 7036 7805 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74430 r0 *1 773.36,801.36
X$74430 14074 14073 9211 9162 7036 9163 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74432 m0 *1 799.68,771.12
X$74432 14074 14073 8657 8608 7036 8610 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74434 m0 *1 741.44,771.12
X$74434 14074 14073 8565 8612 7036 8479 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74436 r0 *1 752.64,771.12
X$74436 14074 14073 8759 8567 7036 8652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74439 m0 *1 730.24,851.76
X$74439 14074 14073 9960 8199 7036 9961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74441 r0 *1 736.96,831.6
X$74441 14074 14073 9729 9728 7036 9568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74443 r0 *1 726.88,781.2
X$74443 14074 14073 8757 8651 7036 8758 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74445 r0 *1 823.76,761.04
X$74445 14074 14073 8569 8604 7036 8570 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74447 m0 *1 850.08,750.96
X$74447 14074 14073 8247 8081 7036 8246 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74450 m0 *1 767.76,1013.04
X$74450 14074 7036 12496 14073 12452 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74453 m0 *1 782.32,700.56
X$74453 14074 14073 7484 7542 7036 7353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74457 m0 *1 769.44,720.72
X$74457 14074 14073 7882 7799 7036 7918 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74459 m0 *1 802.48,710.64
X$74459 14074 14073 7629 7749 7036 7543 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74514 m0 *1 845.04,952.56
X$74514 14074 14073 11543 7036 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $74517 r0 *1 873.6,680.4
X$74517 14074 14073 7040 7282 7036 7041 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74520 m0 *1 753.2,831.6
X$74520 14074 14073 9727 9570 7036 9672 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74523 m0 *1 826,720.72
X$74523 14074 14073 7917 7831 7036 7974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74530 m0 *1 848.96,690.48
X$74530 14074 14073 7387 7240 7038 7386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74537 m0 *1 785.12,720.72
X$74537 14074 14073 7800 7182 7038 7550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74546 r0 *1 778.4,771.12
X$74546 14074 14073 8653 7319 7038 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74550 m0 *1 834.4,720.72
X$74550 14074 14073 7831 7803 7038 7613 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74552 m0 *1 771.12,811.44
X$74552 14074 14073 9162 8738 7038 7804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74554 m0 *1 886.48,710.64
X$74554 14074 14073 7631 7213 7038 7718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74556 r0 *1 808.08,761.04
X$74556 14074 14073 8608 8459 7038 7806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74559 r0 *1 730.24,771.12
X$74559 14074 14073 8651 7501 7038 8053 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74561 r0 *1 728.56,831.6
X$74561 14074 14073 9728 7403 7038 7633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74563 r0 *1 730.24,791.28
X$74563 14074 14073 9108 7784 7038 7640 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74565 r0 *1 832.16,761.04
X$74565 14074 14073 8604 8290 7038 8090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74567 m0 *1 730.8,801.36
X$74567 14074 14073 9158 8740 7038 7969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74570 m0 *1 790.16,922.32
X$74570 14074 14073 11161 11160 7038 9349 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74575 r0 *1 756,821.52
X$74575 14074 14073 9570 8362 7038 7715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74577 r0 *1 770,831.6
X$74577 14074 14073 9724 9777 7038 8043 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74579 r0 *1 772.24,710.64
X$74579 14074 14073 7799 7832 7038 7745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74649 m0 *1 953.68,791.28
X$74649 14074 8170 7043 14073 9000 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74651 r0 *1 1084.72,761.04
X$74651 14074 8392 7043 14073 8590 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74654 r0 *1 1098.72,831.6
X$74654 14074 7043 8399 14073 9698 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74658 m0 *1 999.04,761.04
X$74658 14074 7043 8060 14073 8509 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74660 m0 *1 1092,861.84
X$74660 14074 7043 7891 14073 10181 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74663 r0 *1 1128.4,861.84
X$74663 14074 7043 10182 14073 10183 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $74686 r0 *1 960.4,740.88
X$74686 14074 14073 8166 8256 7043 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74688 r0 *1 1064.56,740.88
X$74688 14074 14073 8156 8155 7043 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74690 r0 *1 1122.8,871.92
X$74690 14074 14073 7043 10712 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $74692 m0 *1 1046.64,761.04
X$74692 14074 14073 8410 7829 7043 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74699 r0 *1 962.64,670.32
X$74699 14074 14073 7044 7164 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $74742 r0 *1 1107.68,670.32
X$74742 14073 7052 7054 14074 7053 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $74789 m0 *1 1141.28,680.4
X$74789 14074 14073 7176 7059 7060 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74853 m0 *1 201.6,912.24
X$74853 14074 14073 11049 7074 10121 10877 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74855 r0 *1 183.12,922.32
X$74855 14074 14073 11152 7074 10371 11090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74858 r0 *1 165.2,882
X$74858 14074 14073 10551 7074 10345 10552 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74879 m0 *1 458.64,811.44
X$74879 14074 14073 7074 9143 9250 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $74882 m0 *1 180.32,1134
X$74882 14074 12115 14073 13775 13799 12327 7074
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $74884 m0 *1 191.52,1164.24
X$74884 14074 13933 14073 12104 13985 7074 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $74916 m0 *1 899.36,670.32
X$74916 14074 7082 7808 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $74927 r0 *1 456.4,912.24
X$74927 14074 14073 10993 7085 10994 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $74949 r0 *1 455.84,1023.12
X$74949 14074 12585 14073 12663 12644 7085 12210
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $74951 m0 *1 318.08,1013.04
X$74951 14073 14074 11952 12359 12358 7085 12519 11860
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $74960 r0 *1 802.48,670.32
X$74960 14073 7151 14074 7158 7089 7088 7152 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $74968 m0 *1 815.92,851.76
X$74968 14073 9854 9993 7089 10061 9996 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $74984 m0 *1 803.04,851.76
X$74984 14074 14073 7352 9965 9964 7089 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $74987 r0 *1 819.28,861.84
X$74987 14074 9965 14073 10057 9995 10053 7089 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $75011 m0 *1 770.56,982.8
X$75011 14074 14073 12008 11939 8602 7091 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75014 r0 *1 723.52,972.72
X$75014 14074 11848 14073 11884 11731 9856 7091 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $75027 m0 *1 698.88,750.96
X$75027 14074 8377 7094 7834 8319 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $75034 r0 *1 702.8,720.72
X$75034 14074 14073 7094 8140 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75055 m0 *1 593.04,690.48
X$75055 14073 7243 7099 14074 7335 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75064 r0 *1 507.92,680.4
X$75064 14074 14073 7100 7409 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75068 m0 *1 565.04,882
X$75068 14073 7101 10388 14074 10444 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75106 r0 *1 10.64,690.48
X$75106 7102 14073 14074 7414 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $75146 m0 *1 46.48,740.88
X$75146 14074 14073 7103 14151 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $75157 m0 *1 12.32,680.4
X$75157 14074 7104 7103 7180 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $75164 m0 *1 12.88,710.64
X$75164 14074 7589 7103 7730 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $75185 m0 *1 394.24,680.4
X$75185 14074 14073 7104 7119 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75195 m0 *1 68.32,690.48
X$75195 14074 14073 7106 7369 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75210 m0 *1 86.8,841.68
X$75210 14073 7108 9748 14074 9827 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75214 r0 *1 192.64,851.76
X$75214 7110 10374 10334 9998 14074 14073 9621 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $75254 r0 *1 236.88,740.88
X$75254 14074 14073 7111 14164 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $75269 r0 *1 269.92,710.64
X$75269 14074 7652 7111 7686 14073 gf180mcu_fd_sc_mcu9t5v0__dffq_2
* cell instance $75302 m0 *1 454.72,851.76
X$75302 14073 9941 14074 9836 7115 8229 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $75321 r0 *1 287.84,982.8
X$75321 14073 14074 12026 12027 12415 7115 12097 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $75339 r0 *1 379.68,680.4
X$75339 14073 7118 7289 14074 7291 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $75341 r0 *1 392.56,680.4
X$75341 14073 7119 7399 14074 7292 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $75383 m0 *1 478.8,882
X$75383 14073 7327 14074 10466 10467 10468 7123 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $75385 m0 *1 486.64,871.92
X$75385 14073 7123 14074 10277 10279 10278 10357
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $75411 m0 *1 500.08,791.28
X$75411 9117 14074 14073 7125 7617 8948 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $75413 m0 *1 481.6,801.36
X$75413 14074 14073 7125 9056 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75417 r0 *1 465.92,670.32
X$75417 14074 14073 7204 7125 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75422 r0 *1 511.84,982.8
X$75422 14074 14073 12043 7334 10134 7125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75425 r0 *1 479.92,972.72
X$75425 14074 14073 11876 7334 11855 7125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75429 m0 *1 438.48,811.44
X$75429 14074 7126 9408 14073 8944 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75458 m0 *1 496.72,831.6
X$75458 9625 14074 14073 7126 7670 9626 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $75460 r0 *1 478.8,821.52
X$75460 14074 14073 7126 9620 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75464 r0 *1 545.44,982.8
X$75464 14074 14073 12123 8921 10134 7126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75468 r0 *1 645.12,720.72
X$75468 14074 14073 7878 7616 7128 7809 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75470 r0 *1 588,730.8
X$75470 14074 14073 8042 7873 7128 8090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75472 m0 *1 652.96,730.8
X$75472 14074 14073 7963 7531 7128 7646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75474 r0 *1 604.8,710.64
X$75474 14074 14073 7927 7703 7128 7613 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $75476 r0 *1 603.68,720.72
X$75476 14074 14073 8019 7760 7128 7640 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75478 m0 *1 614.88,730.8
X$75478 14074 14073 8097 7961 7128 8194 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75485 m0 *1 683.76,730.8
X$75485 14074 14073 7964 8018 7128 7969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75487 r0 *1 670.88,710.64
X$75487 14074 14073 7787 7704 7128 7632 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $75489 r0 *1 558.88,730.8
X$75489 14074 14073 8104 8103 7128 7804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75491 r0 *1 577.36,710.64
X$75491 14074 14073 7700 7759 7128 7550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75493 r0 *1 588.56,710.64
X$75493 14074 14073 7701 7702 7128 7633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75497 r0 *1 586.88,720.72
X$75497 14074 14073 7876 7851 7128 7806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75499 m0 *1 608.72,720.72
X$75499 14074 14073 8130 7668 7128 7713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75501 r0 *1 612.08,720.72
X$75501 14074 14073 7877 7848 7128 7715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75503 m0 *1 621.04,700.56
X$75503 14074 14073 7447 7496 7128 7582 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75505 r0 *1 633.92,700.56
X$75505 14074 14073 7615 7529 7128 7540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75541 r0 *1 651.28,700.56
X$75541 14074 14073 7617 7581 7128 7546 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $75544 r0 *1 596.4,730.8
X$75544 14074 14073 8099 7850 7128 8043 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75546 r0 *1 684.32,730.8
X$75546 14074 14073 8380 7533 7128 8053 gf180mcu_fd_sc_mcu9t5v0__mux2_4
* cell instance $75554 m0 *1 569.52,720.72
X$75554 14073 7441 14074 7612 7850 7129 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $75572 m0 *1 583.52,710.64
X$75572 14073 7441 14074 7612 7702 7131 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $75594 r0 *1 571.76,690.48
X$75594 14074 14073 7133 7874 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75597 r0 *1 580.72,680.4
X$75597 14074 14073 7134 7241 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75602 r0 *1 609.28,680.4
X$75602 14074 14073 7135 7243 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75611 m0 *1 698.88,690.48
X$75611 14073 7137 7246 7451 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $75613 m0 *1 679.28,680.4
X$75613 14074 14073 7245 7142 7137 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $75619 m0 *1 708.4,680.4
X$75619 14073 7144 7348 14074 7139 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75626 r0 *1 700,680.4
X$75626 7246 7139 7247 7347 14074 14073 7296 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $75629 r0 *1 714.56,670.32
X$75629 14073 7141 7402 7140 7142 7143 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $75631 m0 *1 747.6,680.4
X$75631 14074 7140 7144 7209 7249 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $75639 m0 *1 735.28,680.4
X$75639 14073 7248 7294 7141 7250 7146 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $75648 r0 *1 730.24,720.72
X$75648 7488 14073 14074 7142 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $75660 r0 *1 700,700.56
X$75660 14074 14073 7142 7457 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75662 m0 *1 680.4,690.48
X$75662 14074 14073 7404 7245 7456 7142 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75670 m0 *1 728.56,690.48
X$75670 14074 14073 7348 7143 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $75682 r0 *1 734.72,680.4
X$75682 14073 7393 7349 7145 7461 7294 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $75714 m0 *1 949.2,680.4
X$75714 7255 14074 14073 7254 7148 14091 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $75745 r0 *1 700.56,962.64
X$75745 14074 11709 14073 12181 11450 9856 7150 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $75748 r0 *1 833.84,962.64
X$75748 14074 14073 7150 11737 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75760 m0 *1 783.44,942.48
X$75760 14073 11454 10577 14074 7151 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75763 m0 *1 802.48,690.48
X$75763 14073 7151 14074 7356 7354 7215 7152 gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $75803 m0 *1 760.48,942.48
X$75803 14074 14073 11207 7152 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $75842 r0 *1 789.04,932.4
X$75842 14074 14073 7152 11373 11336 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $75870 r0 *1 834.96,882
X$75870 14074 10486 14073 10057 10529 10053 7153
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $75872 r0 *1 833.28,892.08
X$75872 14074 14073 10679 10486 9964 7153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75874 r0 *1 834.4,861.84
X$75874 14073 14074 10055 9066 8236 7153 10352 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $75893 m0 *1 849.52,892.08
X$75893 14074 14073 7154 10585 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75895 r0 *1 823.2,892.08
X$75895 14074 14073 10695 7240 10395 7154 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $75905 m0 *1 857.92,680.4
X$75905 14073 7253 7193 14074 7156 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $75938 r0 *1 874.16,972.72
X$75938 14074 14073 7159 11935 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $75940 m0 *1 665.84,972.72
X$75940 14074 11852 14073 11810 11660 9856 7159 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $75946 r0 *1 915.04,831.6
X$75946 14074 9577 7160 14073 9676 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75949 r0 *1 924.56,831.6
X$75949 14074 7160 8960 14073 9713 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75952 r0 *1 926.24,811.44
X$75952 14074 8256 7160 14073 9393 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75954 m0 *1 1053.36,771.12
X$75954 14074 7160 7891 14073 8670 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75956 r0 *1 1128.96,791.28
X$75956 14074 7160 7648 14073 9088 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75959 r0 *1 1035.44,771.12
X$75959 14074 7160 8774 14073 8775 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75962 r0 *1 981.12,740.88
X$75962 14074 7160 8151 14073 8300 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75964 m0 *1 1130.64,821.52
X$75964 14074 7160 9185 14073 9478 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75967 m0 *1 1154.16,821.52
X$75967 14074 14073 9479 7160 7639 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $75970 r0 *1 1164.24,841.68
X$75970 14074 7160 9692 14073 9877 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75972 r0 *1 1121.68,821.52
X$75972 14074 7160 9587 14073 9477 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $75994 m0 *1 953.68,781.2
X$75994 14074 14073 8816 7829 7160 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $75996 m0 *1 962.64,811.44
X$75996 14074 14073 8766 9270 7160 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $75998 m0 *1 1160.88,851.76
X$75998 14074 14073 7160 10077 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76008 r0 *1 1102.64,771.12
X$76008 14074 14073 8783 8673 7162 7715 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76010 m0 *1 1146.88,781.2
X$76010 14074 14073 8792 8782 7162 7969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76013 m0 *1 1127.84,781.2
X$76013 14074 14073 8785 8780 7162 8043 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76015 m0 *1 1138.48,781.2
X$76015 14074 14073 8784 8781 7162 7804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76018 r0 *1 1148.56,750.96
X$76018 14074 14073 8405 8406 7162 7718 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76020 m0 *1 962.08,740.88
X$76020 14074 14073 8150 8058 7162 7633 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76022 r0 *1 1120,740.88
X$76022 14074 14073 8278 8269 7162 8090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76024 r0 *1 1141.84,730.8
X$76024 14074 14073 8070 7895 7162 7802 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76027 r0 *1 1115.52,720.72
X$76027 14074 14073 7899 7992 7162 7982 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76029 r0 *1 982.24,720.72
X$76029 14074 14073 7888 7811 7162 7720 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76031 r0 *1 1144.64,710.64
X$76031 14074 14073 7731 7727 7162 7745 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76033 r0 *1 1141.84,700.56
X$76033 14074 14073 7558 7638 7162 7386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76035 r0 *1 1026.48,690.48
X$76035 14074 14073 7474 7468 7162 7466 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76037 m0 *1 1148,740.88
X$76037 14074 14073 8159 8065 7162 7726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76039 r0 *1 1138.48,740.88
X$76039 14074 14073 8271 8281 7162 7384 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76042 r0 *1 1089.2,740.88
X$76042 14074 14073 8268 8157 7162 7237 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76045 r0 *1 1021.44,720.72
X$76045 14074 14073 7981 7890 7162 7550 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76047 r0 *1 1031.52,710.64
X$76047 14074 14073 7729 7813 7162 7540 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76049 m0 *1 1031.52,720.72
X$76049 14074 14073 7812 7737 7162 7390 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76051 r0 *1 1098.72,720.72
X$76051 14074 14073 7816 7903 7162 7640 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76053 r0 *1 1107.12,720.72
X$76053 14074 14073 7898 7983 7162 7806 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76055 r0 *1 1098.72,710.64
X$76055 14074 14073 7725 7820 7162 7548 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76086 r0 *1 1150.24,740.88
X$76086 14074 14073 8279 8272 7162 8172 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76089 m0 *1 968.24,710.64
X$76089 14074 7741 14073 7739 7634 7162 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $76091 m0 *1 1121.68,730.8
X$76091 14074 14073 7986 7893 7162 7646 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76093 m0 *1 1150.8,761.04
X$76093 14074 14073 8496 8066 7162 7713 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76095 r0 *1 1130.64,750.96
X$76095 14074 14073 8402 8270 7162 8400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76098 r0 *1 1149.12,771.12
X$76098 14074 14073 8678 8676 7162 7712 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76107 m0 *1 1112.72,720.72
X$76107 14074 7817 7554 7164 7804 7384 7802 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76110 r0 *1 964.32,710.64
X$76110 14074 7634 7554 7164 7633 7379 7720 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76142 r0 *1 950.32,710.64
X$76142 14074 7721 7633 7478 7613 7720 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76147 m0 *1 1018.08,700.56
X$76147 14074 7564 7478 7164 7540 7390 7550 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76149 m0 *1 964.88,720.72
X$76149 14074 7478 14073 7633 7826 7613 7164 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76151 m0 *1 960.4,730.8
X$76151 14074 7478 14073 7720 7979 7379 7164 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76153 m0 *1 1003.52,710.64
X$76153 14074 7722 7540 7478 7466 7390 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76155 r0 *1 1017.52,710.64
X$76155 14074 7910 7554 7164 7550 7390 7466 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76158 m0 *1 1017.52,720.72
X$76158 14074 7824 7550 7478 7540 7466 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76162 r0 *1 1080.24,720.72
X$76162 14074 7892 7640 7478 7548 7237 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76167 r0 *1 1127.28,720.72
X$76167 14074 7894 7478 7164 7646 7384 7804 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76170 m0 *1 1130.64,740.88
X$76170 14074 8158 7646 7478 7802 7384 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76172 r0 *1 1127.84,730.8
X$76172 14074 8282 7804 7478 7646 7802 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76174 m0 *1 1136.8,730.8
X$76174 14074 8064 7745 7478 7386 7726 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76177 r0 *1 1130.64,710.64
X$76177 14074 7733 7478 7164 7745 7726 7713 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76179 m0 *1 1131.2,710.64
X$76179 14074 7636 7554 7164 7713 7726 7386 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76181 m0 *1 1141.28,720.72
X$76181 14074 7818 7713 7478 7745 7386 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76183 r0 *1 1141.28,761.04
X$76183 14074 8582 7969 7478 8172 7718 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76186 m0 *1 1136.8,761.04
X$76186 14074 8501 7478 7164 8172 7712 7969 7554 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76189 m0 *1 1136.8,750.96
X$76189 14074 8280 7554 7164 7969 7712 7718 7478 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76191 r0 *1 1118.32,761.04
X$76191 14074 8581 8043 7478 8090 8400 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76193 m0 *1 1096.48,750.96
X$76193 14074 8494 7715 7478 7806 7982 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76198 m0 *1 1137.92,771.12
X$76198 14074 8794 8172 7478 7718 7712 7554 7164 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $76208 m0 *1 1021.44,710.64
X$76208 14074 7642 7166 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $76228 r0 *1 1022.56,700.56
X$76228 14074 7166 14077 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $76317 r0 *1 659.12,1002.96
X$76317 14074 10581 14073 12290 10482 7182 12333 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $76324 r0 *1 458.08,1184.4
X$76324 7182 14073 14074 14061 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $76326 r0 *1 676.48,1013.04
X$76326 14074 14073 12447 7182 10395 8045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76353 r0 *1 826.56,1002.96
X$76353 14074 14073 7182 12419 8602 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $76356 m0 *1 650.72,801.36
X$76356 14074 9064 7182 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $76382 r0 *1 177.52,670.32
X$76382 14074 14073 7222 7188 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $76384 r0 *1 195.44,892.08
X$76384 14074 9408 7189 14073 10650 10840 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $76397 m0 *1 222.32,680.4
X$76397 14074 14073 7421 7190 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $76431 m0 *1 464.24,811.44
X$76431 14074 9143 9250 14073 7198 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $76434 m0 *1 297.36,982.8
X$76434 14073 12001 14074 11860 12003 7198 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $76455 m0 *1 437.36,992.88
X$76455 14073 7198 12103 12038 12180 12119 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $76481 m0 *1 791.28,841.68
X$76481 14074 9731 14073 9857 9856 7205 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $76501 m0 *1 840,781.2
X$76501 14074 14073 7205 8761 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $76551 r0 *1 848.96,781.2
X$76551 14074 14073 9009 7213 8602 8761 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76553 m0 *1 799.68,912.24
X$76553 14074 10581 14073 11007 10482 7213 10852 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $76555 r0 *1 1176.56,680.4
X$76555 7213 14073 14074 7264 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $76561 r0 *1 756.56,871.92
X$76561 14074 14073 10532 7213 10395 7464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76580 m0 *1 672.56,690.48
X$76580 14074 14073 7453 7213 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76621 m0 *1 611.52,912.24
X$76621 14074 10139 14073 10897 11076 11001 7216 10250
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $76644 r0 *1 84,720.72
X$76644 14074 7764 7858 7219 7857 14073 7859 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $76648 r0 *1 92.96,720.72
X$76648 7857 7219 7858 7859 14074 14073 7302 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $76670 r0 *1 209.44,1033.2
X$76670 14073 14074 12561 12724 12725 7221 12709 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $76673 m0 *1 348.88,1033.2
X$76673 14074 12210 14073 7221 12657 13100 12713 11795
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $76693 m0 *1 224,690.48
X$76693 14074 14073 7225 7381 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $76697 r0 *1 255.92,750.96
X$76697 14074 14073 8352 7226 8110 8453 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76699 m0 *1 455.28,771.12
X$76699 14073 8640 8554 14074 7226 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $76703 r0 *1 255.36,871.92
X$76703 14074 14073 10265 7226 10345 10266 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76706 m0 *1 256.48,882
X$76706 14074 14073 10456 7226 10371 10457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76708 r0 *1 274.4,801.36
X$76708 7226 14073 7430 9137 14074 9208 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $76736 r0 *1 291.2,1123.92
X$76736 14074 7226 14073 12327 13766 13767 12115
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76738 m0 *1 315.84,1083.6
X$76738 14074 11952 14073 13412 13355 12349 7226
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76741 r0 *1 367.92,1134
X$76741 14074 12189 14073 7226 13835 12104 13811
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76743 m0 *1 450.24,1033.2
X$76743 14074 11795 14073 12715 12797 7226 11794
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76762 r0 *1 223.44,952.56
X$76762 14074 14073 11574 7230 10371 11579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76766 r0 *1 208.88,932.4
X$76766 14074 14073 11271 7230 7763 11491 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76769 r0 *1 217.84,932.4
X$76769 14074 14073 11327 7230 10345 11240 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76792 m0 *1 266,1023.12
X$76792 14073 14074 12516 12515 12651 7230 12633 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $76795 m0 *1 386.4,1023.12
X$76795 14073 7230 12568 12038 12639 12579 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $76823 r0 *1 834.96,1002.96
X$76823 14074 14073 12377 12420 8602 7233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $76827 m0 *1 656.88,1002.96
X$76827 14074 12331 14073 12289 12184 9856 7233 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $76848 r0 *1 482.16,680.4
X$76848 14074 14073 7297 7235 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76853 r0 *1 487.2,690.48
X$76853 14074 14073 7235 7436 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76855 m0 *1 539.84,902.16
X$76855 14074 10790 10134 7236 8422 8852 8946 7437 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $76876 m0 *1 488.88,902.16
X$76876 14074 14073 7236 10673 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $76879 m0 *1 492.8,902.16
X$76879 10856 14074 14073 7236 9660 10858 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $76911 r0 *1 529.2,690.48
X$76911 14073 7332 7238 7440 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $76913 m0 *1 530.88,700.56
X$76913 14074 14073 7238 7438 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76915 r0 *1 530.32,700.56
X$76915 14073 14074 7238 7526 7332 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $76917 m0 *1 514.08,740.88
X$76917 7239 14074 7524 8102 14073 8038 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $76920 m0 *1 511.84,730.8
X$76920 14073 7239 14074 7390 7780 7726 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $76923 m0 *1 522.48,750.96
X$76923 7239 14074 7524 8233 14073 8368 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $76950 r0 *1 516.32,750.96
X$76950 14073 8323 14074 8619 7524 7239 8233 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $76952 m0 *1 505.68,761.04
X$76952 14073 7239 7390 14074 8465 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $76954 m0 *1 512.4,750.96
X$76954 14073 7929 14074 8432 7524 7239 8102 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $76959 r0 *1 507.92,710.64
X$76959 14074 7871 7584 7628 7588 7239 14073 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $76963 m0 *1 513.52,710.64
X$76963 14074 7697 7699 7439 7239 7665 7661 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $76965 r0 *1 511.84,720.72
X$76965 14074 7239 8039 7698 7726 7331 14073 gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* cell instance $76968 r0 *1 502.32,740.88
X$76968 14074 14073 7609 7239 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $76975 m0 *1 1173.2,761.04
X$76975 7240 14073 14074 8499 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $76981 r0 *1 800.8,882
X$76981 14074 10581 14073 10397 10482 7240 10624 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $77014 m0 *1 820.4,781.2
X$77014 14074 14073 7240 8824 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77016 r0 *1 424.48,811.44
X$77016 14073 7241 8618 14074 9246 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77018 r0 *1 400.4,871.92
X$77018 14073 9550 10439 9660 7241 9249 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77022 r0 *1 447.44,871.92
X$77022 14074 10385 7670 14073 7241 10275 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $77040 r0 *1 409.92,871.92
X$77040 7874 7670 7241 9249 14074 14073 10128 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77043 r0 *1 431.2,871.92
X$77043 7874 7670 7241 9337 14074 14073 10464 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77047 r0 *1 425.6,791.28
X$77047 14074 14073 7241 8226 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77049 r0 *1 551.6,740.88
X$77049 8326 14074 14073 7436 7241 8325 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $77055 m0 *1 605.92,942.48
X$77055 14074 14073 11414 7242 11368 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77058 r0 *1 609.84,942.48
X$77058 14074 14073 11448 11511 7242 11445 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77133 m0 *1 507.36,831.6
X$77133 14073 7243 9558 9624 9556 9555 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77136 m0 *1 507.36,851.76
X$77136 14073 7243 9846 9944 9774 9843 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77138 m0 *1 493.92,841.68
X$77138 14074 14073 9913 9819 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77140 r0 *1 491.12,821.52
X$77140 14074 14073 9521 9554 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77143 r0 *1 507.92,791.28
X$77143 14074 14073 9120 9060 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77145 m0 *1 498.4,801.36
X$77145 14073 7243 9118 9058 9059 9221 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77147 r0 *1 535.36,771.12
X$77147 14073 7243 8711 8744 8829 8830 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77149 r0 *1 548.8,781.2
X$77149 14074 14073 8918 8853 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77151 r0 *1 528.64,841.68
X$77151 14074 14073 9919 9844 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77153 r0 *1 531.44,861.84
X$77153 14074 14073 10247 10282 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77155 r0 *1 547.68,761.04
X$77155 14074 14073 8531 8467 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77158 m0 *1 577.36,761.04
X$77158 14074 14073 8536 8469 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77160 r0 *1 510.16,871.92
X$77160 14073 7243 10388 10387 10447 10446 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77162 m0 *1 492.8,861.84
X$77162 14073 7243 10038 10242 10036 10245 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77165 m0 *1 534.8,821.52
X$77165 14074 14073 9520 9522 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77167 r0 *1 524.16,781.2
X$77167 14074 14073 9026 8743 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77170 m0 *1 522.48,831.6
X$77170 14074 14073 9737 9557 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77173 r0 *1 539.84,801.36
X$77173 14073 7243 9307 9308 9123 9225 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77175 m0 *1 518.56,892.08
X$77175 14074 14073 10764 10638 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77177 r0 *1 581.28,801.36
X$77177 14074 14073 9306 9229 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77179 m0 *1 567.84,831.6
X$77179 14073 7243 9736 9560 9631 9632 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77181 m0 *1 668.64,912.24
X$77181 14074 14073 11071 10956 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77184 m0 *1 675.36,902.16
X$77184 14074 14073 10794 10688 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77186 m0 *1 641.2,912.24
X$77186 14074 14073 11073 10898 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77190 m0 *1 619.92,710.64
X$77190 14074 14073 7845 7667 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77192 r0 *1 616.56,851.76
X$77192 14074 14073 10143 10042 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77194 m0 *1 515.2,912.24
X$77194 14074 14073 10974 10996 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77196 r0 *1 501.2,892.08
X$77196 14073 7243 10762 10761 10857 10674 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77199 m0 *1 521.92,902.16
X$77199 14073 7243 10675 10763 10676 10862 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77201 m0 *1 488.88,912.24
X$77201 14074 14073 11074 10967 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77203 r0 *1 530.88,740.88
X$77203 14074 14073 8196 8126 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77205 m0 *1 558.32,740.88
X$77205 14074 14073 8101 8041 7243 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77218 m0 *1 569.52,922.32
X$77218 14073 11102 7244 7446 10893 11103 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77226 m0 *1 710.08,710.64
X$77226 14074 14073 7488 7246 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77228 r0 *1 703.36,700.56
X$77228 14073 7247 14074 7537 7345 7488 7401 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $77231 r0 *1 713.44,700.56
X$77231 14074 7401 7622 14073 7247 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $77243 r0 *1 749.28,690.48
X$77243 14073 7538 7463 14074 7250 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77279 m0 *1 959.84,710.64
X$77279 14073 7255 7885 14074 7741 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77284 r0 *1 986.16,680.4
X$77284 7257 14074 7258 7275 14073 7265 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $77291 m0 *1 1175.44,700.56
X$77291 7260 14073 14074 7559 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $77319 r0 *1 1167.6,680.4
X$77319 7265 14073 14074 7361 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $77360 r0 *1 961.52,680.4
X$77360 14074 14073 7276 7377 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77367 r0 *1 1059.52,902.16
X$77367 14074 8392 7278 14073 10817 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $77369 m0 *1 1047.76,902.16
X$77369 14074 7829 7278 14073 10709 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $77372 r0 *1 1030.96,821.52
X$77372 14074 7278 8485 14073 9491 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $77376 r0 *1 1038.8,740.88
X$77376 14074 8294 7278 14073 8263 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $77394 r0 *1 1053.36,871.92
X$77394 14074 14073 10177 9867 7278 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77396 r0 *1 1052.8,811.44
X$77396 14074 14073 9377 8396 7278 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77398 m0 *1 1060.64,912.24
X$77398 14074 14073 7278 11016 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77403 r0 *1 909.44,902.16
X$77403 14073 9731 7279 9348 11012 8131 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $77420 r0 *1 845.04,992.88
X$77420 14074 14073 12249 9409 8602 7280 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77424 r0 *1 688.24,992.88
X$77424 14074 12255 14073 12132 12048 9856 7280 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $77437 r0 *1 453.6,761.04
X$77437 14074 14073 8640 7283 8554 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $77459 m0 *1 328.16,912.24
X$77459 14074 10972 11056 10660 7286 14073 11278
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $77544 r0 *1 500.64,720.72
X$77544 14074 14073 7300 7777 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77547 r0 *1 593.04,680.4
X$77547 14074 14073 7301 7445 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77561 r0 *1 356.16,720.72
X$77561 14074 7773 14073 7673 7302 7867 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $77568 r0 *1 35.28,690.48
X$77568 7304 14073 14074 7473 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $77571 r0 *1 10.08,700.56
X$77571 7305 14073 14074 7637 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $77585 m0 *1 170.8,700.56
X$77585 14074 14073 7309 7419 7507 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $77594 r0 *1 355.04,942.48
X$77594 14074 14073 11426 7311 11282 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $77609 r0 *1 364,1053.36
X$77609 14073 14074 13047 12947 13102 12209 13103 7311
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $77626 m0 *1 240.8,720.72
X$77626 7315 7768 7601 7863 14073 14074 7830 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $77628 r0 *1 238,720.72
X$77628 14074 7769 7863 14073 7601 7315 7768 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $77646 m0 *1 400.96,1164.24
X$77646 14074 12189 14073 7317 14000 12104 13940
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $77648 r0 *1 450.8,912.24
X$77648 14073 10993 10994 14074 7317 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77655 m0 *1 313.04,942.48
X$77655 14074 14073 11494 7317 11188 11353 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77657 r0 *1 316.96,922.32
X$77657 14074 14073 11245 7317 10345 10985 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77660 m0 *1 336,1164.24
X$77660 14074 13937 14073 13993 12116 7317 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $77691 r0 *1 877.52,761.04
X$77691 14074 14073 8572 7319 8602 7563 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77693 r0 *1 1156.4,791.28
X$77693 7319 14073 14074 9086 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $77696 r0 *1 714.56,892.08
X$77696 14074 14073 10689 7319 10395 8386 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $77698 m0 *1 707.84,902.16
X$77698 14074 10581 14073 10574 10482 7319 10690 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $77722 r0 *1 680.4,690.48
X$77722 14074 7452 7319 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $77730 m0 *1 378,710.64
X$77730 14073 7320 7432 14074 7746 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77732 r0 *1 377.44,700.56
X$77732 7415 14073 7320 7432 14074 7400 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $77735 r0 *1 360.08,700.56
X$77735 7394 14074 7320 14073 7656 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $77761 r0 *1 418.88,730.8
X$77761 14074 14073 7321 7952 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77789 r0 *1 479.36,690.48
X$77789 14074 14073 7328 7334 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77817 m0 *1 745.36,942.48
X$77817 14074 11409 14073 12009 11375 9856 7329 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $77821 m0 *1 786.8,962.64
X$77821 14074 14073 7329 11666 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77846 r0 *1 415.52,902.16
X$77846 14074 10565 10100 10889 7333 14073 10887
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $77849 r0 *1 408.24,841.68
X$77849 14074 9402 9839 8366 7333 14073 9840 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $77851 r0 *1 394.8,871.92
X$77851 14074 14073 10271 7333 8618 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $77853 m0 *1 518,932.4
X$77853 14073 7333 11195 14074 11199 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $77892 r0 *1 492.24,761.04
X$77892 8462 7778 8463 7333 14074 14073 8616 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77894 m0 *1 404.88,871.92
X$77894 7333 8366 10272 9839 14074 14073 10274 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77896 m0 *1 408.8,851.76
X$77896 7333 8366 9839 9840 14074 14073 9435 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77899 r0 *1 435.68,851.76
X$77899 14073 7333 9842 14074 10101 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $77902 m0 *1 516.32,922.32
X$77902 14074 14073 7333 10564 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77904 r0 *1 514.08,912.24
X$77904 10996 14074 14073 11075 7333 14123 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $77906 r0 *1 439.6,892.08
X$77906 7333 14073 8366 9337 14074 10632 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $77908 r0 *1 389.76,922.32
X$77908 7333 10784 10100 10887 14074 14073 10850 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77910 m0 *1 389.2,922.32
X$77910 7333 10784 10666 10888 14074 14073 8220 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77912 r0 *1 391.44,912.24
X$77912 7333 10889 10666 10888 14074 14073 9764 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $77918 m0 *1 383.6,912.24
X$77918 7333 14073 10666 10888 14074 10883 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $77925 r0 *1 370.72,932.4
X$77925 14074 7334 11281 14073 11282 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $77953 m0 *1 622.16,690.48
X$77953 14074 14073 7334 7339 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $77955 m0 *1 625.52,710.64
X$77955 7666 14074 14073 7334 7447 7758 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $77960 r0 *1 594.72,690.48
X$77960 14074 14073 7335 7527 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $77963 r0 *1 612.08,690.48
X$77963 14074 14073 7443 7961 7336 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $77965 m0 *1 547.12,700.56
X$77965 14073 14074 7411 7337 7526 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $77989 r0 *1 624.4,700.56
X$77989 7667 14074 14073 7339 7664 14109 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $77998 m0 *1 631.68,700.56
X$77998 14074 14073 7450 7529 7341 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78000 m0 *1 688.24,700.56
X$78000 14073 7623 7342 14074 7535 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $78004 m0 *1 702.8,720.72
X$78004 14074 7343 7537 14073 7838 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $78010 m0 *1 714,740.88
X$78010 14074 7344 7348 8049 8141 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $78012 m0 *1 708.4,690.48
X$78012 7344 14074 7345 7401 14073 7398 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $78016 m0 *1 711.2,700.56
X$78016 14074 7397 7488 7344 7345 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $78019 r0 *1 711.76,710.64
X$78019 14074 7488 7789 7924 7345 14073 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $78030 r0 *1 695.52,690.48
X$78030 14074 14073 7345 7455 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78032 r0 *1 715.68,690.48
X$78032 14073 7536 7346 14074 7452 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $78034 m0 *1 715.68,690.48
X$78034 14073 7402 7397 14074 7346 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $78038 r0 *1 726.88,690.48
X$78038 14073 7347 14074 7458 7459 7395 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $78047 m0 *1 721.28,710.64
X$78047 7625 7627 7791 14074 14073 7347 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $78050 m0 *1 712.32,750.96
X$78050 14074 14073 7347 8318 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78065 m0 *1 731.92,700.56
X$78065 14074 7796 14073 7654 7350 7538 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $78067 r0 *1 731.92,700.56
X$78067 14074 14073 7401 7350 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78069 m0 *1 739.2,700.56
X$78069 14074 14073 7461 7539 7351 7462 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78073 m0 *1 742.56,690.48
X$78073 14074 14073 7462 7393 7351 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78075 m0 *1 754.88,720.72
X$78075 14074 14073 7796 7351 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78089 r0 *1 836.64,912.24
X$78089 14074 14073 11009 7354 9854 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $78111 r0 *1 835.52,871.92
X$78111 14074 14073 10292 10399 9964 7354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78139 m0 *1 869.12,1002.96
X$78139 14074 14073 7355 12300 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78141 r0 *1 706.72,992.88
X$78141 14074 12253 14073 12252 11053 9856 7355 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $78162 m0 *1 665.84,892.08
X$78162 14074 14073 10687 7357 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78169 r0 *1 686,932.4
X$78169 14074 14073 11339 7358 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78179 r0 *1 1165.36,690.48
X$78179 7472 14073 14074 7362 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78196 m0 *1 48.72,690.48
X$78196 14074 14073 7475 7367 7366 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78225 r0 *1 1173.76,690.48
X$78225 7374 14073 14074 7469 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78270 r0 *1 945.28,690.48
X$78270 14074 14073 7382 7554 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78302 m0 *1 675.36,972.72
X$78302 14074 11967 14073 11851 11661 9856 7383 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $78304 r0 *1 848.96,942.48
X$78304 14074 14073 11500 11164 8602 7383 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78337 r0 *1 808.64,942.48
X$78337 14074 14073 11456 9461 8602 7385 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78339 m0 *1 712.32,952.56
X$78339 14074 11586 14073 12135 11452 9856 7385 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $78408 m0 *1 580.16,700.56
X$78408 14074 14073 7669 7390 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78436 r0 *1 372.4,700.56
X$78436 14073 7394 7506 14074 7432 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $78442 m0 *1 724.64,700.56
X$78442 14073 7536 7578 14074 7395 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $78453 m0 *1 385.28,710.64
X$78453 7506 14074 7396 14073 7950 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $78460 m0 *1 707.84,700.56
X$78460 14074 14073 7397 7578 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78480 r0 *1 399.28,710.64
X$78480 14074 14073 7400 7691 7692 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78483 r0 *1 394.24,700.56
X$78483 14074 14073 7400 7658 7517 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78497 m0 *1 718.48,730.8
X$78497 14074 7622 8052 7968 7401 14073 gf180mcu_fd_sc_mcu9t5v0__addh_4
* cell instance $78506 m0 *1 714.56,1002.96
X$78506 14074 10581 14073 12296 10482 7403 12223 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78509 r0 *1 738.08,1002.96
X$78509 14074 14073 12373 7403 10395 9569 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78511 m0 *1 459.2,1184.4
X$78511 7403 14073 14074 14060 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78513 r0 *1 774.48,972.72
X$78513 14074 14073 11937 7403 8602 9500 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78545 r0 *1 442.96,761.04
X$78545 14074 14073 7405 8644 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78564 r0 *1 504,801.36
X$78564 14074 14073 7408 9411 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78566 m0 *1 507.36,781.2
X$78566 14074 14073 8557 7408 gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* cell instance $78587 r0 *1 490,861.84
X$78587 10133 14074 14073 7409 7874 10246 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $78589 r0 *1 473.2,871.92
X$78589 14074 14073 7409 10386 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78592 r0 *1 548.8,962.64
X$78592 14074 14073 11726 9218 10134 7409 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78611 r0 *1 2.24,690.48
X$78611 7412 14073 14074 7591 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $78641 r0 *1 383.6,710.64
X$78641 7415 14074 7746 14073 7839 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $78647 r0 *1 106.96,690.48
X$78647 14074 14073 7417 7416 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78660 r0 *1 215.04,922.32
X$78660 14074 11184 10114 7420 10115 10113 11081 11183 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $78679 r0 *1 285.6,690.48
X$78679 14073 7486 7577 7430 7487 7423 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $78686 r0 *1 258.16,690.48
X$78686 14074 14073 7423 7514 7483 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78752 r0 *1 323.12,761.04
X$78752 14074 14073 7427 14171 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $78796 r0 *1 378.56,781.2
X$78796 14074 8184 8735 14073 8848 7430 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $78810 m0 *1 323.12,892.08
X$78810 7431 14073 10558 9329 14074 10749 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $78820 m0 *1 407.12,720.72
X$78820 14073 7952 7433 14074 8015 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $78831 m0 *1 400.96,710.64
X$78831 7600 14073 7433 7692 14074 7748 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $78834 m0 *1 400.96,720.72
X$78834 14074 14073 7433 7776 7583 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78836 r0 *1 375.76,710.64
X$78836 14074 14073 7433 7775 7434 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78865 r0 *1 385.84,740.88
X$78865 14074 14073 7436 8225 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78871 r0 *1 528.64,982.8
X$78871 14074 14073 12046 8363 10134 7436 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $78893 m0 *1 508.48,902.16
X$78893 14074 14073 7437 10859 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $78895 m0 *1 523.6,912.24
X$78895 10789 14074 14073 7437 9550 10892 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $78917 m0 *1 539.28,700.56
X$78917 14074 14073 7525 7441 gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* cell instance $78929 r0 *1 596.96,710.64
X$78929 14074 14073 7441 7783 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78931 m0 *1 551.6,720.72
X$78931 14074 14073 7441 8103 7852 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78934 r0 *1 572.32,720.72
X$78934 14074 14073 7441 7873 7928 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78938 r0 *1 556.64,690.48
X$78938 14074 14073 7444 7496 7442 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78945 r0 *1 617.12,690.48
X$78945 14074 7443 7450 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $78950 r0 *1 561.68,690.48
X$78950 14074 14073 7443 7444 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $78955 r0 *1 604.8,700.56
X$78955 14074 14073 7444 7533 7528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78959 r0 *1 554.4,781.2
X$78959 14074 8919 14073 7527 8918 7445 9226 8920
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78962 m0 *1 498.96,912.24
X$78962 14074 10995 14073 7527 11074 7445 10682 10971
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78964 r0 *1 585.76,811.44
X$78964 14074 9416 14073 7527 9306 7445 9562 9417
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78966 r0 *1 567.84,730.8
X$78966 14074 8100 14073 7527 8101 7445 8128 7959
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78968 r0 *1 539.84,740.88
X$78968 14074 8325 14073 7527 8196 7445 8200 8326
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78971 m0 *1 529.76,771.12
X$78971 14074 14073 8710 8829 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $78973 r0 *1 516.88,902.16
X$78973 14074 10860 14073 7527 10974 7445 10973 10970
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78975 m0 *1 530.88,791.28
X$78975 14074 9028 14073 7527 9026 7445 9029 9027
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78977 r0 *1 517.44,791.28
X$78977 14074 9025 14073 7527 9120 7445 9222 9121
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78979 r0 *1 616,861.84
X$78979 14074 10144 14073 7527 10143 7445 10572 10249
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78981 m0 *1 582.96,761.04
X$78981 14074 8436 14073 7527 8536 7445 8534 8535
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78985 r0 *1 621.04,710.64
X$78985 14074 7758 14073 7527 7845 7445 7843 7666
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78987 m0 *1 553.28,761.04
X$78987 14074 8532 14073 7527 8531 7445 8468 8533
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78989 r0 *1 529.2,892.08
X$78989 14074 10766 14073 7527 10764 7445 10765 10767
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78991 r0 *1 672.56,912.24
X$78991 14074 11069 14073 7527 11071 7445 11111 11070
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78993 r0 *1 674.24,902.16
X$78993 14074 10760 14073 7527 10794 7445 10957 10795
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78995 m0 *1 646.8,912.24
X$78995 14074 10958 14073 7527 11073 7445 11003 10960
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $78997 m0 *1 495.6,851.76
X$78997 14074 9943 14073 7527 9913 7445 9915 10015
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79000 r0 *1 530.88,831.6
X$79000 14074 9739 14073 7527 9737 7445 9845 9738
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79002 r0 *1 534.24,841.68
X$79002 14074 9920 14073 7527 9919 7445 9847 9922
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79004 r0 *1 500.64,821.52
X$79004 14074 9626 14073 7527 9521 7445 9447 9625
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79006 r0 *1 538.72,821.52
X$79006 14074 9519 14073 7527 9520 7445 9665 9630
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79008 m0 *1 531.44,861.84
X$79008 14074 10248 14073 7527 10247 7445 10136 10037
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79069 m0 *1 510.72,841.68
X$79069 14074 14073 9916 9774 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79071 r0 *1 517.44,821.52
X$79071 14074 14073 9627 9556 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79073 r0 *1 500.64,791.28
X$79073 14074 14073 9117 9059 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79076 m0 *1 535.92,801.36
X$79076 14074 14073 9223 9123 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79078 r0 *1 505.12,871.92
X$79078 14074 14073 10280 10447 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79080 m0 *1 487.76,861.84
X$79080 14074 14073 10133 10036 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79082 m0 *1 564.48,821.52
X$79082 14074 14073 9518 9631 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79085 r0 *1 522.48,892.08
X$79085 14074 14073 10789 10676 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79087 r0 *1 494.48,902.16
X$79087 14074 14073 10856 10857 7445 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79090 r0 *1 617.68,952.56
X$79090 14074 14073 11513 11537 7446 11606 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79092 r0 *1 617.12,922.32
X$79092 14074 14073 11165 11203 7446 11104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79095 r0 *1 614.88,912.24
X$79095 14074 14073 10874 10897 7446 11001 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79097 m0 *1 609.84,902.16
X$79097 14074 7446 10684 14073 10793 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $79099 m0 *1 577.92,841.68
X$79099 14074 14073 9666 9816 7446 10040 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79101 r0 *1 584.08,871.92
X$79101 14074 14073 9667 10390 7446 10474 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79136 r0 *1 577.92,871.92
X$79136 14073 7446 10141 14074 10442 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $79139 m0 *1 574,882
X$79139 14074 14073 8127 10389 7446 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79141 m0 *1 618.8,932.4
X$79141 14074 7446 14073 10145 11198 11199 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $79144 r0 *1 619.36,942.48
X$79144 14074 14073 11340 11446 7446 11447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79147 m0 *1 577.92,952.56
X$79147 14074 7446 14073 10895 11534 11532 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $79149 m0 *1 549.92,922.32
X$79149 14074 14073 7446 10134 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79152 m0 *1 575.12,912.24
X$79152 14073 14074 11000 10894 10965 7446 9450 10867
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $79154 m0 *1 564.48,922.32
X$79154 14074 14073 7446 11080 11200 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79168 m0 *1 616.56,710.64
X$79168 14074 14073 7447 7664 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $79173 m0 *1 647.36,700.56
X$79173 14074 14073 7450 7581 7448 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79175 r0 *1 646.24,690.48
X$79175 14074 14073 7450 7531 7449 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79182 r0 *1 642.32,700.56
X$79182 14074 14073 7450 7616 7530 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79187 m0 *1 646.24,710.64
X$79187 14074 14073 7450 7704 7662 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79196 m0 *1 697.76,700.56
X$79196 14074 14073 7536 7454 7451 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79198 m0 *1 687.68,710.64
X$79198 14073 7536 7451 14074 7621 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $79223 r0 *1 700,690.48
X$79223 14073 7455 14074 7456 7707 7457 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $79230 m0 *1 702.8,700.56
X$79230 14074 14073 7457 7659 7456 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79244 m0 *1 732.48,710.64
X$79244 7794 7788 7459 14074 14073 7834 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $79262 r0 *1 704.48,710.64
X$79262 7536 7538 7462 7707 14074 14073 7655 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $79264 m0 *1 696.64,720.72
X$79264 7538 14073 7462 7621 14074 7618 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $79266 r0 *1 739.76,700.56
X$79266 14074 14073 7623 7539 7462 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79270 r0 *1 745.36,700.56
X$79270 14074 14073 7485 7462 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79273 r0 *1 735.28,710.64
X$79273 14074 7709 7624 7654 7463 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $79279 r0 *1 759.36,690.48
X$79279 14074 14073 7485 7463 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $79285 m0 *1 788.48,851.76
X$79285 14073 9854 10000 7464 10058 9857 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $79312 r0 *1 786.24,851.76
X$79312 14074 9963 14073 10057 9999 10053 7464 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $79314 m0 *1 772.8,851.76
X$79314 14074 14073 8329 9963 9964 7464 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79342 r0 *1 1023.12,690.48
X$79342 14074 14073 7564 7468 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $79347 m0 *1 1165.92,700.56
X$79347 7558 14073 14074 7470 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79350 m0 *1 1148.56,700.56
X$79350 7474 14073 14074 7471 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79440 r0 *1 987.84,700.56
X$79440 14074 14073 7556 7478 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79467 r0 *1 1054.48,892.08
X$79467 14074 9867 7479 14073 10728 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $79469 r0 *1 1027.6,841.68
X$79469 14074 7479 8960 14073 9890 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $79471 m0 *1 1045.52,831.6
X$79471 14074 8294 7479 14073 9599 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $79485 m0 *1 1052.8,871.92
X$79485 14074 14073 10176 8396 7479 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $79487 r0 *1 1058.96,922.32
X$79487 14074 14073 7479 11222 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79489 r0 *1 1022.56,902.16
X$79489 14074 14073 10841 7829 7479 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $79521 m0 *1 739.76,730.8
X$79521 14074 7708 14073 7793 7796 7485 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $79529 r0 *1 753.2,700.56
X$79529 14074 14073 7627 7485 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79571 r0 *1 661.92,720.72
X$79571 7705 7879 7880 7494 14073 14074 7786 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $79610 r0 *1 19.04,942.48
X$79610 7501 14073 14074 11267 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $79614 r0 *1 705.6,952.56
X$79614 14074 14073 11609 7501 10395 8867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $79617 r0 *1 714,952.56
X$79617 14074 10581 14073 11663 10482 7501 11586 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $79633 r0 *1 681.52,710.64
X$79633 14074 7534 7501 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $79638 m0 *1 106.4,710.64
X$79638 14074 14073 7502 7676 7595 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79644 m0 *1 117.6,892.08
X$79644 14073 7503 10733 14074 10646 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $79700 r0 *1 213.92,750.96
X$79700 14073 14074 7942 8348 8217 8350 7515 8415
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $79731 m0 *1 491.12,700.56
X$79731 7521 14073 7523 7522 14074 7588 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $79735 r0 *1 491.68,700.56
X$79735 14074 8431 7521 14073 7523 7522 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $79742 r0 *1 486.64,700.56
X$79742 14073 7608 7521 14074 7661 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $79795 r0 *1 551.6,700.56
X$79795 14074 14073 7526 7612 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79798 m0 *1 531.44,902.16
X$79798 14074 14073 10892 10862 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79855 r0 *1 512.4,821.52
X$79855 14074 14073 9446 9555 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79859 r0 *1 512.96,841.68
X$79859 14074 14073 9917 9843 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79864 m0 *1 507.92,801.36
X$79864 14074 14073 8948 9221 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79870 r0 *1 546,771.12
X$79870 14074 14073 8712 8830 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79872 m0 *1 518,871.92
X$79872 14074 14073 10359 10446 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79875 r0 *1 500.64,861.84
X$79875 14074 14073 10246 10245 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79881 r0 *1 549.36,801.36
X$79881 14074 14073 9144 9225 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79884 m0 *1 577.36,831.6
X$79884 14074 14073 9448 9632 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79893 m0 *1 502.88,902.16
X$79893 14074 14073 10858 10674 7527 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $79946 m0 *1 680.4,730.8
X$79946 14074 14073 8189 7534 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $79967 m0 *1 702.24,710.64
X$79967 14074 14073 7622 7536 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $79988 r0 *1 719.6,720.72
X$79988 14074 14073 7538 7623 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $79990 m0 *1 748.16,700.56
X$79990 14074 14073 7625 7538 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80021 r0 *1 761.04,700.56
X$80021 14074 14073 7541 7653 7576 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $80037 m0 *1 814.8,861.84
X$80037 14073 9854 10231 7545 10060 10059 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $80052 m0 *1 818.16,882
X$80052 14074 14073 10530 10302 9964 7545 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $80055 m0 *1 825.44,871.92
X$80055 14074 10302 14073 10057 10299 10053 7545
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $80070 r0 *1 1078.56,710.64
X$80070 14074 14073 7546 7548 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80131 r0 *1 922.88,730.8
X$80131 14074 7977 7978 14073 7551 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $80166 r0 *1 887.6,730.8
X$80166 14074 14073 7551 8250 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80175 m0 *1 920.64,730.8
X$80175 14074 14073 7552 7977 7978 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80180 r0 *1 924.56,720.72
X$80180 14074 14073 7552 7635 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80185 m0 *1 861.84,710.64
X$80185 14074 7886 7572 7552 7647 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $80227 r0 *1 978.32,710.64
X$80227 14074 14073 7554 7810 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80266 r0 *1 995.68,710.64
X$80266 14074 7557 7710 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $80287 r0 *1 1045.52,700.56
X$80287 14074 7639 7562 7635 7735 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $80386 m0 *1 1009.68,720.72
X$80386 14074 14073 7582 7745 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80397 m0 *1 394.8,710.64
X$80397 14073 7589 7583 14074 7692 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $80408 r0 *1 506.8,811.44
X$80408 14074 14073 7584 9660 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80431 m0 *1 501.76,730.8
X$80431 14073 7588 7871 14074 7957 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $80445 m0 *1 401.52,730.8
X$80445 14073 7589 7776 14074 8013 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $80453 r0 *1 34.16,942.48
X$80453 14074 11479 10114 7590 10115 11143 11478 11645 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $80462 m0 *1 75.6,771.12
X$80462 14074 14073 8625 7592 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80465 m0 *1 82.88,750.96
X$80465 8283 7593 8284 8207 14074 14073 8285 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $80474 m0 *1 85.12,710.64
X$80474 14074 14073 7594 7675 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80481 r0 *1 392,942.48
X$80481 14074 14073 11431 7596 11413 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $80497 r0 *1 384.72,1033.2
X$80497 14073 7596 12733 12038 12949 12811 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $80509 r0 *1 653.52,710.64
X$80509 14074 14073 7705 7644 7597 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80511 m0 *1 675.36,710.64
X$80511 7619 7620 7706 14074 14073 7597 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $80537 r0 *1 401.52,720.72
X$80537 14073 7600 7691 14074 7953 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $80561 m0 *1 240.24,912.24
X$80561 14074 10940 10114 7602 10115 10113 10719 10981 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $80563 r0 *1 467.6,892.08
X$80563 14074 10673 14073 10569 7603 10670 8914 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $80566 r0 *1 240.24,932.4
X$80566 14074 14073 11350 7603 10345 10981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $80575 r0 *1 272.16,902.16
X$80575 14074 14073 10777 7603 10371 10778 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $80606 r0 *1 350,1123.92
X$80606 14074 12115 14073 13742 13810 12116 7603
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $80608 r0 *1 412.72,1033.2
X$80608 14074 14073 7603 7837 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80610 r0 *1 411.6,1134
X$80610 14074 13744 14073 12104 13839 12189 7603
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $80618 m0 *1 516.88,992.88
X$80618 14074 14073 12044 7606 10134 8093 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $80640 m0 *1 484.4,811.44
X$80640 14074 14073 7606 9251 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80643 m0 *1 540.96,801.36
X$80643 9223 14074 14073 7606 7615 9144 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $80667 r0 *1 631.12,821.52
X$80667 14074 14073 9512 9622 8131 7607 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $80670 m0 *1 369.04,720.72
X$80670 14074 14073 7607 7867 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80675 m0 *1 573.44,730.8
X$80675 7959 14074 14073 7607 7700 8100 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $80696 m0 *1 500.64,761.04
X$80696 14074 14073 7609 8463 7669 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $80700 m0 *1 511.84,720.72
X$80700 14073 7780 14074 7849 7781 7610 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $80705 m0 *1 437.92,871.92
X$80705 14074 14073 10276 7611 8618 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80716 m0 *1 499.52,841.68
X$80716 9819 14074 14073 9914 7611 14104 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $80719 r0 *1 441.28,882
X$80719 7611 10383 10384 10632 14074 14073 10634 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $80721 m0 *1 484.4,861.84
X$80721 14074 14073 7611 10035 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80781 r0 *1 538.72,791.28
X$80781 14074 14073 7615 9309 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80796 r0 *1 492.8,791.28
X$80796 14074 14073 7617 9057 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80804 m0 *1 668.08,710.64
X$80804 14074 7706 14073 7755 7619 7620 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $80811 r0 *1 723.52,700.56
X$80811 14074 14073 7620 7624 7655 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80840 m0 *1 691.6,720.72
X$80840 14074 14073 7791 7788 7624 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $80843 m0 *1 743.12,720.72
X$80843 14074 7796 7625 7798 7797 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $80853 m0 *1 747.6,710.64
X$80853 14074 7708 7627 7653 7626 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $80864 r0 *1 800.24,710.64
X$80864 14074 14073 7712 7628 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $80892 m0 *1 863.52,902.16
X$80892 14073 14074 10055 9171 8236 7630 10849 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $80894 m0 *1 875.84,902.16
X$80894 14074 14073 7630 10807 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80910 m0 *1 926.24,730.8
X$80910 14074 14073 7632 7720 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $80952 r0 *1 921.76,710.64
X$80952 14074 7717 7716 7635 7742 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $80963 m0 *1 1145.2,710.64
X$80963 14074 14073 7636 7727 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80973 r0 *1 1138.48,700.56
X$80973 14074 14073 7733 7638 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $80983 m0 *1 1149.12,892.08
X$80983 14074 14073 7639 10608 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $80986 m0 *1 1158.08,811.44
X$80986 14074 14073 9282 7808 7639 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80988 r0 *1 1115.52,801.36
X$80988 14074 14073 9189 9084 7639 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80991 r0 *1 1110.48,781.2
X$80991 14074 14073 8972 8968 7639 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $80993 r0 *1 1150.24,892.08
X$80993 14074 14073 7639 10717 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81029 r0 *1 1030.4,831.6
X$81029 14074 14073 7641 9867 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81031 m0 *1 1025.92,831.6
X$81031 14074 14073 7641 8872 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81034 m0 *1 1034.88,740.88
X$81034 14074 14073 7641 8155 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81036 m0 *1 1032.08,821.52
X$81036 14074 14073 7641 9270 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81050 r0 *1 782.32,902.16
X$81050 14074 7642 9567 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $81052 r0 *1 863.52,992.88
X$81052 14074 7642 11330 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $81058 r0 *1 824.32,811.44
X$81058 14074 7642 8178 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $81063 m0 *1 756.56,882
X$81063 14074 7642 14073 gf180mcu_fd_sc_mcu9t5v0__inv_20
* cell instance $81068 r0 *1 700,1002.96
X$81068 14074 7642 11294 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $81071 r0 *1 749.28,1073.52
X$81071 14074 7642 12454 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $81088 m0 *1 660.24,710.64
X$81088 14074 14073 7755 7644 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81093 m0 *1 934.08,730.8
X$81093 14074 14073 7645 8257 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81125 m0 *1 1130.08,841.68
X$81125 14074 7807 7648 14073 9588 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $81138 r0 *1 1128.4,851.76
X$81138 14074 14073 7648 10182 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81140 r0 *1 1110.48,831.6
X$81140 14074 14073 7648 9688 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81142 m0 *1 1087.52,791.28
X$81142 14074 14073 7648 8967 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81173 r0 *1 404.32,710.64
X$81173 7652 14074 7748 14073 7840 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $81191 r0 *1 389.76,720.72
X$81191 14073 7922 7657 14074 8089 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $81216 m0 *1 540.4,710.64
X$81216 14074 14073 7756 7663 7757 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $81255 m0 *1 388.08,851.76
X$81255 14073 7670 9249 14074 9766 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $81280 m0 *1 472.64,831.6
X$81280 14074 14073 7670 9551 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81283 r0 *1 388.08,871.92
X$81283 7874 14073 7670 9249 14074 10462 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $81286 r0 *1 426.72,861.84
X$81286 14073 7670 8226 14074 10130 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $81290 r0 *1 438.48,861.84
X$81290 7874 14073 7670 8226 14074 10383 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $81294 r0 *1 431.76,861.84
X$81294 14074 14073 7670 10531 10275 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $81297 m0 *1 423.36,851.76
X$81297 7874 7670 8226 9249 14074 14073 9839 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $81300 r0 *1 10.08,710.64
X$81300 7671 14073 14074 7672 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81310 m0 *1 71.12,982.8
X$81310 14074 14073 11834 7673 10371 11787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81312 r0 *1 35.28,962.64
X$81312 14074 14073 11688 7673 10345 11645 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81315 r0 *1 70.56,791.28
X$81315 14074 14073 9090 7673 8110 8722 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81318 r0 *1 49.28,710.64
X$81318 14074 14073 7732 7673 7763 7762 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81334 r0 *1 49.28,992.88
X$81334 14074 12342 14073 12104 12188 7673 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $81338 m0 *1 120.96,1002.96
X$81338 14074 12115 14073 12402 12240 12327 7673
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $81358 r0 *1 126.56,811.44
X$81358 14074 7678 14073 8211 9750 7989 9378 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $81360 r0 *1 126,710.64
X$81360 14074 14073 7678 7679 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81412 m0 *1 665.28,730.8
X$81412 14074 7879 7690 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $81420 r0 *1 674.24,730.8
X$81420 14074 14073 7690 7803 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81440 m0 *1 446.32,791.28
X$81440 14074 14073 7694 8946 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81455 r0 *1 485.52,730.8
X$81455 14074 14073 7696 8125 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81460 m0 *1 507.92,750.96
X$81460 14074 14073 7697 8232 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $81462 r0 *1 508.48,750.96
X$81462 14074 14073 7697 8366 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81467 m0 *1 560,720.72
X$81467 14074 14073 7699 7802 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81477 r0 *1 567.84,720.72
X$81477 14074 14073 7700 7930 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81490 r0 *1 589.12,791.28
X$81490 14074 14073 7701 9119 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81492 r0 *1 597.52,811.44
X$81492 9417 14074 14073 8946 7701 9416 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $81511 r0 *1 654.08,720.72
X$81511 14074 14073 7705 7832 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81514 r0 *1 728,730.8
X$81514 14074 14073 7791 7706 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81516 m0 *1 722.96,720.72
X$81516 14073 7794 14074 7706 7792 7793 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $81533 m0 *1 743.68,710.64
X$81533 14074 14073 7708 7709 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81550 m0 *1 725.2,892.08
X$81550 14074 9731 14073 10691 9856 7710 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $81613 r0 *1 865.2,710.64
X$81613 14074 14073 7714 7885 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81650 r0 *1 1158.08,811.44
X$81650 14074 14073 9366 7808 7717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $81652 r0 *1 1163.68,811.44
X$81652 14074 14073 7717 9367 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81654 m0 *1 1087.52,801.36
X$81654 14074 14073 9193 8968 7717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $81682 r0 *1 938,730.8
X$81682 14074 7719 8294 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $81685 r0 *1 991.76,801.36
X$81685 7719 14073 14074 8170 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $81710 r0 *1 1014.16,710.64
X$81710 14074 14073 7722 7890 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81713 r0 *1 1039.92,710.64
X$81713 14074 14073 7723 7891 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81716 r0 *1 1086.96,710.64
X$81716 14074 14073 7724 7903 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81718 r0 *1 1162,710.64
X$81718 7725 14073 14074 7819 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81751 r0 *1 1153.6,710.64
X$81751 7731 14073 14074 7728 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81754 r0 *1 1181.04,720.72
X$81754 7729 14073 14074 7897 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81782 m0 *1 100.24,942.48
X$81782 14074 11486 10114 7736 10115 11143 11268 11418 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $81796 m0 *1 1018.08,710.64
X$81796 14074 14073 7824 7737 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $81802 r0 *1 1174.88,730.8
X$81802 7739 14073 14074 8276 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81818 m0 *1 978.32,740.88
X$81818 14074 14073 7740 8152 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81820 m0 *1 1026.48,740.88
X$81820 14074 14073 7740 8399 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81823 m0 *1 1066.8,902.16
X$81823 7740 14073 14074 8774 gf180mcu_fd_sc_mcu9t5v0__buf_3
* cell instance $81881 r0 *1 889.84,791.28
X$81881 14073 8869 14074 8602 9007 7752 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $81893 r0 *1 731.92,861.84
X$81893 14074 9731 14073 10480 9856 7752 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $81901 r0 *1 454.72,750.96
X$81901 14074 14073 7753 8364 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $81928 r0 *1 5.04,730.8
X$81928 7761 14073 14074 8069 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $81937 m0 *1 58.24,831.6
X$81937 14074 14073 9593 9423 7763 9422 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81940 m0 *1 112,912.24
X$81940 14074 14073 10929 10875 7763 10546 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81942 m0 *1 52.08,861.84
X$81942 14074 14073 10108 9514 7763 9983 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81947 m0 *1 59.36,912.24
X$81947 14074 14073 10922 10645 7763 10768 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81949 r0 *1 35.28,750.96
X$81949 14074 14073 8404 8202 7763 8203 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81952 m0 *1 43.68,801.36
X$81952 14074 14073 9035 8980 7763 9036 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81955 m0 *1 137.76,831.6
X$81955 14074 14073 9643 9532 7763 9644 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81957 r0 *1 139.44,882
X$81957 14074 14073 10451 10549 7763 10452 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81959 r0 *1 202.16,821.52
X$81959 14074 14073 9498 9433 7763 9241 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $81962 m0 *1 201.6,781.2
X$81962 14074 14073 8809 8726 7763 8728 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82038 m0 *1 358.96,740.88
X$82038 14074 8119 14073 7941 7769 8225 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82068 m0 *1 438.48,942.48
X$82068 14074 14073 11356 7771 11357 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $82071 m0 *1 213.92,982.8
X$82071 14073 14074 11861 11863 11993 7771 11921 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $82103 r0 *1 500.64,761.04
X$82103 8463 7778 8462 14074 14073 8557 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $82105 m0 *1 492.24,761.04
X$82105 8466 8462 7778 8463 14074 14073 8617 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $82108 m0 *1 441.28,821.52
X$82108 14074 7781 8555 7779 14073 9444 gf180mcu_fd_sc_mcu9t5v0__or3_4
* cell instance $82117 r0 *1 440.72,821.52
X$82117 14074 7781 9337 9732 8555 7779 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $82119 m0 *1 486.08,831.6
X$82119 9615 14073 14074 8555 7779 7781 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $82122 r0 *1 439.04,831.6
X$82122 14073 9249 14074 9730 8555 7779 7781 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $82124 m0 *1 440.16,831.6
X$82124 14073 8466 14074 9661 8555 7779 8465 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $82128 r0 *1 442.96,811.44
X$82128 8852 7779 8555 8465 14073 14074 9336 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $82156 r0 *1 670.32,982.8
X$82156 14074 10581 14073 11966 10482 7784 11967 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $82159 r0 *1 682.64,1002.96
X$82159 14074 14073 12292 7784 10395 8957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82161 r0 *1 488.88,1174.32
X$82161 7784 14073 14074 14065 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82191 m0 *1 495.04,771.12
X$82191 14074 14073 7784 8543 8556 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82193 m0 *1 687.68,942.48
X$82193 14074 14073 7784 11164 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82197 m0 *1 656.88,791.28
X$82197 8752 8952 9064 8953 14073 14074 7785 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $82210 m0 *1 675.92,720.72
X$82210 14074 14073 7787 8138 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82221 r0 *1 734.72,720.72
X$82221 14074 7920 7791 7795 7970 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $82232 r0 *1 691.6,750.96
X$82232 14074 8381 14073 8427 8243 7792 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82241 r0 *1 691.6,740.88
X$82241 14074 8383 14073 8185 7792 7966 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82249 m0 *1 752.08,730.8
X$82249 14074 14073 7920 7794 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82301 r0 *1 846.72,761.04
X$82301 14074 14073 8571 7803 8602 8483 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82303 m0 *1 692.16,972.72
X$82303 14074 10581 14073 11811 10482 7803 11730 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $82305 r0 *1 456.4,1164.24
X$82305 7803 14073 14074 14050 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82307 r0 *1 674.8,962.64
X$82307 14074 14073 11729 7803 10395 8003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82391 m0 *1 924,831.6
X$82391 14074 9577 7807 14073 9605 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82393 r0 *1 927.92,781.2
X$82393 14074 7807 8485 14073 8870 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82395 m0 *1 1074.64,771.12
X$82395 14074 7807 7891 14073 8671 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82398 m0 *1 1096.48,781.2
X$82398 14074 7807 8399 14073 8797 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82400 m0 *1 1058.96,771.12
X$82400 14074 7807 8392 14073 8688 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82406 m0 *1 1141.28,831.6
X$82406 14074 7807 8257 14073 9691 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82422 r0 *1 969.36,771.12
X$82422 14074 14073 8767 8396 7807 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82424 m0 *1 1010.8,821.52
X$82424 14074 14073 9601 9270 7807 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82426 r0 *1 1019.76,730.8
X$82426 14074 14073 7807 8059 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82428 m0 *1 1135.68,841.68
X$82428 14074 14073 7807 9798 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82431 r0 *1 907.2,831.6
X$82431 14074 7808 9790 14073 9716 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82433 m0 *1 904.96,851.76
X$82433 14074 9577 7808 14073 9966 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82435 m0 *1 957.04,771.12
X$82435 14074 14073 8664 7808 7829 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82438 r0 *1 1111.04,811.44
X$82438 14074 7808 9185 14073 9362 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82440 r0 *1 1092,791.28
X$82440 14074 7808 8967 14073 9092 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82442 r0 *1 1134.56,791.28
X$82442 14074 7808 8257 14073 9085 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82447 m0 *1 949.76,821.52
X$82447 14074 7808 9470 14073 9389 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82449 m0 *1 975.52,750.96
X$82449 14074 7808 8151 14073 8301 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82451 r0 *1 1025.36,771.12
X$82451 14074 7808 7891 14073 8773 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82453 m0 *1 991.76,740.88
X$82453 14074 7808 8152 14073 8171 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $82474 r0 *1 938,841.68
X$82474 14074 14073 9802 8256 7808 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82476 r0 *1 1156.4,841.68
X$82476 14074 14073 7808 9876 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82491 r0 *1 952.56,730.8
X$82491 14074 14073 7809 7982 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82494 r0 *1 960.96,730.8
X$82494 14073 7979 14074 7885 8058 7810 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $82504 r0 *1 1162,771.12
X$82504 7812 14073 14074 8787 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82512 r0 *1 1034.32,720.72
X$82512 14074 14073 7910 7813 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82516 r0 *1 1093.68,710.64
X$82516 14074 14073 7815 7820 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82519 m0 *1 1173.2,730.8
X$82519 7816 14073 14074 8068 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82525 r0 *1 1123.92,720.72
X$82525 14074 14073 7817 7893 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82528 r0 *1 1149.68,720.72
X$82528 14074 14073 7818 8065 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82541 m0 *1 81.76,892.08
X$82541 14073 7821 10731 14074 10543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $82570 r0 *1 1020.88,952.56
X$82570 14074 14073 11697 7829 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82572 m0 *1 1037.12,962.64
X$82572 14074 14073 11839 7829 11244 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82577 r0 *1 1044.96,942.48
X$82577 14074 14073 11571 7829 11305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82581 m0 *1 1048.88,750.96
X$82581 14074 14073 8265 7829 8266 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82584 m0 *1 1020.88,740.88
X$82584 14074 14073 8296 7829 8059 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $82608 m0 *1 925.12,821.52
X$82608 14074 14073 7829 9356 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82611 r0 *1 1034.32,942.48
X$82611 14074 14073 7829 10598 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82627 m0 *1 483.28,1184.4
X$82627 7832 14073 14074 14064 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $82629 r0 *1 743.12,962.64
X$82629 14074 14073 11733 7832 10395 7972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82631 r0 *1 741.44,932.4
X$82631 14074 10581 14073 11006 10482 7832 11409 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $82633 r0 *1 782.32,962.64
X$82633 14074 14073 11736 7832 8602 11666 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82663 r0 *1 710.08,740.88
X$82663 14073 8140 7834 14074 7965 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $82672 m0 *1 700,761.04
X$82672 14074 8317 14073 8425 7834 8140 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82683 m0 *1 416.08,1073.52
X$82683 14074 13250 14073 13300 11713 7837 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82691 r0 *1 336,1063.44
X$82691 14073 11860 13189 7837 13298 13190 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $82712 m0 *1 444.08,720.72
X$82712 14074 14073 7841 8093 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82726 m0 *1 639.52,932.4
X$82726 14074 14073 11204 11250 8131 7844 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $82738 r0 *1 633.92,791.28
X$82738 14074 14073 7846 8198 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $82745 r0 *1 465.92,811.44
X$82745 14073 9337 14074 9338 7847 8431 9550 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $82787 r0 *1 42.56,730.8
X$82787 14074 14073 8072 7855 8020 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $82806 m0 *1 81.2,781.2
X$82806 14074 8220 14073 7858 8295 8722 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $82814 r0 *1 77.28,962.64
X$82814 14074 11430 14073 11753 11627 10377 7859 11787
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $82840 r0 *1 226.24,932.4
X$82840 14074 7863 11184 11403 11329 14073 11272
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $82855 m0 *1 283.36,821.52
X$82855 14073 9435 9329 14074 7865 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $82874 r0 *1 558.32,720.72
X$82874 8041 14074 14073 7867 7930 14112 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $82909 m0 *1 542.08,831.6
X$82909 14074 14073 7872 9053 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82911 m0 *1 617.12,861.84
X$82911 10249 14074 14073 7872 10043 10144 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $82935 m0 *1 384.72,841.68
X$82935 14074 14073 7874 9811 9249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $82938 r0 *1 423.36,871.92
X$82938 7874 8618 10382 10130 14074 14073 10381 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $82941 m0 *1 445.2,871.92
X$82941 14073 7874 9337 14074 10275 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $82944 r0 *1 470.96,841.68
X$82944 14074 14073 7874 9663 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82958 r0 *1 619.92,841.68
X$82958 14074 14073 7875 10043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82960 m0 *1 623.28,851.76
X$82960 10042 14074 14073 9053 7875 14107 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $82974 r0 *1 519.12,781.2
X$82974 14074 14073 7876 9024 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82977 m0 *1 519.12,791.28
X$82977 9121 14074 14073 8921 7876 9025 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $82989 r0 *1 550.48,821.52
X$82989 9630 14074 14073 8190 7877 9519 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $82991 r0 *1 545.44,811.44
X$82991 14074 14073 7877 9414 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $82998 r0 *1 649.04,740.88
X$82998 14074 14073 7878 8330 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83007 m0 *1 680.96,740.88
X$83007 14074 7879 8139 14073 8188 8242 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $83009 m0 *1 692.16,841.68
X$83009 9669 14074 9850 14073 7880 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $83016 r0 *1 666.4,831.6
X$83016 14074 7880 7997 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $83045 r0 *1 953.68,821.52
X$83045 14074 14073 7886 8960 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83048 r0 *1 869.12,720.72
X$83048 14074 7886 8485 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* cell instance $83068 r0 *1 905.52,811.44
X$83068 14073 14074 7887 10164 9355 gf180mcu_fd_sc_mcu9t5v0__nand2_4
* cell instance $83074 r0 *1 1166.48,730.8
X$83074 7888 14073 14074 8403 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83088 m0 *1 1109.92,801.36
X$83088 14074 14073 7889 9185 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83090 m0 *1 1114.4,811.44
X$83090 14074 14073 7889 9280 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83096 m0 *1 1072.4,902.16
X$83096 14074 9796 7891 14073 10836 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83102 r0 *1 1089.76,831.6
X$83102 14074 9595 7891 14073 9686 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83104 m0 *1 999.04,750.96
X$83104 14074 8173 7891 14073 8258 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83107 m0 *1 999.04,740.88
X$83107 14074 8153 7891 14073 8168 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83134 r0 *1 1078,791.28
X$83134 14074 14073 7891 9081 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83136 r0 *1 1061.2,992.88
X$83136 14074 14073 7891 11903 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83138 m0 *1 1050.56,1002.96
X$83138 14074 14073 12309 11244 7891 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $83142 r0 *1 1094.24,730.8
X$83142 14074 14073 7892 8165 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83147 r0 *1 1141.28,720.72
X$83147 14074 14073 7894 7895 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83151 r0 *1 1167.04,720.72
X$83151 7898 14073 14074 7896 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83160 m0 *1 1155.28,730.8
X$83160 7899 14073 14074 7984 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83171 r0 *1 684.32,841.68
X$83171 14074 7901 9956 9783 14073 gf180mcu_fd_sc_mcu9t5v0__xor2_4
* cell instance $83179 m0 *1 655.76,851.76
X$83179 14074 14073 7901 8033 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83208 m0 *1 137.76,730.8
X$83208 14074 14073 7994 7908 7937 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $83220 m0 *1 750.96,1002.96
X$83220 14074 12374 14073 12297 9731 9856 12248 7911
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $83230 m0 *1 775.6,992.88
X$83230 14074 14073 7911 12140 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83249 m0 *1 226.24,740.88
X$83249 14074 7914 7942 14073 8174 8117 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $83308 m0 *1 524.16,892.08
X$83308 14074 14073 7927 10639 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83310 m0 *1 530.32,892.08
X$83310 10767 14074 14073 8231 7927 10766 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $83324 r0 *1 516.88,740.88
X$83324 14073 7929 8038 14074 8322 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $83360 m0 *1 346.64,1093.68
X$83360 14074 13516 14073 13467 7935 11713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $83407 r0 *1 196.56,781.2
X$83407 14074 8728 14073 7936 9240 7989 8213 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83428 m0 *1 215.6,750.96
X$83428 14074 7940 8218 8347 8212 14073 8349 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $83448 m0 *1 238.56,1134
X$83448 14074 12115 14073 13779 13649 12116 7941
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83450 m0 *1 225.12,1164.24
X$83450 14074 13879 14073 12104 13986 12189 7941
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83452 r0 *1 211.68,740.88
X$83452 14074 7999 7942 14073 8116 8216 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $83455 m0 *1 239.12,730.8
X$83455 14074 7942 7998 14073 8000 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83463 r0 *1 206.64,750.96
X$83463 14074 7942 8212 14073 8347 8218 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $83465 m0 *1 254.8,801.36
X$83465 14074 7943 9134 14073 9135 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83477 r0 *1 245.28,740.88
X$83477 14074 14073 7944 8117 7943 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $83479 r0 *1 265.44,750.96
X$83479 14074 14073 8029 7943 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83481 m0 *1 266.56,730.8
X$83481 14074 7944 7945 14073 8004 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83488 r0 *1 229.04,740.88
X$83488 14074 14073 8108 7944 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83497 r0 *1 269.36,801.36
X$83497 14073 7945 9136 14074 9207 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $83561 r0 *1 701.68,740.88
X$83561 14074 14073 7956 8382 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83580 r0 *1 629.44,740.88
X$83580 14073 7960 14074 8315 8132 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $83600 r0 *1 649.04,902.16
X$83600 10960 14074 14073 8644 7963 10958 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $83602 m0 *1 651.84,902.16
X$83602 14074 14073 7963 10872 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83614 m0 *1 680.96,902.16
X$83614 10795 14074 14073 8527 7964 10760 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $83616 r0 *1 693.28,892.08
X$83616 14074 14073 7964 10758 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83622 m0 *1 693.84,750.96
X$83622 14073 7966 8321 14074 8243 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $83624 r0 *1 712.32,750.96
X$83624 14074 8383 7966 8385 8384 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $83636 r0 *1 723.52,740.88
X$83636 14074 14073 7966 8317 8320 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $83640 r0 *1 718.48,871.92
X$83640 14073 9854 10435 7967 10631 10295 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $83655 m0 *1 739.2,871.92
X$83655 14074 14073 10361 10296 9964 7967 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $83659 r0 *1 744.8,871.92
X$83659 14074 10296 14073 10057 10433 10053 7967
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83705 m0 *1 873.04,932.4
X$83705 14074 14073 11250 11154 9731 7972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $83735 r0 *1 866.32,871.92
X$83735 14074 7972 14073 8250 10426 10401 7976 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83737 r0 *1 870.8,942.48
X$83737 14074 14073 11583 11461 10804 7972 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $83740 m0 *1 907.76,962.64
X$83740 14074 7972 14073 8661 11701 11673 8251 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83756 m0 *1 912.8,730.8
X$83756 14074 14073 7975 7976 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83781 m0 *1 896,750.96
X$83781 14073 7976 8307 14074 8306 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $83785 m0 *1 901.04,781.2
X$83785 14074 7976 14073 8819 8818 8250 8568 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83787 m0 *1 907.76,750.96
X$83787 14074 14073 8057 7978 8254 7976 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $83789 m0 *1 895.44,791.28
X$83789 14074 7976 14073 9006 9002 8250 8957 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83791 m0 *1 904.4,892.08
X$83791 14074 7976 14073 10620 10489 8250 9786 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83793 m0 *1 895.44,892.08
X$83793 14074 7976 14073 10742 10591 8250 10238 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83795 r0 *1 903.28,821.52
X$83795 14074 7976 14073 9496 9584 8250 9348 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83798 m0 *1 885.36,761.04
X$83798 14074 7976 14073 8518 8412 8250 8486 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83800 r0 *1 885.92,761.04
X$83800 14074 7976 14073 8601 8490 8250 8480 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83802 m0 *1 875.84,861.84
X$83802 14074 7976 14073 10228 10224 8250 8650 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83804 m0 *1 890.4,882
X$83804 14074 7976 14073 10525 10516 8250 9787 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83809 r0 *1 882.56,740.88
X$83809 14074 7976 14073 8175 8167 8250 8045 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83811 m0 *1 889.28,841.68
X$83811 14074 7976 14073 9674 9791 8250 8654 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83813 r0 *1 889.28,851.76
X$83813 14074 7976 14073 9990 9991 8250 8867 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83815 r0 *1 884.8,841.68
X$83815 14074 7976 14073 9900 9889 8250 9569 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83818 r0 *1 889.28,831.6
X$83818 14074 7976 14073 9717 9712 8250 8003 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83820 r0 *1 889.28,821.52
X$83820 14074 7976 14073 9466 9467 8250 8520 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83829 r0 *1 922.88,740.88
X$83829 14074 14073 7977 8251 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $83836 m0 *1 916.16,750.96
X$83836 14074 14073 8304 8255 8254 7978 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $83841 m0 *1 1030.4,902.16
X$83841 14074 8170 7980 14073 10706 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83843 r0 *1 1015.28,892.08
X$83843 14074 8485 7980 14073 10704 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $83851 r0 *1 1012.48,922.32
X$83851 14074 7980 11216 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $83853 r0 *1 1170.4,771.12
X$83853 7981 14073 14074 8790 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83878 r0 *1 1099.28,730.8
X$83878 14074 14073 8063 7983 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83883 m0 *1 1164.8,730.8
X$83883 7986 14073 14074 7985 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $83893 m0 *1 42,730.8
X$83893 14074 14073 8021 7987 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83905 r0 *1 274.96,851.76
X$83905 14073 9434 9435 14074 7989 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $83947 r0 *1 117.6,831.6
X$83947 14074 9425 14073 8295 9704 7989 9492 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83950 m0 *1 230.72,761.04
X$83950 14074 8220 14073 8516 7989 8451 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $83955 m0 *1 115.36,841.68
X$83955 14074 9641 14073 8295 9801 7989 9642 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $83966 m0 *1 1111.6,730.8
X$83966 14074 14073 7991 7992 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83982 r0 *1 1163.12,730.8
X$83982 14074 14073 7995 8163 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $83997 r0 *1 680.96,831.6
X$83997 14074 14073 7997 8362 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84000 r0 *1 230.16,730.8
X$84000 14074 14073 8117 7998 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84046 m0 *1 893.76,922.32
X$84046 14074 14073 8003 11153 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84050 r0 *1 889.84,952.56
X$84050 14074 14073 11545 11640 10804 8003 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84053 r0 *1 908.32,972.72
X$84053 14074 14073 8003 11892 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84142 m0 *1 532.56,831.6
X$84142 9738 14074 14073 9218 8019 9739 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $84144 r0 *1 535.36,821.52
X$84144 14074 14073 8019 9629 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84162 m0 *1 100.8,761.04
X$84162 8169 8023 8589 8443 14074 14073 8445 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $84173 r0 *1 182.56,740.88
X$84173 14074 14073 8291 8026 8449 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84211 r0 *1 292.32,892.08
X$84211 8030 10747 10942 10655 14074 14073 10569 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $84226 r0 *1 654.08,841.68
X$84226 9259 14074 8033 9849 14073 9950 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $84240 m0 *1 654.08,841.68
X$84240 14074 14073 8033 9777 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84243 r0 *1 646.24,841.68
X$84243 9949 14073 14074 8033 9259 9849 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $84257 r0 *1 448,1184.4
X$84257 8036 14073 14074 14059 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84261 m0 *1 737.52,1002.96
X$84261 14074 10581 14073 12139 10482 8036 12251 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $84279 r0 *1 739.76,892.08
X$84279 14074 14073 8083 8036 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84282 r0 *1 756.56,962.64
X$84282 14074 14073 8036 11665 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84285 m0 *1 729.12,1013.04
X$84285 14074 10575 14073 12450 8036 10238 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $84290 m0 *1 476.56,750.96
X$84290 14074 14073 8037 8231 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84296 r0 *1 523.04,730.8
X$84296 14074 14073 8039 8040 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $84298 r0 *1 521.92,761.04
X$84298 14074 14073 8039 8852 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84304 r0 *1 539.84,750.96
X$84304 14074 14073 8040 8466 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84313 r0 *1 583.52,750.96
X$84313 8535 14074 14073 8363 8042 8436 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $84317 r0 *1 580.16,750.96
X$84317 14074 14073 8042 8371 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84373 m0 *1 637.84,992.88
X$84373 14074 14073 12128 12186 11371 8045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84376 m0 *1 633.36,740.88
X$84376 14074 14073 8045 8095 8236 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84384 m0 *1 898.24,1033.2
X$84384 14074 14073 8045 12855 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84387 r0 *1 784,932.4
X$84387 14074 14073 11296 11336 8046 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84389 m0 *1 763.84,942.48
X$84389 14073 11504 14074 8046 11372 11506 10054
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $84391 r0 *1 775.6,932.4
X$84391 14074 14073 11261 8046 11453 11208 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84438 m0 *1 970.48,740.88
X$84438 14074 14073 8053 8172 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84450 m0 *1 781.76,740.88
X$84450 14074 14073 8180 8055 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84452 m0 *1 827.68,740.88
X$84452 14074 14073 8055 8176 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84477 m0 *1 1029.28,831.6
X$84477 14074 14073 8485 8060 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84479 r0 *1 1029.28,750.96
X$84479 14074 8412 8395 8579 8061 8263 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $84484 m0 *1 1089.2,740.88
X$84484 14074 14073 8062 8157 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84490 r0 *1 1150.24,730.8
X$84490 14074 14073 8064 8066 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84496 r0 *1 1158.64,740.88
X$84496 8279 14073 14074 8067 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84509 m0 *1 1156.4,740.88
X$84509 8070 14073 14074 8160 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84513 m0 *1 1180.48,781.2
X$84513 8071 14073 14074 8789 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84527 r0 *1 101.92,740.88
X$84527 14074 14073 8442 8073 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84529 r0 *1 101.92,750.96
X$84529 14074 8408 14073 8289 8073 8209 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $84531 r0 *1 1155.84,851.76
X$84531 14074 8153 8074 14073 9976 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $84544 m0 *1 1153.6,861.84
X$84544 14074 14073 10080 9281 8074 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $84546 m0 *1 1144.64,871.92
X$84546 14074 14073 8074 10319 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84581 r0 *1 810.88,982.8
X$84581 14074 14073 8076 11969 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84584 r0 *1 757.12,982.8
X$84584 14073 8076 9856 14074 12052 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $84608 m0 *1 1062.32,952.56
X$84608 14074 14073 8079 11554 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84610 r0 *1 1068.48,952.56
X$84610 14074 14073 8079 11629 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84626 m0 *1 732.48,882
X$84626 14074 10392 10294 14073 8083 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $84699 r0 *1 445.76,781.2
X$84699 14074 14073 8092 8856 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84736 m0 *1 563.36,781.2
X$84736 8920 14074 14073 8093 8330 8919 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $84738 m0 *1 491.68,781.2
X$84738 14074 14073 8093 8741 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84763 r0 *1 616.56,740.88
X$84763 14074 14073 8097 8333 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84783 r0 *1 529.76,771.12
X$84783 14074 14073 8099 8828 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84785 r0 *1 532,781.2
X$84785 9027 14074 14073 8422 8099 9028 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $84815 m0 *1 536.48,771.12
X$84815 8710 14074 14073 8464 8104 8712 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $84817 m0 *1 543.76,781.2
X$84817 14074 14073 8104 8831 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84820 m0 *1 10.08,750.96
X$84820 8105 14073 14074 8213 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84823 r0 *1 10.08,740.88
X$84823 8106 14073 14074 8108 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84834 m0 *1 33.04,942.48
X$84834 14074 11480 10114 8107 10115 11143 11388 11516 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $84841 m0 *1 223.44,761.04
X$84841 14074 8108 14073 8515 8451 8600 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $84845 r0 *1 81.2,740.88
X$84845 14074 14073 8206 8109 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $84848 r0 *1 86.8,750.96
X$84848 14074 8985 14073 8337 8408 8109 8336 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $84851 r0 *1 111.44,750.96
X$84851 14074 14073 8210 8202 8110 8339 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84855 r0 *1 72.24,841.68
X$84855 14074 14073 9746 9514 8110 9747 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84858 r0 *1 417.2,841.68
X$84858 14073 9543 9909 14074 8110 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $84863 r0 *1 135.52,841.68
X$84863 14074 14073 9751 9433 8110 9425 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84866 r0 *1 101.92,892.08
X$84866 14074 14073 10545 10549 8110 9531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84868 m0 *1 71.12,821.52
X$84868 14074 14073 9370 9423 8110 8891 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84871 r0 *1 71.12,892.08
X$84871 14074 14073 10644 10645 8110 9697 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84873 r0 *1 131.04,821.52
X$84873 14074 14073 9429 9532 8110 9233 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84875 r0 *1 76.16,801.36
X$84875 14074 14073 9191 8980 8110 9126 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84884 m0 *1 188.72,781.2
X$84884 14074 14073 8807 8726 8110 8346 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84913 r0 *1 104.72,902.16
X$84913 14074 14073 10770 10875 8110 9749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $84915 r0 *1 115.92,740.88
X$84915 14073 8339 8112 14074 8111 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $84917 r0 *1 174.72,740.88
X$84917 14073 8212 14074 8289 8174 8111 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $84922 r0 *1 10.08,750.96
X$84922 8334 14073 14074 8112 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $84930 m0 *1 110.32,761.04
X$84930 14074 8112 14073 8339 8444 8442 8209 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $84933 m0 *1 128.8,750.96
X$84933 8342 8113 8340 8341 14074 14073 8411 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $84935 r0 *1 124.88,750.96
X$84935 14074 8359 8340 8113 8342 14073 8341 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $84942 r0 *1 192.64,740.88
X$84942 14074 14073 8114 8293 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $84949 m0 *1 205.52,750.96
X$84949 14074 14073 8215 8116 8214 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $84958 r0 *1 221.76,740.88
X$84958 14073 8212 8117 14074 8216 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85001 r0 *1 465.36,740.88
X$85001 14074 14073 8124 8229 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85014 r0 *1 487.76,821.52
X$85014 14074 14073 8125 9553 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85016 m0 *1 569.52,821.52
X$85016 9518 14074 14073 8125 8333 9448 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $85021 r0 *1 525.28,972.72
X$85021 14074 14073 11962 8856 10134 8125 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85023 r0 *1 427.28,740.88
X$85023 8126 14074 14073 8225 8226 14117 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $85028 m0 *1 619.92,761.04
X$85028 14073 8372 14074 8523 8529 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85030 m0 *1 601.44,831.6
X$85030 14074 14073 9628 8127 9619 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85034 m0 *1 613.76,811.44
X$85034 14073 9304 14074 9299 9253 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85036 m0 *1 600.32,781.2
X$85036 14073 8746 14074 8756 8747 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85038 r0 *1 615.44,761.04
X$85038 14073 8621 14074 8470 8859 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85046 r0 *1 658,861.84
X$85046 14073 10150 10149 8127 9952 10290 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $85048 m0 *1 657.44,871.92
X$85048 14073 10286 10148 8127 10287 10289 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $85052 m0 *1 603.68,912.24
X$85052 14073 10683 14074 10952 10896 8127 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85102 r0 *1 565.6,882
X$85102 14074 8127 14073 10473 10538 10570 10139
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85108 r0 *1 641.76,902.16
X$85108 14074 8127 14073 10873 8236 10238 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $85111 m0 *1 610.96,841.68
X$85111 8127 14073 9735 9779 14074 9918 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $85114 m0 *1 585.2,882
X$85114 14074 8435 10250 10139 10475 10253 10571 8127 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $85117 m0 *1 653.52,882
X$85117 14074 14073 8127 10290 10099 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $85120 r0 *1 655.2,882
X$85120 14073 8127 10099 14074 10437 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85122 r0 *1 584.64,892.08
X$85122 8127 14073 10868 10681 14074 10477 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $85141 r0 *1 566.16,761.04
X$85141 14074 14073 8130 8620 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85143 m0 *1 565.04,761.04
X$85143 8533 14074 14073 8364 8130 8532 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $85145 m0 *1 606.48,851.76
X$85145 14074 14073 9921 10012 8131 9924 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85147 r0 *1 586.88,801.36
X$85147 14074 14073 9146 9254 8131 9228 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85149 r0 *1 619.36,821.52
X$85149 14074 14073 9418 9563 8131 9517 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85151 r0 *1 618.8,811.44
X$85151 14074 14073 9148 9255 8131 9218 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85153 r0 *1 590.24,781.2
X$85153 14074 14073 8855 8832 8131 8921 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85156 m0 *1 624.96,771.12
X$85156 14074 14073 8472 8715 8131 8363 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85158 r0 *1 617.68,791.28
X$85158 14074 14073 8951 9114 8131 8364 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85160 r0 *1 660.24,882
X$85160 14074 8131 10099 14073 10287 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85162 r0 *1 669.2,882
X$85162 14074 14073 10393 8131 10099 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85164 r0 *1 637.28,871.92
X$85164 14074 14073 10440 10438 8131 10362 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85167 r0 *1 602,871.92
X$85167 14074 14073 10441 10292 8131 9451 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85170 m0 *1 566.72,912.24
X$85170 14074 14073 10968 10963 8131 11079 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85172 m0 *1 560,902.16
X$85172 14074 14073 10791 10679 8131 10865 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85175 m0 *1 666.96,871.92
X$85175 10286 8131 10291 10046 10437 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $85177 m0 *1 600.32,882
X$85177 14074 14073 10539 10356 8131 10471 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85179 r0 *1 560.56,771.12
X$85179 14074 8131 8714 14073 8716 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85182 m0 *1 908.88,932.4
X$85182 14073 8131 14074 11297 8388 11248 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85184 m0 *1 663.6,932.4
X$85184 14074 14073 11266 11293 8131 11109 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85186 r0 *1 674.8,922.32
X$85186 14074 14073 11265 11110 8131 11112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85188 m0 *1 684.88,922.32
X$85188 14074 14073 10796 11113 8131 10899 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85191 m0 *1 627.76,922.32
X$85191 14074 14073 11002 11106 8131 8622 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85193 r0 *1 649.04,922.32
X$85193 14074 14073 11264 11108 8131 11107 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85196 m0 *1 581.28,851.76
X$85196 14074 8131 9947 14073 9902 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85198 m0 *1 563.92,861.84
X$85198 14074 14073 10137 10050 8131 10104 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85256 r0 *1 714,912.24
X$85256 14073 11114 8131 10954 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $85258 r0 *1 670.32,861.84
X$85258 10150 8131 10393 10045 10244 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $85260 r0 *1 674.8,871.92
X$85260 14074 10294 10534 8131 10048 10393 10150 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* cell instance $85264 r0 *1 654.64,871.92
X$85264 14074 10392 10286 8131 10437 10363 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $85266 m0 *1 881.44,902.16
X$85266 14074 14073 8131 9858 10808 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $85272 m0 *1 633.92,821.52
X$85272 14074 9258 9342 9512 8132 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $85280 r0 *1 637.28,740.88
X$85280 14074 8237 8136 8133 8134 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $85288 r0 *1 664.72,740.88
X$85288 14074 8239 8136 14073 8137 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85291 r0 *1 664.16,750.96
X$85291 14074 14073 8240 8378 8136 8379 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85303 m0 *1 658.56,761.04
X$85303 14073 8473 8136 14074 8374 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85305 m0 *1 652.96,761.04
X$85305 14073 8136 8373 14074 8560 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85307 r0 *1 656.32,750.96
X$85307 14073 8136 8375 14074 8331 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85309 r0 *1 674.8,740.88
X$85309 14073 8136 8241 14074 8327 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $85314 m0 *1 670.88,750.96
X$85314 14073 8240 14074 8137 8328 8428 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85322 m0 *1 512.96,821.52
X$85322 14074 14073 8138 9523 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85325 m0 *1 519.12,821.52
X$85325 9627 14074 14073 8138 9245 14093 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $85355 m0 *1 799.68,962.64
X$85355 14074 14073 11611 11296 11610 8146 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85357 m0 *1 790.16,942.48
X$85357 14074 14073 11455 11373 11372 8146 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85363 m0 *1 753.76,851.76
X$85363 14073 9854 9906 8147 10153 9855 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $85387 m0 *1 760.48,861.84
X$85387 14074 9894 14073 10057 10237 10053 8147 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85389 m0 *1 747.6,871.92
X$85389 14074 14073 10358 9894 9964 8147 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85403 r0 *1 948.64,761.04
X$85403 14074 14073 8149 8574 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85405 r0 *1 958.16,750.96
X$85405 14074 14073 8149 8396 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85407 r0 *1 950.88,740.88
X$85407 14074 14073 8149 8256 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85409 r0 *1 1161.44,750.96
X$85409 8150 14073 14074 8584 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $85424 r0 *1 950.32,750.96
X$85424 14074 14073 8151 8488 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85427 r0 *1 1009.68,750.96
X$85427 14074 14073 8151 8392 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85429 r0 *1 988.4,750.96
X$85429 14074 8153 8152 14073 8390 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85435 r0 *1 971.6,750.96
X$85435 14074 14073 8513 8173 8152 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85440 r0 *1 901.04,861.84
X$85440 14074 9577 8153 14073 10221 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85442 r0 *1 909.44,861.84
X$85442 14074 8153 9790 14073 10063 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85444 m0 *1 935.76,811.44
X$85444 14074 8153 9356 14073 9392 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85447 m0 *1 954.24,761.04
X$85447 14074 14073 8514 8153 8488 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85449 m0 *1 1026.48,791.28
X$85449 14074 14073 8990 8153 8967 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85452 m0 *1 1178.24,861.84
X$85452 14074 14073 10187 8153 8164 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85455 m0 *1 1148.56,821.52
X$85455 14074 14073 9481 8153 9274 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85482 m0 *1 930.16,861.84
X$85482 14074 14073 10065 8256 8153 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85484 m0 *1 950.32,841.68
X$85484 14074 14073 9800 9470 8153 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85486 m0 *1 1167.04,892.08
X$85486 14074 14073 8153 10609 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $85489 m0 *1 1144.08,801.36
X$85489 14074 14073 8153 9084 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85493 r0 *1 1005.2,740.88
X$85493 14074 8154 8391 8288 8297 8167 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $85497 m0 *1 1043.28,740.88
X$85497 14074 14073 8292 8155 8266 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85503 r0 *1 1047.76,740.88
X$85503 14074 8265 8264 8286 8156 8267 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $85511 r0 *1 1140.16,771.12
X$85511 14074 14073 8158 8781 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85515 r0 *1 1167.04,740.88
X$85515 8159 14073 14074 8274 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $85520 r0 *1 1178.24,740.88
X$85520 8278 14073 14074 8161 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $85527 r0 *1 1179.36,750.96
X$85527 8163 14073 14074 8498 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $85532 m0 *1 1173.2,851.76
X$85532 14074 9876 8164 14073 9875 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85544 r0 *1 1149.68,841.68
X$85544 14074 14073 9978 9281 8164 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85547 m0 *1 1172.08,871.92
X$85547 14074 14073 8164 10411 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85553 r0 *1 1022,740.88
X$85553 14074 8296 8298 8261 8292 8166 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $85563 r0 *1 986.72,740.88
X$85563 14074 8300 8302 8260 8171 8168 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $85576 r0 *1 1041.6,871.92
X$85576 14074 8170 8394 14073 10407 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85609 m0 *1 946.4,831.6
X$85609 14074 14073 9793 8173 9356 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85611 r0 *1 942.48,851.76
X$85611 14074 14073 9987 8173 9470 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85613 r0 *1 920.08,861.84
X$85613 14074 14073 10218 8173 8256 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85615 r0 *1 952.56,761.04
X$85615 14074 14073 8663 8173 8488 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85619 r0 *1 880.88,851.76
X$85619 14074 8173 9790 14073 10062 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $85638 m0 *1 999.04,811.44
X$85638 14074 14073 8173 8968 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85640 m0 *1 885.36,861.84
X$85640 14074 14073 10226 9577 8173 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $85780 m0 *1 704.48,771.12
X$85780 8563 14074 8526 14073 8189 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $85788 r0 *1 715.68,771.12
X$85788 14074 14073 8189 9461 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85791 r0 *1 476.56,871.92
X$85791 14073 8852 14074 10134 10467 8190 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85794 r0 *1 484.4,871.92
X$85794 14073 8466 14074 10134 10277 8190 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85817 r0 *1 515.76,811.44
X$85817 14074 14073 8190 9302 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $85847 m0 *1 1086.4,761.04
X$85847 14074 14073 8194 8400 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85849 r0 *1 918.96,982.8
X$85849 14074 14073 8195 11980 8484 10399 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85856 m0 *1 646.24,992.88
X$85856 14074 14073 12186 12129 8236 8195 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85876 r0 *1 640.64,851.76
X$85876 14073 10011 14074 10043 10147 8198 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $85879 r0 *1 624.96,851.76
X$85879 14074 10043 8198 10099 9053 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $85940 r0 *1 110.32,972.72
X$85940 14074 14073 11837 8202 10371 11648 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85944 r0 *1 40.32,952.56
X$85944 14074 14073 11625 8202 10345 11516 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $85962 r0 *1 318.64,771.12
X$85962 14074 8698 14073 8202 8411 8635 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $85965 m0 *1 212.8,1103.76
X$85965 14074 8202 14073 12349 13571 12116 13409
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85967 r0 *1 122.08,1113.84
X$85967 14074 12115 14073 13656 13657 12327 8202
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85971 m0 *1 61.04,1113.84
X$85971 14074 13521 14073 12104 13632 8202 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85979 m0 *1 72.24,781.2
X$85979 14074 14073 8722 8793 8204 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $85984 m0 *1 64.4,781.2
X$85984 14074 14073 8721 8204 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $85991 r0 *1 80.08,761.04
X$85991 14074 8206 14073 8336 8539 8439 8440 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $85993 m0 *1 2.24,761.04
X$85993 8437 14073 14074 8206 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $85996 r0 *1 76.16,972.72
X$85996 14074 11430 14073 11786 11831 10377 8207 11857
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $86009 m0 *1 92.96,761.04
X$86009 14074 8220 14073 8284 8295 8209 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86046 m0 *1 194.32,750.96
X$86046 14074 14073 8346 8212 8213 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86058 r0 *1 112.56,761.04
X$86058 14074 14073 8539 8214 8538 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86066 m0 *1 210.56,750.96
X$86066 14073 8215 8216 14074 8217 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86069 m0 *1 150.64,761.04
X$86069 14074 14073 8444 8215 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86071 m0 *1 224.56,750.96
X$86071 14074 14073 8218 8299 8216 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86080 r0 *1 122.64,761.04
X$86080 8444 14073 8539 8540 14074 8218 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $86090 m0 *1 269.92,831.6
X$86090 14073 9537 9437 14074 8219 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86109 m0 *1 255.36,831.6
X$86109 14073 8696 8219 14074 9137 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86111 m0 *1 231.28,841.68
X$86111 14074 8220 14073 9893 8219 9755 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86116 r0 *1 274.4,831.6
X$86116 8220 9758 9538 9901 14073 14074 9649 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $86176 m0 *1 120.4,761.04
X$86176 14074 8220 14073 8340 8295 8339 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86180 r0 *1 78.96,811.44
X$86180 14074 8220 14073 9489 8295 8891 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86184 r0 *1 103.04,801.36
X$86184 14074 8220 14073 9128 8295 9126 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86192 r0 *1 89.04,761.04
X$86192 14074 8220 14073 8589 8295 8336 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86195 m0 *1 80.64,761.04
X$86195 14074 8220 14073 8502 8295 8440 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86197 m0 *1 146.16,831.6
X$86197 14074 8220 14073 9534 8295 9233 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86201 r0 *1 88.48,841.68
X$86201 14074 8220 14073 9748 8295 9747 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86205 r0 *1 80.08,892.08
X$86205 14074 8220 14073 10731 8295 9697 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86207 r0 *1 110.88,892.08
X$86207 14074 8220 14073 10733 8295 9749 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86213 r0 *1 281.12,750.96
X$86213 14074 14073 8417 8353 8221 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86241 r0 *1 459.76,861.84
X$86241 14073 10131 14074 9030 8223 9734 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $86244 m0 *1 449.12,1063.44
X$86244 14074 8223 14073 11794 13125 11795 12950
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $86246 r0 *1 305.2,1023.12
X$86246 14073 14074 12028 8223 12636 12654 12653 12091
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $86299 m0 *1 462.56,851.76
X$86299 14074 8229 9836 14073 9912 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86316 m0 *1 508.48,871.92
X$86316 10280 14074 14073 8229 8618 10359 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $86319 m0 *1 505.68,882
X$86319 14074 14073 8229 10535 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86324 m0 *1 533.68,992.88
X$86324 14074 14073 12122 8231 10134 8229 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86360 m0 *1 475.44,912.24
X$86360 14074 14073 8231 10640 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86371 r0 *1 511.84,761.04
X$86371 14074 14073 8232 8618 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86381 r0 *1 571.2,831.6
X$86381 14074 14073 8234 9731 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86384 m0 *1 619.36,750.96
X$86384 14074 14073 8235 8236 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86386 m0 *1 910,982.8
X$86386 14074 14073 11297 8236 11893 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $86388 r0 *1 908.88,942.48
X$86388 14074 11496 8236 14073 10901 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $86390 m0 *1 725.76,982.8
X$86390 14074 14073 11968 12010 8236 11732 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86392 r0 *1 690.48,982.8
X$86392 14074 14073 12102 12048 8236 11539 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86396 m0 *1 654.64,992.88
X$86396 14074 14073 12185 12184 8236 12011 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86399 r0 *1 887.04,942.48
X$86399 14074 14073 11544 8236 11332 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $86401 m0 *1 874.16,942.48
X$86401 14074 14073 11461 11375 8236 11154 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86404 r0 *1 700,942.48
X$86404 14074 14073 11512 11450 8236 11052 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86406 r0 *1 715.12,942.48
X$86406 14074 14073 11451 11452 8236 11055 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86409 m0 *1 675.92,962.64
X$86409 14074 14073 11608 11661 8236 11449 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86411 m0 *1 662.48,962.64
X$86411 14074 14073 11659 11660 8236 11538 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86413 r0 *1 652.96,952.56
X$86413 14074 14073 11588 11607 8236 11205 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86415 r0 *1 725.76,962.64
X$86415 14074 14073 11778 11731 8236 10943 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86478 m0 *1 832.72,942.48
X$86478 14073 8236 10804 14074 11213 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86486 m0 *1 902.72,932.4
X$86486 14073 9787 8236 14074 11248 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86488 m0 *1 644.56,750.96
X$86488 14074 8237 8331 14073 8238 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86491 r0 *1 636.72,750.96
X$86491 14073 8373 8237 14074 8434 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86496 m0 *1 647.92,761.04
X$86496 14073 8373 8238 14074 8528 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86498 r0 *1 645.12,750.96
X$86498 8374 8376 8238 8433 8373 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $86501 r0 *1 672.56,750.96
X$86501 14073 8379 14074 8427 8474 8239 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $86508 m0 *1 667.52,761.04
X$86508 14074 14073 8239 8378 8379 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86510 m0 *1 663.6,761.04
X$86510 14074 14073 8473 8239 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86519 m0 *1 682.64,761.04
X$86519 8477 8526 8375 8241 8324 14073 14074 gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $86524 r0 *1 680.4,750.96
X$86524 14074 14073 8328 8242 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86532 m0 *1 679.84,750.96
X$86532 14074 14073 8243 8319 8429 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $86543 r0 *1 729.68,902.16
X$86543 14073 9854 10861 8245 11068 10480 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $86568 m0 *1 744.24,902.16
X$86568 14074 10239 14073 10057 10798 10053 8245
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $86570 m0 *1 739.2,861.84
X$86570 14074 14073 10240 10239 9964 8245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86600 r0 *1 873.6,962.64
X$86600 14074 14073 8249 11773 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86603 m0 *1 654.08,972.72
X$86603 14074 11781 14073 11880 11607 9856 8249 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $86649 m0 *1 901.04,750.96
X$86649 14074 8251 8306 14073 8252 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86663 m0 *1 906.08,771.12
X$86663 14074 14073 8253 8661 8254 8251 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86666 m0 *1 898.8,962.64
X$86666 14074 8650 14073 8661 11702 11671 8251 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $86668 m0 *1 902.16,761.04
X$86668 14074 14073 8487 8252 8254 8255 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86673 r0 *1 893.2,902.16
X$86673 14073 9731 10804 14074 8254 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86688 r0 *1 900.48,902.16
X$86688 14074 10809 14073 8254 11011 10803 9786 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $86716 r0 *1 1120,791.28
X$86716 14074 9084 8257 14073 9089 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86730 m0 *1 1032.08,791.28
X$86730 14074 14073 8988 8968 8257 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $86733 r0 *1 1140.16,831.6
X$86733 14074 14073 8257 9587 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86735 r0 *1 1141.84,841.68
X$86735 14074 14073 8257 9874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86737 m0 *1 981.12,750.96
X$86737 14074 8301 8389 8259 8390 8258 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $86743 r0 *1 994,750.96
X$86743 14074 14073 8259 8413 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86745 r0 *1 1004.08,750.96
X$86745 14074 14073 8260 8595 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86748 m0 *1 1036.56,761.04
X$86748 14074 14073 8261 8491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86751 m0 *1 1027.6,750.96
X$86751 14074 8395 8577 8578 8288 8262 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $86755 m0 *1 1044.96,750.96
X$86755 14074 14073 8264 8262 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86763 r0 *1 1079.12,761.04
X$86763 14074 8392 8266 14073 8591 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86765 m0 *1 1080.8,761.04
X$86765 14074 8266 8399 14073 8493 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $86776 m0 *1 1165.36,791.28
X$86776 8268 14073 14074 8884 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86782 m0 *1 1121.68,750.96
X$86782 14074 14073 8407 8269 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86785 m0 *1 1126.16,750.96
X$86785 14074 14073 8401 8270 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86789 r0 *1 1164.8,791.28
X$86789 8271 14073 14074 8976 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86794 m0 *1 1150.8,750.96
X$86794 14074 14073 8280 8272 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86797 m0 *1 1179.92,750.96
X$86797 8402 14073 14074 8273 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86802 m0 *1 1170.4,750.96
X$86802 8405 14073 14074 8275 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86826 r0 *1 1133.44,740.88
X$86826 14074 14073 8282 8281 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86846 r0 *1 427.84,781.2
X$86846 14074 8910 14073 8912 8285 8911 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $86851 r0 *1 1067.36,761.04
X$86851 14074 14073 8286 8801 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $86869 m0 *1 655.2,781.2
X$86869 14074 14073 8752 8290 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86874 r0 *1 674.24,972.72
X$86874 14074 14073 11809 8290 10395 8520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86876 r0 *1 865.2,962.64
X$86876 14074 14073 11703 8290 8602 11773 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $86878 m0 *1 932.4,771.12
X$86878 8290 14073 14074 8585 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $86880 r0 *1 663.04,962.64
X$86880 14074 10581 14073 11729 10482 8290 11781 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $86909 m0 *1 977.76,942.48
X$86909 14074 14073 11576 8294 11244 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $86932 m0 *1 922.32,841.68
X$86932 14074 14073 8294 9577 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $86934 m0 *1 1023.12,851.76
X$86934 14074 14073 8294 9971 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $86936 r0 *1 270.48,882
X$86936 14073 9434 9437 14074 8295 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $86981 m0 *1 134.96,892.08
X$86981 14074 9764 14073 10647 8295 9531 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $87000 r0 *1 1018.64,750.96
X$87000 14074 14073 8298 8393 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87017 r0 *1 982.24,750.96
X$87017 14074 14073 8302 8510 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87067 m0 *1 451.92,761.04
X$87067 14074 14073 8314 8422 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $87092 m0 *1 684.88,750.96
X$87092 14074 8324 14073 8428 8477 8320 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $87097 r0 *1 704.48,750.96
X$87097 14074 14073 8321 8320 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $87107 m0 *1 707.84,761.04
X$87107 14074 14073 8478 8321 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $87110 m0 *1 434,962.64
X$87110 12030 14073 14074 11287 8322 11529 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $87113 m0 *1 427.28,962.64
X$87113 8322 14074 11287 11529 14073 11721 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $87123 r0 *1 428.4,952.56
X$87123 14074 10992 8619 8322 11287 11529 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $87128 r0 *1 526.4,750.96
X$87128 14073 8368 8323 14074 8370 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87133 m0 *1 707.28,781.2
X$87133 14074 8324 8478 8865 8866 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $87136 m0 *1 692.72,761.04
X$87136 14074 8324 8525 14073 8381 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87173 m0 *1 556.08,771.12
X$87173 14074 14073 8330 8641 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87194 m0 *1 561.12,821.52
X$87194 14074 14073 8333 9340 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87202 m0 *1 19.04,761.04
X$87202 8335 14073 14074 8442 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $87214 m0 *1 82.88,771.12
X$87214 14074 14073 8440 8337 8439 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $87218 m0 *1 87.92,761.04
X$87218 14073 8338 8502 14074 8441 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87236 r0 *1 112,952.56
X$87236 14074 11430 14073 11630 11564 10377 8341 11648
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $87261 r0 *1 151.76,761.04
X$87261 14074 14073 8344 8506 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87281 r0 *1 233.52,761.04
X$87281 8546 14073 8545 8347 14074 8351 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $87283 r0 *1 104.16,811.44
X$87283 9234 9316 9317 9427 14074 14073 8347 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $87292 m0 *1 215.04,761.04
X$87292 14074 14073 8450 8348 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87295 m0 *1 218.4,761.04
X$87295 14073 8515 8450 14074 8349 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87300 m0 *1 113.12,811.44
X$87300 14073 9234 9316 14074 8350 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87313 r0 *1 278.32,761.04
X$87313 8354 14074 8603 8549 14073 8605 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $87321 m0 *1 292.32,831.6
X$87321 14074 14073 9650 9539 8355 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87324 m0 *1 297.92,831.6
X$87324 14074 14073 9540 9541 8355 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87365 m0 *1 461.44,1174.32
X$87365 8362 14073 14074 14048 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $87367 r0 *1 801.92,982.8
X$87367 14074 14073 12055 8362 8602 11969 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $87370 m0 *1 746.48,992.88
X$87370 14074 14073 12139 8362 10395 9786 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $87372 r0 *1 758.24,1002.96
X$87372 14074 10581 14073 12298 10482 8362 12224 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $87403 m0 *1 291.2,922.32
X$87403 14074 8363 10935 14073 11157 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87421 r0 *1 446.88,750.96
X$87421 14074 14073 8426 8363 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $87423 r0 *1 589.12,761.04
X$87423 14074 14073 8363 8558 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87428 m0 *1 377.44,882
X$87428 14074 8364 10453 14073 10461 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87460 m0 *1 549.92,761.04
X$87460 14074 14073 8364 8530 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87481 m0 *1 374.64,902.16
X$87481 14074 8365 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* cell instance $87485 r0 *1 374.64,902.16
X$87485 14074 10649 8365 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $87494 r0 *1 432.32,892.08
X$87494 14074 10567 8366 14073 10668 10568 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $87523 r0 *1 419.44,861.84
X$87523 8366 10128 8616 10235 14074 14073 10127 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $87525 m0 *1 407.12,892.08
X$87525 8366 14073 8370 9839 14074 10666 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $87527 m0 *1 400.96,892.08
X$87527 10564 14073 8366 10272 14074 10563 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $87529 m0 *1 428.96,871.92
X$87529 8366 10275 8370 10130 14074 14073 10100 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $87533 m0 *1 509.04,882
X$87533 10387 14074 14073 10535 8366 14094 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $87537 m0 *1 428.96,902.16
X$87537 8366 10464 10668 10568 14074 14073 10886 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $87555 m0 *1 853.44,922.32
X$87555 14073 14074 9731 8369 10055 10160 11402 11121
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $87572 r0 *1 407.68,962.64
X$87572 14074 11777 8370 14073 11285 10381 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $87585 m0 *1 406,952.56
X$87585 14073 8370 10665 8432 11285 10381 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $87587 r0 *1 422.24,952.56
X$87587 8370 14073 10383 11599 14074 11598 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $87590 r0 *1 579.6,761.04
X$87590 8469 14074 14073 8558 8371 14114 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $87596 m0 *1 627.76,761.04
X$87596 14074 8471 8373 8472 8529 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $87611 r0 *1 658,761.04
X$87611 14074 8375 8473 8561 8562 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $87617 r0 *1 677.6,761.04
X$87617 14074 14073 8375 8379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87624 r0 *1 686,750.96
X$87624 14074 8381 8425 14073 8376 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87629 m0 *1 637.28,771.12
X$87629 8377 14074 8476 8528 14073 8461 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $87631 m0 *1 640.08,801.36
X$87631 8377 8476 8528 9303 14073 14074 9153 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $87644 r0 *1 651.84,801.36
X$87644 14073 9154 14074 9219 8476 8377 8528 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $87647 r0 *1 660.24,811.44
X$87647 14074 9413 9412 9454 8476 8377 14073 gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $87649 r0 *1 634.48,771.12
X$87649 14073 8750 14074 8745 8476 8377 8751 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $87653 r0 *1 653.52,771.12
X$87653 8750 14073 8560 8378 14074 8753 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $87673 r0 *1 681.52,791.28
X$87673 14074 14073 8380 9616 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $87682 r0 *1 683.76,761.04
X$87682 14073 8381 8429 14074 8476 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87685 m0 *1 692.16,962.64
X$87685 14074 11730 14073 11662 9731 9856 11641 8382
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $87700 m0 *1 715.68,761.04
X$87700 14073 8478 8383 14074 8525 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $87707 r0 *1 722.96,892.08
X$87707 14073 9854 10586 8386 10863 10691 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $87733 r0 *1 860.16,871.92
X$87733 14074 14073 8386 10400 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87737 m0 *1 866.32,932.4
X$87737 14074 14073 11401 8387 9854 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87759 m0 *1 847.28,861.84
X$87759 14074 14073 9012 10160 9964 8387 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $87766 r0 *1 977.2,750.96
X$87766 14074 14073 8389 8489 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87773 m0 *1 1004.64,761.04
X$87773 14074 8391 8667 8507 8393 8508 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $87775 m0 *1 1056.16,1013.04
X$87775 14074 14073 12467 8392 11244 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87778 r0 *1 1076.32,922.32
X$87778 14074 8392 11222 14073 11223 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87780 r0 *1 1089.2,982.8
X$87780 14074 8392 11216 14073 12068 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87782 m0 *1 1075.76,982.8
X$87782 14074 8392 11305 14073 11905 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87789 m0 *1 1090.88,841.68
X$87789 14074 8392 9796 14073 9687 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87807 m0 *1 1044.96,811.44
X$87807 14074 14073 8392 8986 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87812 m0 *1 1024.8,902.16
X$87812 14074 8394 8960 14073 10732 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $87822 m0 *1 1032.64,912.24
X$87822 14074 14073 10914 8396 8394 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87824 m0 *1 1027.04,922.32
X$87824 14074 8394 11305 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $87829 m0 *1 1048.32,932.4
X$87829 14074 14073 11219 8396 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87832 m0 *1 1039.36,831.6
X$87832 14074 14073 9600 8396 9595 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87850 r0 *1 1024.24,942.48
X$87850 14074 14073 11244 8396 11462 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $87852 r0 *1 1050.56,750.96
X$87852 14074 8410 8492 8409 8398 8397 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $87875 m0 *1 1067.36,791.28
X$87875 14074 14073 8399 8879 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87877 m0 *1 1057.28,1002.96
X$87877 14074 14073 12468 11244 8399 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $87914 r0 *1 1145.2,750.96
X$87914 14074 14073 8501 8406 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87924 r0 *1 1075.2,750.96
X$87924 14074 14073 8409 8592 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $87941 m0 *1 975.52,771.12
X$87941 14074 8666 8665 8873 8413 8510 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $87950 r0 *1 117.6,761.04
X$87950 14074 14073 8539 8415 8540 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $87960 m0 *1 932.96,761.04
X$87960 14074 8416 8573 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $87968 m0 *1 282.24,761.04
X$87968 14074 14073 8418 8454 8519 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $87988 m0 *1 479.36,902.16
X$87988 14073 8852 14074 10134 10855 8422 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $87993 r0 *1 476,882
X$87993 14073 8466 14074 10134 10466 8422 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88016 r0 *1 507.92,771.12
X$88016 14074 14073 8422 8635 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $88046 r0 *1 672.56,761.04
X$88046 14073 8473 8560 14074 8429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88052 m0 *1 689.92,771.12
X$88052 14073 8526 8429 14074 8649 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88056 m0 *1 680.96,771.12
X$88056 14074 14073 8526 8647 8429 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88070 m0 *1 406,962.64
X$88070 14074 11717 8432 14073 11285 10381 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $88085 m0 *1 404.32,882
X$88085 8917 14073 9249 8432 14074 10272 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $88088 r0 *1 427.28,892.08
X$88088 14073 8917 8432 14074 10668 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88092 r0 *1 416.08,952.56
X$88092 8432 14073 10383 11599 14074 11528 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $88097 m0 *1 640.08,761.04
X$88097 14074 14073 8433 8448 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $88101 r0 *1 635.04,761.04
X$88101 14074 8471 8434 14073 8559 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $88125 r0 *1 13.44,761.04
X$88125 8537 14073 14074 8439 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88147 r0 *1 78.96,882
X$88147 14074 9213 11085 8441 8718 14073 10614 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $88157 m0 *1 82.32,952.56
X$88157 14074 11430 14073 11520 11484 10377 8443 11521
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $88172 r0 *1 467.6,781.2
X$88172 14074 8742 14073 8445 8915 8851 8914 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $88181 m0 *1 180.88,982.8
X$88181 14073 11948 14074 11943 11860 11945 8446
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $88202 m0 *1 265.44,972.72
X$88202 14074 11792 14073 11842 8446 11713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $88222 r0 *1 641.76,761.04
X$88222 14074 14073 8752 8461 8448 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $88226 r0 *1 221.76,761.04
X$88226 14074 8452 14073 8453 8450 8545 8544 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $88234 m0 *1 19.04,771.12
X$88234 8623 14073 14074 8451 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88245 m0 *1 2.24,771.12
X$88245 8624 14073 14074 8452 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88271 m0 *1 358.4,902.16
X$88271 14074 10850 14073 11094 9653 8456 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $88294 m0 *1 671.44,992.88
X$88294 14074 14073 11966 8459 10395 8568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88297 m0 *1 453.04,1174.32
X$88297 8459 14073 14074 14051 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88301 r0 *1 662.48,972.72
X$88301 14074 10581 14073 11809 10482 8459 11852 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $88303 r0 *1 864.08,972.72
X$88303 14074 14073 11813 8459 8602 11935 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88331 r0 *1 659.68,791.28
X$88331 14074 8952 8459 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $88334 r0 *1 443.52,771.12
X$88334 14074 14073 8460 8921 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $88361 m0 *1 478.8,912.24
X$88361 14073 8466 14074 10134 10891 8464 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88364 r0 *1 479.36,912.24
X$88364 14073 8852 14074 10134 11172 8464 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88384 m0 *1 501.2,781.2
X$88384 14074 14073 8464 8742 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $88398 m0 *1 471.52,902.16
X$88398 14073 8466 14074 10134 10671 8946 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88400 m0 *1 531.44,1002.96
X$88400 14074 14073 12284 12046 8466 12122 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88402 m0 *1 525.28,992.88
X$88402 14074 14073 11963 12122 8466 12045 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88404 r0 *1 523.6,992.88
X$88404 14074 14073 12217 12045 8466 11962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88406 r0 *1 479.92,992.88
X$88406 14074 14073 12214 11959 8466 12042 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88409 r0 *1 491.12,992.88
X$88409 14074 14073 12215 12121 8466 11961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88411 m0 *1 484.96,992.88
X$88411 14074 14073 11801 12042 8466 12121 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88413 r0 *1 474.32,982.8
X$88413 14074 14073 12041 11960 8466 11723 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88415 r0 *1 479.92,952.56
X$88415 14074 14073 11601 11434 8466 11503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88418 r0 *1 463.12,992.88
X$88418 14074 14073 12213 12040 8466 12120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88422 r0 *1 540.4,962.64
X$88422 14074 14073 11602 11437 8466 11726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88424 m0 *1 529.76,952.56
X$88424 14074 14073 11531 11196 8466 11505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88427 r0 *1 402.08,932.4
X$88427 14074 11285 10663 9659 8466 14073 8616 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $88481 r0 *1 546,841.68
X$88481 9922 14074 14073 9734 8466 9920 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $88486 m0 *1 546,942.48
X$88486 14073 11362 14074 11443 11359 8466 11361
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $88489 r0 *1 533.68,932.4
X$88489 14074 14073 8466 11344 11362 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88491 m0 *1 371.28,922.32
X$88491 14073 8466 9411 14074 10988 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88495 m0 *1 367.36,902.16
X$88495 8466 9411 9659 10663 14074 14073 10379 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $88497 r0 *1 553.28,761.04
X$88497 8467 14074 14073 8530 8620 14111 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $88512 m0 *1 641.2,781.2
X$88512 14074 8471 8528 14073 8751 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $88523 m0 *1 621.6,781.2
X$88523 14074 8854 14073 8860 8471 8748 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $88538 m0 *1 669.76,771.12
X$88538 14074 8559 14073 8646 8474 8560 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $88545 r0 *1 641.76,791.28
X$88545 9063 8749 8475 8753 14074 14073 8862 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $88547 r0 *1 627.2,771.12
X$88547 14074 8645 14073 8833 8753 8475 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $88579 r0 *1 707.84,771.12
X$88579 14074 14073 8478 8526 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $88607 r0 *1 667.52,1013.04
X$88607 14074 14073 12290 9259 10395 8480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88609 m0 *1 646.24,982.8
X$88609 14074 14073 10962 12011 9731 8480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88611 m0 *1 648.48,1002.96
X$88611 14074 14073 12257 12185 11371 8480 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88616 m0 *1 903.28,1033.2
X$88616 14074 14073 8480 12786 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88630 m0 *1 926.24,952.56
X$88630 14074 14073 11581 11578 8484 10589 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88632 r0 *1 927.36,982.8
X$88632 14074 14073 12000 12089 8484 10584 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88634 r0 *1 929.6,972.72
X$88634 14074 14073 11732 11894 8484 10340 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88637 m0 *1 924,982.8
X$88637 14074 14073 11893 11978 8484 10159 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88640 m0 *1 915.6,982.8
X$88640 14074 14073 11539 11999 8484 9963 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88642 r0 *1 920.08,952.56
X$88642 14074 14073 11538 11639 8484 10297 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88645 r0 *1 924,932.4
X$88645 14074 14073 11205 11328 8484 10800 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88648 r0 *1 925.68,942.48
X$88648 14074 14073 11496 11495 8484 10699 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88650 r0 *1 918.96,922.32
X$88650 14073 11247 14074 8484 11122 10486 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88652 r0 *1 920.64,912.24
X$88652 14074 14073 10809 11051 8484 10239 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88655 r0 *1 909.44,912.24
X$88655 14074 14073 11052 11050 8484 9965 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88658 m0 *1 913.92,912.24
X$88658 14073 10588 11012 8484 10938 9731 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $88661 r0 *1 862.4,922.32
X$88661 14074 14073 11055 11123 8484 10302 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88663 m0 *1 856.24,912.24
X$88663 14074 14073 10943 11047 8484 10300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88665 m0 *1 876.96,922.32
X$88665 14074 14073 11154 11044 8484 10160 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88697 r0 *1 887.04,972.72
X$88697 14074 14073 9731 11121 8484 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88699 m0 *1 865.76,922.32
X$88699 14073 10804 8484 14074 9854 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88701 m0 *1 850.08,902.16
X$88701 14074 14073 10804 10053 8484 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88703 r0 *1 852.32,851.76
X$88703 14073 9731 8484 14074 9964 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $88705 m0 *1 939.68,932.4
X$88705 14073 8484 14074 11325 11247 11298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $88707 m0 *1 931.28,922.32
X$88707 14074 14073 8484 10938 11895 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88711 r0 *1 1019.76,841.68
X$88711 14074 14073 8485 9866 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $88728 r0 *1 978.88,942.48
X$88728 14074 14073 11636 11244 8485 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $88733 m0 *1 693.84,952.56
X$88733 14074 14073 11113 11539 9731 8486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88751 m0 *1 697.76,1023.12
X$88751 14074 14073 12448 8740 10395 8486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88754 r0 *1 700,982.8
X$88754 14074 14073 11882 12102 11371 8486 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88761 r0 *1 899.92,1023.12
X$88761 14074 14073 8486 12788 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88769 r0 *1 959.84,761.04
X$88769 14074 8597 8599 8596 8489 8598 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $88776 m0 *1 981.12,761.04
X$88776 14074 8511 8576 8508 8509 8490 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $88779 m0 *1 1032.08,771.12
X$88779 14074 8806 8690 8668 8689 8491 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $88785 r0 *1 1048.32,761.04
X$88785 14074 14073 8492 8669 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $88787 m0 *1 1080.24,771.12
X$88787 14074 8671 8686 8684 8493 8590 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $88792 m0 *1 1102.08,761.04
X$88792 14074 14073 8494 8503 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $88795 r0 *1 1162,781.2
X$88795 8495 14073 14074 8788 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88800 r0 *1 1181.6,761.04
X$88800 8496 14073 14074 8583 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $88837 m0 *1 1015.28,771.12
X$88837 14074 8507 8874 8876 8577 8690 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $88863 m0 *1 959.84,761.04
X$88863 8598 14074 14073 8514 8513 8575 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $88884 m0 *1 247.52,861.84
X$88884 14074 9942 10219 8517 9323 14073 10029 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $88919 m0 *1 650.72,932.4
X$88919 14074 14073 11106 11205 9731 8520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88922 r0 *1 642.88,962.64
X$88922 14074 14073 11783 11588 11371 8520 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $88927 m0 *1 908.88,992.88
X$88927 14074 14073 8520 12142 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $88960 r0 *1 482.16,922.32
X$88960 14074 14073 11171 8527 10134 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $88964 m0 *1 377.44,801.36
X$88964 14074 8527 9213 14073 8848 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $88995 m0 *1 690.48,902.16
X$88995 14074 14073 8527 10757 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89012 m0 *1 652.4,811.44
X$89012 9258 9343 8528 9341 14073 14074 9413 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $89050 m0 *1 107.52,771.12
X$89050 14074 14073 8540 8538 8626 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89060 r0 *1 70,781.2
X$89060 14074 8721 14073 8722 8540 8928 8891 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $89073 r0 *1 133.84,942.48
X$89073 14074 11633 10114 8541 10115 11143 11477 11522 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $89078 m0 *1 160.16,771.12
X$89078 14074 14073 8840 8542 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89092 r0 *1 586.88,771.12
X$89092 14074 8642 14073 8543 8745 8643 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $89094 m0 *1 20.72,781.2
X$89094 8835 14073 14074 8544 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $89103 r0 *1 229.6,771.12
X$89103 14074 14073 8544 8546 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89116 r0 *1 321.44,821.52
X$89116 8545 14073 9434 9437 14074 9507 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89119 r0 *1 271.04,821.52
X$89119 8546 14073 9434 9435 14074 9538 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89127 m0 *1 152.88,1093.68
X$89127 14074 13555 14073 13500 12116 8547 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $89129 r0 *1 290.64,902.16
X$89129 14074 14073 10879 8547 10345 10779 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89131 r0 *1 301.28,932.4
X$89131 14074 14073 11406 8547 11188 10983 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89160 r0 *1 154,1093.68
X$89160 14074 13456 14073 12104 13526 8547 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $89162 m0 *1 406,801.36
X$89162 14074 8942 14073 8547 9054 9053 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $89165 r0 *1 254.8,1093.68
X$89165 14074 11952 14073 13464 13606 12349 8547
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $89167 m0 *1 411.04,1093.68
X$89167 14074 11713 14073 8547 13531 13416 11795
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $89181 m0 *1 332.08,1033.2
X$89181 12349 8551 12656 12732 12731 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $89192 r0 *1 415.52,1023.12
X$89192 14073 8551 12660 12038 12583 12661 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $89195 r0 *1 406.56,972.72
X$89195 14074 14073 11058 8551 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89222 r0 *1 594.16,771.12
X$89222 8642 14073 8643 8745 14074 8556 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89233 r0 *1 511.28,781.2
X$89233 14074 14073 8557 8949 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89247 r0 *1 630,781.2
X$89247 14074 8854 14073 8861 8559 8750 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $89278 m0 *1 658,952.56
X$89278 14074 14073 9254 11538 9731 8568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89299 r0 *1 651.28,962.64
X$89299 14074 14073 11658 11659 11371 8568 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89305 r0 *1 906.08,1002.96
X$89305 14074 14073 8568 12491 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89317 r0 *1 852.32,962.64
X$89317 14074 14073 11738 8571 8762 11739 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89322 r0 *1 868.56,771.12
X$89322 14074 14073 8695 8572 8762 8659 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89345 m0 *1 949.2,771.12
X$89345 14073 8574 8573 14074 8662 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89348 m0 *1 1037.68,791.28
X$89348 14074 14073 8573 8892 8986 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89351 r0 *1 1017.52,831.6
X$89351 14074 14073 8573 9684 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89353 r0 *1 967.68,781.2
X$89353 14073 8872 8573 14074 8899 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89355 m0 *1 1143.52,841.68
X$89355 14074 14073 8573 9589 9874 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89358 r0 *1 1149.68,882
X$89358 14073 8573 10608 14074 10322 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89360 r0 *1 1117.2,831.6
X$89360 14074 14073 8573 9696 9280 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89363 m0 *1 1079.68,791.28
X$89363 14074 14073 8573 8971 9081 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89365 m0 *1 1113.84,831.6
X$89365 14074 14073 8573 9476 9688 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89367 r0 *1 1067.36,781.2
X$89367 14074 14073 8573 8777 8879 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89370 m0 *1 1149.12,902.16
X$89370 14074 14073 8573 11024 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89381 r0 *1 1027.6,861.84
X$89381 14074 14073 8574 10497 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89387 r0 *1 953.68,801.36
X$89387 9174 14074 14073 9268 8575 9176 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $89390 m0 *1 981.12,781.2
X$89390 14074 8576 8896 8812 8814 8768 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89394 r0 *1 1038.8,781.2
X$89394 14074 8890 9078 8970 8578 8877 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89399 m0 *1 1046.08,781.2
X$89399 14074 8669 8877 8982 8579 8878 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89407 r0 *1 1132.32,761.04
X$89407 14074 14073 8581 8674 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89410 m0 *1 1151.92,771.12
X$89410 14074 14073 8582 8676 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89423 m0 *1 47.6,771.12
X$89423 14074 14073 8888 8586 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89430 r0 *1 1104.32,761.04
X$89430 14074 14073 8588 8673 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89442 m0 *1 1079.68,781.2
X$89442 14074 8971 8800 8799 8797 8591 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89445 r0 *1 1070.72,771.12
X$89445 14074 8799 8802 8672 8686 8592 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89451 m0 *1 138.32,771.12
X$89451 14074 14073 8685 8593 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89459 m0 *1 1007.44,781.2
X$89459 14074 8595 8810 8771 8770 8769 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89465 r0 *1 979.44,791.28
X$89465 9075 14074 14073 9100 8596 8996 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $89469 r0 *1 950.32,771.12
X$89469 14074 8662 8817 8597 8766 8664 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $89483 r0 *1 953.68,781.2
X$89483 14074 14073 8599 8961 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89521 r0 *1 865.2,1002.96
X$89521 14074 14073 12416 8738 8602 12300 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89528 r0 *1 771.12,992.88
X$89528 14074 14073 12178 9777 8602 12140 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89570 m0 *1 889.28,821.52
X$89570 14074 14073 9355 8602 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89587 r0 *1 268.24,861.84
X$89587 14074 14073 10458 8606 10222 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89596 r0 *1 311.92,962.64
X$89596 14073 11430 11772 14074 8607 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89622 r0 *1 327.04,851.76
X$89622 14073 8609 10002 14074 10095 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89663 m0 *1 420,871.92
X$89663 10128 10129 8616 10276 14074 14073 10351 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $89665 r0 *1 434,882
X$89665 10464 8616 10276 10384 14074 14073 10629 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $89669 r0 *1 424.48,932.4
X$89669 9659 9444 8616 11191 14074 14073 11287 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $89671 m0 *1 415.52,912.24
X$89671 14074 14073 10889 8617 9842 9615 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89691 m0 *1 442.96,922.32
X$89691 14074 10884 14073 11167 8617 9660 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $89693 r0 *1 371.28,892.08
X$89693 9659 14073 8617 10663 14074 9329 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89695 r0 *1 365.68,902.16
X$89695 8617 14073 10887 10634 14074 9653 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89697 m0 *1 365.12,922.32
X$89697 10886 14073 8617 10887 14074 11093 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89699 r0 *1 380.24,882
X$89699 14074 9940 10560 10128 8618 14073 10559 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $89701 m0 *1 450.8,831.6
X$89701 8618 8619 9549 9662 14073 14074 9332 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $89703 m0 *1 444.08,892.08
X$89703 14074 10635 8618 14073 10568 10560 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $89731 r0 *1 452.48,831.6
X$89731 14074 9437 9662 14073 9549 8618 8619 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $89733 m0 *1 383.6,892.08
X$89733 8618 10128 10560 10559 14074 14073 10561 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $89743 m0 *1 435.12,912.24
X$89743 14073 8618 10568 14074 10959 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89745 r0 *1 406,892.08
X$89745 14073 8618 10128 14074 10664 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89747 m0 *1 427.84,952.56
X$89747 14074 11529 9337 8618 9842 14073 10383 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $89750 m0 *1 420.56,952.56
X$89750 9842 14073 8618 9249 14074 11599 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89754 m0 *1 445.2,962.64
X$89754 8619 14074 11287 11529 14073 11706 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $89776 m0 *1 440.16,912.24
X$89776 14074 14073 10560 8917 8619 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $89802 m0 *1 105.28,811.44
X$89802 14073 9234 14074 9317 8626 9318 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $89809 m0 *1 152.88,781.2
X$89809 14074 14073 8627 8803 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89821 r0 *1 250.32,771.12
X$89821 14074 14073 8730 8631 8692 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89847 r0 *1 520.24,771.12
X$89847 8743 14074 14073 8635 8828 14124 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $89856 r0 *1 361.2,912.24
X$89856 14074 8636 14073 10885 11063 10987 11280
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $89864 r0 *1 389.2,801.36
X$89864 14074 14073 8638 9142 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89871 r0 *1 454.16,781.2
X$89871 14074 14073 8914 8640 8947 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89875 m0 *1 549.36,781.2
X$89875 8853 14074 14073 8741 8641 14095 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $89878 r0 *1 626.08,791.28
X$89878 14073 8858 14074 8860 9062 8642 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $89880 r0 *1 622.16,781.2
X$89880 8916 14073 14074 8857 8642 8861 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $89892 m0 *1 610.96,791.28
X$89892 14073 8642 8857 14074 9023 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89894 r0 *1 610.96,791.28
X$89894 14074 14073 9063 8642 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $89900 m0 *1 594.16,781.2
X$89900 14074 14073 8854 8643 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89902 r0 *1 418.88,811.44
X$89902 14074 8644 9305 14073 9335 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $89905 m0 *1 508.48,992.88
X$89905 14074 14073 12045 8644 10134 9245 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $89935 m0 *1 661.92,912.24
X$89935 14074 14073 8644 10961 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $89941 r0 *1 614.88,781.2
X$89941 14074 8645 8857 14073 8858 8861 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $89947 r0 *1 674.24,791.28
X$89947 8955 14073 8646 9260 14074 9021 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89950 m0 *1 673.68,781.2
X$89950 14074 14073 8646 8826 8754 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89952 m0 *1 683.76,781.2
X$89952 14074 14073 8646 8864 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $89954 m0 *1 678.72,781.2
X$89954 14073 8754 8646 14074 8863 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $89960 r0 *1 673.12,801.36
X$89960 8955 14073 8647 9260 14074 9111 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $89977 r0 *1 700,791.28
X$89977 14074 14073 8649 9017 9154 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $89982 r0 *1 734.16,962.64
X$89982 14074 14073 11664 11778 10804 8650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90001 r0 *1 726.88,912.24
X$90001 14074 14073 9619 10943 9731 8650 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90021 r0 *1 690.48,922.32
X$90021 14074 14073 11108 11052 9731 8654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90040 r0 *1 690.48,942.48
X$90040 14074 14073 11515 11512 11371 8654 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90047 r0 *1 899.92,972.72
X$90047 14074 14073 8654 11891 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90058 m0 *1 853.44,781.2
X$90058 14074 14073 8822 8658 8762 8697 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90060 m0 *1 864.64,801.36
X$90060 14074 9293 9071 9170 8659 9070 9168 8959 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $90070 r0 *1 902.72,781.2
X$90070 14074 8660 8661 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $90072 r0 *1 904.96,1023.12
X$90072 14074 14073 11671 12592 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90076 m0 *1 903.28,1023.12
X$90076 14074 14073 9787 12591 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90079 r0 *1 906.64,952.56
X$90079 14074 14073 8867 11672 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90097 m0 *1 913.36,1033.2
X$90097 14074 14073 9348 12675 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90105 m0 *1 913.36,1023.12
X$90105 14074 14073 11673 12538 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90110 m0 *1 908.32,1023.12
X$90110 14074 14073 8957 12637 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90113 r0 *1 902.72,1013.04
X$90113 14074 14073 10238 12460 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90115 m0 *1 898.24,1023.12
X$90115 14074 14073 9569 12711 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90117 m0 *1 913.36,1013.04
X$90117 14074 14073 9786 12593 8661 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90122 r0 *1 948.64,841.68
X$90122 9862 14074 14073 9861 8663 9897 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $90127 r0 *1 976.64,771.12
X$90127 14074 14073 8665 8897 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90129 m0 *1 959.28,781.2
X$90129 14074 8816 8815 8666 8767 8899 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90133 r0 *1 992.32,771.12
X$90133 14074 8811 8813 8808 8812 8667 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90136 r0 *1 1046.08,771.12
X$90136 14074 14073 8668 8776 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90140 r0 *1 1053.36,771.12
X$90140 14074 8670 8689 8687 8777 8688 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90146 r0 *1 1087.52,781.2
X$90146 14074 14073 8672 8880 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90154 m0 *1 1172.08,781.2
X$90154 8675 14073 14074 8883 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90163 r0 *1 1178.8,781.2
X$90163 8678 14073 14074 8881 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90175 r0 *1 58.8,771.12
X$90175 14074 14073 8720 8681 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90197 r0 *1 1075.2,821.52
X$90197 14074 8684 9705 9484 9586 9475 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90211 m0 *1 1062.88,781.2
X$90211 14074 8687 8890 8778 8800 8801 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90248 m0 *1 320.32,1002.96
X$90248 14074 12332 8696 12205 9730 14073 11430 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90278 m0 *1 263.76,1002.96
X$90278 14074 12274 10431 8696 12205 14073 11430
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90281 m0 *1 256.48,1002.96
X$90281 12205 8696 10431 11430 14074 14073 12267 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $90284 m0 *1 306.32,871.92
X$90284 14074 14073 8696 10120 10269 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90287 m0 *1 378.56,1002.96
X$90287 9730 12033 8696 11430 14074 14073 12280 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $90291 m0 *1 368.48,1002.96
X$90291 14073 12033 8696 14074 12279 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $90293 m0 *1 346.08,1002.96
X$90293 14074 12277 10431 8696 12033 14073 11430
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90295 r0 *1 843.92,791.28
X$90295 14074 9352 9071 8697 9069 9070 8956 8903 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $90376 m0 *1 557.2,882
X$90376 10453 10470 8717 10469 14073 14074 10472 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $90398 r0 *1 244.16,982.8
X$90398 14074 11996 14073 11949 8719 11713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $90401 m0 *1 211.12,992.88
X$90401 14073 14074 12020 12022 12021 8719 12087 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $90416 m0 *1 10.64,781.2
X$90416 8834 14073 14074 8721 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90434 r0 *1 154.56,821.52
X$90434 9430 8723 9534 9533 14074 14073 9602 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $90437 m0 *1 153.44,831.6
X$90437 14074 9331 9534 8723 9430 14073 9533 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90441 r0 *1 171.36,952.56
X$90441 14074 8725 11488 11637 11596 14073 11595
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90452 m0 *1 183.12,942.48
X$90452 14074 14073 11423 8726 10345 11347 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90456 r0 *1 187.6,952.56
X$90456 14074 14073 11638 8726 10371 11523 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90487 m0 *1 370.16,811.44
X$90487 14074 9401 14073 8726 9322 9302 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $90489 m0 *1 201.6,1103.76
X$90489 14074 13267 14073 13570 13558 12349 8726
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90492 r0 *1 113.12,1113.84
X$90492 14074 12115 14073 13679 13680 12116 8726
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90495 r0 *1 78.96,1113.84
X$90495 14074 13561 14073 12104 13678 8726 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90498 m0 *1 355.04,1103.76
X$90498 14074 11795 14073 13520 13654 8726 11794
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90500 m0 *1 201.6,811.44
X$90500 14074 9292 9294 9240 8727 14073 9321 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $90503 r0 *1 203.84,811.44
X$90503 8727 9240 9294 9321 14074 14073 9322 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $90513 m0 *1 244.72,791.28
X$90513 14074 14073 8729 8936 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90518 r0 *1 313.04,781.2
X$90518 14074 14073 8905 8845 8731 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90523 m0 *1 352.8,871.92
X$90523 14074 14073 10123 8732 10345 10270 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90526 r0 *1 330.96,861.84
X$90526 14074 14073 10122 8732 10121 9937 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90531 r0 *1 328.16,952.56
X$90531 14074 14073 11597 8732 11188 10661 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90541 r0 *1 418.88,821.52
X$90541 14074 9515 14073 8732 9617 9445 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $90544 r0 *1 211.12,1144.08
X$90544 14074 12115 14073 13877 13913 12327 8732
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90546 r0 *1 211.12,1154.16
X$90546 14074 12204 14073 12104 14006 8732 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $90556 m0 *1 339.36,851.76
X$90556 8733 14073 9938 9329 14074 10096 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $90566 m0 *1 372.4,791.28
X$90566 14074 14073 8914 8735 9019 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $90591 m0 *1 702.8,1002.96
X$90591 14074 10581 14073 12448 10482 8738 12253 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $90594 r0 *1 470.96,1164.24
X$90594 8738 14073 14074 14019 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90596 m0 *1 715.12,1013.04
X$90596 14074 14073 12296 8738 10395 9348 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90628 m0 *1 679.84,1002.96
X$90628 14074 10581 14073 12447 10482 8740 12255 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $90630 m0 *1 481.04,1174.32
X$90630 8740 14073 14074 14045 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90649 m0 *1 664.72,791.28
X$90649 14074 14073 8953 8740 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $90661 m0 *1 534.24,781.2
X$90661 8744 14074 14073 8742 8831 14102 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $90681 r0 *1 598.64,781.2
X$90681 14074 8854 8748 8747 8855 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $90684 m0 *1 633.36,801.36
X$90684 8748 14073 9063 8857 14074 9151 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $90691 m0 *1 633.36,781.2
X$90691 14074 14073 8748 8750 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $90694 m0 *1 630,781.2
X$90694 14074 14073 8857 8749 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90696 m0 *1 625.52,801.36
X$90696 14073 9116 14074 9224 9149 8749 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $90704 m0 *1 627.76,791.28
X$90704 14074 14073 9022 9023 8858 8749 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90710 r0 *1 649.6,791.28
X$90710 14073 8750 8827 14074 8952 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $90756 m0 *1 832.16,781.2
X$90756 14074 14073 8823 8760 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90758 r0 *1 831.6,781.2
X$90758 14074 14073 9010 8760 8762 8956 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90764 r0 *1 813.68,811.44
X$90764 14074 14073 9350 9399 8762 9265 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90766 m0 *1 856.8,791.28
X$90766 14074 14073 9008 9009 8762 8903 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90768 r0 *1 868,811.44
X$90768 14074 14073 9167 9396 8762 9168 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90770 m0 *1 887.04,791.28
X$90770 14074 14073 8958 9007 8762 8959 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90772 r0 *1 881.44,801.36
X$90772 14074 14073 9169 9203 8762 9170 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90774 m0 *1 799.68,811.44
X$90774 14074 14073 9297 9296 8762 9164 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90776 m0 *1 799.68,801.36
X$90776 14074 14073 9105 9106 8762 9264 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90779 r0 *1 835.52,791.28
X$90779 14074 14073 9067 9068 8762 9069 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90785 r0 *1 868,952.56
X$90785 14074 14073 11613 11460 8762 11670 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90788 m0 *1 856.24,962.64
X$90788 14074 14073 11668 11703 8762 11669 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90790 r0 *1 768.88,962.64
X$90790 14074 14073 11734 11776 8762 11612 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90792 m0 *1 839.44,982.8
X$90792 14074 14073 12006 11846 8762 11889 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90794 r0 *1 843.92,1013.04
X$90794 14074 14073 12537 12299 8762 12456 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90796 r0 *1 852.32,1013.04
X$90796 14074 14073 12378 12455 8762 12457 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90798 r0 *1 881.44,1013.04
X$90798 14074 14073 12560 12416 8762 12459 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90800 m0 *1 870.8,1013.04
X$90800 14074 14073 12379 12380 8762 12458 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90803 m0 *1 818.72,992.88
X$90803 14074 14073 12141 12007 8762 11971 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90805 r0 *1 782.32,982.8
X$90805 14074 14073 12053 12101 8762 11888 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90807 r0 *1 784.56,972.72
X$90807 14074 14073 11885 11937 8762 11886 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90809 r0 *1 780.64,992.88
X$90809 14074 14073 12225 12178 8762 12056 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90811 r0 *1 798,972.72
X$90811 14074 14073 11936 11736 8762 11887 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90813 r0 *1 799.68,992.88
X$90813 14074 14073 12054 12055 8762 12057 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90815 r0 *1 848.96,831.6
X$90815 14074 14073 9789 9720 8762 9574 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90818 r0 *1 833.28,831.6
X$90818 14074 14073 9572 9721 8762 9575 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90820 r0 *1 858.48,821.52
X$90820 14074 14073 9497 9608 8762 9465 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90822 r0 *1 820.4,831.6
X$90822 14074 14073 9722 9462 8762 9573 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90864 r0 *1 856.8,982.8
X$90864 14074 14073 12096 11813 8762 11974 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90866 m0 *1 777.28,1023.12
X$90866 14074 14073 12588 8762 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $90868 m0 *1 816.48,801.36
X$90868 14074 14073 9210 9104 8762 9165 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $90871 m0 *1 924,781.2
X$90871 14074 8818 9004 8900 8763 8870 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90874 m0 *1 940.8,781.2
X$90874 14074 14073 8815 8764 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90878 r0 *1 934.08,781.2
X$90878 14074 8764 8901 8895 8900 8871 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90880 r0 *1 941.36,771.12
X$90880 14074 14073 8817 8765 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90882 m0 *1 932.96,801.36
X$90882 14074 9004 9266 9102 9173 8765 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90891 m0 *1 1007.44,821.52
X$90891 14074 14073 9473 8768 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90893 r0 *1 1009.68,821.52
X$90893 14074 9601 9473 8769 9600 9583 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90899 r0 *1 1022,771.12
X$90899 14074 14073 8772 8770 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90902 r0 *1 1018.08,791.28
X$90902 9099 14074 14073 9097 8771 8991 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $90904 m0 *1 1025.92,781.2
X$90904 14074 8773 8772 8806 8775 8892 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90911 r0 *1 1053.36,992.88
X$90911 14074 11216 8774 14073 12066 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $90916 r0 *1 1066.8,922.32
X$90916 14074 11016 8774 14073 11221 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $90918 m0 *1 1076.32,972.72
X$90918 14074 11222 8774 14073 11836 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $90920 r0 *1 1092,992.88
X$90920 14074 11305 8774 14073 12154 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $90924 r0 *1 1099.84,871.92
X$90924 14074 9796 8774 14073 10317 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $90937 m0 *1 1043.84,791.28
X$90937 14074 8776 8969 9096 8983 8889 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90942 r0 *1 1071.28,801.36
X$90942 14074 9093 9194 9277 9192 8778 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $90947 r0 *1 1126.72,771.12
X$90947 14074 14073 8796 8780 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90952 r0 *1 1144.64,771.12
X$90952 14074 14073 8794 8782 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $90956 m0 *1 1163.68,781.2
X$90956 8783 14073 14074 8882 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90961 m0 *1 1165.92,801.36
X$90961 8784 14073 14074 8977 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90966 m0 *1 1181.6,791.28
X$90966 8785 14073 14074 8975 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90969 m0 *1 1155.28,781.2
X$90969 8792 14073 14074 8786 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $90988 m0 *1 79.52,791.28
X$90988 14073 8793 14074 8984 8985 8930 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $91026 r0 *1 1058.96,791.28
X$91026 14074 8802 9079 9275 8982 9080 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91036 r0 *1 252.56,922.32
X$91036 14074 14073 11185 8805 11157 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91054 r0 *1 259.84,962.64
X$91054 14074 11652 14073 11700 8805 11713 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $91065 r0 *1 1007.44,781.2
X$91065 14074 8966 8965 8875 8808 8874 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91075 m0 *1 1000.72,781.2
X$91075 14074 14073 8810 8811 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91089 m0 *1 981.12,791.28
X$91089 14074 8813 8997 8963 8993 8992 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91094 m0 *1 936.88,791.28
X$91094 14074 9003 8871 8814 9000 9002 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91154 m0 *1 661.92,831.6
X$91154 14073 8827 9815 9564 9260 9618 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $91156 r0 *1 688.8,831.6
X$91156 14073 9812 14074 9669 8827 9564 9671 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $91227 m0 *1 238.56,791.28
X$91227 14074 14073 8842 8935 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91236 m0 *1 292.32,902.16
X$91236 14074 10844 10114 8844 10115 10113 10654 10779 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $91251 r0 *1 304.08,892.08
X$91251 8844 14073 10558 9329 14074 10656 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $91260 m0 *1 324.8,902.16
X$91260 14074 9054 10783 14073 10846 8845 10845 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $91278 r0 *1 462.56,791.28
X$91278 14074 14073 8850 9218 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $91283 r0 *1 470.4,962.64
X$91283 14074 14073 11724 11434 8852 11723 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91288 r0 *1 486.64,902.16
X$91288 14073 8852 14074 10134 10966 8946 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $91290 r0 *1 543.2,992.88
X$91290 14074 14073 12218 12123 8852 11726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91294 r0 *1 532,992.88
X$91294 14074 14073 11877 12046 8852 12123 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91297 r0 *1 515.2,992.88
X$91297 14074 14073 12216 12043 8852 12044 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91300 m0 *1 479.92,952.56
X$91300 14074 14073 11530 11358 8852 11503 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91303 r0 *1 471.52,992.88
X$91303 14074 14073 11802 11959 8852 12120 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91305 m0 *1 542.08,962.64
X$91305 14074 14073 11725 11437 8852 11505 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91346 m0 *1 532,851.76
X$91346 9844 14074 14073 9818 8852 14097 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91351 m0 *1 496.16,932.4
X$91351 11260 14074 14073 8949 8852 11345 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91355 r0 *1 482.72,982.8
X$91355 14074 14073 11800 11960 8852 11961 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91358 r0 *1 520.24,982.8
X$91358 14074 14073 11803 12044 8852 11962 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91360 r0 *1 442.4,962.64
X$91360 14073 8852 9337 14074 11720 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91363 m0 *1 444.08,952.56
X$91363 9249 9411 8852 14074 14073 10431 gf180mcu_fd_sc_mcu9t5v0__and3_4
* cell instance $91375 m0 *1 618.24,801.36
X$91375 14074 9147 14073 9224 8854 9063 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $91385 r0 *1 396.48,932.4
X$91385 14074 8856 11284 14073 11413 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $91415 r0 *1 684.32,912.24
X$91415 11070 14074 14073 8856 9616 11069 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91419 m0 *1 695.52,912.24
X$91419 14074 14073 8856 10955 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91423 m0 *1 616,791.28
X$91423 14074 8950 8857 8859 8951 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $91440 r0 *1 627.76,801.36
X$91440 14074 8950 14073 9150 8857 9062 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $91452 m0 *1 614.32,801.36
X$91452 14074 14073 9147 8858 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91472 r0 *1 689.36,791.28
X$91472 14074 14073 9065 9111 8864 9112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91502 r0 *1 711.76,922.32
X$91502 14074 14073 11110 11055 9731 8867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91506 m0 *1 711.2,942.48
X$91506 14074 14073 11411 11451 11371 8867 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $91533 m0 *1 1038.24,912.24
X$91533 14073 8872 9353 14074 10933 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91536 m0 *1 1028.16,942.48
X$91536 14073 8872 11380 14074 11463 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91539 r0 *1 989.52,781.2
X$91539 8994 14074 14073 8893 8873 8964 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91546 r0 *1 1021.44,801.36
X$91546 14074 14073 8875 9181 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91549 m0 *1 1025.92,801.36
X$91549 14074 8876 9182 9196 9078 9077 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91555 r0 *1 1038.24,821.52
X$91555 14074 9491 8878 9486 9599 9584 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91562 m0 *1 1070.72,791.28
X$91562 14074 14073 8879 9276 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $91567 m0 *1 1091.44,811.44
X$91567 14074 8880 9373 9278 9285 9361 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91594 m0 *1 1103.76,791.28
X$91594 14074 8978 8889 8979 8973 8972 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91603 r0 *1 78.96,791.28
X$91603 14073 8891 9037 14074 8930 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91616 r0 *1 1025.92,781.2
X$91616 8987 14074 14073 8988 8990 8893 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91625 r0 *1 972.72,781.2
X$91625 14074 8896 8962 8993 8895 8897 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91649 r0 *1 937.44,791.28
X$91649 14074 8901 9202 9101 9102 8961 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $91682 r0 *1 342.72,922.32
X$91682 14074 8906 14073 11093 11159 11189 11279
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $91704 r0 *1 550.48,791.28
X$91704 14074 14073 8946 8911 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91707 r0 *1 579.6,791.28
X$91707 9229 14074 14073 8911 9119 14115 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $91759 r0 *1 466.48,801.36
X$91759 14074 9056 14073 9248 9217 9220 8914 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $91763 m0 *1 465.36,801.36
X$91763 14073 8914 9115 14074 9143 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91765 r0 *1 388.64,861.84
X$91765 14074 14073 8914 10125 10273 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91767 m0 *1 372.4,882
X$91767 14074 14073 8914 10460 10380 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91769 m0 *1 455.84,861.84
X$91769 14074 14073 8914 10131 10241 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91772 m0 *1 459.2,871.92
X$91772 14073 8914 10354 14074 10034 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91774 m0 *1 465.36,841.68
X$91774 14074 14073 8914 9772 9817 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91776 r0 *1 447.44,841.68
X$91776 14074 14073 8914 9941 9911 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91778 r0 *1 462.56,922.32
X$91778 14074 11101 14073 11078 11058 11258 8914
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $91781 m0 *1 459.2,922.32
X$91781 14074 14073 8914 10993 11169 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91783 m0 *1 448.56,942.48
X$91783 14074 14073 8914 11356 11415 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91786 m0 *1 453.6,942.48
X$91786 14074 14073 8914 11432 11416 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91790 r0 *1 413.84,811.44
X$91790 14074 14073 8914 9334 9406 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91792 r0 *1 434,791.28
X$91792 14074 14073 8914 9055 8945 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91796 m0 *1 401.52,791.28
X$91796 14073 8914 9052 14074 8942 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91799 r0 *1 397.04,942.48
X$91799 14074 14073 8914 11431 11501 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91801 m0 *1 372.4,932.4
X$91801 14074 14073 8914 11185 11338 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91803 r0 *1 379.12,942.48
X$91803 14074 14073 8914 11426 11429 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $91833 m0 *1 462,912.24
X$91833 14074 14073 8917 9842 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91836 r0 *1 398.16,922.32
X$91836 14073 8917 9615 14074 10784 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91838 m0 *1 404.32,922.32
X$91838 14073 8917 9249 14074 11096 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $91872 r0 *1 496.16,791.28
X$91872 14074 14073 8921 9043 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $91880 m0 *1 579.04,821.52
X$91880 14073 9410 14074 9450 8922 9252 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $91882 r0 *1 4.48,791.28
X$91882 8923 14073 14074 8928 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $91905 r0 *1 40.32,932.4
X$91905 14074 11517 10114 8927 10115 11143 11387 11518 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $91911 r0 *1 62.72,791.28
X$91911 14074 14073 8928 9037 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $91917 r0 *1 67.2,932.4
X$91917 14074 11270 10114 8929 10115 11143 11309 11269 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $91931 r0 *1 59.92,851.76
X$91931 8931 14073 14074 14081 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $92021 r0 *1 364.56,811.44
X$92021 14074 8936 9400 9332 9403 9402 9141 14073 9439
+ gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $92028 r0 *1 360.64,902.16
X$92028 14074 14073 9543 8938 10885 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $92117 m0 *1 287.28,1002.96
X$92117 14073 14074 12207 12356 12355 8941 12250 12028
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $92121 m0 *1 413.28,1002.96
X$92121 14074 11713 14073 8941 12340 12282 12258 12281
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $92177 r0 *1 517.44,851.76
X$92177 9944 14074 14073 9945 8949 14128 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92189 m0 *1 610.96,801.36
X$92189 14074 14073 8950 9116 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92200 m0 *1 670.32,801.36
X$92200 14074 14073 9216 8953 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92213 r0 *1 670.32,851.76
X$92213 8955 14074 9953 9670 14073 9781 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $92215 r0 *1 679.28,821.52
X$92215 14073 9565 14074 9260 9614 8955 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $92226 m0 *1 682.64,821.52
X$92226 14073 8955 9564 14074 9344 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $92228 m0 *1 687.68,821.52
X$92228 14074 14073 9155 8955 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92234 r0 *1 672,821.52
X$92234 14074 14073 8955 9456 9565 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $92257 r0 *1 673.12,952.56
X$92257 14074 14073 11587 11608 11371 8957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $92259 m0 *1 678.16,942.48
X$92259 14074 14073 11293 11449 9731 8957 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $92292 m0 *1 922.32,851.76
X$92292 14074 14073 8960 9790 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $92300 r0 *1 959.84,791.28
X$92300 14074 9101 9073 9074 8962 8998 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $92304 r0 *1 994.56,791.28
X$92304 14074 14073 8963 9076 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92307 m0 *1 999.6,791.28
X$92307 14074 14073 8964 8992 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92310 r0 *1 1004.64,791.28
X$92310 14074 14073 8965 9180 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92312 m0 *1 1011.92,791.28
X$92312 14074 14073 8991 8966 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92321 r0 *1 1008,791.28
X$92321 14074 14073 9100 8968 8967 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $92324 m0 *1 1104.32,801.36
X$92324 14074 8968 9185 14073 9083 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $92329 r0 *1 1146.32,811.44
X$92329 14074 14073 9283 8968 9274 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $92344 r0 *1 1148.56,801.36
X$92344 14074 14073 8968 9281 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $92350 r0 *1 1037.12,791.28
X$92350 14074 14073 8969 9077 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92352 m0 *1 1052.24,801.36
X$92352 14074 8970 9183 9273 9079 9194 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $92360 m0 *1 1120.56,791.28
X$92360 14074 14073 8974 8973 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92362 m0 *1 1123.36,801.36
X$92362 14074 9188 8974 9187 9085 9088 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $92374 r0 *1 1116.08,781.2
X$92374 14074 14073 9091 8978 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92379 r0 *1 1099.84,791.28
X$92379 14074 14073 8979 9093 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92381 m0 *1 47.04,952.56
X$92381 14074 14073 11561 8980 10345 11518 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $92387 r0 *1 92.4,962.64
X$92387 14074 14073 11710 8980 10371 11647 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $92402 m0 *1 118.16,801.36
X$92402 14074 9109 14073 8980 9195 9043 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $92404 r0 *1 47.04,1002.96
X$92404 14074 12341 14073 12104 12318 8980 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $92406 r0 *1 107.52,1002.96
X$92406 14074 12115 14073 12323 12345 12327 8980
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $92410 m0 *1 1100.4,791.28
X$92410 14074 14073 9082 8981 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92412 r0 *1 1043.84,791.28
X$92412 8983 14074 14073 8987 8981 9097 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92427 m0 *1 84.56,811.44
X$92427 14074 9490 14073 9286 8984 9315 9233 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $92437 m0 *1 1046.64,972.72
X$92437 14074 14073 8986 11824 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $92466 m0 *1 981.12,801.36
X$92466 14074 8994 9179 9198 9076 9180 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $92476 m0 *1 972.72,791.28
X$92476 14074 14073 8996 8998 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92481 m0 *1 976.08,791.28
X$92481 14074 14073 8997 8999 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92489 r0 *1 969.92,801.36
X$92489 14074 8999 9177 9271 9178 9075 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $92576 r0 *1 679.28,801.36
X$92576 14074 9020 9018 9216 9215 14073 gf180mcu_fd_sc_mcu9t5v0__nand3_4
* cell instance $92601 m0 *1 509.6,791.28
X$92601 9060 14074 14073 9043 9024 14105 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92626 r0 *1 476,861.84
X$92626 14074 9734 9030 14073 10353 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $92630 r0 *1 333.76,932.4
X$92630 14073 11425 9030 11355 11335 10095 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $92646 m0 *1 560,831.6
X$92646 14074 9339 14073 9031 9559 9776 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $92658 r0 *1 10.08,801.36
X$92658 9033 14073 14074 9232 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $92661 r0 *1 26.88,801.36
X$92661 9034 14073 14074 9186 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $92700 m0 *1 108.08,801.36
X$92700 14074 9041 9128 9094 9127 14073 9129 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $92738 m0 *1 248.64,801.36
X$92738 14074 14073 9045 9133 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92742 m0 *1 272.16,801.36
X$92742 9207 14074 9046 9208 14073 9209 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $92759 m0 *1 347.76,821.52
X$92759 9048 14073 9435 9329 14074 9438 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $92781 r0 *1 385.28,801.36
X$92781 14074 14073 9051 9141 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92786 r0 *1 408.24,791.28
X$92786 14073 9053 9054 14074 9113 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $92789 m0 *1 576.24,942.48
X$92789 14074 14073 11367 9053 11362 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $92792 m0 *1 582.4,942.48
X$92792 14074 9053 11362 14073 11442 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $92817 r0 *1 528.64,932.4
X$92817 14074 14073 9053 11360 10134 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $92837 m0 *1 488.88,801.36
X$92837 9058 14074 14073 9056 9057 14108 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92856 r0 *1 616,801.36
X$92856 14074 9147 9063 9148 9253 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $92868 r0 *1 644.56,801.36
X$92868 9152 14073 9219 9153 14074 9064 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $92878 r0 *1 693.28,801.36
X$92878 14074 14073 9215 9262 9065 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $92897 r0 *1 852.32,1033.2
X$92897 14074 14073 12856 12743 9070 11372 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $92899 r0 *1 825.44,1053.36
X$92899 12823 14074 13071 9070 14073 12958 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $92924 r0 *1 862.4,1013.04
X$92924 14074 12098 9071 12459 12456 9070 12457 12458 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92926 m0 *1 820.4,982.8
X$92926 14074 11972 9071 11889 11888 9070 11887 11971 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92928 r0 *1 815.36,982.8
X$92928 14074 12005 9071 11612 12056 9070 11886 12057 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92930 m0 *1 857.92,982.8
X$92930 14074 11973 9071 11670 11669 9070 11739 11974 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92934 m0 *1 812.56,811.44
X$92934 14074 9351 9071 9265 9164 9070 9165 9264 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92936 m0 *1 841.68,831.6
X$92936 14074 9463 9071 9465 9573 9070 9574 9575 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $92938 r0 *1 820.4,1053.36
X$92938 14074 14073 9070 12956 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92941 r0 *1 810.88,1053.36
X$92941 12294 14074 14073 9070 13071 14126 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92943 m0 *1 809.2,1053.36
X$92943 12136 14074 14073 9070 12957 14101 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92945 m0 *1 818.72,1053.36
X$92945 12138 14074 14073 12956 12957 9071 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $92973 r0 *1 844.48,1063.44
X$92973 14074 14073 9071 13130 11704 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $92978 m0 *1 958.16,801.36
X$92978 14074 14073 9073 9175 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92981 m0 *1 977.76,801.36
X$92981 14074 14073 9074 9178 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $92996 r0 *1 1056.16,831.6
X$92996 14074 9706 9080 9702 9486 9795 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93002 m0 *1 1077.44,801.36
X$93002 14074 14073 9081 9184 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $93004 r0 *1 1103.2,791.28
X$93004 14074 9083 9082 9091 9089 9092 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93010 m0 *1 1117.76,801.36
X$93010 14074 9084 9185 14073 9188 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $93013 r0 *1 1151.92,811.44
X$93013 14074 14073 9284 9084 9367 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $93056 r0 *1 110.32,801.36
X$93056 9127 9094 9128 9129 14074 14073 9195 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $93066 r0 *1 1053.36,791.28
X$93066 14074 14073 9096 9098 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93072 r0 *1 1037.12,801.36
X$93072 14074 9098 9197 9272 9196 9183 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93077 m0 *1 1006.88,811.44
X$93077 14074 9099 9382 9380 9181 9287 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93136 m0 *1 694.96,801.36
X$93136 14073 9155 9154 14074 9112 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93185 r0 *1 31.92,811.44
X$93185 9124 14073 14074 9526 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $93191 m0 *1 79.52,811.44
X$93191 14074 14073 9126 9286 9125 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $93193 m0 *1 64.96,811.44
X$93193 14074 14073 9232 9125 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $93201 m0 *1 94.08,811.44
X$93201 14074 9186 14073 9233 9234 9232 9126 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $93216 m0 *1 91.28,962.64
X$93216 14074 11430 14073 11646 11626 10377 9129 11647
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $93259 r0 *1 260.4,851.76
X$93259 14074 14073 9132 14157 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $93286 r0 *1 250.32,811.44
X$93286 9133 14073 9324 9325 14074 9205 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $93297 r0 *1 270.48,811.44
X$93297 14073 9325 9395 14074 9136 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93299 r0 *1 276.08,811.44
X$93299 14074 9136 9327 14073 9326 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $93313 m0 *1 274.96,831.6
X$93313 14073 9326 14074 9137 9715 9648 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $93315 r0 *1 291.2,811.44
X$93315 14073 9137 9327 14074 9328 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93325 r0 *1 246.96,811.44
X$93325 14074 14073 9137 9324 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93374 r0 *1 640.08,811.44
X$93374 14074 9258 14073 9260 9149 9342 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $93380 r0 *1 636.16,801.36
X$93380 14074 14073 9150 9257 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $93382 m0 *1 633.36,811.44
X$93382 14074 14073 9341 9256 9150 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $93389 r0 *1 647.36,811.44
X$93389 14073 9151 9342 9154 14074 gf180mcu_fd_sc_mcu9t5v0__and2_4
* cell instance $93391 r0 *1 641.76,821.52
X$93391 14074 14073 9511 9342 9151 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $93394 r0 *1 647.36,821.52
X$93394 14074 14073 9342 9564 9151 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $93397 m0 *1 638.96,811.44
X$93397 14074 9341 14073 9152 9511 9257 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $93413 m0 *1 674.8,811.44
X$93413 14074 9261 14073 9508 9301 9154 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $93418 m0 *1 647.36,821.52
X$93418 9258 9343 9341 9154 14073 14074 9509 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $93420 m0 *1 691.04,831.6
X$93420 14074 9671 9670 9455 9155 14073 9783 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $93422 m0 *1 692.16,811.44
X$93422 9343 14074 14073 9300 9214 9155 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93430 m0 *1 683.2,811.44
X$93430 14074 14073 9262 9344 9260 9155 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $93505 r0 *1 942.48,801.36
X$93505 14074 14073 9202 9172 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93507 m0 *1 943.04,811.44
X$93507 14074 9172 9267 9269 9288 9174 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93510 m0 *1 929.6,831.6
X$93510 14074 9467 9607 9173 9605 9711 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93515 r0 *1 957.6,811.44
X$93515 9387 14074 14073 9269 9175 9386 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93519 r0 *1 950.88,811.44
X$93519 14074 14073 9176 9468 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93525 r0 *1 962.64,821.52
X$93525 9603 14074 14073 9177 9387 9581 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93532 r0 *1 979.44,811.44
X$93532 9384 14074 14073 9271 9179 9385 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93541 r0 *1 1024.8,801.36
X$93541 14074 14073 9182 9287 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93547 m0 *1 1079.68,992.88
X$93547 14074 14073 11132 12153 9184 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $93550 m0 *1 1078.56,1002.96
X$93550 14073 11380 9184 14074 12229 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93558 m0 *1 1133.44,882
X$93558 14074 9798 9185 14073 10499 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $93568 r0 *1 1122.24,892.08
X$93568 14074 14073 9185 10711 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $93574 r0 *1 92.96,811.44
X$93574 14074 14073 9186 9315 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $93576 r0 *1 1098.72,801.36
X$93576 14074 9360 9192 9190 9187 9279 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $93588 r0 *1 1088.08,801.36
X$93588 9375 14074 14073 9193 9189 9372 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93591 m0 *1 1108.24,811.44
X$93591 14074 14073 9190 9285 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93617 r0 *1 1028.16,801.36
X$93617 14074 14073 9197 9379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93623 r0 *1 989.52,811.44
X$93623 9358 14074 14073 9198 9382 9381 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $93631 r0 *1 168,801.36
X$93631 14074 14073 9201 9237 9200 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $93650 r0 *1 258.16,801.36
X$93650 14074 9205 14073 9295 9394 9206 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $93734 r0 *1 475.44,821.52
X$93734 14074 14073 9218 9552 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93786 m0 *1 15.68,821.52
X$93786 9231 14073 14074 9420 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $93820 m0 *1 171.36,912.24
X$93820 9237 9708 11181 11043 14073 14074 10935 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $93839 m0 *1 182.56,882
X$93839 14074 9239 14073 10260 10454 10114 10190
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $93890 m0 *1 488.32,821.52
X$93890 14074 14073 9245 9445 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $93903 m0 *1 400.96,821.52
X$93903 9247 14074 9332 9440 14073 9395 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $93931 m0 *1 423.36,882
X$93931 14073 9842 9249 14074 10382 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93933 r0 *1 394.24,831.6
X$93933 14073 9249 14074 9537 9550 9660 9444 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $93936 m0 *1 409.92,841.68
X$93936 14073 9336 10033 9659 9444 9249 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $93985 r0 *1 389.2,932.4
X$93985 14074 14073 10564 11283 9249 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $93987 m0 *1 392,932.4
X$93987 14073 9249 14074 9550 10378 9660 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $93989 m0 *1 400.96,952.56
X$93989 14073 9249 9444 14074 11527 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $93994 r0 *1 482.16,821.52
X$93994 14073 9553 9621 14074 9250 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94006 m0 *1 535.92,811.44
X$94006 9308 14074 14073 9251 9309 14103 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94037 r0 *1 636.72,811.44
X$94037 14074 14073 9342 9256 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94039 m0 *1 646.24,811.44
X$94039 14074 14073 9256 9303 9257 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94058 r0 *1 670.88,1002.96
X$94058 14074 10581 14073 12292 10482 9259 12331 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $94061 r0 *1 480.48,1174.32
X$94061 9259 14073 14074 14042 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94084 r0 *1 818.16,1002.96
X$94084 14074 14073 9259 12420 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94101 m0 *1 670.88,811.44
X$94101 14074 14073 9260 9261 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94128 m0 *1 932.96,821.52
X$94128 14074 9266 9606 9357 9469 9468 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94133 r0 *1 945.28,861.84
X$94133 10213 14074 14073 9267 10212 10305 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94136 r0 *1 954.24,811.44
X$94136 14074 14073 9390 9268 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94147 m0 *1 960.4,821.52
X$94147 14074 14073 9270 9470 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94154 r0 *1 1050,841.68
X$94154 14074 14073 9272 9887 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94158 m0 *1 1052.8,831.6
X$94158 14074 9597 9685 9886 9273 9585 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94166 r0 *1 1152.48,831.6
X$94166 14074 14073 9274 9692 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94171 m0 *1 1069.6,831.6
X$94171 14074 9275 9585 9701 9596 9703 14073 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $94174 r0 *1 1075.76,982.8
X$94174 14074 14073 11132 11906 9276 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94177 m0 *1 1073.52,1002.96
X$94177 14073 11380 9276 14074 12322 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94179 m0 *1 1083.6,811.44
X$94179 14074 14073 9277 9374 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94183 m0 *1 1098.16,851.76
X$94183 9974 14074 14073 9878 9278 9881 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94186 m0 *1 1110.48,821.52
X$94186 14074 9362 9279 9483 9477 9476 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94192 m0 *1 1115.52,851.76
X$94192 14074 14073 9280 10075 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94198 r0 *1 1152.48,871.92
X$94198 14074 14073 9281 10501 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94201 m0 *1 1141.28,811.44
X$94201 14074 9284 9365 9368 9282 9283 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94229 r0 *1 950.32,801.36
X$94229 14074 14073 9357 9288 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94248 m0 *1 837.2,821.52
X$94248 14074 9464 9788 9293 9351 9499 9463 9352 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $94291 r0 *1 532,811.44
X$94291 9522 14074 14073 9302 9414 14121 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94303 r0 *1 83.44,851.76
X$94303 14074 9305 10544 9827 10084 14073 10024 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $94327 r0 *1 6.16,821.52
X$94327 9310 14073 14074 9530 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94330 r0 *1 5.04,831.6
X$94330 9311 14073 14074 9639 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94333 m0 *1 3.36,821.52
X$94333 9312 14073 14074 9637 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $94349 r0 *1 101.92,821.52
X$94349 14074 9530 14073 9425 9316 9426 9531 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $94356 r0 *1 112,811.44
X$94356 14074 14073 9316 9318 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94361 r0 *1 75.04,831.6
X$94361 14074 9637 14073 9747 9317 9639 9697 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $94372 r0 *1 167.44,821.52
X$94372 14074 9319 14073 9532 9602 9552 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $94383 m0 *1 188.72,952.56
X$94383 14074 11430 14073 11766 11490 10377 9321 11523
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $94414 m0 *1 291.2,821.52
X$94414 14073 9326 14074 9328 9503 9436 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $94447 m0 *1 300.72,882
X$94447 14073 9938 9329 14074 10115 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94483 m0 *1 407.68,821.52
X$94483 14073 9334 9335 14074 9514 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94492 m0 *1 421.68,841.68
X$94492 14074 9813 9770 14073 9771 9659 9336 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $94495 m0 *1 393.12,851.76
X$94495 9660 14074 9336 9547 14073 10009 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $94499 m0 *1 393.12,831.6
X$94499 9659 14074 9336 9547 14073 9400 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $94525 m0 *1 436.24,902.16
X$94525 9337 10668 10383 10632 14074 14073 10669 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $94530 m0 *1 421.12,902.16
X$94530 14073 10634 14074 10787 10566 9338 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $94532 m0 *1 433.44,892.08
X$94532 14073 9338 14074 10669 10667 10629 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $94535 r0 *1 342.16,902.16
X$94535 14073 9338 10884 14074 10948 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94552 m0 *1 434.56,932.4
X$94552 14073 9338 11255 14074 11288 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94556 m0 *1 362.88,912.24
X$94556 9338 14073 10634 10884 14074 10987 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $94558 m0 *1 352.8,932.4
X$94558 9338 14073 10886 11190 14074 11189 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $94564 r0 *1 561.12,821.52
X$94564 9560 14074 14073 9553 9340 14127 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94590 m0 *1 674.24,831.6
X$94590 9618 14073 14074 9343 9733 9458 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $94600 r0 *1 668.64,821.52
X$94600 14074 14073 9343 9565 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94604 r0 *1 677.04,841.68
X$94604 14074 9458 14073 9782 9343 9455 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $94610 m0 *1 700.56,821.52
X$94610 9458 14074 14073 9506 9345 9455 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94653 m0 *1 907.2,912.24
X$94653 14074 14073 9348 10939 10803 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94678 m0 *1 799.68,922.32
X$94678 14074 14073 9349 11160 10575 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94680 r0 *1 784,922.32
X$94680 14073 14074 11161 11208 10579 9349 11209 10575
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $94683 r0 *1 860.16,811.44
X$94683 14074 14073 9354 9349 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94702 m0 *1 1042.72,892.08
X$94702 14074 14073 10497 10602 9353 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94704 m0 *1 1028.72,882
X$94704 14074 14073 9353 10517 9866 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94706 m0 *1 1043.28,851.76
X$94706 14074 14073 9971 9868 9353 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $94708 r0 *1 1046.08,912.24
X$94708 14074 9353 11132 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $94716 r0 *1 888.72,811.44
X$94716 14074 14073 9354 9355 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $94733 m0 *1 986.16,831.6
X$94733 14074 9682 9582 9358 9493 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $94735 m0 *1 1050,821.52
X$94735 14074 9488 9474 9485 9359 9377 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94738 r0 *1 1099.84,811.44
X$94738 14074 14073 9372 9360 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94742 m0 *1 1100.4,821.52
X$94742 14074 14073 9371 9361 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94746 r0 *1 1118.32,811.44
X$94746 14074 9483 9371 9364 9363 9369 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94748 r0 *1 1132.32,821.52
X$94748 14074 9478 9363 9482 9589 9588 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94752 r0 *1 1132.32,841.68
X$94752 14074 14073 9364 9880 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94756 r0 *1 1135.12,811.44
X$94756 14074 14073 9365 9369 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94758 r0 *1 1150.24,821.52
X$94758 14074 9479 9590 9480 9366 9481 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94763 r0 *1 1167.6,871.92
X$94763 14074 14073 10321 10077 9367 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $94769 m0 *1 1153.6,932.4
X$94769 14074 9367 11228 14073 gf180mcu_fd_sc_mcu9t5v0__buf_8
* cell instance $94771 m0 *1 1151.36,922.32
X$94771 14074 14073 9367 11136 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94776 m0 *1 1147.44,851.76
X$94776 9975 14074 14073 9978 9368 9878 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94797 r0 *1 1086.4,811.44
X$94797 14074 14073 9373 9596 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94802 r0 *1 1072.96,811.44
X$94802 9487 14074 14073 9375 9374 9376 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94811 r0 *1 1061.76,821.52
X$94811 14074 14073 9376 9597 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $94820 m0 *1 105.28,821.52
X$94820 14074 14073 9426 9378 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $94822 r0 *1 110.88,821.52
X$94822 14073 9531 9378 14074 9494 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94826 r0 *1 1017.52,811.44
X$94826 10085 14074 14073 9380 9379 9493 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94831 m0 *1 986.16,821.52
X$94831 14074 9471 9472 9384 9381 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $94846 r0 *1 148.4,902.16
X$94846 14074 10772 10114 9383 10115 10113 10828 10976 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $94856 r0 *1 966.56,831.6
X$94856 9794 14074 14073 9603 9385 9677 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94861 r0 *1 954.8,861.84
X$94861 10211 14074 14073 10213 9386 10168 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $94875 r0 *1 934.08,811.44
X$94875 14074 9393 9495 9390 9389 9392 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $94883 r0 *1 206.08,861.84
X$94883 14073 10216 10217 14074 9391 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $94937 r0 *1 395.92,841.68
X$94937 14073 9835 14074 9402 9838 9837 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $94947 r0 *1 364,851.76
X$94947 14074 10032 9939 9403 9940 9837 10081 14073 10004
+ gf180mcu_fd_sc_mcu9t5v0__oai33_2
* cell instance $94950 r0 *1 404.32,831.6
X$94950 9660 14074 9547 9661 14073 9403 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $94990 r0 *1 592.48,871.92
X$94990 10390 10139 10441 10365 9408 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $95015 m0 *1 354.48,992.88
X$95015 12032 14073 9411 11720 14074 12175 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95042 m0 *1 366.8,992.88
X$95042 12275 14073 9411 11720 14074 11957 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95044 m0 *1 418.32,972.72
X$95044 14073 9411 11720 14074 11190 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95047 m0 *1 361.2,982.8
X$95047 11871 14073 9411 11720 14074 11932 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95049 m0 *1 355.04,982.8
X$95049 11869 14073 9411 11720 14074 11870 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95052 m0 *1 655.2,821.52
X$95052 14073 9509 9456 14074 9412 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95065 m0 *1 572.88,841.68
X$95065 14074 14073 10867 9816 9415 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95083 m0 *1 33.04,821.52
X$95083 9419 14073 14074 9426 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $95089 m0 *1 103.6,831.6
X$95089 14074 9526 14073 9641 9427 9420 9749 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95106 m0 *1 41.44,912.24
X$95106 14074 14073 11032 9423 10371 10975 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95109 r0 *1 31.92,892.08
X$95109 14074 14073 10718 9423 10345 10541 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95111 m0 *1 367.36,882
X$95111 14073 10460 10461 14074 9423 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95129 r0 *1 38.08,1013.04
X$95129 14074 12505 14073 12104 12503 9423 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95131 r0 *1 181.44,1002.96
X$95131 14074 11952 14073 12490 12406 12349 9423
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95133 m0 *1 109.2,1002.96
X$95133 14074 12115 14073 12237 12239 12116 9423
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95138 m0 *1 72.24,882
X$95138 14074 10453 10449 9424 9528 14073 10508 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $95150 r0 *1 95.76,821.52
X$95150 14074 14073 9425 9598 9492 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95197 r0 *1 162.96,871.92
X$95197 14074 10649 9428 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $95248 r0 *1 257.6,922.32
X$95248 14073 11185 11157 14074 9433 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95250 r0 *1 150.08,912.24
X$95250 14074 14073 11041 9433 10345 10976 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95252 m0 *1 148.96,922.32
X$95252 14074 14073 11087 9433 10371 11088 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95271 m0 *1 224.56,1013.04
X$95271 14074 14073 9433 12351 12349 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95274 m0 *1 146.72,1033.2
X$95274 14074 12506 14073 12104 12699 9433 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95276 r0 *1 141.12,1013.04
X$95276 14074 12115 14073 12486 12559 12327 9433
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95278 r0 *1 399.84,892.08
X$95278 9660 14073 9615 10663 14074 9434 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95281 r0 *1 384.72,892.08
X$95281 14074 10754 10560 10664 9434 14073 10559
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $95294 r0 *1 392.56,882
X$95294 14074 10439 14073 10463 10626 10561 9434
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95296 m0 *1 300.72,892.08
X$95296 14073 9434 10561 14074 10557 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95301 r0 *1 377.44,892.08
X$95301 9434 10664 10560 10559 14074 14073 10659 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $95303 m0 *1 412.16,871.92
X$95303 9435 14074 10274 10351 14073 10349 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95305 r0 *1 405.44,861.84
X$95305 14073 9838 14074 10350 10274 9435 10127 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $95323 r0 *1 269.92,841.68
X$95323 9833 14073 9435 9537 14074 9901 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95329 r0 *1 352.8,831.6
X$95329 9654 14073 9435 9537 14074 9655 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95348 m0 *1 334.32,831.6
X$95348 9436 14073 9537 9437 14074 9611 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95351 r0 *1 276.08,841.68
X$95351 9648 14073 9537 9437 14074 9758 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95371 r0 *1 360.64,821.52
X$95371 9439 14074 9611 9438 14073 9544 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95385 r0 *1 426.16,821.52
X$95385 14074 14073 9441 9543 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $95387 m0 *1 423.36,972.72
X$95387 14074 11853 11190 9441 10992 14073 11288
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $95390 m0 *1 432.32,972.72
X$95390 10992 10884 9441 11288 14074 14073 11934 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $95396 m0 *1 431.2,882
X$95396 14074 9443 9841 10465 10385 10531 10567 10635 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai33_4
* cell instance $95398 m0 *1 400.96,851.76
X$95398 9659 14074 9444 9547 14073 9837 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95411 r0 *1 431.2,841.68
X$95411 9659 14074 9444 9771 14073 9841 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95419 m0 *1 500.08,821.52
X$95419 9624 14074 14073 9523 9445 9446 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $95456 m0 *1 667.52,882
X$95456 14074 9454 10533 14073 10291 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $95458 m0 *1 677.04,871.92
X$95458 14073 10048 14074 9454 10363 10151 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $95460 m0 *1 679.84,882
X$95460 14074 10151 9454 14073 10534 gf180mcu_fd_sc_mcu9t5v0__or2_4
* cell instance $95472 r0 *1 685.44,861.84
X$95472 9953 14074 9454 10152 14073 10244 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95474 m0 *1 673.12,882
X$95474 9953 14073 9454 10048 14074 10289 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95479 m0 *1 664.72,851.76
X$95479 14073 9454 9951 14074 9952 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95481 m0 *1 682.08,851.76
X$95481 14073 9954 14074 9956 9733 9953 9454 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $95483 m0 *1 673.12,861.84
X$95483 14074 14073 9951 9455 10048 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $95486 r0 *1 687.12,821.52
X$95486 14074 9458 14073 9784 9614 9455 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $95488 m0 *1 688.8,861.84
X$95488 14074 10151 9783 9670 9455 14073 9850 gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $95506 r0 *1 679.84,861.84
X$95506 14074 14073 9455 10533 10152 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95508 m0 *1 677.04,821.52
X$95508 14073 9455 9456 14074 9457 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95512 r0 *1 683.2,851.76
X$95512 14074 14073 9455 9953 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $95524 m0 *1 682.08,831.6
X$95524 14074 9458 9457 14073 9668 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $95537 r0 *1 689.92,851.76
X$95537 14074 9851 14073 9954 9458 9670 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $95547 r0 *1 704.48,831.6
X$95547 9851 14074 14073 9809 9460 9670 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $95567 r0 *1 836.64,972.72
X$95567 14074 14073 11705 9464 12099 11812 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95589 r0 *1 927.36,821.52
X$95589 14074 9607 9578 9469 9579 9495 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $95604 r0 *1 983.36,831.6
X$95604 14074 14073 9471 9679 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $95606 r0 *1 990.08,821.52
X$95606 14074 9582 9865 9471 9472 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $95610 r0 *1 996.24,831.6
X$95610 14074 14073 9472 9681 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $95615 r0 *1 1051.12,831.6
X$95615 14074 14073 9474 9706 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $95617 m0 *1 1074.08,821.52
X$95617 14074 14073 9485 9475 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $95633 m0 *1 1159.2,861.84
X$95633 10195 14074 14073 10079 9480 10191 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $95639 m0 *1 1124.48,831.6
X$95639 14074 9592 9689 9690 9482 9694 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $95651 r0 *1 1107.12,831.6
X$95651 14074 14073 9484 9871 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $95662 r0 *1 1051.12,851.76
X$95662 14074 9487 10072 10203 10083 9972 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $95674 r0 *1 87.92,821.52
X$95674 14073 9598 14074 9529 9490 9494 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $95686 m0 *1 95.76,831.6
X$95686 14074 14073 9530 9492 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $95711 r0 *1 832.72,1043.28
X$95711 14073 12823 12893 14074 9499 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $95713 m0 *1 837.76,1053.36
X$95713 14074 14073 11704 13035 9499 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95719 r0 *1 836.64,982.8
X$95719 14074 11812 9788 12005 11973 9499 11972 12098 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $95742 m0 *1 307.44,821.52
X$95742 14074 14073 9504 9505 9503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $95760 r0 *1 347.2,821.52
X$95760 9510 14074 9507 9610 14073 10006 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $95767 m0 *1 669.2,841.68
X$95767 14073 9508 9849 9781 9814 9815 14074 gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $95791 m0 *1 46.48,982.8
X$95791 14074 14073 11915 9514 10371 11856 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95798 m0 *1 47.04,892.08
X$95798 14074 14073 10726 9514 10345 10542 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95811 r0 *1 43.68,1043.28
X$95811 14074 12800 14073 12104 13019 9514 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95813 r0 *1 137.76,1043.28
X$95813 14074 12115 14073 12913 12868 12116 9514
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95815 m0 *1 403.76,1053.36
X$95815 14074 11795 14073 13050 12986 9514 11794
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95864 m0 *1 35.28,882
X$95864 14074 10506 10114 9525 10260 10113 10505 10541 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $95871 r0 *1 92.96,831.6
X$95871 14074 14073 9526 9642 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $95886 r0 *1 84,831.6
X$95886 14074 9699 14073 9640 9529 9638 9747 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95909 r0 *1 134.96,952.56
X$95909 14074 14073 11592 9532 10345 11522 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95914 r0 *1 146.16,972.72
X$95914 14074 14073 11789 9532 10371 11711 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $95924 r0 *1 142.8,1002.96
X$95924 14074 12115 14073 12348 12269 12327 9532
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95926 r0 *1 70.56,992.88
X$95926 14074 12105 14073 12104 12263 9532 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $95932 m0 *1 147.28,962.64
X$95932 14074 11430 14073 11650 11594 10377 9533 11711
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $95945 m0 *1 114.8,861.84
X$95945 14073 10025 10204 14074 9535 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95974 r0 *1 342.72,851.76
X$95974 9937 14073 9938 9537 14074 10005 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95979 m0 *1 301.28,871.92
X$95979 14073 9938 9537 14074 10269 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $95981 m0 *1 351.68,861.84
X$95981 10031 14073 9938 9537 14074 10230 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $95997 m0 *1 372.96,841.68
X$95997 9767 14074 14073 9539 9811 9769 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96013 m0 *1 330.96,841.68
X$96013 14074 14073 9541 9762 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96021 r0 *1 347.2,902.16
X$96021 10886 14073 9543 10948 14074 10121 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $96025 r0 *1 355.6,902.16
X$96025 14073 9543 10785 14074 10951 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96027 m0 *1 427.28,992.88
X$96027 14074 14073 12030 12117 9543 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96051 m0 *1 346.08,992.88
X$96051 12030 9543 11190 11288 14074 14073 12116 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $96053 r0 *1 426.16,982.8
X$96053 14073 12030 9543 14074 12037 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96056 m0 *1 342.72,932.4
X$96056 14073 9543 11189 14074 11188 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96059 m0 *1 362.88,942.48
X$96059 14073 10850 9543 14074 11497 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96061 r0 *1 351.12,982.8
X$96061 14074 12031 11190 9543 12030 14073 11288
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $96063 m0 *1 365.68,831.6
X$96063 9544 9656 9612 9723 14073 14074 9548 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $96068 r0 *1 360.64,831.6
X$96068 14074 9617 9723 14073 9612 9544 9656 gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $96074 m0 *1 379.68,831.6
X$96074 14074 9725 9658 14073 9546 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96126 r0 *1 500.64,932.4
X$96126 14073 11289 14074 11195 9660 11192 9550 gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $96128 r0 *1 512.4,942.48
X$96128 14073 9550 11175 14074 11435 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $96134 m0 *1 476.56,831.6
X$96134 9554 14074 14073 9620 9551 14090 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96144 r0 *1 525.28,821.52
X$96144 9557 14074 14073 9552 9629 14116 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96173 m0 *1 561.68,912.24
X$96173 14074 14073 10139 9559 10999 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96184 m0 *1 855.12,902.16
X$96184 14074 14073 9563 10699 9964 10807 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $96254 r0 *1 782.32,912.24
X$96254 14074 14073 9567 14137 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $96280 m0 *1 722.4,972.72
X$96280 14074 14073 11114 11732 9731 9569 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $96295 r0 *1 722.96,982.8
X$96295 14074 14073 12050 11968 11371 9569 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $96351 m0 *1 930.16,851.76
X$96351 14074 9578 10087 9986 9898 9860 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96354 r0 *1 930.16,831.6
X$96354 14074 9713 9899 9579 9712 9710 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96356 r0 *1 944.16,821.52
X$96356 14074 14073 9606 9580 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96360 m0 *1 939.12,861.84
X$96360 14074 9580 10215 10212 10066 9862 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96363 r0 *1 964.32,861.84
X$96363 10308 14074 14073 10211 9581 10309 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96368 m0 *1 976.08,831.6
X$96368 14073 9582 9678 14074 10340 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $96372 r0 *1 1025.36,831.6
X$96372 14073 10598 9684 14074 9583 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96385 m0 *1 1088.64,831.6
X$96385 14074 9686 9586 9594 9698 9687 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96388 r0 *1 1142.96,942.48
X$96388 14074 11472 9587 14073 11482 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96390 r0 *1 1127.28,922.32
X$96390 14074 10712 9587 14073 11135 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96393 r0 *1 1119.44,1002.96
X$96393 14074 11222 9587 14073 12389 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96396 r0 *1 1145.76,972.72
X$96396 14074 11471 9587 14073 11829 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96399 r0 *1 1138.48,992.88
X$96399 14074 11016 9587 14073 12233 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96401 r0 *1 1100.4,1043.28
X$96401 14074 11216 9587 14073 12907 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96404 r0 *1 1111.04,1043.28
X$96404 14074 11305 9587 14073 12836 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96408 m0 *1 1142.4,882
X$96408 14074 9595 9587 14073 10410 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96429 r0 *1 1081.92,1053.36
X$96429 14074 14073 13144 12545 9587 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $96441 m0 *1 1147.44,831.6
X$96441 14074 14073 9590 9592 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96455 r0 *1 1080.8,861.84
X$96455 14074 9594 10178 10199 10180 10179 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96468 r0 *1 1167.04,882
X$96468 14074 9595 10826 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $96532 r0 *1 348.88,851.76
X$96532 10096 10004 10030 10005 14073 14074 9612 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $96570 m0 *1 426.16,932.4
X$96570 9660 14073 9615 11191 14074 10787 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $96578 r0 *1 687.12,902.16
X$96578 14074 14073 9616 10900 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96654 m0 *1 6.72,892.08
X$96654 9633 14073 14074 10540 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96657 r0 *1 27.44,902.16
X$96657 9634 14073 14074 10880 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96660 r0 *1 21.84,892.08
X$96660 9635 14073 14074 10719 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $96667 r0 *1 44.8,871.92
X$96667 14074 10417 10114 9636 10260 10113 10416 10542 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $96674 r0 *1 67.2,831.6
X$96674 14074 14073 9637 9638 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $96688 r0 *1 80.64,841.68
X$96688 14074 14073 9639 9931 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $96691 m0 *1 82.88,851.76
X$96691 14074 14073 9697 9640 9931 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96703 r0 *1 102.48,831.6
X$96703 14073 9641 9642 14074 9699 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96722 m0 *1 169.68,841.68
X$96722 14073 9801 9893 14074 9645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96751 m0 *1 353.92,851.76
X$96751 10006 9649 10007 10008 14073 14074 9836 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $96758 r0 *1 290.64,841.68
X$96758 14074 14073 9651 9761 9760 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96762 r0 *1 305.2,831.6
X$96762 14074 14073 9652 9718 9719 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96776 m0 *1 357.84,841.68
X$96776 14074 9764 9655 14073 9723 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $96783 m0 *1 371.28,972.72
X$96783 14074 11355 14073 9656 11933 11850 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $96785 r0 *1 370.72,831.6
X$96785 14074 14073 9767 9657 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96789 r0 *1 371.84,841.68
X$96789 14074 9765 14073 9725 9657 9768 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $96791 r0 *1 379.12,841.68
X$96791 14073 9768 9769 14074 9658 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96794 m0 *1 468.72,942.48
X$96794 14074 14073 9660 9659 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $96796 r0 *1 419.44,922.32
X$96796 14074 11097 9659 14073 9661 11099 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $96798 r0 *1 426.72,922.32
X$96798 9659 14073 9661 11099 14074 11100 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $96837 r0 *1 488.32,892.08
X$96837 10761 14074 14073 10673 9659 14110 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96842 m0 *1 418.88,932.4
X$96842 14073 9659 11191 14074 10887 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96844 r0 *1 384.16,912.24
X$96844 14073 9659 10663 14074 10888 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96846 m0 *1 493.36,942.48
X$96846 14073 9659 11290 14074 11359 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $96886 r0 *1 490,942.48
X$96886 14073 9660 11290 14074 11604 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $96904 m0 *1 469.84,861.84
X$96904 10242 14074 14073 10386 9663 14088 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $96919 m0 *1 678.72,841.68
X$96919 14074 14073 9814 9782 9733 9668 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $96933 m0 *1 687.68,841.68
X$96933 14074 14073 9670 9733 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96957 r0 *1 1031.52,851.76
X$96957 14074 14073 9971 10705 9675 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $96959 r0 *1 1033.76,882
X$96959 14073 9675 9866 14074 10599 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96962 r0 *1 1045.52,932.4
X$96962 14073 10497 9675 14074 11307 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $96965 r0 *1 1026.48,932.4
X$96965 14074 14073 9675 11380 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $96969 m0 *1 905.52,841.68
X$96969 14074 9716 9859 9804 9676 9791 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $96974 m0 *1 963.76,851.76
X$96974 14073 9677 9967 14074 9963 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $96976 m0 *1 973.28,851.76
X$96976 14074 14073 9677 9895 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $96979 r0 *1 976.08,831.6
X$96979 14074 9679 14073 9678 9680 9681 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $96981 m0 *1 972.72,841.68
X$96981 9896 14073 14074 9679 9794 9682 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $96988 m0 *1 976.64,851.76
X$96988 14073 9863 14074 9967 9680 9895 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $96994 r0 *1 981.12,841.68
X$96994 14073 9681 9968 14074 9894 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $97003 r0 *1 991.2,831.6
X$97003 14074 14073 9682 9683 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97006 r0 *1 990.64,841.68
X$97006 14074 14073 9683 9984 9865 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97008 m0 *1 990.08,841.68
X$97008 14074 14073 9683 9799 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97013 m0 *1 1024.24,841.68
X$97013 14074 14073 9971 9710 9684 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97016 m0 *1 1019.2,841.68
X$97016 14074 14073 9684 9711 9866 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97022 r0 *1 1047.2,831.6
X$97022 14074 14073 9685 9888 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97032 m0 *1 1109.36,841.68
X$97032 14074 14073 9688 9872 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97039 m0 *1 1120,841.68
X$97039 14074 14073 9689 9879 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97041 m0 *1 1109.36,871.92
X$97041 14074 10328 10512 10415 9690 10199 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97046 r0 *1 1123.36,831.6
X$97046 14074 9696 9694 10318 9691 9695 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97055 r0 *1 1162,871.92
X$97055 14074 14073 10323 9876 9692 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $97057 m0 *1 1159.76,962.64
X$97057 14074 14073 9692 11684 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97059 r0 *1 1158.64,952.56
X$97059 14074 14073 9692 11621 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97097 r0 *1 1072.96,831.6
X$97097 14074 9705 9701 9869 9702 9700 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97099 m0 *1 1044.96,861.84
X$97099 14074 10205 9700 10201 9885 10175 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97111 m0 *1 1060.64,851.76
X$97111 14074 9883 9982 10082 9703 9973 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97119 r0 *1 164.64,831.6
X$97119 14074 14073 9704 9708 9707 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97137 m0 *1 165.76,972.72
X$97137 14074 14073 11430 9709 11790 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97161 m0 *1 263.76,831.6
X$97161 14074 14073 9806 9714 9715 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97238 r0 *1 331.52,1002.96
X$97238 14074 9730 14073 12497 11425 12360 10431
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $97241 r0 *1 346.08,982.8
X$97241 14073 11955 9730 14074 11931 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97243 r0 *1 342.72,992.88
X$97243 14073 12204 9730 14074 11956 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97246 r0 *1 380.8,972.72
X$97246 14074 14073 9730 11873 11430 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97248 r0 *1 393.68,982.8
X$97248 14073 12034 9730 14074 11958 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97251 r0 *1 405.44,982.8
X$97251 14073 12035 9730 14074 11872 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97256 r0 *1 899.36,912.24
X$97256 14073 11053 10907 9731 11012 10804 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $97262 m0 *1 824.32,902.16
X$97262 9731 10803 10946 10484 14073 14074 10746 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $97266 m0 *1 888.16,1002.96
X$97266 14073 11121 14074 12302 11975 12094 9731
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $97269 r0 *1 888.16,982.8
X$97269 14073 11121 14074 12058 11890 11977 9731
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $97326 m0 *1 729.68,952.56
X$97326 14073 10901 14074 11508 11585 9731 11540
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $97333 r0 *1 884.8,902.16
X$97333 14074 14073 10808 10809 9731 9786 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $97336 m0 *1 885.36,922.32
X$97336 14074 14073 10963 11122 9731 11153 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $97351 m0 *1 443.52,902.16
X$97351 14074 14073 9732 10884 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97354 m0 *1 692.72,851.76
X$97354 14073 9852 14074 9784 9957 9733 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $97386 m0 *1 530.88,841.68
X$97386 14074 14073 9734 9818 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97410 r0 *1 26.88,922.32
X$97410 9740 14073 14074 11081 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97415 r0 *1 43.68,922.32
X$97415 9741 14073 14074 11144 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97422 r0 *1 10.64,892.08
X$97422 9742 14073 14074 10654 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97425 r0 *1 27.44,932.4
X$97425 9743 14073 14074 11389 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97465 r0 *1 138.32,892.08
X$97465 14073 9750 10647 14074 10648 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97474 r0 *1 208.32,952.56
X$97474 14074 14073 11430 9753 11524 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97507 r0 *1 333.76,841.68
X$97507 14074 14073 9937 9904 9762 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97511 m0 *1 363.44,841.68
X$97511 9765 14074 14073 9762 9766 9768 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $97583 r0 *1 425.6,841.68
X$97583 14074 14073 9909 9841 9770 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $97604 m0 *1 566.72,952.56
X$97604 14074 14073 9775 11532 11534 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $97617 r0 *1 534.24,1174.32
X$97617 9777 14073 14074 14063 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97619 m0 *1 758.8,1013.04
X$97619 14074 14073 12298 9777 10395 9787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $97621 r0 *1 746.48,1002.96
X$97621 14074 10581 14073 12373 10482 9777 12374 10579
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $97665 r0 *1 706.72,841.68
X$97665 14074 9958 9783 9910 9810 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $97682 m0 *1 701.12,851.76
X$97682 14073 9783 9955 14074 10003 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $97684 r0 *1 700,851.76
X$97684 14074 9958 14073 9812 9957 9783 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $97746 m0 *1 879.76,1002.96
X$97746 14074 14073 12301 12247 10804 9787 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $97756 m0 *1 828.24,1053.36
X$97756 14073 12955 12958 14074 9788 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $97762 m0 *1 844.48,1043.28
X$97762 14074 14073 11704 12895 9788 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $97782 r0 *1 921.2,841.68
X$97782 14074 9792 10088 9898 9899 9804 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97784 m0 *1 930.16,841.68
X$97784 14074 14073 9803 9792 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97788 m0 *1 933.52,841.68
X$97788 14074 9802 9803 9861 9800 9793 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97797 r0 *1 969.92,841.68
X$97797 14074 14073 9794 9863 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97800 r0 *1 1033.2,841.68
X$97800 14074 9890 9795 9885 9868 9889 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $97805 m0 *1 1138.48,922.32
X$97805 14074 9796 10182 14073 11022 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $97819 r0 *1 1132.88,922.32
X$97819 14074 14073 9796 11472 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97830 m0 *1 1158.64,902.16
X$97830 14074 14073 9798 10915 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $97836 m0 *1 984.48,851.76
X$97836 14074 9799 14073 9865 9969 9864 9985 gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $97918 r0 *1 2.24,892.08
X$97918 9820 14073 14074 10716 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97921 r0 *1 25.76,871.92
X$97921 9821 14073 14074 10505 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97924 r0 *1 2.24,861.84
X$97924 9822 14073 14074 10320 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97927 m0 *1 10.08,851.76
X$97927 9823 14073 14074 9977 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97930 r0 *1 25.2,912.24
X$97930 9824 14073 14074 11031 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97935 r0 *1 9.52,922.32
X$97935 9825 14073 14074 11309 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97938 r0 *1 2.24,851.76
X$97938 9826 14073 14074 10019 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $97958 m0 *1 164.64,882
X$97958 14074 10618 10114 9829 10260 10113 10422 10552 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $97968 m0 *1 20.16,851.76
X$97968 14074 14073 9977 9831 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $97971 m0 *1 202.16,851.76
X$97971 14074 14073 10001 9832 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98009 m0 *1 406.56,861.84
X$98009 14073 9838 10349 14074 10126 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98057 r0 *1 461.44,912.24
X$98057 10967 14074 14073 11101 9842 14125 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98094 m0 *1 706.16,851.76
X$98094 10243 14074 14073 9959 9853 9850 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98102 m0 *1 706.16,861.84
X$98102 14074 10243 14073 10048 10049 9850 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $98109 r0 *1 700,841.68
X$98109 14074 14073 9851 9852 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98119 r0 *1 860.16,902.16
X$98119 14074 10587 10699 10805 10849 10807 9854 10806 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai222_2
* cell instance $98147 m0 *1 856.24,892.08
X$98147 14073 14074 10587 10159 10586 10400 10744 9854
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $98164 r0 *1 731.36,982.8
X$98164 14073 10482 11117 14074 9856 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98250 m0 *1 909.44,861.84
X$98250 14074 10090 10163 10166 10089 9859 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98255 r0 *1 945.28,841.68
X$98255 14074 14073 9897 9860 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98267 r0 *1 979.44,851.76
X$98267 14073 9863 9985 14074 9968 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98269 r0 *1 980,861.84
X$98269 14073 9895 10594 10169 9864 10171 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $98272 m0 *1 979.44,871.92
X$98272 14073 9864 14074 9895 10405 10310 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $98279 r0 *1 973.28,841.68
X$98279 14074 14073 9896 9864 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $98293 r0 *1 1037.12,932.4
X$98293 14074 14073 11322 9867 11305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $98295 r0 *1 1032.08,952.56
X$98295 14074 14073 11744 9867 11244 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $98298 r0 *1 1052.24,942.48
X$98298 14074 14073 11570 9867 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $98310 m0 *1 1077.44,851.76
X$98310 14074 10074 9973 9870 9869 9981 14073 gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $98313 r0 *1 1094.24,841.68
X$98313 14074 14073 9882 9870 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98316 r0 *1 1102.64,841.68
X$98316 14074 9880 9882 9873 9879 9871 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98324 r0 *1 1111.04,1002.96
X$98324 14074 14073 9872 12396 11132 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98326 m0 *1 1095.36,1023.12
X$98326 14074 14073 9872 12606 11380 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98328 r0 *1 1113.28,861.84
X$98328 10200 14074 14073 10197 9873 10198 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98333 m0 *1 1139.6,851.76
X$98333 14074 14073 9874 9979 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $98335 r0 *1 1161.44,851.76
X$98335 14074 9976 10076 10078 9875 9877 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98338 r0 *1 1180.48,902.16
X$98338 14074 9876 10319 14073 10714 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $98350 r0 *1 1167.6,912.24
X$98350 14074 14073 9876 11026 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98371 r0 *1 1086.4,841.68
X$98371 14074 14073 9881 9883 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98390 r0 *1 1067.92,841.68
X$98390 14074 14073 9886 10083 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98393 m0 *1 1028.72,851.76
X$98393 10073 14074 14073 9887 9888 9891 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98412 r0 *1 1013.6,851.76
X$98412 10070 14074 14073 10085 9891 9970 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98435 m0 *1 914.48,892.08
X$98435 14074 14073 9894 10588 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98439 m0 *1 981.12,861.84
X$98439 14074 9895 10169 14073 9985 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $98478 m0 *1 215.04,882
X$98478 14074 10652 14073 10377 10217 10269 9903
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $98488 m0 *1 783.44,851.76
X$98488 14074 14073 10000 9905 9999 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98495 m0 *1 755.44,861.84
X$98495 14074 14073 9906 10051 10237 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98569 r0 *1 576.24,861.84
X$98569 14074 10250 14073 10284 9923 10141 9947 10139
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $98577 m0 *1 568.96,932.4
X$98577 14073 11198 11103 11199 11201 9925 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $98586 r0 *1 559.44,882
X$98586 14073 9925 10283 14074 10470 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98591 m0 *1 586.32,922.32
X$98591 14074 14073 11168 9925 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98593 r0 *1 2.24,932.4
X$98593 9926 14073 14074 11268 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $98598 r0 *1 16.24,912.24
X$98598 9927 14073 14074 11028 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $98601 r0 *1 19.04,851.76
X$98601 9928 14073 14074 10021 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $98636 m0 *1 305.2,861.84
X$98636 14074 10119 14073 9935 10120 10227 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $98645 r0 *1 305.2,871.92
X$98645 14074 10556 14073 10377 10430 10269 9936
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $98647 m0 *1 312.48,861.84
X$98647 14074 14073 9936 10227 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98658 r0 *1 381.92,871.92
X$98658 10128 14073 10272 10271 14074 9938 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $98673 m0 *1 306.88,882
X$98673 14073 9938 10379 14074 10113 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98679 m0 *1 321.44,882
X$98679 10378 14073 9938 10431 14074 10527 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $98681 r0 *1 353.92,871.92
X$98681 10662 10378 9938 10431 14074 14073 10434 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $98684 r0 *1 361.2,871.92
X$98684 10459 14073 9938 10379 14074 10124 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $98688 r0 *1 344.96,882
X$98688 10661 10378 9938 10431 14074 14073 10030 gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $98692 m0 *1 381.92,871.92
X$98692 14074 9939 10128 14073 10272 10271 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $98718 r0 *1 558.32,861.84
X$98718 10283 10139 10137 10041 9942 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $98733 m0 *1 609.28,861.84
X$98733 14073 10144 14074 9948 10251 10252 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $98762 r0 *1 686.56,851.76
X$98762 14074 14073 9954 9955 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98775 r0 *1 707.28,851.76
X$98775 14074 9958 10003 14073 10049 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $98788 m0 *1 743.12,882
X$98788 14073 9961 14074 10479 10481 10293 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $98802 r0 *1 743.68,882
X$98802 14073 10578 14074 10628 10293 9961 10479
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $98821 m0 *1 837.2,902.16
X$98821 14073 10804 9964 14074 10057 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98826 r0 *1 843.92,882
X$98826 14074 14073 10438 10584 9964 10585 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $98828 m0 *1 855.68,861.84
X$98828 14074 14073 10012 10159 9964 10400 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $98875 r0 *1 855.12,902.16
X$98875 14074 14073 10804 10587 9964 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98883 m0 *1 907.2,882
X$98883 10524 14074 14073 10425 10423 9965 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98895 r0 *1 899.36,851.76
X$98895 14074 9991 10091 10089 10063 9966 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98903 m0 *1 973.28,861.84
X$98903 14074 14073 10310 9967 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $98908 r0 *1 985.6,851.76
X$98908 14073 10067 9969 14074 10159 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $98912 r0 *1 997.36,851.76
X$98912 14073 9970 9984 14074 10069 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98915 r0 *1 1002.96,851.76
X$98915 14074 14073 9970 10067 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $98925 m0 *1 1054.48,851.76
X$98925 14074 14073 9982 9972 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $98935 m0 *1 1058.96,871.92
X$98935 14074 10332 10333 10613 10313 9974 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98942 m0 *1 1143.52,861.84
X$98942 10184 14074 14073 9975 10191 10197 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $98959 m0 *1 1075.76,1043.28
X$98959 14073 11380 9979 14074 12847 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $98961 r0 *1 1121.12,1023.12
X$98961 14074 14073 11132 12685 9979 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $98967 m0 *1 1075.76,871.92
X$98967 14074 10513 10331 10315 9981 10314 14073 gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $98987 m0 *1 999.6,861.84
X$98987 14074 14073 9984 10208 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $98999 r0 *1 951.44,851.76
X$98999 14074 14073 9986 10066 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99002 r0 *1 928.48,851.76
X$99002 10064 14074 14073 9987 10065 9988 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $99008 r0 *1 916.72,851.76
X$99008 14074 14073 9988 10090 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99023 m0 *1 825.44,851.76
X$99023 14074 14073 9993 9992 9995 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99084 m0 *1 355.6,972.72
X$99084 14074 11355 14073 10007 11849 11799 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $99095 m0 *1 357.84,861.84
X$99095 10124 10097 10230 10434 14073 14074 10008 gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $99107 m0 *1 660.24,861.84
X$99107 14074 14073 10010 10046 10045 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $99127 m0 *1 567.28,871.92
X$99127 10288 14073 10443 10538 14074 10014 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $99136 r0 *1 25.2,882
X$99136 10016 14073 14074 10611 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99139 r0 *1 10.64,861.84
X$99139 10017 14073 14074 10190 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99142 r0 *1 10.64,902.16
X$99142 10018 14073 14074 10830 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99151 r0 *1 19.04,861.84
X$99151 10257 14073 14074 10020 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99157 r0 *1 28,851.76
X$99157 14074 14073 10021 10081 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99167 r0 *1 58.8,871.92
X$99167 14073 10507 10417 14074 10024 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99172 r0 *1 103.6,871.92
X$99172 14074 14073 10372 10025 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99186 m0 *1 241.92,861.84
X$99186 14073 10094 10338 14074 10029 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99196 m0 *1 366.24,861.84
X$99196 14074 14073 10270 10032 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99202 m0 *1 409.36,922.32
X$99202 14074 11253 14073 10033 10990 11097 11096
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $99210 m0 *1 426.16,861.84
X$99210 14073 10035 10129 14074 10235 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99227 r0 *1 581.84,912.24
X$99227 14074 14073 10040 11000 10965 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $99245 m0 *1 650.72,861.84
X$99245 14074 14073 10149 10044 10148 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99261 m0 *1 665.84,861.84
X$99261 14073 10149 10148 14074 10047 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99273 m0 *1 683.76,861.84
X$99273 14074 14073 10048 10152 10151 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99306 m0 *1 840.56,892.08
X$99306 14074 10584 14073 10057 10696 10053 10585
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $99323 m0 *1 773.92,942.48
X$99323 14074 14073 11206 10054 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99325 r0 *1 846.16,912.24
X$99325 14073 11059 14074 10055 10399 11010 11121
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $99343 m0 *1 784,922.32
X$99343 14074 14073 10482 10055 11117 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99351 r0 *1 784.56,861.84
X$99351 14073 10234 14074 10056 10355 10154 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $99391 m0 *1 788.48,902.16
X$99391 14073 10852 14074 10058 10853 10577 10949
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $99395 m0 *1 819.28,912.24
X$99395 14073 10947 14074 11061 10060 11008 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $99399 m0 *1 813.68,902.16
X$99399 14073 10802 14074 10061 10851 10577 10905
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $99401 r0 *1 879.2,861.84
X$99401 14074 10062 10092 10161 10221 10224 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $99407 m0 *1 919.52,871.92
X$99407 14074 10165 10304 10521 10343 10064 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $99417 m0 *1 992.88,861.84
X$99417 14074 14073 10067 10068 10208 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99420 r0 *1 990.08,861.84
X$99420 14074 10170 14073 10595 10171 10068 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $99424 m0 *1 999.04,871.92
X$99424 14074 10071 14073 10418 10406 10069 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $99428 r0 *1 996.24,871.92
X$99428 10311 14073 10312 10069 14074 10495 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $99431 r0 *1 1011.92,861.84
X$99431 10173 14073 10172 10070 14074 10339 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $99433 m0 *1 1009.12,861.84
X$99433 14074 14073 10070 10071 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $99435 r0 *1 1000.16,861.84
X$99435 14074 14073 10171 10071 10174 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $99442 m0 *1 1023.68,861.84
X$99442 14074 10174 10173 10073 10072 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $99449 r0 *1 1076.88,871.92
X$99449 14074 10178 10074 10511 10201 10408 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $99455 m0 *1 1095.92,1063.44
X$99455 14073 13077 10075 14074 13145 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99457 r0 *1 1106,1043.28
X$99457 14074 14073 11132 12835 10075 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99462 r0 *1 1159.76,861.84
X$99462 14074 14073 10076 10189 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99464 r0 *1 1173.2,902.16
X$99464 14074 10077 10411 14073 10713 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $99466 m0 *1 1177.68,942.48
X$99466 14074 10077 10319 14073 11476 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $99477 m0 *1 1168.16,952.56
X$99477 14074 14073 10077 11560 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $99479 m0 *1 1166.48,902.16
X$99479 14074 10078 10824 10827 10829 10825 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $99486 m0 *1 1168.72,861.84
X$99486 10192 14074 14073 10080 10187 10079 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $99502 r0 *1 1072.96,861.84
X$99502 14074 14073 10082 10313 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99521 r0 *1 932.96,861.84
X$99521 14074 14073 10087 10167 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99524 r0 *1 920.64,851.76
X$99524 14074 14073 10088 10165 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99537 m0 *1 897.68,871.92
X$99537 14074 14073 10091 10220 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99542 r0 *1 876.96,851.76
X$99542 14074 14073 10092 10093 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99547 m0 *1 874.16,871.92
X$99547 10347 14074 14073 10348 10093 10300 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $99629 m0 *1 10.08,871.92
X$99629 10105 14073 14074 10214 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99632 m0 *1 10.08,952.56
X$99632 10106 14073 14074 11478 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99647 r0 *1 11.2,871.92
X$99647 10254 14073 14074 10110 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $99707 m0 *1 130.48,932.4
X$99707 14074 14073 10113 11143 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $99709 m0 *1 187.04,932.4
X$99709 14074 10269 14073 11182 10113 11347 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $99765 r0 *1 117.04,922.32
X$99765 14074 11150 10114 10550 10115 11143 11031 11180 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* cell instance $99775 r0 *1 282.8,902.16
X$99775 14074 14073 10557 10114 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $99826 r0 *1 59.36,892.08
X$99826 14074 14073 10115 10260 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $99858 r0 *1 296.8,861.84
X$99858 14074 14073 10118 10342 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $99861 m0 *1 297.36,932.4
X$99861 14074 11424 14073 10377 11277 10269 10118
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $99866 r0 *1 301.28,861.84
X$99866 14074 10119 14073 10225 10120 10342 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $99931 m0 *1 372.96,892.08
X$99931 14073 10128 10563 14074 10558 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99954 m0 *1 454.16,871.92
X$99954 14073 10131 10353 14074 10263 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $99956 r0 *1 466.48,871.92
X$99956 14073 10386 10267 14074 10132 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $100031 r0 *1 476,922.32
X$100031 14073 11101 10134 14074 11170 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $100039 m0 *1 529.2,871.92
X$100039 10282 14074 14073 10360 10135 14100 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100047 r0 *1 570.08,871.92
X$100047 10138 10444 10680 10389 14073 14074 10443
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $100053 r0 *1 572.88,892.08
X$100053 14074 10866 14073 10759 10680 10139 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $100055 r0 *1 575.12,912.24
X$100055 14074 14073 10964 10139 10999 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $100057 r0 *1 562.8,922.32
X$100057 14074 14073 11262 10139 10998 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $100059 m0 *1 618.24,952.56
X$100059 14074 14073 11370 11537 10139 11606 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100062 m0 *1 619.36,942.48
X$100062 14074 14073 11412 11446 10139 11447 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100066 m0 *1 586.32,892.08
X$100066 14074 14073 10642 10571 10139 10475 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100096 m0 *1 581.28,871.92
X$100096 14074 10442 14073 10140 10284 10139 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $100105 r0 *1 614.32,882
X$100105 14073 10139 10476 14074 10637 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $100111 m0 *1 567.84,972.72
X$100111 14074 10141 11199 11533 11805 11435 11727 11806 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $100132 m0 *1 647.92,871.92
X$100132 14073 10147 10146 14074 10286 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $100134 r0 *1 648.48,861.84
X$100134 10147 14074 10146 14073 10150 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $100177 m0 *1 753.76,892.08
X$100177 14073 10627 14074 10153 10756 10577 10799
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $100180 m0 *1 784,892.08
X$100180 14073 10752 10625 14074 10154 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $100185 m0 *1 927.92,882
X$100185 14074 14073 10589 10155 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100189 r0 *1 792.4,861.84
X$100189 14073 10156 14074 10232 10233 10298 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $100196 r0 *1 828.24,861.84
X$100196 14074 14073 10231 10158 10299 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $100210 r0 *1 869.68,861.84
X$100210 10348 14074 14073 10301 10226 10160 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100226 m0 *1 903.28,871.92
X$100226 14074 14073 10161 10162 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100231 m0 *1 891.52,861.84
X$100231 14074 10218 10346 10344 10162 10220 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100234 m0 *1 910,871.92
X$100234 14074 14073 10163 10303 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100238 r0 *1 926.8,922.32
X$100238 14074 10164 11244 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $100244 r0 *1 927.36,861.84
X$100244 14074 14073 10166 10343 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100247 m0 *1 932.96,882
X$100247 10523 14074 14073 10521 10167 10522 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100250 r0 *1 957.6,871.92
X$100250 10306 14074 14073 10420 10168 10419 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100257 m0 *1 964.32,871.92
X$100257 14074 10308 14073 10169 10404 10309 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $100263 m0 *1 992.32,871.92
X$100263 14074 14073 10170 10311 10174 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $100271 m0 *1 1033.2,871.92
X$100271 14074 10337 10172 10333 10203 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $100277 m0 *1 1015.28,871.92
X$100277 14074 14073 10172 10312 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $100285 r0 *1 1018.08,861.84
X$100285 14074 14073 10173 10311 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $100294 m0 *1 1008,871.92
X$100294 14074 10339 14073 10518 10174 10312 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $100297 m0 *1 1033.76,882
X$100297 14074 10517 10175 10514 10407 10516 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100302 r0 *1 1047.2,861.84
X$100302 14074 10335 10206 10202 10177 10176 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100316 r0 *1 1076.32,861.84
X$100316 14074 14073 10202 10179 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100318 m0 *1 1092.56,871.92
X$100318 14074 10181 10180 10723 10317 10316 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100323 m0 *1 1141.28,952.56
X$100323 14074 10182 11471 14073 11383 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $100326 r0 *1 1102.08,1033.2
X$100326 14074 10182 11216 14073 12759 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $100328 r0 *1 1109.92,1023.12
X$100328 14074 10182 11305 14073 12689 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $100330 r0 *1 1134.56,972.72
X$100330 14074 10182 11016 14073 11832 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $100332 m0 *1 1123.92,1002.96
X$100332 14074 10182 11222 14073 12232 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $100335 r0 *1 1087.52,1053.36
X$100335 14074 14073 13016 10182 12545 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $100346 r0 *1 1131.2,871.92
X$100346 14074 10499 10327 10414 10410 10183 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100354 m0 *1 1111.04,882
X$100354 14074 10184 10510 10509 10413 10409 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100356 m0 *1 1148,882
X$100356 14074 10501 10185 10500 10504 10502 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100358 r0 *1 1144.08,861.84
X$100358 14074 14073 10185 10413 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100360 r0 *1 1163.12,861.84
X$100360 14074 10192 10194 10188 10189 10186 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100364 m0 *1 1153.6,871.92
X$100364 14074 10323 10412 10186 10321 10322 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100373 r0 *1 1155.84,902.16
X$100373 11025 14074 14073 10188 10917 10832 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100399 r0 *1 1150.24,861.84
X$100399 14074 14073 10194 10502 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100405 r0 *1 1156.4,861.84
X$100405 14074 14073 10195 10504 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100417 r0 *1 1107.12,861.84
X$100417 14074 14073 10198 10314 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100427 m0 *1 1066.24,892.08
X$100427 14074 10200 10597 10835 10604 10603 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $100446 r0 *1 1043.84,861.84
X$100446 14074 14073 10206 10205 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100489 r0 *1 929.04,871.92
X$100489 10421 14074 14073 10215 10523 10402 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $100508 m0 *1 274.96,952.56
X$100508 14074 14073 11430 10219 12330 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $100572 r0 *1 768.32,902.16
X$100572 14073 10854 14074 10236 10904 10801 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $100605 m0 *1 752.64,962.64
X$100605 14074 14073 10238 10578 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100609 r0 *1 728,942.48
X$100609 14074 14073 11510 11508 11371 10238 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100618 r0 *1 1002.4,871.92
X$100618 14073 10311 10418 14074 10239 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $100686 r0 *1 597.52,882
X$100686 14074 14073 10474 10285 10250 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $100689 m0 *1 610.96,871.92
X$100689 14074 14073 10250 10364 10476 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $100691 r0 *1 577.36,902.16
X$100691 14074 14073 10250 10894 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $100707 r0 *1 2.24,871.92
X$100707 10255 14073 14074 10370 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $100710 r0 *1 34.16,871.92
X$100710 10256 14073 14074 10416 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $100715 m0 *1 6.72,882
X$100715 10258 14073 14074 10422 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $100718 m0 *1 10.08,922.32
X$100718 10259 14073 14074 11142 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $100749 m0 *1 290.64,952.56
X$100749 14074 14073 11492 10263 11188 11424 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100752 r0 *1 212.24,912.24
X$100752 14074 14073 10979 10263 10345 10980 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100755 m0 *1 362.88,972.72
X$100755 14074 14073 11775 10263 11497 11427 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100758 m0 *1 319.2,1123.92
X$100758 14074 13701 14073 13660 12116 10263 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $100774 m0 *1 400.96,1123.92
X$100774 14074 13666 14073 12104 13745 12189 10263
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $100806 m0 *1 191.52,912.24
X$100806 14074 11090 14073 10377 10936 10269 10877
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $100832 m0 *1 233.52,892.08
X$100832 14074 10653 14073 10377 10428 10269 10621
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $100835 r0 *1 262.64,922.32
X$100835 14074 11273 14073 10377 11243 10269 10982
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $100848 m0 *1 390.88,882
X$100848 10462 14073 10272 10271 14074 10463 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $100888 m0 *1 482.72,1002.96
X$100888 14074 12222 11604 11601 10672 11653 10278 11173 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $100901 m0 *1 526.4,942.48
X$100901 14073 10281 11360 14074 11365 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $100904 m0 *1 531.44,942.48
X$100904 10281 14073 11360 11344 14074 11436 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $100908 r0 *1 559.44,992.88
X$100908 14074 14073 10283 12219 11534 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100912 m0 *1 585.2,992.88
X$100912 14074 14073 10284 11367 12183 11438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $100962 m0 *1 687.68,871.92
X$100962 14074 14073 10294 10293 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $100980 m0 *1 899.36,882
X$100980 14074 14073 10340 10296 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $100984 m0 *1 923.44,902.16
X$100984 14074 10810 10297 10697 10739 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $100996 r0 *1 792.96,882
X$100996 14073 10751 10483 14074 10298 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101012 m0 *1 869.68,871.92
X$101012 14074 14073 10426 10301 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101017 m0 *1 885.92,871.92
X$101017 10425 14074 14073 10347 10346 10302 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $101028 r0 *1 908.88,871.92
X$101028 10424 14074 14073 10344 10303 10423 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $101031 m0 *1 916.72,882
X$101031 10488 14074 14073 10304 10424 10619 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $101033 r0 *1 945.84,871.92
X$101033 14074 10420 10403 10305 10421 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $101037 m0 *1 954.8,871.92
X$101037 14074 14073 10306 10307 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101039 m0 *1 965.44,882
X$101039 14073 10307 14074 10491 10520 10492 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $101041 m0 *1 957.6,882
X$101041 14073 10307 14074 10490 10404 10491 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $101049 m0 *1 971.6,871.92
X$101049 14074 10308 14073 10310 10520 10309 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $101056 r0 *1 967.12,871.92
X$101056 10309 14074 10404 14073 10399 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $101082 r0 *1 979.44,882
X$101082 10312 14073 10594 10595 14074 10593 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $101085 m0 *1 983.36,892.08
X$101085 14074 10312 14073 10735 10595 10594 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $101087 m0 *1 972.72,892.08
X$101087 14073 10312 10596 14074 10736 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101098 r0 *1 1080.24,882
X$101098 14074 14073 10315 10604 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101104 m0 *1 1126.72,871.92
X$101104 14074 10327 10328 10325 10318 10324 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $101108 r0 *1 1174.88,1033.2
X$101108 14074 10712 10319 14073 12840 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101110 r0 *1 1178.8,1023.12
X$101110 14074 10826 10319 14073 12611 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101112 r0 *1 1174.88,992.88
X$101112 14074 10915 10319 14073 12234 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101115 r0 *1 1098.72,1113.84
X$101115 14074 11305 10319 14073 13675 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101117 m0 *1 1107.12,1134
X$101117 14074 11216 10319 14073 13786 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101119 r0 *1 1137.36,1083.6
X$101119 14074 11016 10319 14073 13368 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101121 r0 *1 1132.88,1093.68
X$101121 14074 11222 10319 14073 13488 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101123 m0 *1 1152.48,1073.52
X$101123 14074 11471 10319 14073 13226 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101125 m0 *1 1164.8,1053.36
X$101125 14074 11472 10319 14073 13022 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101141 r0 *1 1075.2,1134
X$101141 14074 14073 13847 12545 10319 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $101143 m0 *1 1132.32,1123.92
X$101143 14074 14073 10319 12075 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101165 r0 *1 1148.56,871.92
X$101165 14074 14073 10412 10324 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101167 m0 *1 1114.96,902.16
X$101167 14074 10325 10834 10823 10822 10720 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $101195 r0 *1 1066.8,861.84
X$101195 14074 14073 10331 10332 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101205 r0 *1 183.68,882
X$101205 14073 10618 10936 14074 10334 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101216 r0 *1 1001.28,892.08
X$101216 10337 14074 10702 10703 14073 10734 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $101222 m0 *1 999.04,892.08
X$101222 14074 14073 10337 10493 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101224 r0 *1 993.44,892.08
X$101224 10596 14073 10701 10337 14074 10913 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $101265 m0 *1 106.4,952.56
X$101265 14074 14073 11417 10875 10345 11418 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101272 r0 *1 58.8,932.4
X$101272 14074 14073 11315 10645 10345 11269 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101274 r0 *1 120.96,932.4
X$101274 14074 14073 11323 10549 10345 11180 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101283 r0 *1 257.6,952.56
X$101283 14074 14073 11580 11091 10345 11186 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101292 m0 *1 346.64,922.32
X$101292 14074 14073 11057 11058 10345 10986 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101353 m0 *1 357.28,922.32
X$101353 14074 14073 10951 10345 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101374 m0 *1 402.08,902.16
X$101374 10953 10350 11067 10755 14074 14073 10890
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $101380 m0 *1 832.72,882
X$101380 14073 10529 14074 10352 10528 10485 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $101439 r0 *1 2.24,902.16
X$101439 10366 14073 14074 10828 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101442 m0 *1 7.28,942.48
X$101442 10367 14073 14074 11477 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101447 m0 *1 24.08,942.48
X$101447 10368 14073 14074 11388 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101450 r0 *1 14,932.4
X$101450 10369 14073 14074 11387 gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* cell instance $101457 m0 *1 119.28,972.72
X$101457 14074 14073 11757 10875 10371 11649 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101461 r0 *1 64.96,952.56
X$101461 14074 14073 11563 10645 10371 11519 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101468 m0 *1 103.04,932.4
X$101468 14074 14073 11178 10549 10371 11179 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101482 r0 *1 259.28,942.48
X$101482 14074 14073 11331 11091 10371 11273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $101527 r0 *1 292.32,952.56
X$101527 14074 14073 11188 10371 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101534 m0 *1 119.28,942.48
X$101534 14074 11281 11632 10646 10373 14073 11346
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $101539 m0 *1 195.44,972.72
X$101539 14074 14073 11430 10374 12111 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101546 r0 *1 239.68,871.92
X$101546 14073 10375 10428 14074 10429 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101555 m0 *1 255.92,962.64
X$101555 14074 14073 11430 10376 11769 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101558 m0 *1 119.28,922.32
X$101558 14074 14073 11179 11086 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101563 m0 *1 52.64,972.72
X$101563 14074 14073 11856 10507 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101617 m0 *1 230.72,942.48
X$101617 14074 14073 11525 11403 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101619 m0 *1 157.36,922.32
X$101619 14074 14073 11088 10977 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101621 m0 *1 75.6,952.56
X$101621 14074 14073 11519 11565 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101624 r0 *1 48.72,902.16
X$101624 14074 14073 10975 10448 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101626 m0 *1 168.56,962.64
X$101626 14074 14073 11651 11637 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101628 m0 *1 180.32,912.24
X$101628 14074 14073 11089 10876 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101630 m0 *1 122.08,962.64
X$101630 14074 14073 11649 11569 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101635 m0 *1 313.6,882
X$101635 14074 14073 10527 10377 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101638 m0 *1 267.12,882
X$101638 14074 14073 10457 10458 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101642 m0 *1 48.72,962.64
X$101642 14074 14073 11785 10729 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101645 r0 *1 307.44,912.24
X$101645 14074 14073 10983 11054 10377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101661 m0 *1 393.12,942.48
X$101661 14074 14073 10378 11355 11283 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $101663 m0 *1 388.08,942.48
X$101663 14073 10378 11283 14074 11498 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101666 r0 *1 318.64,912.24
X$101666 14073 10378 10431 14074 10782 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $101682 m0 *1 306.88,902.16
X$101682 10779 14073 10558 10379 14074 10780 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $101684 r0 *1 324.24,912.24
X$101684 10985 14073 10558 10379 14074 10847 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $101749 m0 *1 588,1002.96
X$101749 14073 12126 10390 11442 12566 12286 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $101757 m0 *1 659.68,882
X$101757 14074 14073 10392 10479 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101770 m0 *1 748.16,892.08
X$101770 14074 14073 10756 10575 10394 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $101863 r0 *1 800.8,1023.12
X$101863 14074 12671 10395 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $101868 r0 *1 778.4,892.08
X$101868 14073 10396 10752 10575 10750 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $101875 m0 *1 789.04,892.08
X$101875 14073 10397 10751 10575 10694 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $101883 m0 *1 816.48,892.08
X$101883 14074 14073 10851 10575 10398 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $101902 m0 *1 932.4,892.08
X$101902 10590 14074 14073 10617 10402 10739 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $101906 m0 *1 949.76,892.08
X$101906 10592 14074 14073 10590 10403 10616 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $101908 r0 *1 946.96,882
X$101908 14074 14073 10403 10737 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101917 r0 *1 985.6,882
X$101917 14074 11129 10495 10405 10496 10734 14073
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* cell instance $101919 r0 *1 988.4,871.92
X$101919 14074 14073 10405 10406 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $101922 m0 *1 988.4,882
X$101922 10495 10406 10496 10494 10493 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $101932 r0 *1 1047.2,882
X$101932 14074 10600 10408 10610 10514 10601 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $101937 r0 *1 1118.88,871.92
X$101937 14074 14073 10415 10409 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $101942 r0 *1 1172.64,1002.96
X$101942 14074 10826 10411 14073 12314 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101944 r0 *1 1173.2,1023.12
X$101944 14074 10712 10411 14073 12613 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101946 m0 *1 1171.52,982.8
X$101946 14074 10915 10411 14073 11914 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101948 m0 *1 1157.52,1063.44
X$101948 14074 11471 10411 14073 13081 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101950 m0 *1 1101.52,1123.92
X$101950 14074 11216 10411 14073 13715 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101953 m0 *1 1127.28,1083.6
X$101953 14074 11222 10411 14073 13367 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101955 m0 *1 1145.2,1073.52
X$101955 14074 11016 10411 14073 13225 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101958 r0 *1 1111.04,1103.76
X$101958 14074 11305 10411 14073 13635 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101961 r0 *1 1169.84,1043.28
X$101961 14074 11472 10411 14073 12841 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $101963 r0 *1 1140.72,1113.84
X$101963 14074 14073 10411 11557 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $101974 r0 *1 1088.64,1123.92
X$101974 14074 14073 13817 12545 10411 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $101985 m0 *1 1128.4,912.24
X$101985 14074 10921 10822 11033 10414 11034 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $102008 r0 *1 937.44,882
X$102008 10492 14074 10419 14073 10584 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $102010 m0 *1 954.24,882
X$102010 14074 14073 10419 10491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $102126 m0 *1 190.96,982.8
X$102126 14074 11944 14073 10431 11920 11946 11791
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102129 r0 *1 291.2,1023.12
X$102129 14074 12575 14073 10431 12576 11946 12524
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102132 r0 *1 279.44,1013.04
X$102132 14074 12435 14073 10431 12495 11946 12211
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102138 m0 *1 192.64,1113.84
X$102138 14074 14073 10431 12110 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $102140 m0 *1 192.64,1123.92
X$102140 14074 14073 10431 12573 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $102142 m0 *1 260.96,1144.08
X$102142 14074 13736 14073 10431 13243 11946 13934
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102144 m0 *1 294.56,1134
X$102144 14074 13806 14073 10431 13063 11946 13974
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102147 m0 *1 241.36,1144.08
X$102147 14074 13658 14073 10431 12712 11946 13879
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102149 r0 *1 255.36,1134
X$102149 14074 13780 14073 10431 13465 11946 13971
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102151 m0 *1 292.32,1073.52
X$102151 14074 13119 14073 10431 13244 11946 13069
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102153 r0 *1 224,1053.36
X$102153 14074 12871 14073 10431 13091 11946 12947
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102155 r0 *1 288.4,1053.36
X$102155 14074 13062 14073 10431 13094 11946 12815
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102158 m0 *1 291.76,1083.6
X$102158 14074 12942 14073 10431 13385 11946 13000
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102160 r0 *1 285.04,1093.68
X$102160 14074 12728 14073 10431 13446 11946 12659
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102162 r0 *1 353.92,1053.36
X$102162 14074 13066 14073 10431 13099 10884 12951
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102164 r0 *1 367.92,1123.92
X$102164 14074 13781 14073 10431 13191 10884 13744
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102166 m0 *1 357.28,1123.92
X$102166 14074 13703 14073 10431 13175 10884 13743
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102168 m0 *1 325.92,1053.36
X$102168 14074 12880 14073 10431 12946 10884 12885
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102170 m0 *1 365.12,1073.52
X$102170 14074 13067 14073 10431 13123 10884 12813
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102172 m0 *1 325.92,1093.68
X$102172 14074 13411 14073 10431 11929 10884 13578
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102174 r0 *1 425.6,1023.12
X$102174 14074 12662 14073 10431 11722 10884 12582
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102176 m0 *1 332.08,1134
X$102176 14074 13739 14073 10431 12881 10884 13811
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102178 m0 *1 347.2,1154.16
X$102178 14074 13936 14073 10431 12004 10884 13940
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102180 m0 *1 318.08,1154.16
X$102180 14074 13882 14073 10431 12945 10884 13992
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102182 m0 *1 374.64,1154.16
X$102182 14074 13943 14073 10431 11716 10884 13942
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102184 r0 *1 340.48,1013.04
X$102184 14074 12359 14073 10431 12437 10884 12585
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102186 r0 *1 301.28,992.88
X$102186 14074 11953 14073 10431 12174 10884 12039
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102188 m0 *1 339.36,1043.28
X$102188 14074 12808 14073 10431 12882 10884 12584
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102199 r0 *1 713.44,871.92
X$102199 14074 14073 10435 10436 10433 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102230 m0 *1 390.88,892.08
X$102230 14074 10562 10462 14073 10563 10439 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $102261 m0 *1 50.96,882
X$102261 14073 10448 10506 14074 10508 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102264 m0 *1 81.2,982.8
X$102264 14074 14073 11430 10449 11941 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102288 r0 *1 185.92,932.4
X$102288 14074 14073 11182 11490 10454 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102333 m0 *1 427.84,912.24
X$102333 10464 10560 10787 10959 14074 14073 11060
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102343 r0 *1 478.8,962.64
X$102343 14074 11727 11604 11724 10788 11653 10468 11530 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $102357 m0 *1 553.84,882
X$102357 14074 14073 10537 10471 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $102367 r0 *1 565.6,972.72
X$102367 14074 10474 11199 11367 11806 11435 11805 11533 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $102376 r0 *1 574,1013.04
X$102376 14074 10475 11199 12527 12424 11439 12444 12445 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $102384 r0 *1 601.44,962.64
X$102384 14074 10476 11199 11605 11780 11439 11657 11536 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $102416 m0 *1 761.6,1043.28
X$102416 12821 10481 10628 12822 14074 14073 12529
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102418 m0 *1 751.52,1043.28
X$102418 12821 10481 10628 12890 14074 14073 12533
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102421 r0 *1 756.56,1043.28
X$102421 12955 10481 10628 12890 14074 14073 12130
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102423 m0 *1 757.68,1053.36
X$102423 12955 10481 10628 12822 14074 14073 12134
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102426 m0 *1 764.96,1053.36
X$102426 12955 10481 10628 12920 14074 14073 13008
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102429 m0 *1 750.4,1053.36
X$102429 12821 10481 10628 12920 14074 14073 13006
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102432 r0 *1 788.48,1043.28
X$102432 14073 10481 10628 14074 12671 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102434 m0 *1 784,1053.36
X$102434 12955 12741 10481 10628 14074 14073 13070
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102521 r0 *1 819.84,952.56
X$102521 14074 14073 11642 10482 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $102534 r0 *1 829.36,882
X$102534 14073 10748 10583 14074 10485 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102538 r0 *1 917.28,882
X$102538 10487 14074 14073 10619 10524 10486 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $102548 r0 *1 925.12,892.08
X$102548 10697 14074 14073 10741 10487 10800 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $102552 r0 *1 927.36,882
X$102552 10617 14074 14073 10522 10488 10741 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $102555 m0 *1 1023.12,892.08
X$102555 14074 10732 10601 10707 10706 10489 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $102562 r0 *1 952.56,882
X$102562 14074 10592 14073 10490 10616 10698 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $102575 r0 *1 939.12,892.08
X$102575 14074 10740 10589 10738 10737 10492 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $102579 m0 *1 977.76,892.08
X$102579 14074 10493 10593 14073 10700 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $102585 m0 *1 988.4,912.24
X$102585 14073 10912 10494 14074 11044 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $102594 m0 *1 1010.24,882
X$102594 14074 14073 10518 10496 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $102606 m0 *1 1089.2,892.08
X$102606 14074 10727 10498 10722 10610 10724 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $102608 m0 *1 1088.64,882
X$102608 14074 10498 10513 10607 10511 10512 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $102615 r0 *1 1120,902.16
X$102615 14074 10500 10925 10923 10920 10823 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $102623 r0 *1 1168.16,1023.12
X$102623 14074 14073 10826 12839 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102625 r0 *1 1169.28,1013.04
X$102625 14074 14073 10915 12614 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102627 r0 *1 1120,1073.52
X$102627 14074 14073 11471 13370 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102630 r0 *1 1092.56,1113.84
X$102630 14074 14073 11305 13674 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102632 m0 *1 1144.64,1063.44
X$102632 14074 14073 11472 13082 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102648 r0 *1 1154.16,1043.28
X$102648 14074 14073 10712 13084 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102650 m0 *1 1079.68,1134
X$102650 14073 11216 10503 14074 13785 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102653 m0 *1 1092,1144.08
X$102653 14073 12545 10503 14074 13849 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102655 r0 *1 1106,1103.76
X$102655 14074 14073 11222 13636 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102658 m0 *1 1118.32,1093.68
X$102658 14074 14073 11016 13424 10503 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102662 m0 *1 1066.8,952.56
X$102662 14074 11554 10503 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $102692 r0 *1 1122.8,882
X$102692 14074 14073 10509 10605 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $102697 r0 *1 1090.88,882
X$102697 14074 14073 10510 10606 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $102718 r0 *1 140.56,912.24
X$102718 10515 10648 11593 11042 14074 14073 10969
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $102784 r0 *1 758.24,902.16
X$102784 14074 14073 10853 10575 10532 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $102813 r0 *1 320.88,892.08
X$102813 10659 10540 10749 10660 10847 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $102827 r0 *1 81.2,932.4
X$102827 14074 11284 11321 10543 10615 14073 11396
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $102832 m0 *1 87.92,992.88
X$102832 14074 14073 11430 10544 12431 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102847 m0 *1 443.52,942.48
X$102847 14073 11356 11357 14074 10549 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $102868 r0 *1 278.32,962.64
X$102868 14074 14073 11713 11770 10549 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102870 r0 *1 80.64,1023.12
X$102870 14074 12647 14073 12104 12691 10549 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102872 r0 *1 117.6,1023.12
X$102872 14074 12115 14073 12571 12617 12327 10549
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $102894 r0 *1 213.36,942.48
X$102894 14074 10649 10555 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $102923 r0 *1 213.36,952.56
X$102923 14074 14073 10555 14139 gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* cell instance $102976 m0 *1 319.76,902.16
X$102976 14074 14073 10558 10658 10782 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $102978 m0 *1 320.88,922.32
X$102978 11353 14073 10558 10782 14074 10848 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $103011 r0 *1 393.68,892.08
X$103011 10665 14073 10754 10562 14074 10755 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $103039 r0 *1 516.88,932.4
X$103039 14073 10564 11195 14074 11366 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $103063 r0 *1 439.04,922.32
X$103063 14074 14073 10568 11255 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $103071 r0 *1 567.84,992.88
X$103071 14074 11534 14073 12262 12124 12125 10570 12220
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $103078 r0 *1 567.84,902.16
X$103078 14073 10570 10866 10894 10968 10969 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103080 m0 *1 585.2,952.56
X$103080 14074 14073 10571 11533 11534 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $103093 m0 *1 712.32,892.08
X$103093 14074 14073 10633 10575 10574 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $103095 m0 *1 658,892.08
X$103095 14074 14073 10636 10575 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103100 m0 *1 811.44,912.24
X$103100 14073 10693 14074 10582 11061 10575 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $103102 m0 *1 817.04,942.48
X$103102 14073 11210 11404 10575 11970 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103105 m0 *1 767.76,912.24
X$103105 14073 10692 10950 10575 10903 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103108 r0 *1 809.2,922.32
X$103108 14073 11007 11155 10575 11457 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103111 m0 *1 825.44,922.32
X$103111 14074 14073 11158 10575 10695 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $103114 r0 *1 725.76,922.32
X$103114 14073 10693 14074 11005 11163 10575 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $103117 r0 *1 742,922.32
X$103117 14073 11006 11116 10575 11541 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103120 r0 *1 710.64,902.16
X$103120 14074 14073 10864 10575 10689 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $103122 r0 *1 745.92,992.88
X$103122 14074 14073 12179 10575 12139 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $103177 m0 *1 777.28,942.48
X$103177 11296 14073 10575 11372 14074 11453 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $103180 m0 *1 814.8,922.32
X$103180 11257 10575 11158 10946 10577 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $103184 m0 *1 777.84,902.16
X$103184 14073 10580 10748 10575 11064 10693 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103186 r0 *1 750.4,1013.04
X$103186 14073 14074 12534 12532 10693 10575 12297 12298
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103188 m0 *1 657.44,1013.04
X$103188 14073 14074 12370 12528 10693 10575 12425 12447
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103191 r0 *1 655.2,1013.04
X$103191 14073 14074 12564 12446 10693 10575 12289 12290
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103194 m0 *1 703.92,992.88
X$103194 14073 14074 12049 12295 10693 10575 12135 11609
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103197 r0 *1 736.4,982.8
X$103197 14073 14074 12051 12372 10693 10575 12009 11733
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103199 m0 *1 713.44,982.8
X$103199 14073 14074 11883 11940 10693 10575 11884 11663
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103201 r0 *1 686.56,1013.04
X$103201 14073 14074 12563 12795 10693 10575 12132 12448
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103204 m0 *1 675.92,1013.04
X$103204 14073 14074 12499 12371 10693 10575 11851 12292
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103208 r0 *1 722.96,1013.04
X$103208 14073 14074 12531 12449 10693 10575 12498 12373
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103210 r0 *1 703.36,1013.04
X$103210 14073 14074 12530 12587 10693 10575 12252 12296
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103212 m0 *1 691.6,992.88
X$103212 14073 14074 12133 12293 10693 10575 12181 11811
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103215 m0 *1 664.72,982.8
X$103215 14073 14074 11965 11881 10693 10575 11662 11729
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103217 r0 *1 665.28,992.88
X$103217 14073 14074 12182 12291 10693 10575 11810 11966
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103219 r0 *1 657.44,982.8
X$103219 14073 14074 12047 11964 10693 10575 11880 11809
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $103221 r0 *1 717.36,882
X$103221 14073 10630 14074 10631 10633 10577 10576
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $103223 m0 *1 718.48,1073.52
X$103223 13006 12138 11117 10576 13314 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $103228 m0 *1 736.4,1013.04
X$103228 10577 14074 12450 12451 14073 12137 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $103230 r0 *1 716.24,902.16
X$103230 14073 10690 14074 10863 10864 10577 10797
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $103232 m0 *1 810.88,1013.04
X$103232 14074 14073 12376 10577 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $103234 r0 *1 751.52,992.88
X$103234 14073 14074 12179 10577 12422 12052 11459 12224
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $103255 r0 *1 761.6,942.48
X$103255 14074 14073 11454 11295 10577 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $103269 r0 *1 762.16,962.64
X$103269 11454 14074 10578 11665 14073 11735 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $103339 m0 *1 766.64,952.56
X$103339 14074 14073 11207 10579 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103342 r0 *1 770,952.56
X$103342 14074 14073 11643 10693 11372 10579 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $103426 r0 *1 822.08,1013.04
X$103426 14074 10581 14073 12642 12494 12536 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $103444 m0 *1 783.44,1033.2
X$103444 14073 10581 11372 14074 12668 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103446 m0 *1 785.12,1023.12
X$103446 14073 10581 12535 14074 12643 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103450 m0 *1 776.72,1013.04
X$103450 14074 14073 12375 10581 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103520 m0 *1 941.92,892.08
X$103520 14074 14073 10590 10740 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $103523 r0 *1 1020.88,892.08
X$103523 14074 10704 10730 10815 10705 10591 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103530 r0 *1 977.2,892.08
X$103530 14074 10593 10735 14073 10699 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $103541 m0 *1 978.32,902.16
X$103541 14074 10595 10812 10594 10910 10736 14073
+ gf180mcu_fd_sc_mcu9t5v0__and4_4
* cell instance $103551 r0 *1 982.24,902.16
X$103551 14074 10596 10813 14073 10843 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $103553 m0 *1 1011.36,892.08
X$103553 14074 10702 10596 10613 10597 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $103564 r0 *1 987.84,902.16
X$103564 14074 14073 10596 10912 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103574 r0 *1 1052.8,932.4
X$103574 14074 14073 10598 11320 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103577 r0 *1 1026.48,952.56
X$103577 14073 10598 11380 14074 11634 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103579 r0 *1 1037.12,922.32
X$103579 14074 11322 11218 11220 11219 10599 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103584 m0 *1 1048.32,892.08
X$103584 14074 10709 10600 10725 10728 10602 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103598 m0 *1 1083.04,892.08
X$103598 14074 14073 10710 10603 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $103605 m0 *1 1086.96,912.24
X$103605 14074 10605 10819 11039 10821 10927 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103608 m0 *1 1088.64,902.16
X$103608 14074 10606 10710 10821 10607 10820 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103613 m0 *1 1155.28,892.08
X$103613 14074 14073 10608 10833 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $103617 r0 *1 1169.84,892.08
X$103617 14074 10609 10829 10715 10714 10713 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $103630 m0 *1 59.36,892.08
X$103630 14073 10729 10612 14074 10614 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103672 m0 *1 246.4,892.08
X$103672 14074 14073 10622 10743 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $103689 r0 *1 398.72,912.24
X$103689 14073 10990 11066 10989 11286 10626 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103752 m0 *1 370.16,912.24
X$103752 10988 14073 10887 10634 14074 10885 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $103768 m0 *1 509.04,892.08
X$103768 10638 14074 14073 10640 10639 14106 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $103783 r0 *1 470.96,912.24
X$103783 14074 14073 10640 11357 10969 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $103811 m0 *1 58.24,1053.36
X$103811 14074 12987 14073 12104 13083 10645 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $103820 m0 *1 393.12,952.56
X$103820 14073 11431 11413 14074 10645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103839 m0 *1 184.24,1033.2
X$103839 14074 11952 14073 12803 12707 12349 10645
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $103841 m0 *1 113.68,1053.36
X$103841 14074 12115 14073 12934 13053 12327 10645
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $103865 m0 *1 278.32,992.88
X$103865 14074 10649 11275 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103872 r0 *1 226.8,1123.92
X$103872 14074 10649 12994 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103874 m0 *1 98,1093.68
X$103874 14074 10649 12477 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103876 m0 *1 84.56,972.72
X$103876 14074 10649 11176 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103878 r0 *1 353.92,1103.76
X$103878 14074 10649 12438 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103880 m0 *1 447.44,1073.52
X$103880 14074 10649 12036 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* cell instance $103885 m0 *1 353.92,952.56
X$103885 14074 10649 14073 gf180mcu_fd_sc_mcu9t5v0__inv_20
* cell instance $103890 m0 *1 203.84,952.56
X$103890 14074 14073 11430 10650 11573 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $103912 r0 *1 310.24,892.08
X$103912 14073 10654 10659 14074 10657 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $103923 m0 *1 313.04,902.16
X$103923 10656 14074 10657 10780 14073 10845 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $103930 m0 *1 318.64,912.24
X$103930 14073 10658 10846 10881 10945 10882 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $103977 r0 *1 385.84,972.72
X$103977 10665 11095 11343 11355 14073 14074 11874
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $103979 m0 *1 386.4,972.72
X$103979 14074 11798 11355 14073 11343 10665 11095
+ gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $103991 r0 *1 399.84,962.64
X$103991 11527 10665 11095 11355 14073 14074 11719
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $103993 r0 *1 407.68,922.32
X$103993 14074 11251 11096 14073 10666 11097 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $104002 m0 *1 400.96,922.32
X$104002 14074 14073 10666 10989 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104030 r0 *1 480.48,1023.12
X$104030 14074 12364 11604 12041 11173 11653 10672 11601 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104063 m0 *1 563.92,962.64
X$104063 14074 10680 11199 11367 11603 11435 11708 11441 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104079 r0 *1 602.56,1002.96
X$104079 14074 10684 11199 12219 12369 11435 12222 12288 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104082 r0 *1 631.12,902.16
X$104082 14074 10685 14073 10871 10870 10873 10901
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $104087 m0 *1 640.64,922.32
X$104087 14074 14073 10686 11117 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104094 r0 *1 683.76,892.08
X$104094 10688 14074 14073 10757 10758 14120 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $104156 m0 *1 790.16,1023.12
X$104156 14074 14073 12453 12643 11372 10693 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104158 r0 *1 811.44,1013.04
X$104158 14074 14073 12376 10693 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104182 m0 *1 825.44,932.4
X$104182 14074 11256 14073 11252 11254 10693 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $104184 m0 *1 784,1073.52
X$104184 13201 14074 11117 13129 14073 10694 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $104201 r0 *1 842.8,892.08
X$104201 14073 10696 10746 14074 10745 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $104208 m0 *1 952.56,902.16
X$104208 14074 14073 10810 10698 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104223 m0 *1 981.12,912.24
X$104223 14074 10813 14073 11045 10700 10912 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $104225 m0 *1 1013.04,902.16
X$104225 14074 10703 10701 10814 10835 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $104228 r0 *1 994,912.24
X$104228 14073 10701 10813 14074 11015 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $104231 r0 *1 985.6,892.08
X$104231 14074 14073 10701 10812 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104241 r0 *1 999.6,902.16
X$104241 14074 14073 10702 10813 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104246 m0 *1 1002.96,902.16
X$104246 14074 14073 10703 10811 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104256 r0 *1 1037.68,892.08
X$104256 14074 10707 10724 10816 10730 10708 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104261 m0 *1 1042.72,902.16
X$104261 14074 14073 10839 10708 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104267 m0 *1 1134.56,952.56
X$104267 14074 10712 10711 14073 11469 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104269 m0 *1 1103.2,1013.04
X$104269 14074 11016 10711 14073 12398 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104271 m0 *1 1104.32,1033.2
X$104271 14074 11222 10711 14073 12690 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104273 r0 *1 1089.76,1033.2
X$104273 14074 11305 10711 14073 12756 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104275 r0 *1 1140.16,972.72
X$104275 14074 11472 10711 14073 11833 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104277 r0 *1 1129.52,992.88
X$104277 14074 11471 10711 14073 12231 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104297 m0 *1 1081.36,1073.52
X$104297 14074 14073 13233 12545 10711 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104299 r0 *1 1079.12,1043.28
X$104299 14074 14073 12965 11216 10711 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104301 r0 *1 1156.96,912.24
X$104301 14074 14073 11030 10826 10711 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104307 m0 *1 1152.48,1013.04
X$104307 14074 14073 12475 10712 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104312 m0 *1 1177.12,992.88
X$104312 14074 14073 12074 10712 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104314 r0 *1 1167.04,952.56
X$104314 14074 14073 11623 10712 10717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104336 r0 *1 1169.84,932.4
X$104336 14074 10715 11138 11386 11310 11229 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104347 m0 *1 1143.52,1033.2
X$104347 14074 14073 12768 10717 11016 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104350 m0 *1 1131.76,1063.44
X$104350 14074 14073 13078 10717 11222 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104352 r0 *1 1098.72,1073.52
X$104352 14074 14073 13218 10717 11305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104354 r0 *1 1075.76,1093.68
X$104354 14074 14073 13539 10717 12545 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104356 m0 *1 1102.64,1093.68
X$104356 14074 14073 13495 10717 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104372 r0 *1 1168.16,992.88
X$104372 14074 14073 12156 11472 10717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104376 r0 *1 1164.24,932.4
X$104376 14074 14073 11390 10826 10717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104379 m0 *1 1168.16,912.24
X$104379 14074 14073 11029 10915 10717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104381 m0 *1 1156.96,1023.12
X$104381 14074 14073 12547 11471 10717 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104394 r0 *1 1098.72,892.08
X$104394 14074 10723 10727 10720 10721 10725 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104396 r0 *1 1065.12,902.16
X$104396 14074 10836 10721 10930 10818 10817 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104401 r0 *1 1098.72,902.16
X$104401 14074 10834 10820 10926 10722 10928 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104463 m0 *1 946.4,892.08
X$104463 14074 14073 10810 10738 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104513 r0 *1 781.2,1063.44
X$104513 13200 14074 11117 13174 14073 10750 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $104527 r0 *1 776.16,902.16
X$104527 14073 10950 10753 14074 10801 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $104605 m0 *1 160.72,912.24
X$104605 14074 14073 10977 11043 10772 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $104613 r0 *1 182,902.16
X$104613 10876 14073 10774 11046 14074 10840 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $104617 r0 *1 266.56,902.16
X$104617 14074 14073 10982 10776 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104644 m0 *1 333.76,972.72
X$104644 14074 14073 11430 10781 11847 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $104650 r0 *1 327.04,962.64
X$104650 14073 11430 11774 14074 10783 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $104662 r0 *1 334.32,902.16
X$104662 14074 14073 10784 10882 10883 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $104666 r0 *1 370.16,912.24
X$104666 10886 14073 10988 10887 14074 10785 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $104671 m0 *1 353.92,912.24
X$104671 14074 10880 14073 11060 11062 10785 10986
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $104679 m0 *1 307.44,912.24
X$104679 14074 10786 10844 11054 10984 14073 10944
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $104686 m0 *1 480.48,962.64
X$104686 14074 14073 11707 10788 11653 11530 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104696 m0 *1 543.2,1023.12
X$104696 14074 12219 11359 11197 11438 11653 10790 11725 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104698 m0 *1 562.24,1023.12
X$104698 14074 12127 11604 11367 10790 11653 11197 11438 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104700 r0 *1 545.44,1023.12
X$104700 14074 12527 11604 11197 12218 11361 11725 10790 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $104702 m0 *1 562.24,1002.96
X$104702 14074 14073 12367 10790 11653 11438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104712 r0 *1 609.28,952.56
X$104712 14074 14073 10792 11536 11534 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104737 m0 *1 716.24,1053.36
X$104737 13006 12136 11117 10797 13007 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $104743 m0 *1 732.48,902.16
X$104743 14074 14073 10861 10902 10798 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $104748 r0 *1 754.32,1063.44
X$104748 13010 12294 11117 10799 13198 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $104772 m0 *1 893.2,912.24
X$104772 14074 14073 10804 10803 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104776 m0 *1 892.08,982.8
X$104776 14074 14073 11976 11977 10804 11671 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104778 r0 *1 899.36,982.8
X$104778 14074 14073 12059 12094 10804 11673 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $104785 m0 *1 858.48,942.48
X$104785 11402 10804 11401 11374 11499 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $104809 m0 *1 734.72,982.8
X$104809 14074 14073 11371 10804 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104819 m0 *1 834.96,922.32
X$104819 14074 10804 14073 11010 11009 11155 11120 11156
+ gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* cell instance $104822 m0 *1 745.92,922.32
X$104822 14073 11116 11162 14074 10805 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $104851 m0 *1 964.32,912.24
X$104851 10811 14074 10910 10934 14073 11014 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $104853 r0 *1 964.32,902.16
X$104853 14074 10811 10911 14073 10937 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $104858 r0 *1 974.96,902.16
X$104858 14074 10811 14073 11128 10843 10812 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $104867 m0 *1 971.04,912.24
X$104867 14073 10812 11045 14074 11047 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $104882 m0 *1 1083.6,902.16
X$104882 14074 14073 10819 10814 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104884 m0 *1 1031.52,932.4
X$104884 14074 11217 11040 11319 10815 11306 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104889 m0 *1 1070.16,912.24
X$104889 14074 11018 10928 11019 10816 11040 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104911 r0 *1 1165.36,902.16
X$104911 14074 14073 10824 10917 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104913 r0 *1 1169.84,902.16
X$104913 14074 14073 10916 10825 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104923 m0 *1 1171.52,972.72
X$104923 14074 14073 11752 10826 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104926 r0 *1 1162.56,992.88
X$104926 14074 14073 12155 10826 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $104942 r0 *1 1173.2,912.24
X$104942 14074 14073 10827 11027 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104964 r0 *1 1140.72,902.16
X$104964 14074 14073 10832 10920 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $104970 r0 *1 1144.08,902.16
X$104970 14074 14073 10833 10919 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $104988 r0 *1 1028.16,902.16
X$104988 14074 10841 10839 10838 10933 10914 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $104991 r0 *1 1056.16,902.16
X$104991 14074 14073 10838 10931 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $105049 m0 *1 357.28,942.48
X$105049 14074 14073 11427 11408 10850 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105122 m0 *1 569.52,982.8
X$105122 14074 12124 14073 10867 11938 11199 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $105140 r0 *1 658.56,902.16
X$105140 10898 14074 14073 10961 10872 14119 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $105155 m0 *1 108.08,1144.08
X$105155 14074 13771 14073 12104 13875 10875 12189
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $105160 r0 *1 350,942.48
X$105160 14073 11426 11282 14074 10875 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $105178 m0 *1 231.84,1083.6
X$105178 14073 10875 12349 14074 13306 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $105180 m0 *1 134.4,1134
X$105180 14074 12115 14073 13769 13789 12327 10875
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $105189 m0 *1 273.84,912.24
X$105189 14073 10878 10940 14074 10942 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $105200 r0 *1 313.6,912.24
X$105200 14074 14073 10983 10881 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $105214 m0 *1 378.56,912.24
X$105214 14074 14073 10889 10953 10883 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105262 m0 *1 300.16,1123.92
X$105262 14074 14073 10884 11946 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $105342 r0 *1 607.6,912.24
X$105342 14074 14073 11078 11076 10896 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105345 m0 *1 609.84,992.88
X$105345 14074 14073 10897 12127 11534 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $105361 m0 *1 686,912.24
X$105361 10956 14074 14073 10955 10900 14099 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $105376 r0 *1 772.24,1053.36
X$105376 13039 14074 11117 13009 14073 10903 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $105384 m0 *1 801.36,1063.44
X$105384 13070 12294 11117 10905 13274 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $105392 m0 *1 838.32,932.4
X$105392 14074 10906 14073 11334 11252 11213 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $105395 m0 *1 901.04,912.24
X$105395 14074 14073 10939 10908 10907 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105399 m0 *1 956.48,922.32
X$105399 14073 10909 14074 11125 11246 11126 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $105403 r0 *1 960.96,922.32
X$105403 14074 14073 10911 10909 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $105405 m0 *1 957.04,912.24
X$105405 14074 11013 14073 11048 10909 11126 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $105412 r0 *1 952.56,912.24
X$105412 14074 10937 11048 11377 10934 10910 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $105418 m0 *1 977.2,922.32
X$105418 14074 14073 11131 10911 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $105421 m0 *1 964.32,922.32
X$105421 14074 10911 14073 11149 11014 11127 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $105429 m0 *1 999.04,912.24
X$105429 14074 11015 10913 14073 10934 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $105438 m0 *1 1172.08,932.4
X$105438 14074 14073 11384 10915 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105442 m0 *1 1163.68,972.72
X$105442 14074 14073 11751 10915 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105463 m0 *1 1151.36,912.24
X$105463 14074 11023 10918 10916 11029 11030 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $105471 m0 *1 1145.2,912.24
X$105471 14074 14073 10918 10921 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $105482 m0 *1 1096.48,1083.6
X$105482 14073 10919 13077 14074 13365 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $105484 m0 *1 1121.12,1063.44
X$105484 14073 10919 11132 14074 13147 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $105499 r0 *1 1099.28,922.32
X$105499 14074 11235 11133 11146 10923 11037 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $105510 m0 *1 1103.76,912.24
X$105510 14074 10925 10927 11037 10926 11035 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $105529 r0 *1 1069.6,912.24
X$105529 14074 10930 11018 11020 11017 10931 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $105624 r0 *1 792.96,1063.44
X$105624 13010 12131 11117 10949 13273 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $105702 r0 *1 577.36,1002.96
X$105702 14074 14073 10965 11366 12368 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105799 m0 *1 310.24,972.72
X$105799 14074 14073 11430 10984 11796 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105824 r0 *1 408.24,912.24
X$105824 14074 10989 10990 14073 11067 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $105864 m0 *1 538.16,952.56
X$105864 14074 11533 11361 11531 11077 11359 11436 10997 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $105866 r0 *1 540.4,952.56
X$105866 14074 11605 11359 11531 10997 11193 11077 11602 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $105873 r0 *1 549.92,932.4
X$105873 14074 14073 11363 11193 10997 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105876 r0 *1 532,952.56
X$105876 14074 14073 11644 11436 11361 10997 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $105878 m0 *1 554.96,1013.04
X$105878 14074 10998 11199 12125 12366 11435 12365 12262 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $105888 r0 *1 554.4,1013.04
X$105888 14074 10999 11435 12127 12442 11199 12364 12443 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $105897 r0 *1 582.96,1002.96
X$105897 11366 14073 12285 12336 14074 11000 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $105905 m0 *1 609.84,972.72
X$105905 14074 14073 11001 11854 11435 11808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $105916 m0 *1 719.04,922.32
X$105916 14073 11004 14074 11163 11068 11115 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $105936 r0 *1 813.68,1063.44
X$105936 13070 12131 11117 11008 13205 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $105946 m0 *1 888.72,942.48
X$105946 14074 14073 11400 11399 11011 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $105954 r0 *1 957.6,922.32
X$105954 14074 14073 11124 11013 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $105962 m0 *1 1062.32,982.8
X$105962 14074 11016 11903 14073 11902 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $105969 m0 *1 1139.04,1063.44
X$105969 14074 14073 13079 11016 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105972 r0 *1 1112.72,1063.44
X$105972 14074 14073 13221 11016 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $105994 m0 *1 1066.8,932.4
X$105994 14074 11221 11017 11224 11223 11318 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106001 m0 *1 1093.68,922.32
X$106001 14074 11395 11035 11225 11019 11145 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106006 m0 *1 1117.2,922.32
X$106006 14074 11033 11145 11141 11134 11020 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106011 r0 *1 1128.96,912.24
X$106011 14074 11135 11034 11227 11022 11021 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106018 r0 *1 1148.56,912.24
X$106018 14073 11024 11136 14074 11023 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106021 m0 *1 1154.72,992.88
X$106021 14074 11024 11629 14073 12157 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106029 r0 *1 1155.28,982.8
X$106029 14074 14073 11024 11913 12075 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106031 m0 *1 1153.04,952.56
X$106031 14074 14073 11024 11475 11557 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106033 r0 *1 1158.64,942.48
X$106033 14073 11024 11621 14074 11474 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106037 r0 *1 1151.92,922.32
X$106037 14074 11025 11232 11140 11230 11137 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106041 r0 *1 1166.48,942.48
X$106041 14074 11026 11310 11622 11476 11475 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106044 r0 *1 1168.72,922.32
X$106044 11308 14074 14073 11027 11139 11230 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $106092 r0 *1 1010.24,912.24
X$106092 14074 14073 11039 11147 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106103 m0 *1 124.32,922.32
X$106103 14073 11086 11150 14074 11042 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106134 m0 *1 946.96,922.32
X$106134 14073 11124 11149 14074 11050 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $106146 r0 *1 924,1043.28
X$106146 14074 14073 11051 12898 13034 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $106188 r0 *1 333.2,942.48
X$106188 14074 14073 11354 11058 11188 11279 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $106199 r0 *1 352.8,1154.16
X$106199 14074 12115 14073 13965 13984 12116 11058
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $106202 r0 *1 381.36,1154.16
X$106202 14074 12189 14073 11058 13977 12104 13942
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $106220 r0 *1 357.28,922.32
X$106220 14074 11249 11062 11063 11094 14073 11159
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $106227 m0 *1 770.56,1073.52
X$106227 13199 14074 11117 13248 14073 11064 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $106281 r0 *1 538.16,972.72
X$106281 14074 11807 11604 11531 11877 11361 11602 11077 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $106293 m0 *1 540.4,942.48
X$106293 14074 14073 11507 11361 11077 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $106302 r0 *1 431.76,932.4
X$106302 14074 11249 14073 11078 11600 11288 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $106320 r0 *1 58.24,952.56
X$106320 14074 14073 11082 11831 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106333 m0 *1 86.24,982.8
X$106333 14074 14073 11430 11085 11858 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106355 r0 *1 448.56,942.48
X$106355 14073 11432 11433 14074 11091 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106362 m0 *1 323.68,1164.24
X$106362 14074 13983 14073 14005 12116 11091 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $106375 r0 *1 362.88,1164.24
X$106375 14074 12189 14073 11091 14053 12104 13992
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $106380 r0 *1 324.8,932.4
X$106380 11408 14073 11092 11277 14074 11335 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $106402 m0 *1 401.52,972.72
X$106402 14074 14073 11718 11717 11095 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $106406 r0 *1 379.12,982.8
X$106406 11095 14073 11873 12176 14074 11717 gf180mcu_fd_sc_mcu9t5v0__nor3_4
* cell instance $106408 m0 *1 385.84,982.8
X$106408 11717 11095 11343 11355 14073 14074 11867
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $106443 r0 *1 565.6,932.4
X$106443 14074 14073 11199 11102 11291 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106450 r0 *1 550.48,1002.96
X$106450 14074 11104 11199 11367 12262 11435 12366 12125 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $106499 r0 *1 716.8,1063.44
X$106499 13006 12131 11117 11115 13195 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $106505 m0 *1 659.12,1033.2
X$106505 14074 12737 11117 14073 12528 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106508 r0 *1 656.32,1023.12
X$106508 14074 12586 11117 14073 11964 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106510 m0 *1 653.52,1033.2
X$106510 14074 12736 11117 14073 12446 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106513 m0 *1 805.28,932.4
X$106513 14074 14073 11254 11118 11117 11502 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $106515 m0 *1 731.92,1073.52
X$106515 14074 13196 11117 14073 12372 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106517 m0 *1 673.12,1063.44
X$106517 14074 13127 11117 14073 12371 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106520 m0 *1 691.04,1063.44
X$106520 14074 13128 11117 14073 12293 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106523 m0 *1 702.8,1073.52
X$106523 14074 13194 11117 14073 12295 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106525 r0 *1 705.6,1023.12
X$106525 14074 12665 11117 14073 12587 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106527 r0 *1 686,1033.2
X$106527 14074 12818 11117 14073 12795 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106529 m0 *1 720.16,1033.2
X$106529 14074 12740 11117 14073 12449 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106532 m0 *1 710.08,1033.2
X$106532 14074 12739 11117 14073 11940 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106535 r0 *1 748.16,1023.12
X$106535 14074 12667 11117 14073 12532 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106537 m0 *1 811.44,1023.12
X$106537 12536 14074 11117 12590 14073 11457 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $106542 m0 *1 665.84,1053.36
X$106542 14074 13003 11117 14073 12291 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106544 m0 *1 660.24,1053.36
X$106544 14074 13002 11117 14073 11881 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106547 m0 *1 817.6,1073.52
X$106547 13204 14074 11117 13246 14073 11970 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $106585 m0 *1 744.24,1033.2
X$106585 12533 12131 11117 12422 12820 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $106587 m0 *1 729.12,1023.12
X$106587 12533 12294 11117 12451 12666 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $106591 r0 *1 741.44,1063.44
X$106591 13197 14074 11117 13177 14073 11541 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $106623 m0 *1 887.04,932.4
X$106623 14074 14073 11122 11332 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $106625 r0 *1 948.08,922.32
X$106625 14073 11127 11125 14074 11123 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $106630 r0 *1 973.28,932.4
X$106630 14074 11324 11214 14073 11124 11300 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $106634 m0 *1 949.2,932.4
X$106634 11246 11124 11301 11325 11300 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $106639 r0 *1 965.44,932.4
X$106639 14074 14073 11302 11124 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $106643 m0 *1 971.6,922.32
X$106643 14074 11129 11128 14073 11125 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106651 m0 *1 961.52,932.4
X$106651 14074 14073 11214 11126 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106655 r0 *1 964.32,922.32
X$106655 14074 14073 11214 11127 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $106664 m0 *1 966,932.4
X$106664 14074 11324 11130 11299 11128 11129 14073
+ gf180mcu_fd_sc_mcu9t5v0__oai31_4
* cell instance $106672 r0 *1 981.68,922.32
X$106672 14074 11242 14073 11130 11215 11300 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $106675 r0 *1 986.72,932.4
X$106675 11302 14073 11303 11131 14074 11242 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $106677 m0 *1 986.16,922.32
X$106677 14074 11131 11214 11147 11148 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $106682 r0 *1 1084.16,1113.84
X$106682 14074 11132 11629 14073 13673 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $106684 m0 *1 1104.88,1073.52
X$106684 14073 11136 11132 14074 13228 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106704 r0 *1 1100.96,1103.76
X$106704 14073 13586 11132 14074 13542 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106707 m0 *1 1123.92,1113.84
X$106707 14074 14073 11132 13631 12075 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106709 m0 *1 1125.6,1103.76
X$106709 14074 14073 11132 13491 11557 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106711 m0 *1 1054.48,972.72
X$106711 14074 14073 11824 11825 11132 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106718 r0 *1 1062.88,932.4
X$106718 14074 14073 11320 11318 11132 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $106723 m0 *1 1022,922.32
X$106723 14074 14073 11133 11148 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106727 m0 *1 1130.08,932.4
X$106727 14074 11233 11134 11311 11227 11226 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $106741 m0 *1 1096.48,1093.68
X$106741 14073 11136 13077 14074 13496 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $106744 m0 *1 1156.4,922.32
X$106744 14074 14073 11141 11137 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106752 m0 *1 1167.6,922.32
X$106752 14074 14073 11138 11139 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106761 r0 *1 1148.56,922.32
X$106761 14074 14073 11140 11312 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106811 r0 *1 1005.76,922.32
X$106811 14074 14073 11146 11241 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $106924 r0 *1 480.48,1013.04
X$106924 14074 12365 11604 12215 11601 11653 11173 12041 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $107001 r0 *1 87.92,972.72
X$107001 14074 14073 11176 14165 gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* cell instance $107024 m0 *1 170.8,992.88
X$107024 14073 11430 12016 14074 11181 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107033 m0 *1 230.16,932.4
X$107033 14074 14073 11183 11240 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107049 m0 *1 268.8,932.4
X$107049 14073 11187 11243 14074 11333 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107097 m0 *1 492.8,932.4
X$107097 14074 14073 11260 11192 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107101 r0 *1 494.48,932.4
X$107101 14073 11192 11289 14074 11290 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107112 r0 *1 510.72,952.56
X$107112 14074 14073 11193 11653 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $107116 r0 *1 510.72,932.4
X$107116 14074 14073 11345 11194 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107125 m0 *1 535.92,1013.04
X$107125 14074 12262 11604 11197 12218 11653 12284 11725 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $107139 r0 *1 561.68,952.56
X$107139 14074 14073 11198 11603 11435 11441 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107142 r0 *1 621.04,932.4
X$107142 14074 14073 11203 11198 11199 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107150 m0 *1 570.64,1002.96
X$107150 14073 11199 11439 14074 12220 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107152 r0 *1 593.04,1013.04
X$107152 14074 12566 11199 14073 11435 12527 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $107157 m0 *1 590.8,972.72
X$107157 14074 14073 11854 11779 11199 11807 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107159 m0 *1 610.4,982.8
X$107159 14074 14073 11879 11807 11199 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107161 m0 *1 600.32,972.72
X$107161 14073 11532 11369 11435 11728 11199 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107164 m0 *1 621.04,1002.96
X$107164 14074 14073 11606 12259 11199 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107166 m0 *1 607.6,962.64
X$107166 14074 11537 11435 11367 11536 11199 11657 11605 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $107202 r0 *1 603.68,992.88
X$107202 14073 11199 11435 14074 11534 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107204 r0 *1 592.48,972.72
X$107204 14074 14073 11808 11878 11199 11532 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107207 r0 *1 600.88,1013.04
X$107207 14074 11368 11199 11367 12442 11435 12443 12127 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $107209 m0 *1 603.12,1002.96
X$107209 14074 14073 11199 11444 12287 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107212 m0 *1 609.28,1013.04
X$107212 14074 11446 11199 11367 12288 11435 12369 12219 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $107234 r0 *1 568.4,942.48
X$107234 14073 11509 14074 11200 11439 11366 11441
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $107238 m0 *1 570.64,942.48
X$107238 14074 11366 11342 14073 11201 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107241 m0 *1 600.88,952.56
X$107241 14073 11535 11369 14074 11202 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107273 m0 *1 790.72,932.4
X$107273 14073 11209 14074 11211 11259 11296 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $107285 r0 *1 833.28,942.48
X$107285 11211 11404 11213 11542 14074 14073 11499
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $107287 m0 *1 832.72,932.4
X$107287 14074 14073 11211 11212 11213 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107297 r0 *1 840.56,942.48
X$107297 14074 14073 11213 11400 11459 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107310 m0 *1 986.16,932.4
X$107310 14074 11215 11302 11241 11239 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $107315 r0 *1 957.6,932.4
X$107315 14074 14073 11215 11301 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $107320 m0 *1 1062.88,1002.96
X$107320 14074 14073 12310 11216 11903 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107344 m0 *1 1073.52,1103.76
X$107344 14074 14073 13547 13422 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107349 m0 *1 1084.72,1083.6
X$107349 14074 14073 13363 11228 11216 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107355 r0 *1 1033.76,922.32
X$107355 14074 14073 11218 11217 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107363 r0 *1 1055.6,922.32
X$107363 14074 14073 11220 11317 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107375 m0 *1 1067.92,982.8
X$107375 14074 11222 11903 14073 11904 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107380 m0 *1 1126.16,1063.44
X$107380 14074 14073 13222 11222 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107383 r0 *1 1089.2,1073.52
X$107383 14074 14073 13284 11222 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107409 r0 *1 1079.12,932.4
X$107409 14074 11224 11397 11313 11381 11317 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $107411 m0 *1 1098.72,932.4
X$107411 14074 11234 11235 11314 11225 11236 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $107415 m0 *1 1132.88,942.48
X$107415 14074 11469 11226 11473 11482 11383 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $107423 r0 *1 1079.12,1103.76
X$107423 14074 14073 13628 11228 12545 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107425 m0 *1 1109.36,1093.68
X$107425 14074 14073 13486 11228 11305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107450 m0 *1 1164.24,1023.12
X$107450 14074 14073 12548 11472 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107452 m0 *1 1152.48,1033.2
X$107452 14074 14073 12761 11471 11228 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $107454 m0 *1 1179.92,932.4
X$107454 14074 14073 11385 11229 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107467 r0 *1 1145.2,922.32
X$107467 14074 14073 11232 11234 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107473 m0 *1 1150.24,932.4
X$107473 14074 14073 11391 11233 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107485 m0 *1 1092.56,942.48
X$107485 14074 11392 11236 11467 11393 11394 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $107488 r0 *1 1098.72,932.4
X$107488 14074 11465 11237 11316 11314 11312 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $107491 m0 *1 1023.68,932.4
X$107491 14074 14073 11237 11239 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107534 r0 *1 1070.16,1013.04
X$107534 14074 14073 11244 12545 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $107577 r0 *1 400.4,1043.28
X$107577 14073 14074 11875 12921 11251 12922 12497 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai221_2
* cell instance $107604 m0 *1 804.16,1073.52
X$107604 14074 13203 14073 11257 13010 12138 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $107653 m0 *1 79.52,942.48
X$107653 14073 11565 11270 14074 11396 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107657 r0 *1 205.52,942.48
X$107657 14074 14073 11271 11348 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $107706 r0 *1 278.32,992.88
X$107706 14074 11275 14179 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $107738 m0 *1 338.8,972.72
X$107738 14074 14073 11430 11278 11868 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107789 r0 *1 369.6,972.72
X$107789 14073 11932 11849 11872 11285 11598 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107791 r0 *1 371.84,982.8
X$107791 14073 11285 11528 14074 12033 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $107793 m0 *1 369.6,982.8
X$107793 14073 11957 11933 11958 11285 11598 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107797 r0 *1 404.88,952.56
X$107797 14073 11285 14074 11528 11286 11598 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $107814 r0 *1 398.72,982.8
X$107814 14074 14073 11285 11875 11528 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107816 m0 *1 393.68,982.8
X$107816 14074 14073 11285 11954 11598 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107818 r0 *1 360.08,972.72
X$107818 14073 11870 11799 11931 11285 11528 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107820 r0 *1 360.08,982.8
X$107820 14073 12175 11850 11956 11285 11528 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107862 m0 *1 572.32,992.88
X$107862 14074 14073 11291 12125 11435 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $107877 m0 *1 700,1013.04
X$107877 11294 14073 14074 14079 gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* cell instance $107958 r0 *1 774.48,942.48
X$107958 14074 14073 11296 11504 11372 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $107961 m0 *1 874.16,1002.96
X$107961 14074 11297 12248 14073 12247 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107969 m0 *1 941.36,952.56
X$107969 14074 11378 11298 14073 11615 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107972 r0 *1 942.48,932.4
X$107972 14074 14073 11299 11298 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $107974 m0 *1 946.4,982.8
X$107974 14074 11299 11815 14073 11897 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107978 r0 *1 945.28,982.8
X$107978 14073 11299 12143 11815 11819 12060 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $107983 r0 *1 954.8,942.48
X$107983 14074 11300 11378 14073 11577 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $107985 r0 *1 947.52,942.48
X$107985 14074 11378 14073 11493 11376 11300 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $107996 r0 *1 994,932.4
X$107996 14074 14073 11303 11300 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $107998 m0 *1 946.96,952.56
X$107998 11616 14073 14074 11378 11301 11547 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $108005 m0 *1 956.48,942.48
X$108005 14074 14073 11301 11398 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108014 m0 *1 986.16,942.48
X$108014 14074 11378 11303 11304 11379 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $108020 r0 *1 1011.92,932.4
X$108020 14074 14073 11316 11304 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108027 m0 *1 1061.76,992.88
X$108027 14074 11305 11903 14073 12067 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $108059 m0 *1 1074.08,1093.68
X$108059 14074 14073 13428 13422 11305 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $108070 m0 *1 1036.56,942.48
X$108070 14074 14073 11572 11306 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108073 m0 *1 1045.52,952.56
X$108073 14074 11571 11552 11553 11570 11307 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108080 r0 *1 1124.48,942.48
X$108080 14074 11308 11468 11485 11481 11470 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108092 m0 *1 1113.84,942.48
X$108092 14074 11311 11392 11556 11382 11313 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108125 m0 *1 1075.76,942.48
X$108125 14074 11568 11395 11393 11319 11397 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108132 r0 *1 93.52,952.56
X$108132 14074 14073 11430 11321 11694 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108151 r0 *1 205.52,932.4
X$108151 14074 14073 11327 11326 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108162 r0 *1 938,942.48
X$108162 14073 11546 11493 14074 11328 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $108168 m0 *1 244.72,952.56
X$108168 14074 14073 11430 11329 11526 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108212 m0 *1 866.88,992.88
X$108212 14074 11330 14172 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $108271 m0 *1 504.56,962.64
X$108271 14074 11342 11435 11656 11707 11359 11654 11655 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108297 r0 *1 122.08,942.48
X$108297 14073 11569 11486 14074 11346 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $108313 r0 *1 210,942.48
X$108313 14074 14073 11349 11491 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108323 m0 *1 311.36,952.56
X$108323 14074 14073 11430 11352 11582 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108361 m0 *1 556.08,942.48
X$108361 14074 14073 11365 11364 11359 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108363 r0 *1 547.12,942.48
X$108363 14073 14074 11363 11359 11507 11364 11441 11440
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $108365 m0 *1 524.16,962.64
X$108365 14074 14073 11708 11655 11359 11656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108382 m0 *1 524.16,1023.12
X$108382 14074 12288 11359 12217 12218 11653 12284 12216 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108387 m0 *1 488.32,982.8
X$108387 14074 11805 11359 11801 11876 11653 11802 11800 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108391 m0 *1 486.08,1023.12
X$108391 14074 12369 11359 12215 12213 11653 12214 12041 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108399 r0 *1 537.04,982.8
X$108399 14074 14073 11804 11877 11361 11963 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108403 m0 *1 506.24,972.72
X$108403 14074 14073 11656 11802 11361 11801 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108431 r0 *1 515.2,1013.04
X$108431 14074 12444 11604 12217 12213 11361 12216 12284 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108434 m0 *1 493.36,1013.04
X$108434 14074 12424 11604 12215 11601 11361 12041 12214 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $108455 m0 *1 594.16,952.56
X$108455 14073 11365 11443 14074 11536 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $108458 r0 *1 589.68,942.48
X$108458 14074 11435 14073 11589 11443 11365 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $108465 r0 *1 589.12,1002.96
X$108465 11366 11435 12221 12335 14073 14074 12286
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $108468 r0 *1 584.08,992.88
X$108468 11366 14074 11439 12221 14073 12183 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $108472 r0 *1 579.6,942.48
X$108472 14073 11442 14074 11439 11509 11366 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $108474 m0 *1 607.04,952.56
X$108474 14073 11535 14074 11447 11590 11366 11589
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $108493 r0 *1 598.64,942.48
X$108493 14074 14073 11366 11535 11367 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108496 m0 *1 567.28,992.88
X$108496 14073 11366 11367 14074 12124 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $108499 r0 *1 590.8,992.88
X$108499 14074 11366 14073 12126 12221 11439 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $108504 m0 *1 585.2,1013.04
X$108504 14074 14073 12445 11367 12221 11438 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108542 r0 *1 570.08,952.56
X$108542 14074 14073 11532 11644 11604 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108547 r0 *1 569.52,1002.96
X$108547 14073 11367 14074 12221 12336 11439 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $108550 r0 *1 566.16,1023.12
X$108550 14074 14073 12125 12367 11604 11367 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108604 m0 *1 821.52,1033.2
X$108604 14074 12536 14073 12673 12590 11372 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $108609 m0 *1 851.76,1053.36
X$108609 14074 14073 12980 12895 11372 12821 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108611 r0 *1 832.16,1053.36
X$108611 14074 14073 13072 13035 11372 12823 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108613 m0 *1 846.72,1063.44
X$108613 14074 14073 13011 13130 11372 13071 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $108640 m0 *1 841.12,1033.2
X$108640 14074 14073 11372 12743 11704 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108646 r0 *1 781.76,1013.04
X$108646 14074 11454 14073 12496 12535 11372 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $108651 m0 *1 840,952.56
X$108651 14073 11458 11372 14074 11543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $108662 m0 *1 951.44,942.48
X$108662 14074 14073 11398 11376 11377 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108665 m0 *1 946.96,962.64
X$108665 11616 11377 11676 11930 11843 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $108671 m0 *1 957.04,962.64
X$108671 14074 11676 14073 11677 11616 11377 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $108677 m0 *1 941.92,972.72
X$108677 11378 14074 11740 11814 14073 11815 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $108692 m0 *1 1004.08,952.56
X$108692 14074 14073 11555 11379 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108704 r0 *1 1089.76,1043.28
X$108704 14074 14073 11380 13077 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $108706 r0 *1 1049.44,972.72
X$108706 14074 14073 11824 11901 11380 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108717 m0 *1 1059.52,972.72
X$108717 14074 11902 11381 11765 11836 11825 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108723 m0 *1 1132.32,962.64
X$108723 14074 11691 11382 11692 11473 11693 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108731 m0 *1 1160.88,942.48
X$108731 14074 11474 11391 11385 11384 11390 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108737 r0 *1 1183.28,942.48
X$108737 14074 14073 11386 11559 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $108767 m0 *1 1065.12,962.64
X$108767 14074 11681 11394 11761 11620 11682 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $108892 r0 *1 379.12,1033.2
X$108892 14074 11427 12118 14073 12809 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $108895 r0 *1 361.2,1033.2
X$108895 14074 14073 12791 11427 12118 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $108907 m0 *1 368.48,1033.2
X$108907 14074 14073 11427 12625 gf180mcu_fd_sc_mcu9t5v0__inv_2
* cell instance $108962 m0 *1 134.96,972.72
X$108962 14074 14073 11430 11632 11788 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108964 m0 *1 140.56,982.8
X$108964 14074 14073 11430 11593 11859 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108982 m0 *1 173.6,962.64
X$108982 14074 14073 11430 11596 12018 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $108993 r0 *1 384.16,942.48
X$108993 14074 14073 11498 11430 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $109030 m0 *1 576.8,982.8
X$109030 14074 14073 11938 11806 11435 11533 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109033 m0 *1 612.64,1002.96
X$109033 14074 14073 12259 12288 11435 12219 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109069 m0 *1 602.56,1023.12
X$109069 14074 14073 12287 12442 11435 12127 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109080 m0 *1 576.8,1013.04
X$109080 14074 14073 12368 12444 11435 12527 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109113 m0 *1 594.16,1013.04
X$109113 14074 14073 11438 12335 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109121 m0 *1 580.72,1002.96
X$109121 11439 14074 12221 12335 14073 12285 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $109128 r0 *1 600.88,972.72
X$109128 14074 11439 11807 14073 11728 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $109131 r0 *1 610.4,972.72
X$109131 14074 14073 11445 11879 11439 11808 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109133 r0 *1 603.68,952.56
X$109133 14074 14073 11590 11439 11605 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $109177 r0 *1 603.68,942.48
X$109177 14074 14073 11535 11511 11444 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $109203 m0 *1 921.76,952.56
X$109203 14074 14073 11581 11449 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109218 r0 *1 778.4,1023.12
X$109218 14073 11454 12588 14074 12589 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $109224 m0 *1 773.36,1013.04
X$109224 14074 14073 12375 11454 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109231 r0 *1 810.88,972.72
X$109231 14074 14073 11456 12007 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109257 r0 *1 865.76,942.48
X$109257 14074 14073 11500 11460 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109261 m0 *1 1022.56,972.72
X$109261 14074 11634 11742 11838 11745 11462 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109264 r0 *1 1018.08,972.72
X$109264 14074 11462 11823 11839 11744 11922 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $109266 m0 *1 1020.32,962.64
X$109266 14074 11697 11695 11746 11463 11462 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109273 r0 *1 1041.6,942.48
X$109273 14074 14073 11552 11464 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109275 r0 *1 1038.24,952.56
X$109275 14074 11551 11568 11620 11464 11631 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109279 r0 *1 1099.84,942.48
X$109279 14074 11466 11465 11489 11467 11487 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109282 r0 *1 1098.72,962.64
X$109282 14074 11762 11466 11759 11761 11758 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109290 r0 *1 1118.88,942.48
X$109290 14074 14073 11468 11487 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109297 m0 *1 1131.2,952.56
X$109297 14074 14073 11556 11470 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109305 r0 *1 1122.24,1053.36
X$109305 14074 14073 13024 11471 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $109323 r0 *1 1135.12,1033.2
X$109323 14074 14073 12769 11472 11684 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $109365 r0 *1 61.6,952.56
X$109365 14074 14073 11479 11627 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109372 r0 *1 58.24,942.48
X$109372 14074 14073 11480 11564 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109376 m0 *1 1158.08,952.56
X$109376 11562 14074 14073 11559 11558 11481 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $109381 r0 *1 71.68,942.48
X$109381 14074 14073 11483 11484 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109390 m0 *1 1122.8,952.56
X$109390 14074 14073 11485 11566 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109405 m0 *1 1097.04,952.56
X$109405 14074 11566 11555 11628 11489 11567 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109431 r0 *1 921.76,1053.36
X$109431 14073 13013 13073 14074 11495 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $109462 m0 *1 808.64,1033.2
X$109462 14074 12670 12672 14073 11502 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $109528 r0 *1 48.72,952.56
X$109528 14074 14073 11517 11626 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109542 r0 *1 85.68,1073.52
X$109542 14073 11942 14074 13302 13287 11520 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $109568 r0 *1 209.44,1083.6
X$109568 14073 11942 14074 13410 13385 11524 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $109573 m0 *1 232.4,952.56
X$109573 14074 14073 11525 11579 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109575 r0 *1 245.28,1023.12
X$109575 14073 11942 14074 12712 12576 11526 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $109611 m0 *1 485.52,972.72
X$109611 14074 11779 11604 11801 11724 11653 11530 11800 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $109628 m0 *1 551.6,972.72
X$109628 14074 14073 11782 11602 11653 11531 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $109720 r0 *1 884.24,952.56
X$109720 14074 11544 11641 14073 11640 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $109727 r0 *1 939.12,952.56
X$109727 14074 11547 14073 11675 11615 11546 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $109732 r0 *1 948.64,952.56
X$109732 14074 11547 14073 11676 11577 11546 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $109736 r0 *1 956.48,952.56
X$109736 14074 14073 11617 11546 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $109744 r0 *1 944.72,962.64
X$109744 14074 14073 11740 11547 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $109748 m0 *1 966,1043.28
X$109748 14074 11678 12748 12901 12853 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109750 m0 *1 981.12,972.72
X$109750 14074 11678 11767 11840 11741 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109752 r0 *1 969.92,1023.12
X$109752 14074 12541 12634 12749 12540 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109755 m0 *1 973.28,1023.12
X$109755 14074 12541 12557 12701 12307 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109758 m0 *1 981.12,992.88
X$109758 14074 11678 12088 12228 11995 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109760 r0 *1 988.4,982.8
X$109760 14074 11678 11994 12149 11926 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109763 m0 *1 981.12,962.64
X$109763 14074 11678 11635 11698 11699 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109765 m0 *1 958.72,1053.36
X$109765 14074 11678 12902 13211 12783 11548 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109775 r0 *1 952,1053.36
X$109775 14074 14073 11548 13131 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $109777 m0 *1 1018.08,952.56
X$109777 14074 11548 11572 11550 11554 11549 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109780 m0 *1 976.64,952.56
X$109780 14074 11576 11548 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $109786 m0 *1 932.4,962.64
X$109786 14074 14073 11701 11549 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109789 m0 *1 1038.8,952.56
X$109789 14074 14073 11550 11551 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109796 r0 *1 1061.76,952.56
X$109796 14074 14073 11553 11619 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109817 r0 *1 1098.72,1123.92
X$109817 14074 14073 13630 13750 11557 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $109820 r0 *1 1163.68,952.56
X$109820 14074 14073 11689 11558 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109832 r0 *1 1167.04,972.72
X$109832 14074 11560 11687 11912 11913 11914 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109838 r0 *1 1143.52,962.64
X$109838 14074 11562 11756 11750 11754 11748 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109857 m0 *1 1104.88,972.72
X$109857 14074 11760 11567 11835 11759 11828 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $109880 m0 *1 262.64,1093.68
X$109880 14073 11942 14074 13465 13446 11573 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $109890 m0 *1 210,952.56
X$109890 14074 14073 11574 11575 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109902 m0 *1 948.64,972.72
X$109902 11898 14074 11816 14073 11578 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $109917 r0 *1 321.44,1043.28
X$109917 14073 11875 14074 12945 12946 11582 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $109932 r0 *1 730.8,992.88
X$109932 14073 12137 12251 14074 11585 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $109963 r0 *1 148.96,952.56
X$109963 14074 14073 11633 11594 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $109987 r0 *1 432.32,962.64
X$109987 14073 11721 14074 11716 11722 11600 11706
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110002 m0 *1 533.12,982.8
X$110002 14074 11806 11653 11602 11877 11604 11803 11963 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $110015 m0 *1 543.2,972.72
X$110015 14074 14073 11603 11804 11604 11782 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110023 m0 *1 534.8,972.72
X$110023 14074 14073 11657 11655 11604 11804 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110027 r0 *1 510.16,962.64
X$110027 14074 14073 11780 11654 11604 11656 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110054 r0 *1 534.8,1013.04
X$110054 14074 12442 11604 11725 12284 11653 12217 12218 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $110059 m0 *1 512.4,1013.04
X$110059 14074 12366 11604 12217 12213 11653 12214 12216 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $110062 r0 *1 574.56,1023.12
X$110062 14074 14073 11604 12221 11653 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110067 m0 *1 511.84,982.8
X$110067 14074 11878 11604 11963 11876 11653 11802 11803 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $110071 m0 *1 505.12,1023.12
X$110071 14074 12443 11604 12216 12214 11653 12215 12213 14073
+ gf180mcu_fd_sc_mcu9t5v0__mux4_2
* cell instance $110103 m0 *1 837.2,1043.28
X$110103 14074 11610 14073 12981 12742 11704 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $110123 r0 *1 909.44,962.64
X$110123 14074 14073 11614 11741 11672 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110126 r0 *1 911.12,1002.96
X$110126 14074 14073 11614 12307 12142 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110128 m0 *1 902.72,982.8
X$110128 14074 14073 11614 11926 11891 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110130 r0 *1 912.8,982.8
X$110130 14074 14073 11614 11995 11892 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110132 r0 *1 907.76,1013.04
X$110132 14074 14073 11614 12539 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110141 m0 *1 959.84,972.72
X$110141 11617 14074 11740 11814 14073 11841 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $110143 r0 *1 966.56,962.64
X$110143 11740 14074 14073 11618 11768 11617 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $110148 r0 *1 971.6,952.56
X$110148 14074 14073 11628 11618 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110151 r0 *1 1066.8,962.64
X$110151 14074 11765 11681 11683 11764 11619 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110162 r0 *1 1151.36,1093.68
X$110162 14074 14073 11621 13586 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110170 m0 *1 1167.6,962.64
X$110170 14074 11622 11689 11686 11687 11624 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110173 r0 *1 1162,962.64
X$110173 14074 11751 11690 11685 11752 11623 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110179 r0 *1 1176,952.56
X$110179 14074 14073 11685 11624 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110205 r0 *1 1082.48,1123.92
X$110205 14074 14073 13848 13630 11629 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $110208 r0 *1 109.76,1083.6
X$110208 14073 11942 14074 13405 13372 11630 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110217 r0 *1 1013.6,952.56
X$110217 14074 14073 11635 11631 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110237 r0 *1 978.32,952.56
X$110237 14074 11636 11678 14073 gf180mcu_fd_sc_mcu9t5v0__buf_12
* cell instance $110247 m0 *1 935.76,962.64
X$110247 14073 11674 11675 14074 11639 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $110278 r0 *1 90.72,982.8
X$110278 14073 11942 14074 12012 12078 11646 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110294 r0 *1 147.28,982.8
X$110294 14073 11942 14074 12081 11920 11650 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110302 m0 *1 260.96,982.8
X$110302 14074 14073 11652 11712 12093 11951 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110309 r0 *1 515.76,972.72
X$110309 14074 14073 11655 11876 11653 11803 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110314 r0 *1 491.12,972.72
X$110314 14074 14073 11654 11724 11653 11800 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110453 m0 *1 939.12,982.8
X$110453 14074 11843 11674 14073 12145 11979 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $110456 r0 *1 958.16,972.72
X$110456 14074 14073 11817 11674 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110459 m0 *1 952,982.8
X$110459 14074 11896 14073 11816 11677 11674 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $110484 r0 *1 903.84,1063.44
X$110484 14074 14073 11678 13206 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110486 r0 *1 906.08,1053.36
X$110486 14074 13092 11678 12058 13012 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $110490 m0 *1 965.44,1023.12
X$110490 14074 14073 11678 12541 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110493 m0 *1 1011.92,962.64
X$110493 14074 14073 11698 11679 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110495 r0 *1 1010.24,962.64
X$110495 14074 11680 11682 11747 11679 11743 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110499 m0 *1 1015.28,962.64
X$110499 14074 14073 11695 11680 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110510 r0 *1 1124.48,962.64
X$110510 14074 11911 11758 11755 11683 11692 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110526 m0 *1 1087.52,1093.68
X$110526 14074 14073 11684 13422 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110537 r0 *1 1178.8,962.64
X$110537 14074 14073 11686 11749 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110554 m0 *1 1156.4,962.64
X$110554 14074 14073 11690 11691 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110566 m0 *1 1131.76,972.72
X$110566 14074 11833 11693 11830 11829 11832 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110569 r0 *1 90.16,1043.28
X$110569 14073 11942 14074 12933 12911 11694 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110592 m0 *1 917.28,962.64
X$110592 14074 14073 11702 11699 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110649 m0 *1 266,992.88
X$110649 14074 14073 11951 11712 11794 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $110659 m0 *1 253.68,992.88
X$110659 11793 14073 11712 11950 14074 12114 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $110661 r0 *1 262.64,972.72
X$110661 14074 11844 11795 11712 11793 14073 11865
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $110663 r0 *1 206.08,992.88
X$110663 14074 12199 14073 12110 12244 11946 11712
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $110695 r0 *1 461.44,1053.36
X$110695 13068 13045 13069 12954 11713 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $110699 m0 *1 407.68,972.72
X$110699 14074 14073 11713 11719 11718 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $110703 r0 *1 283.36,962.64
X$110703 14074 14073 11770 11771 11714 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $110705 r0 *1 282.24,972.72
X$110705 14074 14073 11714 11924 11793 11845 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $110707 r0 *1 364,1063.44
X$110707 14073 11875 14074 13191 13123 11715 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110727 m0 *1 338.24,982.8
X$110727 14073 11717 14074 12004 12437 11868 11777
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110729 m0 *1 320.88,982.8
X$110729 14073 11717 14074 11866 11929 11774 11777
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110738 m0 *1 410.48,1023.12
X$110738 14073 11719 12581 14074 12569 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $110824 m0 *1 885.36,982.8
X$110824 14073 11890 11735 14074 11975 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $110853 m0 *1 1016.96,972.72
X$110853 14074 14073 11742 11822 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110858 r0 *1 1003.52,962.64
X$110858 14074 14073 11767 11743 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110865 r0 *1 1029.84,962.64
X$110865 14074 14073 11744 11745 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $110870 r0 *1 1037.68,972.72
X$110870 14074 14073 11746 11908 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110874 m0 *1 1084.16,972.72
X$110874 14074 11763 11762 11827 11747 11826 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110878 m0 *1 1154.16,972.72
X$110878 14074 14073 11755 11748 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110881 m0 *1 1151.36,982.8
X$110881 11990 14074 14073 11749 11917 11754 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $110885 r0 *1 1156.96,972.72
X$110885 14074 14073 11750 11918 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110892 r0 *1 90.72,1002.96
X$110892 14073 11942 14074 12395 12397 11753 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110907 r0 *1 1121.12,962.64
X$110907 14074 14073 11756 11760 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110934 r0 *1 1001.28,972.72
X$110934 14074 11925 11763 11923 11821 11822 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110939 r0 *1 1071.28,972.72
X$110939 14074 11904 11764 11907 11906 11905 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $110948 m0 *1 184.24,1093.68
X$110948 14073 11942 14074 13509 13408 11766 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110961 m0 *1 977.76,972.72
X$110961 14074 14073 11820 11768 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $110964 m0 *1 263.2,1073.52
X$110964 14073 11942 14074 13243 13244 11769 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $110977 r0 *1 332.08,1043.28
X$110977 14073 11875 14074 12881 12882 11772 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111038 m0 *1 84,1093.68
X$111038 14073 11942 14074 13449 13430 11786 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111050 r0 *1 151.2,1053.36
X$111050 14073 11942 14074 13089 13091 11788 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111056 m0 *1 161.28,1053.36
X$111056 14073 11942 14074 12989 12936 11790 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111059 r0 *1 272.72,992.88
X$111059 14073 11791 12114 14074 12206 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111061 r0 *1 271.6,972.72
X$111061 14074 14073 11864 11791 11794 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $111064 m0 *1 269.92,982.8
X$111064 14074 14073 11792 11791 11998 11864 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111086 m0 *1 259.84,992.88
X$111086 11793 14073 11795 12024 14074 12093 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111088 m0 *1 201.6,992.88
X$111088 14074 11862 14073 12110 12082 11946 11793
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $111091 r0 *1 290.64,972.72
X$111091 14074 14073 11924 11865 11795 11794 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111093 m0 *1 400.96,1103.76
X$111093 14074 14073 13532 13530 11795 11794 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111095 r0 *1 430.64,992.88
X$111095 14073 12118 12117 14074 11794 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111121 m0 *1 248.08,992.88
X$111121 14074 14073 12092 11950 11794 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $111127 r0 *1 376.32,1083.6
X$111127 14074 14073 13401 13311 11794 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $111129 m0 *1 363.44,1093.68
X$111129 14074 14073 13448 13353 11794 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $111135 m0 *1 451.36,1083.6
X$111135 14074 14073 13313 13105 11795 11794 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111139 r0 *1 451.92,1002.96
X$111139 14074 14073 12423 12363 11795 11794 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111146 m0 *1 400.96,1093.68
X$111146 14074 14073 12177 11795 13415 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $111148 m0 *1 359.52,1013.04
X$111148 14074 12361 11795 14073 11865 12206 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $111151 r0 *1 263.76,982.8
X$111151 11795 14073 12024 12114 14074 11998 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111199 m0 *1 367.92,1053.36
X$111199 14074 14073 11795 13047 12948 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111205 m0 *1 364,1103.76
X$111205 13357 11795 13100 13358 14074 14073 13518
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111209 r0 *1 365.68,1073.52
X$111209 13310 14073 11795 13100 14074 13312 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111211 m0 *1 391.44,1043.28
X$111211 14073 11795 12810 14074 12859 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111213 r0 *1 398.16,1023.12
X$111213 14074 14073 11795 12639 12580 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111215 r0 *1 366.8,1033.2
X$111215 14074 14073 12791 11795 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111218 r0 *1 423.36,1063.44
X$111218 14073 12884 11795 14074 13192 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111221 m0 *1 442.96,1063.44
X$111221 12884 14073 11795 12883 14074 13068 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111224 r0 *1 453.04,1083.6
X$111224 14074 14073 11795 13513 13105 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111226 m0 *1 458.08,1063.44
X$111226 14073 11795 12439 14074 13097 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111231 r0 *1 449.68,1043.28
X$111231 12885 11795 12883 12814 14074 14073 12816
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111233 r0 *1 452.48,1013.04
X$111233 12362 14073 11795 12363 14074 12501 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111237 r0 *1 448.56,1033.2
X$111237 12584 12813 12884 11795 14074 14073 12663
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111239 r0 *1 353.36,1013.04
X$111239 12278 11795 12024 12206 14074 14073 12565
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111241 m0 *1 296.8,972.72
X$111241 14074 14073 11795 11845 11865 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111243 m0 *1 308,982.8
X$111243 14073 11942 14074 11866 11929 11796 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111248 m0 *1 203.28,1123.92
X$111248 14074 11797 13692 14073 13693 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111251 r0 *1 146.72,1134
X$111251 14074 11797 13797 14073 13855 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111253 r0 *1 150.08,1154.16
X$111253 14074 11797 12988 14073 13952 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111255 r0 *1 306.88,1154.16
X$111255 14074 11797 13981 14073 13963 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111257 m0 *1 327.04,1154.16
X$111257 14074 11797 13834 14073 13884 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111273 r0 *1 347.76,972.72
X$111273 14074 14073 11798 11797 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111372 r0 *1 974.4,972.72
X$111372 11814 14074 14073 11928 11927 11817 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $111375 r0 *1 966,972.72
X$111375 14074 11817 11814 14073 11818 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111381 r0 *1 944.72,972.72
X$111381 14074 14073 11814 11896 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111387 m0 *1 948.64,992.88
X$111387 14074 14073 11816 12147 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111396 m0 *1 966.56,972.72
X$111396 14073 11841 11818 14074 11819 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111404 r0 *1 954.8,982.8
X$111404 11897 14073 11819 11979 14074 11997 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111406 m0 *1 960.96,982.8
X$111406 11898 14073 11897 11819 14074 11981 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111409 r0 *1 1098.72,972.72
X$111409 14074 11918 11820 11900 11835 11909 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $111415 m0 *1 1010.24,972.72
X$111415 14074 14073 11840 11821 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $111421 r0 *1 993.44,992.88
X$111421 14074 12088 12169 12168 12149 11823 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $111428 m0 *1 1001.28,1033.2
X$111428 14074 14073 11823 12680 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111430 m0 *1 1004.08,1023.12
X$111430 14074 14073 11823 12601 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111441 m0 *1 1085.28,982.8
X$111441 14074 11907 11826 11910 11983 11908 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $111446 r0 *1 1099.28,982.8
X$111446 14074 11984 11828 12069 11827 12080 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $111460 m0 *1 1130.08,982.8
X$111460 14074 11991 11911 11919 11830 11987 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $111495 r0 *1 1046.08,972.72
X$111495 14074 14073 11838 12085 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $111515 r0 *1 251.44,982.8
X$111515 14074 14073 11996 12092 11844 11950 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111528 m0 *1 351.12,1063.44
X$111528 14073 11875 14074 13175 13099 11847 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111560 r0 *1 418.32,982.8
X$111560 14074 14073 11853 12115 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111579 m0 *1 84,1073.52
X$111579 14073 11942 14074 13227 13184 11858 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111584 r0 *1 137.2,982.8
X$111584 14073 11942 14074 12015 12082 11859 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111587 m0 *1 232.96,1002.96
X$111587 14073 12201 12413 12203 12199 11860 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $111589 r0 *1 203.84,1103.76
X$111589 14073 13457 11860 14074 13570 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111591 m0 *1 247.52,1053.36
X$111591 14073 12873 12940 12941 11860 12805 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $111593 m0 *1 255.92,1063.44
X$111593 14073 12876 12982 12941 11860 13062 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $111598 m0 *1 181.44,1043.28
X$111598 14073 12723 11860 14074 12803 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111601 r0 *1 314.16,992.88
X$111601 14074 12030 12115 14073 11860 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $111633 m0 *1 273.28,992.88
X$111633 14074 14073 11953 12095 11860 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111636 m0 *1 271.04,1013.04
X$111636 14074 14073 12435 12727 11860 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111638 r0 *1 182.56,1013.04
X$111638 14073 12197 11860 14074 12490 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111640 m0 *1 175.84,982.8
X$111640 14074 14073 11944 11943 11860 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111642 m0 *1 280,1113.84
X$111642 14073 12728 11860 14074 13619 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111644 m0 *1 201.6,1073.52
X$111644 14073 13061 11860 14074 13114 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111647 r0 *1 178.08,1063.44
X$111647 12990 14073 11952 11860 14074 12935 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111649 m0 *1 179.2,1093.68
X$111649 14073 13266 11860 14074 13407 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111652 r0 *1 273.28,1083.6
X$111652 14073 12942 11860 14074 13389 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111654 r0 *1 227.36,1083.6
X$111654 12871 14073 13267 11860 14074 13387 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111657 m0 *1 255.36,1093.68
X$111657 14073 13411 11860 14074 13464 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111662 r0 *1 333.76,1083.6
X$111662 14074 13395 13066 14073 11952 11860 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $111664 m0 *1 313.04,1093.68
X$111664 14073 12808 11860 14074 13412 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111667 r0 *1 330.96,1063.44
X$111667 14074 14073 13067 13122 11860 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111669 m0 *1 223.44,992.88
X$111669 14074 14073 11861 12023 12091 12090 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $111677 m0 *1 226.24,982.8
X$111677 14074 14073 11862 11863 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $111679 r0 *1 221.2,1002.96
X$111679 14074 14073 12271 12201 11862 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111681 r0 *1 215.04,1002.96
X$111681 11862 14073 12199 12090 14074 12112 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111685 m0 *1 204.96,1002.96
X$111685 12271 11862 12199 11947 14074 14073 12246
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111687 r0 *1 226.24,982.8
X$111687 14074 11993 11863 14073 11948 12090 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $111695 r0 *1 376.32,1053.36
X$111695 12937 14073 12948 12999 14074 11865 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111719 r0 *1 264.88,1154.16
X$111719 14073 11865 13935 14074 13972 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111722 r0 *1 270.48,1154.16
X$111722 13971 11865 13979 13973 14074 14073 13962
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111725 r0 *1 373.52,1113.84
X$111725 14073 11865 12520 14074 13469 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111728 r0 *1 357.84,1164.24
X$111728 14074 14073 11865 14040 13935 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111731 r0 *1 164.08,1093.68
X$111731 14074 13406 14073 12573 11866 11946 13456
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $111763 r0 *1 216.72,1123.92
X$111763 14074 11869 14073 13915 13763 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $111765 r0 *1 231.84,1144.08
X$111765 11869 14073 13658 13804 14074 13802 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111767 m0 *1 227.92,1144.08
X$111767 11869 14073 13658 13778 14074 13692 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111779 m0 *1 278.88,1033.2
X$111779 11871 14073 12575 12652 14074 12354 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111781 r0 *1 279.44,1033.2
X$111781 11871 12728 12575 12435 14074 14073 12729
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $111783 r0 *1 281.12,1002.96
X$111783 12275 14073 11871 12273 14074 12025 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111785 m0 *1 313.04,992.88
X$111785 14074 14073 11871 12027 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $111797 r0 *1 101.92,1083.6
X$111797 14073 11874 14074 13304 13431 13347 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $111799 r0 *1 106.96,1103.76
X$111799 14073 11874 14074 13564 13616 13304 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $111820 r0 *1 109.76,992.88
X$111820 14074 14073 11874 12161 12192 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111822 r0 *1 274.4,1123.92
X$111822 14074 14073 11874 13699 13805 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111825 m0 *1 154.56,1073.52
X$111825 14074 14073 11874 13232 13183 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111827 r0 *1 110.88,1013.04
X$111827 14074 14073 11874 12553 12554 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111829 r0 *1 112,1063.44
X$111829 14074 14073 11874 13153 13181 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111831 r0 *1 120.4,1063.44
X$111831 14074 14073 11874 13112 13157 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111834 r0 *1 113.12,1033.2
X$111834 14074 14073 11874 12773 12801 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111836 r0 *1 120.96,1123.92
X$111836 14074 14073 11874 13788 13566 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111839 r0 *1 339.36,1103.76
X$111839 14074 14073 11874 13621 13575 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111841 r0 *1 344.96,1123.92
X$111841 14074 14073 11874 13809 13704 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111843 m0 *1 308,1123.92
X$111843 14074 14073 11874 13808 13700 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111846 r0 *1 327.04,1023.12
X$111846 14073 13121 14074 11875 11954 12360 12655
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $111862 m0 *1 319.2,992.88
X$111862 14074 14073 11875 11942 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111898 r0 *1 715.68,992.88
X$111898 14073 12136 12134 14074 11883 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $111948 m0 *1 931.84,1023.12
X$111948 14073 12597 12594 14074 11894 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $111950 r0 *1 933.52,1002.96
X$111950 14073 12146 12414 14074 11895 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $111955 m0 *1 946.96,1002.96
X$111955 12145 14073 11896 11979 14074 12304 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $111968 m0 *1 967.12,982.8
X$111968 14074 14073 11899 11898 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $111974 r0 *1 981.68,992.88
X$111974 14074 12062 11899 12241 12227 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $111978 r0 *1 971.04,992.88
X$111978 14074 14073 11899 12148 12063 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $111983 r0 *1 991.2,972.72
X$111983 14074 14073 11900 11928 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $111986 r0 *1 1050,982.8
X$111986 14074 11901 12083 12152 12067 12066 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112013 m0 *1 1101.52,992.88
X$112013 14074 12079 11909 12065 12069 12163 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112017 m0 *1 1111.04,982.8
X$112017 14074 11919 11984 11986 11985 11910 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112025 r0 *1 1166.48,982.8
X$112025 14074 11912 11988 12073 12072 11989 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112044 m0 *1 1165.36,982.8
X$112044 14074 14073 11988 11917 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112065 m0 *1 1034.88,982.8
X$112065 14074 14073 11922 11982 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112070 m0 *1 1028.16,992.88
X$112070 14074 11923 12080 12166 12086 12084 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112079 r0 *1 997.36,972.72
X$112079 14074 14073 11994 11925 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112088 m0 *1 981.68,982.8
X$112088 14074 14073 11992 11927 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112105 m0 *1 941.36,1013.04
X$112105 12414 14073 14074 11930 12598 12382 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $112111 r0 *1 940.24,1023.12
X$112111 14073 12678 14074 12785 11930 12382 12747
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $112126 m0 *1 436.8,982.8
X$112126 14074 14073 11934 12118 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $112152 r0 *1 83.44,992.88
X$112152 14073 11942 14074 12190 12236 11941 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112158 m0 *1 89.6,1043.28
X$112158 14073 11942 14074 12845 12912 12431 12013
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112170 r0 *1 278.32,1053.36
X$112170 14073 11942 14074 13063 13094 12330 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112177 r0 *1 196,992.88
X$112177 14073 11942 14074 12198 12174 12111 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112180 r0 *1 171.36,1013.04
X$112180 14073 11942 14074 12512 12495 12018 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112183 r0 *1 166.88,992.88
X$112183 14073 11942 14074 12195 12244 12016 11954
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $112186 m0 *1 272.72,1002.96
X$112186 14074 14073 11954 12205 11942 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $112221 m0 *1 236.32,1023.12
X$112221 14074 14073 11942 12028 12267 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $112223 r0 *1 243.04,1013.04
X$112223 14073 11942 12267 14074 12023 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $112237 m0 *1 194.32,1002.96
X$112237 11944 14073 12197 12246 14074 12492 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $112239 r0 *1 188.72,992.88
X$112239 14074 12196 11947 14073 11944 12112 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $112245 m0 *1 182.56,992.88
X$112245 11944 14073 11948 12165 14074 12164 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $112247 r0 *1 180.88,992.88
X$112247 12017 14073 14074 11952 11944 12165 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $112251 m0 *1 175.84,992.88
X$112251 12017 14074 12164 11945 14073 12019 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112255 r0 *1 169.12,1144.08
X$112255 14074 13772 14073 12573 12512 11946 13932
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112306 r0 *1 206.64,1023.12
X$112306 14074 12650 14073 12573 12397 11946 12434
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112308 m0 *1 179.76,1002.96
X$112308 14074 12197 14073 12110 12236 11946 12278
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112310 m0 *1 164.08,1023.12
X$112310 14074 12510 14073 12110 12195 11946 12506
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112321 m0 *1 191.52,992.88
X$112321 14074 11947 14073 12110 12078 11946 11950
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112325 m0 *1 143.36,1134
X$112325 14074 13770 14073 12573 13089 11946 13771
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112327 m0 *1 191.52,1134
X$112327 14074 13800 14073 12573 12198 11946 13933
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112331 m0 *1 175.28,1144.08
X$112331 14074 13773 14073 12573 13410 11946 13966
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112335 r0 *1 205.52,1073.52
X$112335 14074 13061 14073 12573 13184 11946 13310
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112338 m0 *1 152.88,1063.44
X$112338 14074 13059 14073 12573 12989 11946 13109
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112340 r0 *1 203.28,1043.28
X$112340 14074 12271 14073 12573 12912 11946 12937
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112343 m0 *1 215.04,1053.36
X$112343 14074 12805 14073 12573 12936 11946 12522
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112346 r0 *1 187.6,1043.28
X$112346 14074 12723 14073 12573 12911 11946 12879
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112349 m0 *1 211.68,1093.68
X$112349 14074 13409 14073 12573 13372 11946 13353
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112351 m0 *1 183.68,1103.76
X$112351 14074 13457 14073 12573 13408 11946 13576
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112354 m0 *1 174.16,1083.6
X$112354 14074 12990 14073 12573 13287 11946 13311
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112358 m0 *1 170.24,1093.68
X$112358 14074 13266 14073 12573 13430 11946 13357
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112361 m0 *1 109.2,1113.84
X$112361 14074 13565 14073 12110 13509 11946 13561
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112363 r0 *1 82.32,1083.6
X$112363 14074 13349 14073 12110 13302 11946 13259
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112365 r0 *1 80.64,1093.68
X$112365 14074 13522 14073 12110 13449 11946 13404
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112367 m0 *1 99.68,1113.84
X$112367 14074 13563 14073 12110 13405 11946 13521
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112372 m0 *1 80.64,1043.28
X$112372 14074 12720 14073 12110 12845 11946 12800
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112374 m0 *1 80.08,1013.04
X$112374 14074 12106 14073 12110 12190 11946 12505
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112377 m0 *1 134.96,992.88
X$112377 14074 12194 14073 12110 12081 11946 12105
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112379 m0 *1 87.36,1002.96
X$112379 14074 12344 14073 12110 12012 11946 12341
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112381 r0 *1 76.72,1073.52
X$112381 14074 13111 14073 12110 13227 11946 13180
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112383 r0 *1 86.8,1053.36
X$112383 14074 13054 14073 12110 12933 11946 12987
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112386 r0 *1 128.24,1023.12
X$112386 14074 12646 14073 12110 12015 11946 12647
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112388 r0 *1 78.96,1002.96
X$112388 14074 12193 14073 12110 12395 11946 12342
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $112406 r0 *1 217.84,982.8
X$112406 14074 14073 11947 12022 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112410 r0 *1 272.16,1033.2
X$112410 14074 12727 14073 12514 12635 11948 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112412 m0 *1 262.08,1033.2
X$112412 14074 12651 12515 14073 11948 12652 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $112414 r0 *1 193.2,1093.68
X$112414 14073 13458 13527 13351 13457 11948 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $112416 m0 *1 189.84,1083.6
X$112416 14073 11948 14074 13305 13333 13334 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112418 m0 *1 252.56,1113.84
X$112418 14073 11948 14074 13572 13651 13650 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112420 m0 *1 273.28,1083.6
X$112420 14073 11948 14074 13338 13307 13340 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112422 m0 *1 272.16,1103.76
X$112422 14073 11948 14074 13529 13607 13610 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112424 m0 *1 209.44,1073.52
X$112424 14073 11948 14074 13115 13167 13240 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112426 r0 *1 215.04,992.88
X$112426 14074 12021 12022 14073 11948 12112 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $112428 r0 *1 190.4,1002.96
X$112428 14073 11948 14074 12350 12329 12270 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112430 r0 *1 317.52,1023.12
X$112430 12655 14074 11948 12349 14073 12636 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112432 m0 *1 192.64,1043.28
X$112432 14073 11948 14074 12916 12722 12854 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112435 r0 *1 333.2,1073.52
X$112435 14074 14073 13298 13297 11948 13122 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112437 m0 *1 318.08,1093.68
X$112437 14073 11948 14074 13343 13356 13268 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $112478 m0 *1 280,1023.12
X$112478 12518 11948 12354 12353 14074 14073 12562
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $112481 r0 *1 228.48,1113.84
X$112481 14073 14074 13460 13658 13778 11948 13618 13685
+ gf180mcu_fd_sc_mcu9t5v0__oai32_2
* cell instance $112483 m0 *1 285.6,1063.44
X$112483 14074 13245 14073 13172 13064 11948 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112488 r0 *1 309.12,1053.36
X$112488 14074 12919 14073 12918 13044 11948 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112490 m0 *1 295.68,1063.44
X$112490 13119 14073 11948 13064 14074 13173 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $112495 r0 *1 327.6,1033.2
X$112495 14074 12787 14073 12656 12730 11948 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112498 m0 *1 331.52,1043.28
X$112498 12662 14073 11948 12730 14074 12731 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $112516 r0 *1 220.08,1023.12
X$112516 12271 14074 11952 12200 14073 12631 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112519 r0 *1 338.8,1144.08
X$112519 14074 13964 14073 13885 13924 11952 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112522 r0 *1 315.28,1103.76
X$112522 14074 13573 14073 13659 13612 11952 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112524 m0 *1 333.2,1073.52
X$112524 13067 14074 13187 11952 14073 13190 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112526 r0 *1 269.92,982.8
X$112526 14074 14073 12001 12095 11952 12002 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112556 r0 *1 230.72,992.88
X$112556 12199 14074 11952 12202 14073 12272 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112559 m0 *1 208.32,1043.28
X$112559 12650 14074 11952 12804 14073 12725 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112563 r0 *1 287.84,1144.08
X$112563 14074 13880 14073 13833 13881 11952 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112568 m0 *1 175.84,1103.76
X$112568 14074 14073 13267 11952 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $112571 m0 *1 178.64,1063.44
X$112571 14074 11952 14073 13037 13093 13164 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112575 m0 *1 265.44,1063.44
X$112575 13062 14074 11952 12996 14073 12995 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112579 m0 *1 236.88,1083.6
X$112579 14074 11952 14073 13352 13336 13337 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112588 r0 *1 278.32,982.8
X$112588 14073 11953 12025 14074 12002 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $112593 r0 *1 270.48,1002.96
X$112593 14073 12275 11953 14074 12353 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $112644 m0 *1 162.96,1063.44
X$112644 14074 14073 11954 12013 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $112647 r0 *1 219.52,1174.32
X$112647 14074 14035 11955 14073 13879 13970 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $112663 r0 *1 220.08,1154.16
X$112663 11955 13879 13962 13969 14074 14073 13954
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $112665 r0 *1 227.36,1154.16
X$112665 11955 13879 13970 13969 14074 14073 14002
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $112670 m0 *1 257.04,1164.24
X$112670 11955 13971 13879 13987 14074 14073 13968
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $112672 r0 *1 264.32,1174.32
X$112672 14074 14073 11955 14012 14011 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $112674 r0 *1 268.24,1164.24
X$112674 14073 14012 14074 14013 12428 11955 14011
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $112719 m0 *1 665.28,992.88
X$112719 14073 12138 12130 14074 11965 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $112761 m0 *1 926.8,1043.28
X$112761 12899 14074 12785 14073 11978 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $112771 m0 *1 958.72,1002.96
X$112771 14074 14073 12148 12305 11979 gf180mcu_fd_sc_mcu9t5v0__nor2_4
* cell instance $112775 r0 *1 946.96,992.88
X$112775 12145 14073 12146 11979 14074 12060 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $112778 m0 *1 956.48,992.88
X$112778 14073 12061 12171 14074 11980 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $112784 m0 *1 966,992.88
X$112784 14074 12062 11981 14073 12170 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $112787 m0 *1 1032.64,1043.28
X$112787 14074 11982 12905 12752 12682 13140 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_2
* cell instance $112789 r0 *1 1036,1023.12
X$112789 14074 14073 11982 12604 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $112792 m0 *1 1084.72,992.88
X$112792 14074 12153 11983 12162 12154 12068 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112800 r0 *1 1125.6,1002.96
X$112800 14074 12393 11985 12319 12317 12313 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112804 r0 *1 1127.28,982.8
X$112804 14074 14073 11986 12077 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112807 m0 *1 1129.52,1002.96
X$112807 14074 12231 11987 12317 12233 12232 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112813 m0 *1 1177.12,982.8
X$112813 14074 14073 12071 11989 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112818 m0 *1 1128.4,992.88
X$112818 14074 11990 12070 12160 12158 12077 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112824 m0 *1 1151.36,992.88
X$112824 14074 14073 12076 11991 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112826 m0 *1 1011.36,992.88
X$112826 14074 12064 11992 12167 12065 12150 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $112850 m0 *1 940.8,992.88
X$112850 14074 14073 12173 12144 11997 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $112856 m0 *1 931.28,992.88
X$112856 14073 12172 12173 14074 11999 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $112864 r0 *1 909.44,982.8
X$112864 14074 14073 12000 12011 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112899 r0 *1 775.04,982.8
X$112899 14074 14073 12008 12101 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $112950 m0 *1 122.64,992.88
X$112950 14074 12014 14073 12109 12240 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112952 r0 *1 129.36,1002.96
X$112952 14074 12193 14073 12014 12266 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $112969 m0 *1 212.24,1002.96
X$112969 14074 14073 12020 12023 12091 12112 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112979 r0 *1 223.44,992.88
X$112979 12113 14074 12022 12202 14073 12165 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $112983 m0 *1 269.36,1033.2
X$112983 14074 14073 12516 12023 12091 12652 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112985 m0 *1 280,1013.04
X$112985 14074 14073 12207 12023 12091 12354 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112987 r0 *1 219.52,1013.04
X$112987 14074 14073 12561 12023 12091 12433 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112992 m0 *1 226.24,1033.2
X$112992 14074 14073 12574 12023 12091 12726 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $112996 m0 *1 278.88,1002.96
X$112996 14074 14073 12026 12023 12091 12273 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $113005 r0 *1 278.32,1164.24
X$113005 14074 14014 12024 14073 13935 13973 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $113026 r0 *1 262.08,1164.24
X$113026 12024 14073 13935 13973 14074 13987 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113029 r0 *1 381.36,1063.44
X$113029 13000 12937 13105 12999 14074 14073 12024
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $113031 m0 *1 372.96,1123.92
X$113031 14073 12024 12520 14074 13100 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113041 r0 *1 288.96,1002.96
X$113041 14074 12415 12274 12357 12027 14073 12273
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $113066 r0 *1 105.84,1113.84
X$113066 14074 13565 14073 13689 13616 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113069 r0 *1 93.52,1103.76
X$113069 14074 13522 14073 13450 13431 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113071 m0 *1 140,1144.08
X$113071 14074 13770 14073 13902 13855 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113074 m0 *1 118.72,1134
X$113074 14074 13563 14073 13690 13788 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113076 m0 *1 333.76,1113.84
X$113076 14074 12100 14073 13620 13688 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113107 r0 *1 202.72,1123.92
X$113107 14074 12032 14073 13691 13693 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113109 m0 *1 274.96,1123.92
X$113109 14073 12029 13699 14074 13731 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113111 m0 *1 154,1154.16
X$113111 14073 12029 13952 14074 13876 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113113 m0 *1 147.28,1073.52
X$113113 14074 13059 14073 13057 13232 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113115 r0 *1 103.04,1063.44
X$113115 14074 13111 14073 13260 13153 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113117 m0 *1 104.16,1023.12
X$113117 14074 12344 14073 12507 12553 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113120 r0 *1 93.52,992.88
X$113120 14074 12106 14073 12159 12161 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113122 m0 *1 115.92,1063.44
X$113122 14074 13054 14073 13152 13112 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113124 r0 *1 105.84,1033.2
X$113124 14074 12646 14073 12616 12773 12029 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113126 m0 *1 343.28,1113.84
X$113126 14073 12029 13621 14074 13622 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113129 r0 *1 312.48,1154.16
X$113129 14073 12029 13963 14074 13982 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113131 r0 *1 350,1134
X$113131 14073 12029 13809 14074 13873 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113134 r0 *1 309.12,1134
X$113134 14073 12029 13808 14074 13825 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113136 m0 *1 330.96,1164.24
X$113136 14073 12029 13884 14074 14004 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113139 m0 *1 291.76,1103.76
X$113139 14074 14073 13466 12030 12115 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $113156 r0 *1 239.12,1093.68
X$113156 14073 12030 13460 14074 12327 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113175 r0 *1 295.12,1144.08
X$113175 14073 13806 12031 14074 13881 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113177 r0 *1 178.08,1093.68
X$113177 14073 13267 12031 14074 13452 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113179 m0 *1 147.84,1093.68
X$113179 14073 13406 12031 14074 13454 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113181 r0 *1 158.48,1083.6
X$113181 14074 14073 13267 12108 12031 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113183 r0 *1 146.16,1083.6
X$113183 14073 13349 12031 14074 13350 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113185 r0 *1 223.44,1113.84
X$113185 14074 14073 13762 13685 12031 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113187 r0 *1 322.56,1103.76
X$113187 14073 13574 12031 14074 13612 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113190 r0 *1 346.08,1144.08
X$113190 14073 13943 12031 14074 13924 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113193 m0 *1 209.44,1134
X$113193 12032 14073 13800 13802 14074 13182 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113205 m0 *1 201.6,1144.08
X$113205 12032 14073 13800 13692 14074 12988 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113207 r0 *1 200.48,1144.08
X$113207 14074 14073 12032 13801 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113210 r0 *1 210.56,1123.92
X$113210 14074 14073 12032 13877 13692 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113220 m0 *1 437.36,1013.04
X$113220 14074 12212 12034 14073 12363 12440 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $113223 r0 *1 426.16,1002.96
X$113223 14073 12034 12283 14074 12282 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113225 r0 *1 420.56,992.88
X$113225 14074 14073 12340 12034 12260 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $113234 m0 *1 404.32,1013.04
X$113234 12034 12035 12039 12211 14074 14073 12500
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $113244 r0 *1 437.36,1013.04
X$113244 14073 12035 12625 14074 12440 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113247 r0 *1 448.56,1002.96
X$113247 14074 14073 12035 12362 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113281 r0 *1 447.44,1063.44
X$113281 14074 12036 14076 14073 gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* cell instance $113292 r0 *1 434,1053.36
X$113292 14074 14073 13046 12037 12118 13098 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $113295 m0 *1 436.8,1002.96
X$113295 14074 14073 12261 12037 12118 12212 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $113297 r0 *1 423.36,1093.68
X$113297 14074 14073 13473 12037 12118 13474 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $113309 r0 *1 431.2,1002.96
X$113309 14074 14073 12118 12038 12117 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113325 r0 *1 407.68,1063.44
X$113325 14074 14073 12809 13269 12038 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113327 r0 *1 418.32,1043.28
X$113327 14073 12809 12038 14074 12734 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113329 r0 *1 373.52,1002.96
X$113329 14074 14073 12278 12334 12038 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113332 r0 *1 438.48,992.88
X$113332 12039 14074 12118 12212 14073 12119 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $113347 r0 *1 408.8,1002.96
X$113347 14074 14073 12039 12421 12282 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113349 r0 *1 401.52,1002.96
X$113349 12039 12211 12281 12282 14074 14073 12339
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $113351 r0 *1 445.2,992.88
X$113351 14074 14073 12039 12180 12261 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113390 r0 *1 660.24,992.88
X$113390 14073 12136 12130 14074 12047 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113399 r0 *1 701.68,992.88
X$113399 14073 12131 12134 14074 12049 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113405 r0 *1 735.84,992.88
X$113405 14073 12138 12134 14074 12051 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113436 r0 *1 955.36,1002.96
X$113436 14074 14073 12305 12061 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $113443 m0 *1 972.16,1002.96
X$113443 14074 12226 12062 12063 12306 14073 gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* cell instance $113445 r0 *1 987.28,1002.96
X$113445 14074 12306 12063 12411 12383 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $113449 m0 *1 971.6,992.88
X$113449 14073 12063 12170 14074 12089 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $113457 m0 *1 1121.68,992.88
X$113457 14074 14073 12160 12064 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113474 m0 *1 1125.04,992.88
X$113474 14074 14073 12070 12079 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113476 m0 *1 1160.32,992.88
X$113476 14074 12155 12076 12071 12074 12156 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $113480 m0 *1 1167.04,1002.96
X$113480 14074 12157 12072 12315 12234 12314 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $113484 r0 *1 1180.48,992.88
X$113484 14074 14073 12073 12235 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113497 r0 *1 1104.32,1123.92
X$113497 14073 13630 12075 14074 13751 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113531 m0 *1 1044.96,992.88
X$113531 14074 12085 12084 12151 12162 12083 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $113544 m0 *1 999.04,992.88
X$113544 14074 14073 12169 12086 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113559 m0 *1 217.28,1043.28
X$113559 12805 12723 12271 12938 14074 14073 12090
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $113628 r0 *1 832.72,1033.2
X$113628 14073 12891 12742 14074 12099 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $113735 r0 *1 406.56,1083.6
X$113735 14074 14073 13415 12104 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $113755 r0 *1 68.32,1013.04
X$113755 14074 14073 12105 12430 12343 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $113757 m0 *1 66.64,1013.04
X$113757 14073 12430 14074 12479 12428 12105 12343
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $113760 r0 *1 73.36,1013.04
X$113760 14073 12341 12105 14074 12552 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $113765 m0 *1 101.92,1002.96
X$113765 14074 12237 12194 14073 12106 12191 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $113774 r0 *1 123.2,1002.96
X$113774 12194 14073 12106 12347 14074 12264 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113777 r0 *1 116.48,1002.96
X$113777 12194 14073 12106 12193 14074 12346 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113781 r0 *1 102.48,992.88
X$113781 14074 12159 14073 12107 12239 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113783 r0 *1 93.52,1093.68
X$113783 14074 13450 14073 13548 13551 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113786 r0 *1 103.04,1013.04
X$113786 14074 12507 14073 12482 12345 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113790 m0 *1 108.64,1063.44
X$113790 14074 13152 14073 13154 13053 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113793 m0 *1 108.08,1123.92
X$113793 14074 13689 14073 13752 13680 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113796 m0 *1 132.16,1144.08
X$113796 14074 13902 14073 13901 13789 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113798 m0 *1 184.8,1144.08
X$113798 14074 13911 14073 13910 13799 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113801 m0 *1 158.48,1144.08
X$113801 14074 13904 14073 13798 13774 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113822 r0 *1 203.84,1144.08
X$113822 14074 13691 14073 13867 13913 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113824 r0 *1 143.92,1053.36
X$113824 14074 13033 14073 12975 12868 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113826 m0 *1 145.6,1063.44
X$113826 14074 13057 14073 13113 13058 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113828 m0 *1 234.08,1144.08
X$113828 14074 13916 14073 13878 13831 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113831 m0 *1 219.52,1144.08
X$113831 14074 13915 14073 13914 13777 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113834 m0 *1 143.36,1002.96
X$113834 14074 12328 14073 12242 12269 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113836 r0 *1 103.6,1073.52
X$113836 14074 13260 14073 13288 13303 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113838 m0 *1 142.24,1023.12
X$113838 14074 12623 14073 12620 12559 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113840 r0 *1 110.32,1023.12
X$113840 14074 12616 14073 12619 12617 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113842 m0 *1 231.84,1113.84
X$113842 14074 13618 14073 13694 13649 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113844 m0 *1 122.64,1123.92
X$113844 14074 13690 14073 13722 13657 12108 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $113904 m0 *1 222.32,1002.96
X$113904 14074 14073 12199 12113 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $113976 r0 *1 281.68,1144.08
X$113976 13806 14073 12115 13832 14074 13880 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113979 m0 *1 126.56,1103.76
X$113979 13349 14073 12115 13524 14074 13592 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113984 r0 *1 120.96,1083.6
X$113984 13347 14073 12115 13348 14074 13378 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $113987 m0 *1 132.72,1103.76
X$113987 13453 12115 13348 13567 14074 14073 13555
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $114003 m0 *1 235.2,1103.76
X$114003 14074 14073 12115 13460 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114005 m0 *1 221.76,1103.76
X$114005 14074 14073 13409 13559 12115 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114009 r0 *1 142.24,1144.08
X$114009 13735 14073 12115 12988 14074 13931 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114011 r0 *1 310.24,1113.84
X$114011 13574 14073 12115 13702 14074 13573 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114014 r0 *1 328.72,1113.84
X$114014 13661 13574 12115 13461 14074 14073 13688
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $114018 r0 *1 322.56,1154.16
X$114018 13991 12115 13834 13883 14074 14073 13983
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $114020 r0 *1 330.96,1154.16
X$114020 13975 14073 12115 13834 14074 13937 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114023 m0 *1 339.92,1154.16
X$114023 13943 14073 12115 13938 14074 13964 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114025 m0 *1 313.04,1123.92
X$114025 13121 14073 12115 13603 14074 13701 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114059 m0 *1 250.88,1043.28
X$114059 14074 14073 12116 12874 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114083 m0 *1 428.4,1002.96
X$114083 14074 14073 12260 12117 12118 12283 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $114086 m0 *1 53.76,1013.04
X$114086 14073 12188 14074 12476 12473 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114088 m0 *1 79.52,1033.2
X$114088 14073 12691 14074 12692 12770 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114091 m0 *1 75.6,1123.92
X$114091 14073 13678 14074 13655 13717 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114093 m0 *1 84,1144.08
X$114093 14073 13851 14074 13828 13874 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114095 r0 *1 152.32,1103.76
X$114095 14073 13526 14074 13568 13569 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114097 r0 *1 245.84,1174.32
X$114097 14073 14009 14074 14010 14038 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114099 r0 *1 47.6,1093.68
X$114099 14073 13489 14074 13543 13588 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114101 m0 *1 57.12,1063.44
X$114101 14073 13083 14074 13085 13148 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114103 r0 *1 41.44,1053.36
X$114103 14073 13019 14074 13021 13020 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114106 r0 *1 35.84,1073.52
X$114106 14073 13281 14074 13282 13253 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114109 m0 *1 215.04,1174.32
X$114109 14073 14006 14074 14036 14022 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114112 m0 *1 192.64,1174.32
X$114112 14073 13985 14074 14046 14021 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114115 m0 *1 155.68,1174.32
X$114115 14073 14016 14074 14001 14043 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114118 r0 *1 66.64,1113.84
X$114118 14073 13632 14074 13676 13677 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114120 m0 *1 400.96,1134
X$114120 14073 13745 14074 13664 13746 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114122 r0 *1 378,1164.24
X$114122 14073 13977 14074 14003 14027 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114125 m0 *1 372.4,1144.08
X$114125 14073 13835 14074 13872 13836 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114127 r0 *1 399.84,1164.24
X$114127 14073 14000 14074 13999 13996 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114130 r0 *1 422.24,1033.2
X$114130 12582 14074 12118 12581 14073 12661 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $114140 m0 *1 416.08,1144.08
X$114140 14073 13839 14074 13870 13840 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114142 m0 *1 420,1123.92
X$114142 14073 13732 14074 13706 13747 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114144 r0 *1 302.4,1164.24
X$114144 14073 14029 14074 14030 13990 12118 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114193 r0 *1 437.92,1103.76
X$114193 13357 14074 12118 13474 14073 13476 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $114195 r0 *1 432.88,1063.44
X$114195 14074 12118 14073 13124 12884 12625 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114258 m0 *1 688.24,1013.04
X$114258 14073 12294 12130 14074 12499 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114268 r0 *1 678.16,992.88
X$114268 14073 12131 12130 14074 12182 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114273 m0 *1 665.84,1063.44
X$114273 14074 13003 14073 13179 12130 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114275 r0 *1 675.36,1063.44
X$114275 14074 13127 14073 13252 12130 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114278 r0 *1 660.24,1053.36
X$114278 14074 13002 14073 13043 12130 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114280 r0 *1 659.68,1043.28
X$114280 14074 12586 14073 12984 12130 12819 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114283 m0 *1 813.68,1063.44
X$114283 12131 14074 14073 12956 13071 14098 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $114296 m0 *1 778.4,1043.28
X$114296 14073 12131 12668 14074 12889 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114299 m0 *1 686,1023.12
X$114299 14073 12131 12529 14074 12563 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114310 r0 *1 776.16,1063.44
X$114310 14073 12131 13008 14074 13174 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114316 r0 *1 691.04,1002.96
X$114316 14073 12294 12134 14074 12133 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114336 r0 *1 691.6,1053.36
X$114336 14074 12739 14073 13042 12134 12819 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114338 r0 *1 729.12,1073.52
X$114338 14074 13196 14073 13294 12134 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114340 m0 *1 695.52,1073.52
X$114340 14074 13194 14073 13296 12134 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114342 m0 *1 688.24,1073.52
X$114342 14074 13128 14073 13342 12134 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114349 m0 *1 656.88,1023.12
X$114349 14073 12136 12529 14074 12370 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114352 m0 *1 772.24,1053.36
X$114352 14073 12136 13008 14074 13009 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114369 r0 *1 782.32,1033.2
X$114369 12955 14073 12136 12741 14074 12535 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114371 m0 *1 803.6,1043.28
X$114371 12821 12136 12741 12671 14074 14073 12590
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $114374 m0 *1 799.68,1033.2
X$114374 12955 12136 12741 12671 14074 14073 12672
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $114376 m0 *1 773.36,1043.28
X$114376 14073 12136 12668 14074 12819 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114378 m0 *1 750.4,1023.12
X$114378 14073 12136 12533 14074 12534 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114400 m0 *1 789.6,1043.28
X$114400 14073 12138 12668 14074 12887 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114402 m0 *1 661.92,1023.12
X$114402 14073 12138 12529 14074 12564 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114405 m0 *1 724.08,1023.12
X$114405 14073 12138 12533 14074 12531 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114410 m0 *1 812.56,1073.52
X$114410 14073 12138 13070 14074 13246 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114414 m0 *1 765.52,1073.52
X$114414 14073 12138 13008 14074 13248 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114428 m0 *1 934.64,1033.2
X$114428 14074 12897 12143 14073 12596 12676 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $114433 r0 *1 932.96,1023.12
X$114433 12595 14073 12143 12596 14074 12594 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114436 m0 *1 938,1002.96
X$114436 14074 14073 12381 12144 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $114439 m0 *1 957.6,1033.2
X$114439 14074 12598 12145 12705 12704 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $114447 r0 *1 938,992.88
X$114447 14074 14073 12145 12172 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $114450 r0 *1 943.04,1002.96
X$114450 14073 12145 12381 14074 12303 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114452 r0 *1 943.04,1013.04
X$114452 12145 14073 12146 12381 14074 12599 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114454 m0 *1 952,1043.28
X$114454 14074 12679 12146 12852 12828 14073 gf180mcu_fd_sc_mcu9t5v0__addh_2
* cell instance $114456 r0 *1 950.32,1023.12
X$114456 14074 12146 12679 14073 12600 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $114466 m0 *1 948.64,1023.12
X$114466 14074 12599 14073 12596 12598 12146 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114470 r0 *1 953.68,992.88
X$114470 14073 12245 14074 12243 12171 12147 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114478 r0 *1 963.2,992.88
X$114478 14074 14073 12148 12243 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $114485 r0 *1 1016.96,1002.96
X$114485 14074 12401 12150 12385 12324 12410 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $114488 r0 *1 1078.56,1002.96
X$114488 14074 12319 12308 12400 12388 12151 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $114492 m0 *1 1039.36,1013.04
X$114492 14074 12604 12484 12399 12152 12386 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $114510 m0 *1 1146.32,1002.96
X$114510 12230 14074 14073 12235 12316 12158 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $114530 m0 *1 1025.92,1002.96
X$114530 14074 12308 12163 12324 12166 12325 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $114555 r0 *1 1015.28,992.88
X$114555 14074 14073 12167 12241 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114559 r0 *1 1018.64,992.88
X$114559 14074 14073 12168 12408 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114586 m0 *1 384.16,992.88
X$114586 14074 14073 12176 12189 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $114589 m0 *1 390.32,1103.76
X$114589 14074 12625 12177 14073 13577 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $114599 r0 *1 168.56,1023.12
X$114599 14073 12177 12703 12625 12570 12649 14074
+ gf180mcu_fd_sc_mcu9t5v0__oai211_2
* cell instance $114601 r0 *1 400.4,1093.68
X$114601 14074 14073 13517 12625 12177 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $114639 r0 *1 36.96,1002.96
X$114639 14074 14073 12318 12187 12391 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114645 m0 *1 420,1023.12
X$114645 14073 12582 14074 12569 12583 12189 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $114649 m0 *1 431.76,1073.52
X$114649 14074 12189 13124 14073 13193 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $114743 r0 *1 115.92,1073.52
X$114743 14073 12191 13261 14074 13262 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114745 m0 *1 117.04,1023.12
X$114745 12344 14073 12508 12509 14074 12191 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114753 m0 *1 104.16,1083.6
X$114753 14074 14073 12191 13304 13261 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114756 m0 *1 112.56,1013.04
X$114756 14074 14073 12194 12192 12191 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114758 r0 *1 104.16,1002.96
X$114758 14074 14073 12191 12323 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114760 m0 *1 113.12,1073.52
X$114760 14074 14073 12191 13181 12346 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114784 m0 *1 139.44,1013.04
X$114784 14074 14073 12194 12348 12347 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114786 m0 *1 136.08,1002.96
X$114786 14074 12194 14073 12328 12268 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $114796 m0 *1 192.08,1013.04
X$114796 14073 12197 12196 14074 12350 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114798 m0 *1 188.72,1002.96
X$114798 14074 14073 12270 12197 12196 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $114832 m0 *1 234.64,1033.2
X$114832 14074 14073 12807 12200 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $114836 m0 *1 227.36,1002.96
X$114836 14074 12200 12201 14073 12202 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $114860 r0 *1 212.8,1174.32
X$114860 12204 14074 12428 14035 14073 14034 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $114872 r0 *1 207.76,1174.32
X$114872 14074 14073 12204 14033 14035 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114874 m0 *1 201.6,1174.32
X$114874 14074 14073 12204 14032 13968 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $114876 r0 *1 205.52,1154.16
X$114876 14073 12204 13933 14074 13969 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $114896 r0 *1 360.64,1013.04
X$114896 12278 14073 12434 12206 14074 12520 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $114905 m0 *1 360.08,1002.96
X$114905 14074 14073 12208 12334 12361 12278 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $114908 m0 *1 366.8,1013.04
X$114908 14074 12281 12279 14073 12209 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $114918 m0 *1 454.16,1043.28
X$114918 12815 14074 12210 12816 14073 12863 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $114920 m0 *1 459.2,1033.2
X$114920 12585 14074 12210 12663 14073 12714 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $114932 m0 *1 372.4,1013.04
X$114932 14074 14073 12210 12281 12279 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $114937 m0 *1 355.04,1023.12
X$114937 12657 14073 14074 12210 12434 12565 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $114941 m0 *1 394.24,1002.96
X$114941 14074 14073 12256 12211 12337 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $115057 m0 *1 972.16,1013.04
X$115057 14074 14073 12226 12488 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $115060 r0 *1 963.2,1002.96
X$115060 14074 12412 12381 12226 12305 14073 gf180mcu_fd_sc_mcu9t5v0__oai21_4
* cell instance $115063 m0 *1 987.28,1002.96
X$115063 14074 14073 12326 12227 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115066 r0 *1 999.04,1002.96
X$115066 14074 14073 12228 12384 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115068 m0 *1 1053.92,1023.12
X$115068 14074 12387 12544 12626 12229 12468 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115075 m0 *1 1085.28,1002.96
X$115075 14074 12230 12321 12238 12312 12311 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115103 m0 *1 1084.16,1013.04
X$115103 14074 14073 12238 12483 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115132 m0 *1 964.32,1013.04
X$115132 14074 14073 12488 12245 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $115149 r0 *1 857.92,1002.96
X$115149 14074 14073 12249 12380 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115207 r0 *1 72.8,1002.96
X$115207 14074 14073 12394 12320 12263 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115209 m0 *1 130.48,1002.96
X$115209 14074 12267 12264 14073 12266 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115213 r0 *1 136.64,1053.36
X$115213 14074 12720 14073 13033 12802 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115216 m0 *1 247.52,1134
X$115216 14074 13780 14073 13916 13764 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115235 r0 *1 156.24,1123.92
X$115235 14074 13773 14073 13904 13734 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115238 m0 *1 193.2,1144.08
X$115238 14074 13800 14073 13911 13866 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115241 r0 *1 140.56,1023.12
X$115241 14074 12510 14073 12623 12648 12265 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115245 r0 *1 137.2,1002.96
X$115245 14074 12267 12347 14073 12268 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115250 m0 *1 137.76,1043.28
X$115250 14074 12267 12432 14073 12802 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115253 m0 *1 141.12,1033.2
X$115253 14074 12267 12721 14073 12648 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115255 m0 *1 248.08,1123.92
X$115255 14074 12267 13695 14073 13764 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115295 m0 *1 222.88,1033.2
X$115295 14074 14073 12271 12513 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115301 m0 *1 229.6,1013.04
X$115301 14074 12352 12413 14073 12272 12351 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $115304 r0 *1 286.72,1033.2
X$115304 12728 14073 12575 12878 14074 12273 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $115312 m0 *1 201.6,1134
X$115312 14073 12274 14074 13776 13866 13801 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $115314 m0 *1 166.32,1144.08
X$115314 14073 12274 14074 13775 13734 13735 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $115316 m0 *1 225.68,1134
X$115316 14073 12274 14074 13803 13763 13762 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $115341 m0 *1 288.4,1013.04
X$115341 14074 12355 12274 12357 12356 14073 12354
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $115353 m0 *1 297.36,1013.04
X$115353 14074 14073 12275 12356 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115356 m0 *1 323.12,1023.12
X$115356 14074 12276 12519 14073 12436 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115358 r0 *1 323.12,1002.96
X$115358 14074 12417 14073 12276 12418 12277 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115392 r0 *1 394.24,1002.96
X$115392 14074 12280 14073 12337 12421 12281 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115396 m0 *1 380.24,1013.04
X$115396 14074 12280 14073 12567 12523 12281 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115425 m0 *1 47.04,1033.2
X$115425 14074 14073 12281 12688 12717 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115428 r0 *1 42,1002.96
X$115428 14074 14073 12281 12391 12474 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115430 r0 *1 67.2,1002.96
X$115430 14074 14073 12281 12394 12479 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115432 m0 *1 156.24,1023.12
X$115432 14074 14073 12281 12572 12511 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115434 r0 *1 166.88,1164.24
X$115434 14074 14073 12281 14017 14044 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115436 r0 *1 232.96,1174.32
X$115436 14074 14073 12281 14069 14023 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115438 r0 *1 269.36,1174.32
X$115438 14074 14073 12281 14055 14058 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115441 r0 *1 285.04,1174.32
X$115441 14074 14073 12281 14056 14013 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115443 m0 *1 58.24,1093.68
X$115443 14074 14073 12281 13425 13258 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115447 r0 *1 105.84,1144.08
X$115447 14074 14073 12281 13899 13950 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115449 m0 *1 379.12,1033.2
X$115449 12522 14073 12281 12578 14074 12658 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $115457 m0 *1 369.04,1184.4
X$115457 14074 14073 12281 14052 14041 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115459 m0 *1 329.28,1002.96
X$115459 14074 14073 12332 12281 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $115470 r0 *1 431.2,1013.04
X$115470 12439 14073 12525 12440 14074 12283 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $115528 r0 *1 777.28,1033.2
X$115528 14073 12294 12668 14074 12738 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115530 m0 *1 706.16,1023.12
X$115530 14073 12294 12529 14074 12530 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115535 r0 *1 736.4,1063.44
X$115535 14073 12294 13006 14074 13177 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115537 m0 *1 777.84,1063.44
X$115537 14073 12294 13008 14074 13129 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115565 r0 *1 917.28,1063.44
X$115565 13275 14074 13169 14073 12302 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $115571 r0 *1 948.08,1002.96
X$115571 14074 12303 12304 14073 12382 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115580 m0 *1 980,1013.04
X$115580 14074 14073 12461 12305 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $115594 r0 *1 1045.52,1013.04
X$115594 14074 12467 12543 12466 12468 12309 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115597 r0 *1 1056.72,1002.96
X$115597 14074 12322 12404 12403 12387 12310 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115600 m0 *1 1094.24,1013.04
X$115600 14074 14073 12400 12311 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115603 m0 *1 1140.72,1023.12
X$115603 12610 14074 14073 12549 12615 12312 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $115608 m0 *1 1108.8,1013.04
X$115608 14074 12398 12313 12469 12389 12396 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115615 m0 *1 1162,1013.04
X$115615 14074 12315 12392 12471 12472 12390 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115620 r0 *1 1155.28,1002.96
X$115620 14074 14073 12392 12316 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115644 r0 *1 1073.52,1002.96
X$115644 14074 14073 12321 12401 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115658 m0 *1 1022.56,1013.04
X$115658 14074 12408 12325 12485 12407 12484 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115663 m0 *1 1005.76,1013.04
X$115663 14074 12483 12326 12409 12385 12463 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $115711 r0 *1 176.4,1002.96
X$115711 14074 14073 12329 12405 12406 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115760 m0 *1 71.68,1023.12
X$115760 14074 12343 12506 14073 12341 12570 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $115762 r0 *1 47.04,1013.04
X$115762 14073 12504 14074 12474 12428 12341 12426
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $115769 r0 *1 48.16,1023.12
X$115769 14074 14073 12341 12504 12426 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115777 m0 *1 63.28,1093.68
X$115777 14074 13614 12767 13404 12342 14073 13371
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $115779 m0 *1 63.28,1073.52
X$115779 14074 13301 12342 14073 13180 12767 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $115788 m0 *1 51.52,1043.28
X$115788 14074 12865 12719 12342 12505 14073 12552
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $115790 m0 *1 54.88,1023.12
X$115790 12427 14073 14074 12428 12342 12429 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $115792 r0 *1 57.68,1013.04
X$115792 14074 12427 14073 12476 12429 12342 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $115794 m0 *1 62.16,1043.28
X$115794 12505 12342 12719 12552 14074 14073 12909
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $115808 r0 *1 122.64,1013.04
X$115808 12344 14073 12432 12509 14074 12347 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $115816 m0 *1 118.16,1013.04
X$115816 14074 14073 12347 12402 12346 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $115823 r0 *1 110.88,1073.52
X$115823 14073 13111 12346 14074 13261 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115827 m0 *1 119.84,1083.6
X$115827 14073 12347 13261 14074 13348 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115845 m0 *1 278.32,1073.52
X$115845 14074 13119 12349 14073 13245 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115848 r0 *1 322,1033.2
X$115848 14074 12662 12349 14073 12787 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115855 r0 *1 314.72,1043.28
X$115855 14074 12880 12349 14073 12919 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $115907 m0 *1 294.56,1093.68
X$115907 14074 14073 13466 12349 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $115920 m0 *1 283.36,1053.36
X$115920 14074 12944 12878 14073 12353 12729 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $115928 r0 *1 283.36,1023.12
X$115928 14073 12354 12353 14074 12635 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115931 m0 *1 276.08,1053.36
X$115931 12942 12877 12353 12729 14074 14073 12992
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $115955 r0 *1 320.32,1063.44
X$115955 14074 12358 12808 14073 13067 13120 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $115965 m0 *1 314.72,1013.04
X$115965 14074 14073 12359 12417 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $115968 m0 *1 323.12,1043.28
X$115968 12808 14073 12359 13065 14074 12730 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $115971 m0 *1 318.08,1043.28
X$115971 14073 12359 12662 14074 12997 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $115980 m0 *1 444.64,1013.04
X$115980 14073 12441 14074 12423 12502 12362 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $115990 m0 *1 434.56,1023.12
X$115990 14073 12812 12525 14074 12363 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116041 m0 *1 840.56,1013.04
X$116041 14074 14073 12377 12455 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116065 m0 *1 990.08,1013.04
X$116065 14074 14073 12487 12383 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116067 r0 *1 996.24,1013.04
X$116067 14074 12384 12407 12462 12556 12555 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116074 r0 *1 1048.32,1002.96
X$116074 14074 14073 12404 12386 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116080 r0 *1 1062.32,1013.04
X$116080 14074 14073 12467 12387 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $116084 m0 *1 1101.52,1023.12
X$116084 14074 12550 12388 12551 12469 12607 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116090 r0 *1 1169.28,1002.96
X$116090 14074 14073 12470 12390 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116104 m0 *1 1149.12,1013.04
X$116104 14074 14073 12478 12393 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116129 r0 *1 1098.72,1013.04
X$116129 14074 12399 12465 12480 12551 12546 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116142 m0 *1 1069.04,1013.04
X$116142 14074 14073 12403 12481 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116166 r0 *1 1005.76,1002.96
X$116166 14074 14073 12409 12411 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116169 r0 *1 1015.28,1013.04
X$116169 14074 12485 12410 12542 12464 12465 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116181 m0 *1 960.96,1013.04
X$116181 14074 14073 12489 12412 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116235 m0 *1 53.2,1033.2
X$116235 14074 14073 12719 12426 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116241 m0 *1 82.88,1154.16
X$116241 13796 14073 14074 12428 13109 13108 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116244 m0 *1 253.12,1184.4
X$116244 13934 14074 12428 14057 14073 14024 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116246 r0 *1 68.32,1053.36
X$116246 12987 14074 12428 13028 14073 13051 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116248 m0 *1 47.6,1073.52
X$116248 13254 14073 14074 12428 13180 12865 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116252 r0 *1 70,1103.76
X$116252 13561 14074 12428 13562 14073 13633 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116254 m0 *1 56,1103.76
X$116254 13404 14074 12428 13492 14073 13544 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116256 m0 *1 408.24,1144.08
X$116256 13929 14073 14074 12428 13744 13838 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116258 m0 *1 411.04,1134
X$116258 13760 14073 14074 12428 13743 13665 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116296 r0 *1 47.04,1033.2
X$116296 14073 12716 14074 12717 12428 12505 12718
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116301 m0 *1 160.72,1164.24
X$116301 14018 14073 14074 12428 13966 13967 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116303 r0 *1 173.04,1174.32
X$116303 14073 14020 14074 14044 12428 13932 14031
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116306 r0 *1 196,1174.32
X$116306 13933 14074 12428 14032 14073 14047 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116309 r0 *1 235.76,1164.24
X$116309 14073 14007 14074 14023 12428 13879 14008
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116312 m0 *1 265.44,1184.4
X$116312 14073 14070 14074 14058 12428 13971 14014
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116319 m0 *1 138.32,1113.84
X$116319 13640 14073 14074 12428 13456 13617 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116321 r0 *1 52.64,1043.28
X$116321 12929 14073 14074 12428 12800 12866 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116325 r0 *1 59.36,1073.52
X$116325 14073 13257 14074 13258 12428 13259 13301
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116327 r0 *1 81.2,1043.28
X$116327 12647 14074 12428 12867 14073 12910 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116330 r0 *1 57.68,1113.84
X$116330 13733 14073 14074 12428 13521 13614 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116332 m0 *1 102.48,1154.16
X$116332 14073 13930 14074 13950 12428 13771 12932
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116335 r0 *1 407.12,1093.68
X$116335 14074 14073 13517 12428 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $116337 r0 *1 310.24,1164.24
X$116337 14071 14073 14074 12428 13974 13976 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116339 m0 *1 381.92,1164.24
X$116339 14025 14073 14074 12428 13942 13995 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116341 r0 *1 404.88,1154.16
X$116341 13997 14073 14074 12428 13940 13886 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $116345 r0 *1 365.12,1174.32
X$116345 14073 14072 14074 14041 12428 13992 14040
+ gf180mcu_fd_sc_mcu9t5v0__oai31_2
* cell instance $116348 m0 *1 62.72,1023.12
X$116348 14074 12429 12570 12505 12506 14073 12552
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $116355 m0 *1 132.16,1063.44
X$116355 14073 13182 13056 14074 12432 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116358 r0 *1 135.52,1013.04
X$116358 14074 14073 12432 12486 12509 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116361 r0 *1 134.96,1033.2
X$116361 12720 14073 12646 12432 14074 12721 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $116365 r0 *1 132.72,1043.28
X$116365 14074 14073 12720 12913 12432 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116368 r0 *1 226.24,1033.2
X$116368 14073 12726 12492 14074 12433 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116387 r0 *1 276.08,1013.04
X$116387 14074 14073 12435 12518 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116398 r0 *1 349.44,1103.76
X$116398 14074 14073 12438 14148 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $116460 r0 *1 443.52,1043.28
X$116460 12884 14073 12883 12953 14074 12439 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $116467 r0 *1 404.32,1023.12
X$116467 14074 14073 12659 12641 12439 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116469 r0 *1 406.56,1053.36
X$116469 13000 14073 12439 12526 14074 12948 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $116574 m0 *1 747.04,1083.6
X$116574 14074 14073 12454 14141 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $116613 m0 *1 918.4,1033.2
X$116613 14074 14073 12539 12710 12460 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116615 r0 *1 974.4,1013.04
X$116615 12489 14074 14073 12558 12706 12461 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $116620 r0 *1 1018.08,1023.12
X$116620 14074 12627 12464 12751 12462 12603 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116624 m0 *1 1014.72,1023.12
X$116624 14074 12622 12463 12629 12542 12630 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116637 r0 *1 1047.76,1033.2
X$116637 14074 14073 12466 12752 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116654 r0 *1 1152.48,1013.04
X$116654 14074 12475 12478 12470 12548 12547 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116660 r0 *1 1174.32,1013.04
X$116660 14074 14073 12471 12549 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116664 m0 *1 1169.84,1023.12
X$116664 14074 12614 12472 12762 12611 12613 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116722 r0 *1 101.92,1093.68
X$116722 14074 12477 14173 14073 gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* cell instance $116753 r0 *1 1124.48,1013.04
X$116753 14074 14073 12480 12609 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116756 r0 *1 1051.12,1023.12
X$116756 14074 12604 12627 12694 12481 12605 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116781 r0 *1 1001.28,1023.12
X$116781 14074 12624 12487 12632 12629 12602 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $116799 m0 *1 918.4,1023.12
X$116799 14074 14073 12539 12540 12491 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116809 r0 *1 231.28,1033.2
X$116809 14073 12807 12492 14074 12782 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116812 m0 *1 226.8,1043.28
X$116812 12650 14073 12806 12492 14074 12870 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $116814 r0 *1 267.12,1013.04
X$116814 12514 14074 12562 12517 14073 12493 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $116848 r0 *1 412.72,1013.04
X$116848 14073 12525 12500 14074 12526 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116859 r0 *1 42,1023.12
X$116859 14074 14073 12503 12612 12688 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116882 r0 *1 42,1033.2
X$116882 14074 14073 12505 12716 12718 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116885 r0 *1 63.84,1033.2
X$116885 12506 12505 12570 12552 14074 14073 12767
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $116889 r0 *1 76.72,1033.2
X$116889 14074 14073 12647 12931 12506 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116907 m0 *1 161.84,1033.2
X$116907 14074 14073 12506 12649 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116912 r0 *1 131.6,1053.36
X$116912 14073 12988 13056 14074 12508 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $116917 r0 *1 118.16,1033.2
X$116917 14074 12571 12720 14073 12646 12508 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $116923 m0 *1 111.44,1023.12
X$116923 14074 14073 12508 12554 12509 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116926 m0 *1 110.32,1053.36
X$116926 14074 14073 12508 12934 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116928 m0 *1 114.24,1043.28
X$116928 14074 14073 12720 12801 12508 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $116930 m0 *1 134.4,1033.2
X$116930 12720 14073 12646 12510 14074 12509 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $116951 m0 *1 165.2,1033.2
X$116951 14073 12703 14074 12570 12511 12649 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $116966 r0 *1 268.8,1033.2
X$116966 14074 14073 12575 12515 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $116986 r0 *1 362.88,1154.16
X$116986 13942 12520 13705 13941 14074 14073 13935
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $116988 r0 *1 372.96,1154.16
X$116988 13942 12520 13705 13941 14074 14073 13979
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $116991 r0 *1 380.24,1013.04
X$116991 14074 14073 12521 12522 12567 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $116996 m0 *1 379.12,1053.36
X$116996 14074 12810 12947 14073 12522 12948 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $117010 m0 *1 372.96,1053.36
X$117010 12947 14073 12522 12879 14074 12999 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $117012 m0 *1 382.48,1063.44
X$117012 14074 12523 12947 13000 12625 14073 13105
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $117019 m0 *1 383.04,1023.12
X$117019 14074 14073 12523 12578 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117029 r0 *1 390.88,1023.12
X$117029 14074 14073 12524 12579 12734 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117031 r0 *1 410.48,1023.12
X$117031 14073 12659 12524 14074 12525 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $117033 m0 *1 400.96,1023.12
X$117033 14073 12524 12641 14074 12580 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $117052 m0 *1 417.76,1063.44
X$117052 14073 12812 12526 14074 13105 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $117054 m0 *1 410.48,1063.44
X$117054 13000 12812 12526 12999 14074 14073 13178
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $117077 m0 *1 656.32,1043.28
X$117077 14074 12736 14073 12886 12529 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117079 r0 *1 661.36,1033.2
X$117079 14074 12737 14073 12798 12529 12819 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117084 r0 *1 691.6,1033.2
X$117084 14074 12665 14073 12861 12529 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117086 m0 *1 683.2,1043.28
X$117086 14074 12818 14073 12983 12529 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117106 r0 *1 745.36,1033.2
X$117106 14074 12667 14073 12792 12533 12819 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117110 m0 *1 729.12,1033.2
X$117110 14074 12666 14073 12860 12533 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117113 r0 *1 717.36,1043.28
X$117113 14074 12740 14073 12925 12533 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117115 r0 *1 748.72,1043.28
X$117115 14074 12820 14073 12923 12533 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117132 m0 *1 916.72,1043.28
X$117132 14074 14073 12539 12896 12538 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117145 r0 *1 916.72,1023.12
X$117145 14074 14073 12539 12638 12593 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117148 r0 *1 915.04,1033.2
X$117148 14074 14073 12539 12744 12675 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117152 r0 *1 920.08,1033.2
X$117152 14074 14073 12539 12783 12786 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117154 r0 *1 921.76,1023.12
X$117154 14074 14073 12539 12853 12637 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117158 m0 *1 911.12,1043.28
X$117158 14074 14073 12539 12826 12855 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117160 r0 *1 911.12,1023.12
X$117160 14074 14073 12539 12677 12591 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117163 m0 *1 906.08,1043.28
X$117163 14074 14073 12539 12825 12711 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117165 r0 *1 910,1033.2
X$117165 14074 14073 12539 13207 12788 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117168 m0 *1 908.32,1033.2
X$117168 14073 12539 12592 14074 12674 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $117183 r0 *1 1044.4,1023.12
X$117183 14074 14073 12543 12682 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117186 m0 *1 1050.56,1023.12
X$117186 14074 14073 12544 12605 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117202 r0 *1 1073.52,1103.76
X$117202 14074 14073 13627 13422 12545 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117211 r0 *1 1107.68,1033.2
X$117211 14074 12772 12546 12844 12771 12760 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117224 m0 *1 1129.52,1023.12
X$117224 14074 14073 12618 12550 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117239 r0 *1 57.12,1033.2
X$117239 14074 14073 12719 12718 12552 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117254 m0 *1 1000.72,1023.12
X$117254 14074 14073 12557 12555 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117263 m0 *1 1002.4,1083.6
X$117263 14074 14073 12601 12556 gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* cell instance $117265 r0 *1 996.8,1113.84
X$117265 14074 14073 12556 13683 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $117272 m0 *1 994.56,1023.12
X$117272 14074 14073 12632 12558 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117324 m0 *1 69.44,1043.28
X$117324 14074 14073 12570 12866 12842 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117332 m0 *1 156.24,1033.2
X$117332 14074 14073 12699 12700 12572 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117410 m0 *1 435.12,1033.2
X$117410 14074 14073 12625 12581 12735 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117421 m0 *1 434,1043.28
X$117421 12584 12813 12585 12582 14074 14073 12883
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $117434 m0 *1 440.72,1033.2
X$117434 12584 14074 12862 14073 12715 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $117436 r0 *1 435.12,1033.2
X$117436 12584 12813 12585 12814 14074 14073 12735
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $117438 r0 *1 429.52,1033.2
X$117438 14074 14073 12584 12794 12734 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117462 m0 *1 664.72,1033.2
X$117462 14074 14073 12799 12589 12798 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117464 m0 *1 674.24,1073.52
X$117464 14074 14073 13251 12589 13252 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117467 m0 *1 682.64,1073.52
X$117467 14074 14073 13271 12589 13296 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117470 r0 *1 686,1053.36
X$117470 14074 14073 13004 12589 13042 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117473 m0 *1 678.16,1053.36
X$117473 14074 14073 12927 12589 12983 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117476 r0 *1 712.32,1083.6
X$117476 14074 14073 13341 12589 13396 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117479 r0 *1 706.72,1083.6
X$117479 14074 14073 13398 12589 13295 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117482 m0 *1 724.08,1093.68
X$117482 14074 14073 13397 12589 13294 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117484 r0 *1 736.96,1083.6
X$117484 14074 14073 13339 12589 13272 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117487 r0 *1 677.6,1083.6
X$117487 14074 14073 13399 12589 13342 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117489 m0 *1 691.6,1043.28
X$117489 14074 14073 12664 12589 12861 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117492 r0 *1 741.44,1043.28
X$117492 14074 14073 12888 12589 12923 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117494 r0 *1 710.64,1053.36
X$117494 14074 14073 13005 12589 13041 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117496 r0 *1 710.64,1043.28
X$117496 14074 14073 12926 12589 12925 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117498 m0 *1 724.64,1043.28
X$117498 14074 14073 12793 12589 12860 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117501 r0 *1 738.08,1033.2
X$117501 14074 14073 12858 12589 12792 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117504 r0 *1 820.4,1083.6
X$117504 14074 14073 13441 12589 13384 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117506 r0 *1 790.72,1093.68
X$117506 14074 14073 13512 12589 13511 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117508 m0 *1 789.6,1093.68
X$117508 14074 14073 13360 12589 13442 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117510 m0 *1 647.92,1053.36
X$117510 14074 14073 12928 12589 12886 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117512 m0 *1 653.52,1053.36
X$117512 14074 14073 12985 12589 12984 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117515 m0 *1 649.04,1063.44
X$117515 14074 14073 13095 12589 13043 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117517 m0 *1 655.2,1063.44
X$117517 14074 14073 13126 12589 13179 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117519 r0 *1 770.56,1083.6
X$117519 14074 14073 13480 12589 13388 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117522 r0 *1 777.84,1083.6
X$117522 14074 14073 13444 12589 13390 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117525 r0 *1 745.92,1083.6
X$117525 14074 14073 13394 12589 13392 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117528 m0 *1 762.72,1093.68
X$117528 14074 14073 13391 12589 13445 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117530 r0 *1 763.84,1063.44
X$117530 14074 14073 13176 12589 13249 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117532 m0 *1 778.4,1073.52
X$117532 14074 14073 13202 12589 13247 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117534 m0 *1 800.24,1083.6
X$117534 14074 14073 13335 12589 13386 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117561 m0 *1 800.24,1043.28
X$117561 14074 14073 12589 12789 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117577 r0 *1 932.96,1033.2
X$117577 14074 14073 12745 12595 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117586 m0 *1 946.96,1033.2
X$117586 14074 12746 14073 12784 12600 12597 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $117589 r0 *1 939.68,1053.36
X$117589 12597 14074 12746 12827 14073 12961 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $117591 m0 *1 951.44,1063.44
X$117591 12746 14074 14073 13088 13135 12597 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $117598 r0 *1 944.16,1033.2
X$117598 12598 14074 12679 12746 14073 12747 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $117613 m0 *1 1004.64,1043.28
X$117613 14074 12849 12602 12777 12850 12831 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117621 r0 *1 997.92,1023.12
X$117621 14074 14073 12702 12603 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117629 m0 *1 1042.16,1033.2
X$117629 14074 12604 12696 12753 12683 12682 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117637 m0 *1 1090.32,1053.36
X$117637 14074 12756 12833 13027 12907 12606 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117640 m0 *1 1109.92,1033.2
X$117640 14074 12690 12607 12771 12685 12689 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117644 r0 *1 1126.16,1023.12
X$117644 14074 12610 12621 12608 12686 12609 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117648 r0 *1 1117.76,1023.12
X$117648 14074 14073 12608 12624 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117673 m0 *1 1149.12,1033.2
X$117673 14074 14073 12765 12615 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117683 r0 *1 1140.72,1033.2
X$117683 14074 12769 12618 12766 12761 12768 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117699 m0 *1 1119.44,1023.12
X$117699 14074 14073 12621 12622 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117711 r0 *1 442.4,1053.36
X$117711 14074 13098 12625 14073 12884 12883 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $117714 m0 *1 378,1093.68
X$117714 14074 13474 12625 14073 13469 13358 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $117741 r0 *1 1069.04,1023.12
X$117741 14074 14073 12626 12683 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117757 r0 *1 1020.32,1033.2
X$117757 14074 12695 12630 12850 12751 12681 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117772 m0 *1 980,1033.2
X$117772 14074 12680 12702 12779 12701 12634 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117791 m0 *1 912.24,1134
X$117791 14074 13579 13794 13782 13648 12638 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $117799 r0 *1 823.2,1023.12
X$117799 14074 14073 12640 12673 12642 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $117815 r0 *1 464.8,1023.12
X$117815 14073 12714 12644 14074 12645 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $117843 m0 *1 75.04,1043.28
X$117843 14074 14073 12800 12842 12647 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117845 r0 *1 76.16,1043.28
X$117845 14074 14073 12647 12693 12867 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $117863 r0 *1 206.08,1033.2
X$117863 14074 14073 12650 12724 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117870 r0 *1 274.96,1043.28
X$117870 12728 14073 12943 12877 14074 12652 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $117887 m0 *1 323.68,1073.52
X$117887 13120 14074 14073 12654 13066 13188 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $117889 m0 *1 328.16,1063.44
X$117889 13066 14073 12654 13067 14074 13065 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $117892 m0 *1 324.8,1033.2
X$117892 14074 14073 12654 12655 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117919 r0 *1 460.32,1093.68
X$117919 14074 14073 12659 13479 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117970 m0 *1 789.6,1033.2
X$117970 14074 12668 14073 12672 12669 12789 12670
+ gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* cell instance $117978 m0 *1 795.2,1043.28
X$117978 14074 14073 12669 12790 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $117996 m0 *1 791.28,1053.36
X$117996 12821 14073 12741 12671 14074 13010 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $118009 m0 *1 904.96,1063.44
X$118009 14074 13437 13131 13012 12674 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $118014 r0 *1 936.32,1033.2
X$118014 12676 14073 14074 12746 12745 12827 gf180mcu_fd_sc_mcu9t5v0__nor3_2
* cell instance $118017 m0 *1 916.16,1123.92
X$118017 14074 13579 13707 13709 13648 12677 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118024 m0 *1 941.92,1033.2
X$118024 14074 14073 12784 12678 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118032 m0 *1 941.36,1043.28
X$118032 14074 14073 12679 12745 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $118038 r0 *1 972.16,1033.2
X$118038 14074 12680 12780 12750 12749 12748 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118044 m0 *1 946.4,1083.6
X$118044 14074 14073 12680 13315 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $118046 r0 *1 970.48,1043.28
X$118046 14074 12680 12976 13032 12901 12902 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118048 m0 *1 961.52,1073.52
X$118048 14074 12680 13241 13212 13211 13210 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118051 m0 *1 1009.12,1033.2
X$118051 14074 12778 12681 12776 12697 12696 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118066 m0 *1 1070.16,1033.2
X$118066 14074 12844 12695 12684 12755 12694 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118070 m0 *1 1081.92,1043.28
X$118070 14074 14073 12684 12754 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118074 m0 *1 1136.8,1043.28
X$118074 12758 14074 14073 12764 12969 12686 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $118079 r0 *1 1157.52,1033.2
X$118079 14074 12762 12765 12763 12838 12687 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118082 m0 *1 1160.32,1033.2
X$118082 14074 14073 12766 12687 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118101 m0 *1 87.36,1033.2
X$118101 14073 12693 12910 14074 12692 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118122 r0 *1 994.56,1033.2
X$118122 14074 14073 12780 12697 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118127 r0 *1 999.04,1033.2
X$118127 14074 12775 12781 12698 12777 12830 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118130 m0 *1 969.36,1033.2
X$118130 14074 14073 12698 12705 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118153 m0 *1 982.8,1043.28
X$118153 14074 14073 12829 12704 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118163 m0 *1 976.64,1033.2
X$118163 14074 14073 12781 12706 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118165 m0 *1 193.2,1033.2
X$118165 14074 14073 12722 12708 12707 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $118180 m0 *1 915.04,1144.08
X$118180 14074 13579 13927 13869 13648 12710 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118225 m0 *1 78.4,1053.36
X$118225 14074 12719 12931 14073 12930 12932 13052
+ gf180mcu_fd_sc_mcu9t5v0__nor4_2
* cell instance $118248 m0 *1 201.6,1043.28
X$118248 14074 14073 12854 12723 12869 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $118258 r0 *1 197.12,1043.28
X$118258 14073 12723 12869 14074 12916 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118261 r0 *1 220.08,1043.28
X$118261 14073 12805 12723 14074 12806 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118265 m0 *1 206.08,1053.36
X$118265 12724 14074 12979 12804 14073 12991 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $118278 r0 *1 232.96,1043.28
X$118278 12871 12875 12992 12806 14074 14073 12726
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $118282 r0 *1 270.48,1093.68
X$118282 14073 12728 13354 14074 13529 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118284 r0 *1 275.52,1093.68
X$118284 14074 14073 13610 12728 13354 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $118318 m0 *1 386.4,1053.36
X$118318 14073 12879 14074 12859 12949 12734 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $118320 r0 *1 386.4,1053.36
X$118320 14073 12947 14074 13049 13102 12734 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $118330 r0 *1 394.24,1053.36
X$118330 14074 14073 12937 13107 12734 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $118334 r0 *1 425.04,1053.36
X$118334 14074 13048 14073 13101 12734 12952 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118350 r0 *1 738.08,1073.52
X$118350 14074 13197 14073 13272 13006 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118367 m0 *1 777.84,1083.6
X$118367 14074 13201 14073 13390 13008 12738 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118369 m0 *1 751.52,1083.6
X$118369 14074 13198 14073 13392 12738 13010 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118371 m0 *1 790.72,1083.6
X$118371 14074 13274 14073 13442 12738 13070 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118391 r0 *1 794.08,1043.28
X$118391 14074 14073 12741 12892 12823 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $118397 m0 *1 830.48,1043.28
X$118397 12821 14074 12823 12857 14073 12742 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $118401 r0 *1 844.48,1033.2
X$118401 14074 12743 12742 14073 12824 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $118413 r0 *1 906.64,1093.68
X$118413 14074 13361 13510 13534 12744 13131 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118440 m0 *1 979.44,1053.36
X$118440 14074 13076 12974 13031 12750 12976 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118449 m0 *1 1053.92,1043.28
X$118449 14074 12753 12848 12906 12834 12832 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118452 r0 *1 1070.16,1033.2
X$118452 14074 12758 12774 12846 12757 12754 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118456 m0 *1 1086.4,1043.28
X$118456 14074 12966 12755 12834 12843 12833 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118462 m0 *1 1107.12,1053.36
X$118462 13026 14074 14073 12970 13025 12757 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $118470 m0 *1 1104.88,1043.28
X$118470 14074 12835 12760 12843 12836 12759 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118487 m0 *1 1164.8,1033.2
X$118487 14074 14073 12763 12764 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118523 m0 *1 1125.04,1043.28
X$118523 14074 14073 12837 12772 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118531 r0 *1 1044.4,1033.2
X$118531 14074 14073 12774 12849 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118537 m0 *1 1070.72,1043.28
X$118537 14074 14073 12846 12775 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118539 r0 *1 1013.6,1043.28
X$118539 14074 12776 12831 12973 12904 12848 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118550 m0 *1 1001.28,1043.28
X$118550 14074 14073 12779 12778 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118567 r0 *1 221.76,1033.2
X$118567 14074 14073 12782 12804 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118578 r0 *1 931.28,1053.36
X$118578 14073 13074 14074 13090 13073 12785 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $118620 r0 *1 442.96,1033.2
X$118620 14074 14073 12797 12796 12794 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $118649 r0 *1 52.08,1053.36
X$118649 14074 12929 14073 13021 12866 12800 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118655 m0 *1 73.36,1053.36
X$118655 14074 14073 12987 12930 12800 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $118682 r0 *1 213.36,1043.28
X$118682 14074 14073 12805 12869 12938 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $118684 m0 *1 236.32,1053.36
X$118684 14074 14073 12805 12939 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118692 m0 *1 232.96,1043.28
X$118692 14073 12872 12806 14074 12807 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118712 m0 *1 322,1063.44
X$118712 12808 14073 13067 13120 14074 12998 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $118714 m0 *1 318.08,1073.52
X$118714 14074 14073 12808 13186 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118716 m0 *1 314.16,1063.44
X$118716 12808 12880 12997 13065 14074 14073 12875
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $118723 m0 *1 381.92,1043.28
X$118723 12879 14074 12809 12810 14073 12811 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $118726 r0 *1 399.28,1053.36
X$118726 14074 14073 13049 12809 12948 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $118745 m0 *1 442.4,1053.36
X$118745 12883 14073 12953 12814 14074 12812 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $118747 m0 *1 441.84,1093.68
X$118747 14073 13479 12812 14074 13515 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $118758 m0 *1 423.36,1073.52
X$118758 14074 14073 13250 13192 12813 13193 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $118768 m0 *1 444.08,1043.28
X$118768 14073 12813 12814 14074 12862 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118776 m0 *1 435.68,1053.36
X$118776 14073 12951 12950 14074 12814 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118799 r0 *1 441.28,1063.44
X$118799 12815 14073 12885 13069 14074 12953 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $118801 r0 *1 470.96,1053.36
X$118801 14073 12815 12885 14074 13045 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118810 m0 *1 469.84,1043.28
X$118810 14073 12863 12864 14074 12817 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118822 r0 *1 764.96,1053.36
X$118822 14074 13039 14073 13249 13008 12819 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118834 r0 *1 716.24,1053.36
X$118834 14074 13007 14073 13041 12819 13006 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118856 r0 *1 763.84,1043.28
X$118856 14074 14073 12821 12955 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118864 r0 *1 767.2,1043.28
X$118864 14074 14073 12822 12891 12823 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $118883 r0 *1 772.8,1043.28
X$118883 14073 12891 12823 14074 12920 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118887 r0 *1 782.88,1043.28
X$118887 14073 12892 12823 14074 12890 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $118890 m0 *1 843.36,1053.36
X$118890 14074 14073 12894 12824 12892 12981 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $118892 r0 *1 912.24,1103.76
X$118892 14074 13579 13604 13580 13648 12825 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118899 m0 *1 902.16,1073.52
X$118899 14074 13206 13210 13208 12826 13131 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118902 m0 *1 947.52,1073.52
X$118902 12827 14074 14073 13292 13316 12899 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $118905 r0 *1 939.12,1043.28
X$118905 14074 12899 12827 14073 12900 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $118909 m0 *1 934.08,1063.44
X$118909 14074 13134 14073 13074 12827 13075 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $118914 m0 *1 955.36,1053.36
X$118914 14074 14073 12977 12828 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $118916 r0 *1 988.4,1043.28
X$118916 14074 12914 12829 12851 12915 12903 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118919 m0 *1 1008,1053.36
X$118919 14074 12972 12830 12915 12973 13030 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118925 r0 *1 1064.56,1053.36
X$118925 14074 13087 12832 13029 13027 13015 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118941 r0 *1 1127.84,1053.36
X$118941 14074 13024 12837 13023 13079 13078 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118945 m0 *1 1167.6,1043.28
X$118945 14074 12839 12838 12908 12840 12841 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118977 m0 *1 1071.28,1053.36
X$118977 14074 12847 12964 13156 13016 12965 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $118994 m0 *1 986.72,1043.28
X$118994 14074 14073 12851 12852 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119018 m0 *1 827.12,1043.28
X$119018 14074 14073 12893 12857 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119048 r0 *1 47.6,1083.6
X$119048 14074 13254 14073 13282 12865 13180 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119050 m0 *1 85.68,1063.44
X$119050 14074 13108 13110 14073 12866 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $119059 r0 *1 77.84,1053.36
X$119059 14074 13028 12930 14073 12867 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $119076 r0 *1 245.28,1093.68
X$119076 14074 13462 12872 14073 12870 13463 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $119082 m0 *1 230.16,1053.36
X$119082 14073 12938 12870 14074 13038 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119084 m0 *1 244.16,1093.68
X$119084 13411 12872 12870 13463 14074 14073 13461
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $119087 r0 *1 239.68,1073.52
X$119087 14074 12871 13242 14073 13337 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $119099 r0 *1 232.96,1053.36
X$119099 12871 14073 12943 12992 14074 12938 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119104 m0 *1 238,1063.44
X$119104 12871 14073 12875 12992 14074 12872 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119106 r0 *1 234.64,1073.52
X$119106 14074 14073 12871 13336 13242 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119122 r0 *1 247.52,1043.28
X$119122 14074 14073 12874 12873 12872 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119124 m0 *1 239.68,1053.36
X$119124 14073 12939 12872 14074 12993 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119131 r0 *1 252.56,1043.28
X$119131 14074 14073 12874 12876 12875 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119149 m0 *1 273.28,1073.52
X$119149 14074 14073 12877 13354 12875 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119151 m0 *1 266.56,1053.36
X$119151 14074 14073 12875 12996 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119153 r0 *1 282.24,1043.28
X$119153 14073 12877 12875 14074 12878 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119159 r0 *1 272.16,1063.44
X$119159 14073 13062 13119 14074 12877 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119184 r0 *1 317.52,1053.36
X$119184 12880 14073 12998 12997 14074 12943 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119214 r0 *1 413.84,1063.44
X$119214 12884 14074 14073 12950 12951 13104 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $119235 r0 *1 453.04,1053.36
X$119235 14074 14073 13001 13068 12885 13046 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $119255 m0 *1 763.28,1083.6
X$119255 14074 13199 14073 13445 13008 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119276 m0 *1 719.6,1083.6
X$119276 14074 13314 14073 13396 13006 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119278 m0 *1 799.68,1093.68
X$119278 14074 13203 14073 13511 13010 12887 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119280 r0 *1 813.12,1083.6
X$119280 14074 13204 14073 13384 12887 13070 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119289 m0 *1 770.56,1083.6
X$119289 14074 13200 14073 13388 13008 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119303 m0 *1 711.2,1073.52
X$119303 14074 13195 14073 13295 13006 12889 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119306 r0 *1 804.72,1073.52
X$119306 14074 13273 14073 13247 12889 13010 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119308 r0 *1 805.84,1083.6
X$119308 14074 13205 14073 13386 12889 13070 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119323 r0 *1 815.36,1043.28
X$119323 14074 14073 12892 12891 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119338 r0 *1 820.96,1043.28
X$119338 12893 14074 14073 12956 12957 14122 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $119349 r0 *1 912.24,1134
X$119349 14074 13579 13822 13756 13648 12896 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $119358 r0 *1 929.6,1043.28
X$119358 12959 14073 12897 12960 14074 12898 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119361 m0 *1 924.56,1053.36
X$119361 14074 12959 14073 13034 12960 12897 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $119364 m0 *1 928.48,1063.44
X$119364 14074 13134 12898 14073 13133 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $119379 m0 *1 941.36,1063.44
X$119379 14074 14073 12899 13090 13075 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119383 m0 *1 940.8,1053.36
X$119383 14073 12961 12900 14074 12960 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119391 m0 *1 999.04,1063.44
X$119391 14074 13161 12903 13160 13139 13138 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $119395 m0 *1 1024.8,1053.36
X$119395 14074 14073 12974 12904 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119399 r0 *1 982.8,1053.36
X$119399 14074 14073 12905 13076 gf180mcu_fd_sc_mcu9t5v0__inv_3
* cell instance $119402 r0 *1 996.24,1053.36
X$119402 14074 14073 12905 13137 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $119408 m0 *1 1062.88,1053.36
X$119408 14074 14073 12906 12963 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119413 m0 *1 1142.4,1053.36
X$119413 14074 12908 12968 12967 13018 13017 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $119419 m0 *1 66.64,1103.76
X$119419 14074 13562 12909 13521 13404 14073 13371
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $119423 r0 *1 64.96,1093.68
X$119423 14074 14073 12909 13492 13371 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119442 m0 *1 1032.64,1053.36
X$119442 14074 14073 12971 12914 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119475 m0 *1 402.08,1113.84
X$119475 14074 14073 13666 12921 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119477 r0 *1 398.72,1113.84
X$119477 14074 14073 13664 13687 12921 13663 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $119484 m0 *1 416.08,1053.36
X$119484 14074 14073 12950 12922 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119522 m0 *1 168.56,1164.24
X$119522 14074 12932 13932 14073 13966 14002 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $119525 m0 *1 97.44,1154.16
X$119525 14074 14073 13771 13930 12932 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119534 m0 *1 177.52,1053.36
X$119534 13037 14074 12935 12978 14073 13036 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $119550 m0 *1 400.96,1063.44
X$119550 12937 14074 13178 14073 13050 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $119567 r0 *1 244.72,1063.44
X$119567 14074 14073 12940 13170 13117 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119575 m0 *1 286.16,1083.6
X$119575 14074 14073 13340 12942 12944 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $119584 r0 *1 287.28,1083.6
X$119584 14073 12942 12944 14074 13338 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119595 m0 *1 286.16,1073.52
X$119595 14073 13062 12943 14074 13064 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119599 r0 *1 239.68,1063.44
X$119599 14074 14073 12943 13242 12992 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119643 r0 *1 450.8,1073.52
X$119643 14073 13125 14074 13269 13270 12950 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $119670 m0 *1 428.96,1053.36
X$119670 14074 14073 12951 12952 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119701 m0 *1 823.2,1063.44
X$119701 14074 14073 13071 12957 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119714 m0 *1 931.84,1053.36
X$119714 14074 14073 13075 12959 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $119725 m0 *1 1046.08,1053.36
X$119725 14074 13026 12962 12971 13014 12963 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $119727 m0 *1 1042.72,1053.36
X$119727 14074 14073 12962 12972 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119734 m0 *1 1067.92,1053.36
X$119734 14074 14073 12964 13015 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119740 m0 *1 1114.4,1063.44
X$119740 14074 14073 13229 12966 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119745 m0 *1 1135.12,1053.36
X$119745 14074 14073 12967 12970 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119750 m0 *1 1139.04,1053.36
X$119750 14074 14073 12968 12969 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119783 m0 *1 981.12,1063.44
X$119783 14074 13162 12977 13165 13160 13136 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $119792 r0 *1 210.56,1053.36
X$119792 14074 14073 13115 12979 13038 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $119795 m0 *1 210.56,1063.44
X$119795 14074 14073 13061 12979 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119799 r0 *1 211.68,1063.44
X$119799 14073 12979 13038 14074 13240 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $119827 m0 *1 394.8,1053.36
X$119827 14074 14073 12986 13106 13107 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119830 r0 *1 85.12,1063.44
X$119830 14074 14073 13109 13110 12987 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119841 m0 *1 73.36,1063.44
X$119841 14074 14073 12987 13086 13028 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119861 r0 *1 152.32,1134
X$119861 13772 14073 13773 12988 14074 13797 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119864 r0 *1 128.8,1063.44
X$119864 14074 14073 12988 13157 13055 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119866 r0 *1 133.28,1123.92
X$119866 14074 14073 12988 13769 13264 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119873 r0 *1 200.48,1083.6
X$119873 14074 13351 13061 14073 12990 13038 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $119875 r0 *1 188.16,1053.36
X$119875 14074 12990 12991 14073 13093 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $119886 m0 *1 185.92,1063.44
X$119886 14074 14073 12990 13164 12991 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $119888 r0 *1 199.36,1073.52
X$119888 12990 14073 13266 13185 14074 13168 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $119890 m0 *1 201.6,1093.68
X$119890 13061 12990 13266 13409 14074 14073 13459
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $119900 m0 *1 195.44,1073.52
X$119900 14074 14073 12991 13185 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $119926 m0 *1 221.76,1123.92
X$119926 14074 14073 12994 14152 gf180mcu_fd_sc_mcu9t5v0__inv_4
* cell instance $119999 r0 *1 323.68,1053.36
X$119999 14073 12998 12997 14074 13044 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120017 r0 *1 450.8,1093.68
X$120017 14074 14073 13514 13313 13000 13513 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $120110 r0 *1 935.76,1083.6
X$120110 13171 14074 14073 13508 13507 13013 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $120118 r0 *1 926.8,1063.44
X$120118 14074 13171 14073 13169 13133 13013 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $120120 m0 *1 923.44,1063.44
X$120120 14073 13013 13073 14074 13132 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120123 r0 *1 1058.96,1063.44
X$120123 13158 14074 14073 13151 13155 13014 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $120136 m0 *1 1075.2,1063.44
X$120136 14074 14073 13016 13143 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $120138 r0 *1 1146.88,1053.36
X$120138 14074 14073 13023 13017 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120143 r0 *1 1154.72,1053.36
X$120143 14074 13084 13018 13080 13022 13081 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120168 r0 *1 1118.88,1053.36
X$120168 14074 14073 13146 13025 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120182 m0 *1 80.64,1144.08
X$120182 14074 14073 13949 13028 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120190 r0 *1 1029.84,1063.44
X$120190 14074 13029 13159 13142 13141 13140 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120197 r0 *1 996.24,1063.44
X$120197 14074 13159 13030 13139 13163 13239 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120203 r0 *1 1004.08,1053.36
X$120203 14074 14073 13031 13163 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120208 r0 *1 992.88,1063.44
X$120208 14074 14073 13032 13238 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120237 m0 *1 242.48,1103.76
X$120237 13411 14073 13038 13463 14074 13603 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $120289 m0 *1 68.32,1063.44
X$120289 14073 13086 13051 14074 13085 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120293 m0 *1 93.52,1134
X$120293 14074 14073 13771 13052 13109 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $120303 m0 *1 127.12,1063.44
X$120303 14073 13054 13055 14074 13056 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120307 m0 *1 135.52,1073.52
X$120307 14073 13059 13264 14074 13055 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120315 m0 *1 140.56,1073.52
X$120315 14074 14073 13182 13263 13055 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $120335 m0 *1 195.44,1063.44
X$120335 14074 14073 13167 13060 13166 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $120375 r0 *1 313.6,1073.52
X$120375 14074 14073 13343 13186 13065 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $120377 r0 *1 319.2,1073.52
X$120377 14073 13186 13065 14074 13268 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120411 r0 *1 328.16,1073.52
X$120411 14074 14073 13067 13297 13187 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $120468 m0 *1 938,1073.52
X$120468 13134 14074 14073 13381 13330 13075 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $120482 r0 *1 972.16,1073.52
X$120482 14074 14073 13076 13291 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $120488 m0 *1 1097.04,1113.84
X$120488 14074 14073 13077 13630 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $120494 r0 *1 1120,1063.44
X$120494 14074 13080 13146 13150 13149 13223 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120501 r0 *1 1141.84,1063.44
X$120501 14074 13082 13149 13220 13226 13225 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120523 m0 *1 1086.4,1063.44
X$120523 14074 14073 13217 13087 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120525 m0 *1 969.36,1063.44
X$120525 14074 14073 13165 13088 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120545 r0 *1 924,1073.52
X$120545 14074 13293 14073 13092 13209 13275 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $120584 m0 *1 386.96,1113.84
X$120584 14073 13100 13652 14074 13530 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120589 m0 *1 372.96,1134
X$120589 14073 13100 13705 14074 13812 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120624 m0 *1 148.96,1164.24
X$120624 14074 13967 13998 14073 13108 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $120630 m0 *1 85.12,1134
X$120630 14074 13796 14073 13828 13108 13109 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $120644 r0 *1 155.68,1154.16
X$120644 14073 13771 13109 14074 13953 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120672 m0 *1 226.8,1103.76
X$120672 14074 14073 13560 13528 13116 13559 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $120692 r0 *1 327.6,1063.44
X$120692 14074 14073 13120 13187 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120695 m0 *1 326.48,1123.92
X$120695 13661 14074 13121 13702 14073 13704 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $120700 r0 *1 327.6,1103.76
X$120700 14074 14073 13574 13121 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120725 r0 *1 906.08,1083.6
X$120725 14074 13361 13332 13417 13207 13131 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120733 m0 *1 925.12,1113.84
X$120733 14074 14073 13131 13648 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $120738 m0 *1 924.56,1073.52
X$120738 14074 13171 13132 14073 13209 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $120749 m0 *1 957.04,1073.52
X$120749 14074 14073 13329 13135 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120753 r0 *1 985.6,1073.52
X$120753 14074 13289 13136 13318 13276 13319 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120757 m0 *1 1001.28,1073.52
X$120757 14074 13238 13239 13278 13237 13137 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120762 m0 *1 999.04,1134
X$120762 14073 13137 13793 14074 13791 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $120765 r0 *1 1004.64,1073.52
X$120765 14074 13290 13138 13276 13278 13277 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120778 r0 *1 1016.4,1083.6
X$120778 14074 14073 13140 13420 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $120780 r0 *1 1035.44,1073.52
X$120780 14074 13140 13290 13280 13286 13279 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120784 r0 *1 1053.36,1073.52
X$120784 14074 13429 13141 13286 13230 13216 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120788 m0 *1 1046.08,1073.52
X$120788 14074 14073 13142 13236 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120791 r0 *1 1069.6,1063.44
X$120791 14074 13143 13234 13231 13145 13144 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120794 m0 *1 1064.56,1073.52
X$120794 14074 13143 13215 13285 13144 13233 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120812 m0 *1 1114.96,1073.52
X$120812 14074 13221 13229 13224 13222 13147 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120825 m0 *1 1117.76,1063.44
X$120825 14074 14073 13150 13151 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120844 r0 *1 1091.44,1063.44
X$120844 14074 14073 13283 13155 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120847 r0 *1 1086.4,1063.44
X$120847 14074 14073 13156 13230 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120853 m0 *1 1029.28,1073.52
X$120853 14074 13158 13213 13235 13214 13236 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $120869 m0 *1 1025.92,1073.52
X$120869 14074 14073 13213 13161 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120874 m0 *1 1018.08,1073.52
X$120874 14074 14073 13235 13162 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120959 r0 *1 70.56,1083.6
X$120959 14073 13180 13259 14074 13371 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $120977 m0 *1 176.96,1134
X$120977 14074 14073 13182 13775 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $120979 m0 *1 152.88,1134
X$120979 14074 13792 13772 14073 13773 13182 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $120981 r0 *1 155.12,1073.52
X$120981 14074 14073 13182 13183 13264 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121093 m0 *1 904.4,1083.6
X$121093 14074 14073 13206 13361 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $121099 m0 *1 912.24,1083.6
X$121099 14074 13315 13380 13382 13332 13208 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121115 m0 *1 968.8,1083.6
X$121115 14074 13291 13327 13379 13212 13380 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121120 r0 *1 1055.6,1083.6
X$121120 13375 14074 14073 13323 13374 13214 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $121127 r0 *1 1047.2,1083.6
X$121127 14074 14073 13215 13421 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121129 m0 *1 1061.2,1073.52
X$121129 14074 14073 13234 13216 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121132 m0 *1 1088.08,1073.52
X$121132 14074 13284 13217 13219 13228 13218 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121138 r0 *1 1104.32,1073.52
X$121138 14074 14073 13219 13321 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121140 m0 *1 1102.08,1083.6
X$121140 14074 13220 13283 13322 13366 13321 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121150 m0 *1 1131.76,1073.52
X$121150 14074 14073 13224 13223 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121175 r0 *1 1072.4,1073.52
X$121175 14074 14073 13231 13324 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121201 m0 *1 983.92,1073.52
X$121201 14074 14073 13241 13237 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121276 r0 *1 54.32,1073.52
X$121276 14074 14073 13425 13256 13255 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121281 r0 *1 56.56,1083.6
X$121281 14074 14073 13259 13257 13301 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121309 m0 *1 115.92,1103.76
X$121309 14074 14073 13262 13590 13523 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121312 m0 *1 120.96,1103.76
X$121312 14074 14073 13262 13679 13567 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121317 r0 *1 150.08,1123.92
X$121317 13772 14073 13773 13770 14074 13264 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $121327 m0 *1 183.12,1083.6
X$121327 14074 14073 13333 13383 13265 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121330 r0 *1 192.64,1083.6
X$121330 14074 14073 13305 13266 13351 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $121339 r0 *1 193.2,1073.52
X$121339 14073 13266 13351 14074 13334 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $121344 m0 *1 195.44,1093.68
X$121344 14074 14073 13266 13458 13409 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121351 m0 *1 140,1103.76
X$121351 14074 13592 14073 13451 13350 13267 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $121365 r0 *1 185.36,1093.68
X$121365 13457 13267 13351 13458 14073 14074 13556
+ gf180mcu_fd_sc_mcu9t5v0__or4_2
* cell instance $121371 r0 *1 143.36,1103.76
X$121371 14074 13594 14073 13525 13454 13267 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $121378 m0 *1 446.32,1103.76
X$121378 14073 13533 14074 13269 13611 13479 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $121381 m0 *1 363.44,1113.84
X$121381 14073 13654 14074 13269 13653 13468 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $121383 r0 *1 387.52,1093.68
X$121383 14073 13414 14074 13269 13359 13471 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $121393 r0 *1 458.64,1073.52
X$121393 14074 14073 13270 13299 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121409 m0 *1 929.04,1083.6
X$121409 13293 14074 14073 13331 13758 13275 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $121423 m0 *1 990.08,1083.6
X$121423 14074 14073 13327 13277 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121427 m0 *1 1034.32,1093.68
X$121427 14074 13373 13279 13433 13324 13421 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121432 m0 *1 1050,1083.6
X$121432 14074 14073 13280 13320 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121452 r0 *1 1070.16,1093.68
X$121452 14074 14073 13285 13583 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121469 m0 *1 1015.84,1083.6
X$121469 14074 14073 13326 13289 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121475 r0 *1 966,1134
X$121475 14074 13291 13819 13861 13841 13862 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121477 r0 *1 929.04,1134
X$121477 14074 13291 13813 13868 13795 13823 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121486 r0 *1 930.16,1093.68
X$121486 14074 13291 13506 13505 13382 13440 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121488 r0 *1 935.76,1144.08
X$121488 14074 13291 13925 13887 13821 13926 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121490 r0 *1 932.96,1123.92
X$121490 14074 13291 13730 13759 13581 13708 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121495 r0 *1 929.04,1103.76
X$121495 14074 13291 13602 13600 13439 13535 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121499 m0 *1 962.08,1083.6
X$121499 14074 14073 13328 13292 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121554 r0 *1 236.32,1083.6
X$121554 13352 14074 13387 13306 14073 13443 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $121557 m0 *1 281.12,1083.6
X$121557 14074 14073 13307 13447 13308 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121562 r0 *1 328.72,1083.6
X$121562 14074 14073 13395 13344 13309 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121575 m0 *1 371.84,1083.6
X$121575 14073 13310 13311 14074 13358 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $121577 m0 *1 369.6,1093.68
X$121577 13310 13311 13357 13353 14074 14073 13413
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $121580 r0 *1 395.36,1093.68
X$121580 14074 14073 13310 13471 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121585 m0 *1 363.44,1083.6
X$121585 14074 14073 13345 13311 13312 13401 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $121609 m0 *1 910.56,1093.68
X$121609 14074 13315 13440 13439 13417 13510 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121611 r0 *1 917.28,1144.08
X$121611 14074 13315 13926 13841 13782 13927 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121613 r0 *1 916.16,1123.92
X$121613 14074 13315 13708 13795 13580 13707 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121621 m0 *1 931.84,1144.08
X$121621 14074 13315 13862 13793 13869 13822 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121625 m0 *1 929.04,1134
X$121625 14074 13315 13823 13821 13709 13794 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121627 m0 *1 913.36,1103.76
X$121627 14074 13315 13535 13581 13534 13604 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121629 m0 *1 954.8,1083.6
X$121629 14074 14073 13317 13316 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121632 r0 *1 955.92,1093.68
X$121632 14074 13553 13317 13438 13502 13537 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121636 r0 *1 968.24,1083.6
X$121636 14074 13377 13329 13328 13318 13418 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121641 m0 *1 981.12,1093.68
X$121641 14074 13436 13319 13501 13419 13481 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121645 m0 *1 1029.84,1083.6
X$121645 14074 13375 13326 13376 13325 13320 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121655 m0 *1 1118.88,1083.6
X$121655 14074 14073 13322 13323 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121666 m0 *1 1051.12,1093.68
X$121666 13434 14074 14073 13432 13427 13325 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $121688 m0 *1 947.52,1093.68
X$121688 14074 14073 13536 13330 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121694 m0 *1 950.88,1093.68
X$121694 14074 14073 13684 13331 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121748 m0 *1 357.84,1083.6
X$121748 14074 14073 13400 13345 13346 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $121758 r0 *1 123.2,1093.68
X$121758 14074 14073 13349 13347 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121762 r0 *1 132.16,1103.76
X$121762 13567 13348 13453 13594 13460 14073 14074
+ gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* cell instance $121768 r0 *1 126,1103.76
X$121768 14074 14073 13348 13524 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121771 r0 *1 120.96,1103.76
X$121771 14074 14073 13348 13566 13523 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121783 m0 *1 101.92,1103.76
X$121783 14073 13349 13522 14074 13523 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $121804 m0 *1 354.48,1093.68
X$121804 14074 14073 13516 13353 13518 13448 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $121819 r0 *1 320.32,1083.6
X$121819 14074 14073 13356 13393 13355 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121834 m0 *1 422.24,1103.76
X$121834 14074 14073 13357 13477 13473 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $121850 m0 *1 905.52,1103.76
X$121850 14074 14073 13361 13579 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $121853 r0 *1 1074.08,1083.6
X$121853 14074 13428 13362 13364 13363 13365 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121855 r0 *1 1070.72,1083.6
X$121855 14074 14073 13362 13373 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121860 r0 *1 1090.88,1083.6
X$121860 14074 14073 13364 13541 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121866 r0 *1 1120.56,1083.6
X$121866 14074 13370 13366 13423 13368 13367 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121877 r0 *1 1115.52,1093.68
X$121877 14074 13423 13494 13369 13493 13426 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $121881 m0 *1 1060.64,1093.68
X$121881 14074 14073 13369 13432 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121902 r0 *1 1065.12,1083.6
X$121902 14074 14073 13494 13374 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121911 r0 *1 1038.8,1083.6
X$121911 14074 14073 13376 13377 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121924 r0 *1 992.88,1083.6
X$121924 14074 14073 13379 13419 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $121932 m0 *1 954.24,1093.68
X$121932 14074 14073 13438 13381 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122003 r0 *1 445.2,1083.6
X$122003 14074 14073 13403 13402 13514 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122023 r0 *1 60.48,1103.76
X$122023 14074 14073 13404 13589 13492 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122039 m0 *1 142.8,1093.68
X$122039 14074 14073 13406 13453 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122047 r0 *1 230.72,1093.68
X$122047 14074 13409 13460 14073 13528 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $122067 r0 *1 248.64,1103.76
X$122067 14074 14073 13572 13411 13462 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $122077 m0 *1 247.52,1113.84
X$122077 14073 13411 13462 14074 13650 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122088 m0 *1 381.92,1113.84
X$122088 14073 13576 13413 14074 13652 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122091 m0 *1 376.88,1113.84
X$122091 14073 13469 13413 14074 13519 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122098 r0 *1 416.64,1093.68
X$122098 14073 13472 13530 14074 13416 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122103 r0 *1 976.08,1093.68
X$122103 14074 13503 13418 13502 13501 13504 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122108 m0 *1 1005.2,1093.68
X$122108 14074 13433 13436 13484 13498 13420 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122110 m0 *1 1010.8,1134
X$122110 14074 13420 13816 13890 13711 13790 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122115 m0 *1 1015.84,1123.92
X$122115 14074 13420 13682 13712 13670 13711 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122118 r0 *1 1009.68,1103.76
X$122118 14074 13420 13595 13593 13591 13625 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122120 m0 *1 1026.48,1103.76
X$122120 14074 13549 13498 13591 13583 13421 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122126 r0 *1 1034.32,1103.76
X$122126 14074 14073 13421 13672 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $122140 m0 *1 1123.36,1093.68
X$122140 14074 13424 13493 13490 13488 13491 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122150 m0 *1 1114.96,1093.68
X$122150 14074 14073 13487 13426 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122155 m0 *1 1081.36,1103.76
X$122155 14074 14073 13546 13427 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122162 m0 *1 1064,1093.68
X$122162 14074 14073 13485 13429 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122180 r0 *1 1000.72,1093.68
X$122180 14074 13434 13554 13499 13552 13483 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122185 m0 *1 134.96,1093.68
X$122185 14073 13451 14074 13435 13497 13452 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122194 m0 *1 999.04,1144.08
X$122194 14074 13860 13859 13437 13858 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $122251 r0 *1 146.16,1093.68
X$122251 14073 13525 14074 13500 13455 13452 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122254 r0 *1 291.2,1134
X$122254 14073 13833 14074 13871 13827 13452 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122256 m0 *1 259.84,1123.92
X$122256 14073 13452 14074 13696 13731 13697 13698
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122259 m0 *1 147.84,1144.08
X$122259 14073 13452 14074 13829 13876 13830 13735
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122261 r0 *1 339.92,1134
X$122261 14073 13452 14074 13810 13873 13824 13740
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122263 r0 *1 301.84,1123.92
X$122263 14073 13452 14074 13766 13825 13738 13768
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122265 r0 *1 316.4,1113.84
X$122265 14073 13659 14074 13660 13686 13452 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122267 r0 *1 333.76,1164.24
X$122267 14073 13452 14074 13993 14004 13994 13975
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122269 r0 *1 344.4,1154.16
X$122269 14073 13885 14074 13984 13939 13452 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122289 m0 *1 313.6,1164.24
X$122289 14073 13452 14074 14005 13982 14015 13991
+ gf180mcu_fd_sc_mcu9t5v0__oai22_2
* cell instance $122307 m0 *1 146.16,1113.84
X$122307 14074 13640 14073 13568 13617 13456 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $122320 r0 *1 206.64,1093.68
X$122320 14073 13457 13459 14074 13463 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122346 m0 *1 332.64,1154.16
X$122346 14074 13938 13936 14073 13461 13741 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $122358 r0 *1 274.96,1134
X$122358 13806 13736 13461 13807 14074 14073 13695
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $122360 r0 *1 276.64,1144.08
X$122360 14074 14073 13461 13832 13807 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122364 m0 *1 327.04,1134
X$122364 14074 14073 13574 13575 13461 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122389 r0 *1 364,1093.68
X$122389 14074 14073 13576 13468 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122393 r0 *1 367.36,1093.68
X$122393 14073 13468 13519 14074 13520 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $122396 r0 *1 378,1093.68
X$122396 14073 13471 13469 14074 13470 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $122402 r0 *1 380.8,1113.84
X$122402 13578 14073 13469 13652 14074 13663 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $122413 m0 *1 414.4,1103.76
X$122413 14073 13531 14074 13532 13613 13472 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $122418 r0 *1 410.48,1103.76
X$122418 14074 14073 13578 13472 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122430 r0 *1 432.32,1093.68
X$122430 14074 13475 13477 14073 13478 13476 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $122451 r0 *1 951.44,1093.68
X$122451 14074 14073 13506 13481 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122456 r0 *1 972.72,1093.68
X$122456 14074 14073 13505 13482 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122458 r0 *1 962.08,1103.76
X$122458 14074 13595 13504 13624 13482 13598 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122463 r0 *1 1017.52,1093.68
X$122463 14074 14073 13484 13483 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122467 r0 *1 1098.72,1093.68
X$122467 14074 13542 13485 13487 13486 13495 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122483 m0 *1 1089.76,1103.76
X$122483 14074 13490 13546 13545 13587 13541 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122511 m0 *1 1050.56,1103.76
X$122511 14074 13547 13550 13540 13496 13539 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122525 r0 *1 993.44,1093.68
X$122525 14074 14073 13499 13553 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122543 m0 *1 987.84,1103.76
X$122543 14074 14073 13554 13503 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122559 m0 *1 946.4,1103.76
X$122559 14074 14073 13647 13507 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122565 m0 *1 943.04,1103.76
X$122565 14074 14073 13538 13508 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122615 r0 *1 63.28,1123.92
X$122615 14074 13733 14073 13676 13614 13521 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $122624 r0 *1 78.96,1103.76
X$122624 14074 14073 13521 13615 13561 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122645 r0 *1 114.8,1103.76
X$122645 13563 14073 13565 13523 14074 13567 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $122647 r0 *1 101.92,1103.76
X$122647 14074 14073 13563 13564 13523 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122651 m0 *1 118.72,1113.84
X$122651 14074 13524 13564 14073 13656 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $122662 m0 *1 192.64,1103.76
X$122662 14074 13557 13556 14073 13527 13558 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $122682 r0 *1 414.96,1113.84
X$122682 14074 13665 13666 14073 13578 13530 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $122701 m0 *1 950.32,1103.76
X$122701 14074 13597 13536 13538 13596 13599 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122704 m0 *1 962.64,1113.84
X$122704 14074 13645 13537 13596 13624 13646 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122715 r0 *1 1054.48,1103.76
X$122715 14074 14073 13539 13584 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $122719 m0 *1 1068.48,1103.76
X$122719 14074 14073 13540 13585 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122728 m0 *1 50.4,1103.76
X$122728 14073 13589 13544 14074 13543 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122738 m0 *1 1022,1103.76
X$122738 14074 14073 13545 13582 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122755 m0 *1 1043.28,1103.76
X$122755 14074 14073 13550 13549 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $122767 m0 *1 1018.08,1113.84
X$122767 13643 14074 14073 13582 13641 13552 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $122802 r0 *1 215.6,1103.76
X$122802 14074 14073 13560 13601 13571 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122814 m0 *1 70,1113.84
X$122814 14074 14073 13561 13634 13562 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122881 r0 *1 331.52,1123.92
X$122881 13703 13574 13739 13781 14074 14073 13741
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $122884 r0 *1 324.8,1123.92
X$122884 13661 14074 13740 13575 14073 13700 gf180mcu_fd_sc_mcu9t5v0__or3_2
* cell instance $122903 r0 *1 393.68,1113.84
X$122903 14074 14073 13663 13687 13577 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122906 r0 *1 383.04,1134
X$122906 14074 14073 13577 13837 13812 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $122920 r0 *1 388.64,1123.92
X$122920 13743 13666 13744 13578 14074 14073 13761
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $122947 r0 *1 1026.48,1103.76
X$122947 14074 14073 13583 13671 gf180mcu_fd_sc_mcu9t5v0__buf_4
* cell instance $122949 r0 *1 1053.92,1113.84
X$122949 14074 13584 13714 13818 13628 13627 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122954 m0 *1 1058.96,1113.84
X$122954 14074 13584 13639 13629 13637 13628 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122957 m0 *1 1062.88,1123.92
X$122957 14074 13716 13638 13720 13721 13585 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122967 m0 *1 1092,1113.84
X$122967 14073 13586 13630 14074 13637 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $122969 m0 *1 1107.12,1113.84
X$122969 14074 13636 13587 13716 13631 13635 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $122995 r0 *1 1012.48,1113.84
X$122995 14074 14073 13593 13669 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123012 m0 *1 986.72,1113.84
X$123012 14074 14073 13642 13597 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123016 r0 *1 948.08,1103.76
X$123016 14074 14073 13602 13598 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123021 r0 *1 957.6,1123.92
X$123021 14074 13757 13599 13729 13668 13748 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123026 r0 *1 953.12,1103.76
X$123026 14074 14073 13600 13623 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123039 m0 *1 274.4,1144.08
X$123039 14074 13805 13806 14073 13603 13807 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $123050 m0 *1 323.68,1144.08
X$123050 14073 13603 13741 14074 13834 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $123052 r0 *1 321.44,1123.92
X$123052 14074 14073 13603 13702 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123059 r0 *1 255.92,1103.76
X$123059 14074 14073 13651 13605 13606 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $123069 r0 *1 270.48,1103.76
X$123069 14074 14073 13607 13608 13609 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $123093 m0 *1 82.32,1113.84
X$123093 14074 13614 13615 14073 13617 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $123115 r0 *1 336,1113.84
X$123115 14073 13620 14074 13622 13662 13661 gf180mcu_fd_sc_mcu9t5v0__oai21_2
* cell instance $123124 r0 *1 953.12,1113.84
X$123124 14074 13682 13646 13668 13623 13667 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123132 r0 *1 1025.36,1113.84
X$123132 14074 13671 13625 13670 13672 13626 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123137 m0 *1 1044.96,1113.84
X$123137 14074 14073 13639 13626 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123152 r0 *1 1072.4,1113.84
X$123152 14074 14073 13629 13754 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123180 m0 *1 76.72,1113.84
X$123180 14073 13634 13633 14074 13655 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $123199 m0 *1 1037.68,1113.84
X$123199 14074 14073 13638 13641 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123213 m0 *1 1001.28,1113.84
X$123213 14074 13643 13644 13642 13681 13669 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123224 m0 *1 992.88,1113.84
X$123224 14074 14073 13644 13645 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123235 m0 *1 950.32,1123.92
X$123235 14074 13727 13647 13684 13729 13710 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123260 r0 *1 383.6,1123.92
X$123260 14073 13652 13761 14074 13705 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $123290 m0 *1 233.52,1134
X$123290 14074 14073 13658 13779 13778 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $123295 r0 *1 225.68,1144.08
X$123295 14074 14073 13658 13762 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123312 m0 *1 333.2,1123.92
X$123312 14074 14073 13703 13661 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123317 r0 *1 404.32,1134
X$123317 14074 13838 13743 14073 13666 13663 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $123333 r0 *1 420,1123.92
X$123333 14074 13760 14073 13706 13665 13743 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $123350 m0 *1 940.24,1123.92
X$123350 14074 14073 13730 13667 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123361 m0 *1 1027.6,1134
X$123361 14074 13671 13711 13790 13672 13784 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123368 m0 *1 1084.72,1123.92
X$123368 14074 13673 13721 13718 13675 13715 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123370 m0 *1 1090.32,1134
X$123370 14074 13674 13753 13787 13786 13750 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123398 m0 *1 1039.92,1123.92
X$123398 13755 14074 14073 13725 13724 13681 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $123409 m0 *1 982.24,1134
X$123409 14074 13756 13683 13860 13783 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $123453 r0 *1 250.32,1134
X$123453 14073 13780 13695 14074 13804 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $123463 r0 *1 266,1123.92
X$123463 14073 13698 13737 14074 13765 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $123466 r0 *1 261.52,1123.92
X$123466 14074 14073 13736 13698 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123476 r0 *1 312.48,1123.92
X$123476 14074 14073 13767 13739 13700 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $123500 m0 *1 344.4,1134
X$123500 14074 14073 13742 13781 13704 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $123527 r0 *1 958.72,1144.08
X$123527 14074 13923 13710 13946 13921 13889 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123536 m0 *1 1032.64,1123.92
X$123536 14074 14073 13712 13713 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123539 r0 *1 1026.48,1123.92
X$123539 14074 13755 13728 13726 13749 13713 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123542 r0 *1 1052.24,1123.92
X$123542 14074 14073 13714 13784 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123558 r0 *1 1065.68,1123.92
X$123558 14074 13718 13723 13719 13753 13754 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123564 r0 *1 1070.16,1134
X$123564 14074 14073 13719 13845 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123568 m0 *1 1059.52,1123.92
X$123568 14074 14073 13720 13725 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123582 m0 *1 1051.12,1123.92
X$123582 14074 14073 13723 13724 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123595 m0 *1 1012.48,1123.92
X$123595 14074 14073 13726 13727 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123604 r0 *1 1008,1123.92
X$123604 14074 14073 13728 13757 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123628 r0 *1 168,1123.92
X$123628 14074 14073 13772 13735 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123648 m0 *1 255.36,1134
X$123648 13736 14073 13780 13737 14074 13778 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $123654 m0 *1 270.48,1144.08
X$123654 14074 14073 13805 13737 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123665 m0 *1 322.56,1134
X$123665 14074 14073 13739 13768 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123675 m0 *1 341.04,1134
X$123675 14074 14073 13781 13740 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123684 r0 *1 324.24,1144.08
X$123684 13882 14073 13741 13883 14074 13807 gf180mcu_fd_sc_mcu9t5v0__and3_2
* cell instance $123712 r0 *1 399.28,1144.08
X$123712 14074 14073 13811 13928 13744 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $123717 r0 *1 411.6,1144.08
X$123717 14074 13929 14073 13870 13838 13744 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $123730 m0 *1 948.64,1134
X$123730 14074 14073 13820 13748 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123732 m0 *1 1036.56,1144.08
X$123732 13892 14074 14073 13845 13857 13749 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $123741 r0 *1 1080.8,1134
X$123741 14074 13785 13853 13850 13751 13817 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123770 m0 *1 966,1134
X$123770 14074 14073 13944 13758 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123773 r0 *1 945.84,1134
X$123773 14074 13865 13820 13922 13759 13813 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123827 m0 *1 154.56,1164.24
X$123827 14074 14073 13966 13998 13771 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $123881 m0 *1 215.04,1144.08
X$123881 14074 14073 13802 13776 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $123915 m0 *1 982.8,1144.08
X$123915 14073 13918 13842 14074 13783 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $123928 m0 *1 1049.44,1154.16
X$123928 14074 13787 13907 13951 13894 13893 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $123946 m0 *1 1020.88,1144.08
X$123946 14074 13791 13844 13858 13856 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $123996 r0 *1 246.96,1134
X$123996 14074 14073 13804 13803 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124012 r0 *1 282.24,1134
X$124012 14074 14073 13826 13806 13832 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $124043 m0 *1 380.24,1144.08
X$124043 14074 14073 13872 13812 13811 13837 gf180mcu_fd_sc_mcu9t5v0__mux2_2
* cell instance $124051 m0 *1 369.6,1154.16
X$124051 14073 13811 13940 14074 13941 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $124058 m0 *1 367.92,1164.24
X$124058 14074 13976 13812 13992 13942 14073 13941
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $124066 m0 *1 376.88,1164.24
X$124066 14074 14073 13812 13995 13941 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124073 r0 *1 988.4,1134
X$124073 14074 13861 13814 13859 13815 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $124075 r0 *1 1025.92,1144.08
X$124075 13814 14074 14073 13908 13905 13957 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $124079 r0 *1 992.32,1144.08
X$124079 13961 14074 13890 14073 13815 gf180mcu_fd_sc_mcu9t5v0__xor2_2
* cell instance $124082 r0 *1 1027.6,1154.16
X$124082 14074 13816 13947 13856 13895 14073 gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* cell instance $124084 m0 *1 960.96,1144.08
X$124084 14074 13864 13921 13917 13863 13816 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124087 m0 *1 972.16,1154.16
X$124087 14074 13920 13919 13961 13843 13816 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124096 r0 *1 962.64,1134
X$124096 14074 14073 13816 13865 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124098 r0 *1 1074.08,1144.08
X$124098 14074 13847 13896 13898 13849 13817 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124100 m0 *1 1074.08,1144.08
X$124100 14074 13847 13846 13852 13817 13848 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124106 r0 *1 1055.6,1144.08
X$124106 14074 13852 13905 13897 13896 13818 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124113 m0 *1 1055.04,1144.08
X$124113 14074 14073 13818 13893 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124116 m0 *1 1058.96,1144.08
X$124116 14129 14074 14073 13896 13818 13895 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $124120 r0 *1 982.8,1134
X$124120 14074 14073 13819 13843 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124175 r0 *1 317.52,1154.16
X$124175 14073 13834 13883 14074 13981 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $124191 r0 *1 406,1144.08
X$124191 14074 13838 13928 14073 13886 gf180mcu_fd_sc_mcu9t5v0__or2_2
* cell instance $124205 r0 *1 969.92,1154.16
X$124205 14074 13978 13944 13842 13946 13945 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124210 m0 *1 1069.6,1154.16
X$124210 14073 13898 13897 14074 13844 gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* cell instance $124220 m0 *1 1069.6,1144.08
X$124220 14074 14073 13846 13854 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124232 r0 *1 1094.24,1144.08
X$124232 14074 14073 13850 13948 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124244 r0 *1 1066.8,1134
X$124244 14074 14073 13853 13894 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124247 r0 *1 1053.36,1154.16
X$124247 14074 13893 13955 13903 13948 13854 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124261 m0 *1 1046.08,1144.08
X$124261 14074 14073 13907 13857 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124286 m0 *1 948.64,1144.08
X$124286 14074 14073 13925 13863 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124291 m0 *1 957.6,1144.08
X$124291 14074 14073 13868 13864 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124332 r0 *1 110.88,1144.08
X$124332 14074 14073 13875 13900 13899 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124341 m0 *1 263.76,1174.32
X$124341 14074 14011 13971 14073 13879 13987 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $124356 r0 *1 239.12,1174.32
X$124356 14074 14073 13879 14007 14008 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124373 r0 *1 325.36,1164.24
X$124373 14074 14073 13882 13991 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124376 r0 *1 337.68,1154.16
X$124376 14073 13936 13943 14074 13883 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $124391 r0 *1 407.68,1164.24
X$124391 14074 13997 14073 13999 13886 13940 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $124395 m0 *1 952,1144.08
X$124395 14074 14073 13887 13920 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124397 r0 *1 975.52,1144.08
X$124397 14074 13888 13945 13918 13917 13919 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124401 m0 *1 1000.72,1154.16
X$124401 14074 14073 13960 13888 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124404 r0 *1 1001.84,1144.08
X$124404 14074 14073 13912 13889 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124410 r0 *1 1005.76,1144.08
X$124410 14074 14073 13890 13891 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124415 r0 *1 1009.12,1144.08
X$124415 14074 13891 13912 13959 13892 13909 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124419 m0 *1 1014.16,1154.16
X$124419 14074 13891 13960 13947 13958 13957 14073
+ gf180mcu_fd_sc_mcu9t5v0__addf_1
* cell instance $124469 r0 *1 1045.52,1144.08
X$124469 14074 14073 13903 13908 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124481 r0 *1 1050.56,1144.08
X$124481 14074 14073 13951 13906 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124483 m0 *1 1033.76,1154.16
X$124483 13958 14074 14073 13906 13956 13909 gf180mcu_fd_sc_mcu9t5v0__addh_1
* cell instance $124544 r0 *1 955.36,1144.08
X$124544 14074 14073 13922 13923 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124576 m0 *1 184.24,1164.24
X$124576 14074 13967 13932 14073 13968 13969 gf180mcu_fd_sc_mcu9t5v0__nand3_2
* cell instance $124588 m0 *1 176.96,1164.24
X$124588 14074 14073 13932 14020 14031 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124591 m0 *1 161.28,1154.16
X$124591 13932 13966 13954 13953 14074 14073 13949
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $124604 m0 *1 202.16,1184.4
X$124604 14074 14073 13933 14068 14032 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124613 r0 *1 252.56,1164.24
X$124613 14074 14008 13972 13971 13934 14073 13980
+ gf180mcu_fd_sc_mcu9t5v0__nand4_2
* cell instance $124621 r0 *1 255.36,1174.32
X$124621 13934 13971 13972 13980 14074 14073 13970
+ gf180mcu_fd_sc_mcu9t5v0__and4_2
* cell instance $124623 m0 *1 250.88,1164.24
X$124623 14074 14073 13934 14026 14057 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124627 m0 *1 264.88,1164.24
X$124627 14073 13934 13980 14074 13973 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $124649 r0 *1 330.4,1164.24
X$124649 14074 14073 13936 13975 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124656 m0 *1 343.28,1164.24
X$124656 14074 14073 13965 13943 13938 gf180mcu_fd_sc_mcu9t5v0__nor2_2
* cell instance $124685 r0 *1 385.84,1164.24
X$124685 14074 14025 14073 14003 13995 13942 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $124751 m0 *1 1046.08,1154.16
X$124751 14074 14073 13955 13956 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124767 r0 *1 1019.76,1154.16
X$124767 14074 14073 13959 13978 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $124796 r0 *1 173.6,1164.24
X$124796 14074 14018 14073 14001 13967 13966 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $124857 m0 *1 275.52,1184.4
X$124857 14074 14073 13971 14070 14014 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124865 m0 *1 259.84,1184.4
X$124865 14074 14073 13972 14057 13980 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124878 m0 *1 310.8,1184.4
X$124878 14074 14071 14073 14030 13976 13974 gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* cell instance $124887 r0 *1 319.2,1164.24
X$124887 14073 13974 13992 14074 13980 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $124947 r0 *1 227.92,1174.32
X$124947 14074 14073 13986 14037 14069 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124953 r0 *1 274.4,1174.32
X$124953 14074 14073 13988 14054 14055 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124956 r0 *1 290.08,1174.32
X$124956 14074 14073 13989 14039 14056 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $124982 r0 *1 355.6,1174.32
X$124982 14074 14073 13992 14072 14040 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $125025 m0 *1 182.56,1174.32
X$125025 14074 14073 14002 14031 gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* cell instance $125053 r0 *1 247.52,1164.24
X$125053 14073 14026 14024 14074 14010 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $125084 m0 *1 163.52,1184.4
X$125084 14074 14073 14067 14066 14017 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $125124 m0 *1 365.68,1174.32
X$125124 14074 14073 14053 14028 14052 gf180mcu_fd_sc_mcu9t5v0__nand2_2
* cell instance $125144 m0 *1 210,1174.32
X$125144 14073 14033 14034 14074 14036 gf180mcu_fd_sc_mcu9t5v0__and2_2
* cell instance $125185 r0 *1 202.72,1174.32
X$125185 14073 14068 14047 14074 14046 gf180mcu_fd_sc_mcu9t5v0__and2_2
.ENDS ibex_core

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 8 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 11 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 3 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 10 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 8 4 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 12 4 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 3 12 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.78 pmos_5p0
M$9 13 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $10 r0 *1 11,3.78 pmos_5p0
M$10 8 6 13 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $11 r0 *1 12.12,3.78 pmos_5p0
M$11 15 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $12 r0 *1 13.24,3.78 pmos_5p0
M$12 7 5 15 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $13 r0 *1 14.36,3.78 pmos_5p0
M$13 14 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $14 r0 *1 15.48,3.78 pmos_5p0
M$14 8 6 14 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 16.6,3.78 pmos_5p0
M$15 16 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 17.67,3.78 pmos_5p0
M$16 7 5 16 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 1 3 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.88,1.005 nmos_5p0
M$25 8 5 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.9272P PS=7.36U PD=9.52U
* device instance $26 r0 *1 11,1.005 nmos_5p0
M$26 2 6 8 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_4

* cell gf180mcu_fd_sc_mcu9t5v0__mux4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin NWELL,VDD
* pin I2
* pin S0
* pin I3
* pin S1
* pin I1
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux4_4 1 6 10 11 12 13 14 16 18
* net 1 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* net 10 NWELL,VDD
* net 11 I2
* net 12 S0
* net 13 I3
* net 14 S1
* net 16 I1
* net 18 I0
* device instance $1 r0 *1 1.035,3.62 pmos_5p0
M$1 3 11 10 10 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.5504P PS=3.44U PD=2.14U
* device instance $2 r0 *1 2.395,3.62 pmos_5p0
M$2 4 12 3 10 pmos_5p0 L=0.5U W=1.28U AS=0.5504P AD=0.4032P PS=2.14U PD=1.91U
* device instance $3 r0 *1 3.525,3.62 pmos_5p0
M$3 5 17 4 10 pmos_5p0 L=0.5U W=1.28U AS=0.4032P AD=0.4576P PS=1.91U PD=1.995U
* device instance $4 r0 *1 4.74,3.62 pmos_5p0
M$4 10 13 5 10 pmos_5p0 L=0.5U W=1.28U AS=0.4576P AD=0.6432P PS=1.995U PD=2.4U
* device instance $5 r0 *1 6.2,3.62 pmos_5p0
M$5 6 2 10 10 pmos_5p0 L=0.5U W=5.12U AS=1.952P AD=1.872P PS=8.4U PD=9.44U
* device instance $9 r0 *1 14.85,3.62 pmos_5p0
M$9 10 14 15 10 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3712P PS=3.44U PD=1.86U
* device instance $10 r0 *1 15.93,3.62 pmos_5p0
M$10 8 16 10 10 pmos_5p0 L=0.5U W=1.28U AS=0.3712P AD=0.3968P PS=1.86U PD=1.9U
* device instance $11 r0 *1 17.05,3.62 pmos_5p0
M$11 7 17 8 10 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.3968P PS=1.9U PD=1.9U
* device instance $12 r0 *1 18.17,3.62 pmos_5p0
M$12 9 12 7 10 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.3328P PS=1.9U PD=1.8U
* device instance $13 r0 *1 19.19,3.62 pmos_5p0
M$13 10 18 9 10 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3968P PS=1.8U PD=1.9U
* device instance $14 r0 *1 20.31,3.62 pmos_5p0
M$14 17 12 10 10 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.5632P PS=1.9U PD=3.44U
* device instance $15 r0 *1 12.05,3.62 pmos_5p0
M$15 2 15 4 10 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $16 r0 *1 13.07,3.62 pmos_5p0
M$16 7 14 2 10 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.5632P PS=1.8U PD=3.44U
* device instance $17 r0 *1 0.985,1.195 nmos_5p0
M$17 3 11 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.48P PS=2.48U PD=2U
* device instance $18 r0 *1 2.785,1.195 nmos_5p0
M$18 4 17 3 1 nmos_5p0 L=0.6U W=0.8U AS=0.48P AD=0.208P PS=2U PD=1.32U
* device instance $19 r0 *1 3.905,1.195 nmos_5p0
M$19 5 12 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 5.025,1.195 nmos_5p0
M$20 1 13 5 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $21 r0 *1 6.145,1.195 nmos_5p0
M$21 6 2 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.832P AD=0.976P PS=5.28U PD=6.44U
* device instance $25 r0 *1 11.56,1.18 nmos_5p0
M$25 2 14 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.364P AD=0.208P PS=2.51U PD=1.32U
* device instance $26 r0 *1 12.68,1.18 nmos_5p0
M$26 7 15 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
* device instance $27 r0 *1 14.76,1.18 nmos_5p0
M$27 1 14 15 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $28 r0 *1 15.88,1.18 nmos_5p0
M$28 8 16 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $29 r0 *1 17,1.18 nmos_5p0
M$29 7 12 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $30 r0 *1 18.12,1.18 nmos_5p0
M$30 9 17 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $31 r0 *1 19.24,1.18 nmos_5p0
M$31 1 18 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $32 r0 *1 20.36,1.18 nmos_5p0
M$32 17 12 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux4_4

* cell gf180mcu_fd_sc_mcu9t5v0__inv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_8 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.9832P PS=16.4U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_8

* cell gf180mcu_fd_sc_mcu9t5v0__tiel
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__tiel 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.97,3.315 pmos_5p0
M$1 3 3 2 2 pmos_5p0 L=0.5U W=0.9U AS=0.396P AD=0.396P PS=2.68U PD=2.68U
* device instance $2 r0 *1 0.92,1.335 nmos_5p0
M$2 4 3 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.2904P PS=2.2U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__tiel

* cell gf180mcu_fd_sc_mcu9t5v0__latsnq_1
* pin PWELL,VSS,gf180mcu_gnd
* pin E
* pin D
* pin Q
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__latsnq_1 1 3 4 9 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 E
* net 4 D
* net 7 SETN
* net 9 Q
* net 13 NWELL,VDD
* device instance $1 r0 *1 9.125,3.555 pmos_5p0
M$1 13 6 8 13 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.573P PS=3.64U PD=2.53U
* device instance $2 r0 *1 10.325,3.78 pmos_5p0
M$2 9 8 13 13 pmos_5p0 L=0.5U W=1.83U AS=0.573P AD=0.8052P PS=2.53U PD=4.54U
* device instance $3 r0 *1 0.97,3.675 pmos_5p0
M$3 13 3 2 13 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.426P PS=3.64U PD=2.08U
* device instance $4 r0 *1 2.17,3.865 pmos_5p0
M$4 14 4 13 13 pmos_5p0 L=0.5U W=1U AS=0.426P AD=0.12P PS=2.08U PD=1.24U
* device instance $5 r0 *1 2.91,3.865 pmos_5p0
M$5 5 2 14 13 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.26P PS=1.24U PD=1.52U
* device instance $6 r0 *1 3.93,3.865 pmos_5p0
M$6 15 3 5 13 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2P PS=1.52U PD=1.4U
* device instance $7 r0 *1 4.83,3.865 pmos_5p0
M$7 15 6 13 13 pmos_5p0 L=0.5U W=1U AS=0.546P AD=0.2P PS=2.32U PD=1.4U
* device instance $8 r0 *1 6.27,3.675 pmos_5p0
M$8 6 5 13 13 pmos_5p0 L=0.5U W=1.38U AS=0.546P AD=0.3588P PS=2.32U PD=1.9U
* device instance $9 r0 *1 7.29,3.675 pmos_5p0
M$9 13 7 6 13 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $10 r0 *1 0.92,1.14 nmos_5p0
M$10 1 3 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.263P PS=2.46U PD=1.49U
* device instance $11 r0 *1 2.22,1.185 nmos_5p0
M$11 10 4 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.263P AD=0.084P PS=1.49U PD=0.94U
* device instance $12 r0 *1 3.06,1.185 nmos_5p0
M$12 5 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.182P PS=0.94U PD=1.22U
* device instance $13 r0 *1 4.18,1.185 nmos_5p0
M$13 11 2 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $14 r0 *1 5.02,1.185 nmos_5p0
M$14 11 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.263P AD=0.084P PS=1.49U PD=0.94U
* device instance $15 r0 *1 6.32,1.14 nmos_5p0
M$15 12 5 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.263P AD=0.0948P PS=1.49U PD=1.03U
* device instance $16 r0 *1 7.16,1.14 nmos_5p0
M$16 6 7 12 1 nmos_5p0 L=0.6U W=0.79U AS=0.0948P AD=0.3476P PS=1.03U PD=2.46U
* device instance $17 r0 *1 9.03,1.27 nmos_5p0
M$17 8 6 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.400275P AD=0.3476P PS=2.065U PD=2.46U
* device instance $18 r0 *1 10.375,1.005 nmos_5p0
M$18 9 8 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.400275P AD=0.5808P PS=2.065U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__latsnq_1

* cell gf180mcu_fd_sc_mcu9t5v0__dlyc_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyc_2 1 7 11 13
* net 1 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* net 11 I
* net 13 NWELL,VDD
* device instance $1 r0 *1 8.34,3.365 pmos_5p0
M$1 6 5 17 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 8.34,4.085 pmos_5p0
M$2 17 5 13 13 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 10.14,3.785 pmos_5p0
M$3 7 6 13 13 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 4.34,3.365 pmos_5p0
M$5 4 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $6 r0 *1 6.18,3.365 pmos_5p0
M$6 16 4 5 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $7 r0 *1 4.34,4.085 pmos_5p0
M$7 13 3 14 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $8 r0 *1 6.18,4.085 pmos_5p0
M$8 13 4 16 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.2412P PS=1.98U PD=1.7U
* device instance $9 r0 *1 2.18,3.365 pmos_5p0
M$9 15 2 3 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $10 r0 *1 0.87,4.085 pmos_5p0
M$10 13 11 2 13 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $11 r0 *1 2.18,4.085 pmos_5p0
M$11 13 2 15 13 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $12 r0 *1 0.92,0.795 nmos_5p0
M$12 1 11 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $13 r0 *1 2.23,0.795 nmos_5p0
M$13 12 2 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $14 r0 *1 2.23,1.515 nmos_5p0
M$14 3 2 12 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $15 r0 *1 4.39,0.52 nmos_5p0
M$15 1 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.2232P PS=1.98U PD=1.6U
* device instance $16 r0 *1 6.23,0.52 nmos_5p0
M$16 10 4 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.2232P AD=0.27P PS=1.6U PD=1.98U
* device instance $17 r0 *1 4.39,1.24 nmos_5p0
M$17 4 3 8 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $18 r0 *1 6.23,1.24 nmos_5p0
M$18 5 4 10 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $19 r0 *1 8.39,0.525 nmos_5p0
M$19 1 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $20 r0 *1 8.39,1.245 nmos_5p0
M$20 6 5 9 1 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $21 r0 *1 10.19,1.005 nmos_5p0
M$21 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyc_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_16 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=29.28U AS=9.3147P AD=9.3147P PS=41.29U PD=41.29U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 2 1 1 nmos_5p0 L=0.6U W=21.12U AS=5.7288P AD=5.7288P PS=31.12U PD=31.12U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_16

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_4 1 3 4 5 6 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 RN
* net 4 Q
* net 5 CLK
* net 6 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 16.975,3.78 pmos_5p0
M$1 4 13 17 17 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U PD=11.59U
* device instance $5 r0 *1 9.55,3.71 pmos_5p0
M$5 10 9 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.285P PS=2.88U PD=1.57U
* device instance $6 r0 *1 10.62,3.71 pmos_5p0
M$6 11 2 10 17 pmos_5p0 L=0.5U W=1U AS=0.285P AD=0.26P PS=1.57U PD=1.52U
* device instance $7 r0 *1 11.64,3.71 pmos_5p0
M$7 12 8 11 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.2875P PS=1.52U PD=1.575U
* device instance $8 r0 *1 12.715,3.71 pmos_5p0
M$8 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.5457P AD=0.2875P PS=2.57U PD=1.575U
* device instance $9 r0 *1 13.955,3.78 pmos_5p0
M$9 13 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5457P AD=0.4758P PS=2.57U PD=2.35U
* device instance $10 r0 *1 14.975,3.78 pmos_5p0
M$10 17 11 13 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $11 r0 *1 3.73,3.41 pmos_5p0
M$11 7 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $12 r0 *1 4.75,3.41 pmos_5p0
M$12 9 8 7 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 5.77,3.41 pmos_5p0
M$13 18 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $14 r0 *1 6.79,3.41 pmos_5p0
M$14 17 10 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $15 r0 *1 7.81,3.41 pmos_5p0
M$15 18 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $16 r0 *1 0.97,3.555 pmos_5p0
M$16 17 5 2 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $17 r0 *1 1.99,3.555 pmos_5p0
M$17 8 2 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $18 r0 *1 16.925,1.005 nmos_5p0
M$18 4 13 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $22 r0 *1 3.9,1.315 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $23 r0 *1 5.02,1.315 nmos_5p0
M$23 9 2 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $24 r0 *1 6.14,1.315 nmos_5p0
M$24 15 8 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $25 r0 *1 6.98,1.315 nmos_5p0
M$25 14 10 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0826P PS=0.83U PD=0.87U
* device instance $26 r0 *1 7.86,1.315 nmos_5p0
M$26 1 3 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.0826P AD=0.2124P PS=0.87U PD=1.31U
* device instance $27 r0 *1 9.18,1.315 nmos_5p0
M$27 10 9 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2124P AD=0.190275P PS=1.31U PD=1.235U
* device instance $28 r0 *1 10.425,1.315 nmos_5p0
M$28 11 8 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.190275P AD=0.1534P PS=1.235U
+ PD=1.11U
* device instance $29 r0 *1 11.545,1.315 nmos_5p0
M$29 12 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $30 r0 *1 12.665,1.315 nmos_5p0
M$30 1 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $31 r0 *1 13.785,1.315 nmos_5p0
M$31 1 3 16 1 nmos_5p0 L=0.6U W=0.59U AS=0.3525P AD=0.1534P PS=2.02U PD=1.11U
* device instance $32 r0 *1 15.085,1.005 nmos_5p0
M$32 13 11 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3525P AD=0.5808P PS=2.02U PD=3.52U
* device instance $33 r0 *1 0.92,1.27 nmos_5p0
M$33 1 5 2 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $34 r0 *1 2.04,1.27 nmos_5p0
M$34 8 2 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_4

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_4 1 8 9 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 8 Q
* net 9 CLK
* net 10 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.97,3.555 pmos_5p0
M$1 14 9 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $2 r0 *1 1.99,3.555 pmos_5p0
M$2 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $3 r0 *1 4.03,3.365 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9696P AD=0.12P PS=5.04U PD=1.24U
* device instance $4 r0 *1 4.77,3.365 pmos_5p0
M$4 4 10 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.36P PS=1.24U PD=1.72U
* device instance $5 r0 *1 5.99,3.365 pmos_5p0
M$5 16 3 4 14 pmos_5p0 L=0.5U W=1U AS=0.36P AD=0.12P PS=1.72U PD=1.24U
* device instance $6 r0 *1 6.73,3.365 pmos_5p0
M$6 14 5 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.45P PS=1.24U PD=1.9U
* device instance $7 r0 *1 8.13,3.365 pmos_5p0
M$7 5 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.45P AD=0.3075P PS=1.9U PD=1.615U
* device instance $8 r0 *1 9.245,3.365 pmos_5p0
M$8 6 3 5 14 pmos_5p0 L=0.5U W=1U AS=0.3075P AD=0.4625P PS=1.615U PD=1.925U
* device instance $9 r0 *1 10.67,3.365 pmos_5p0
M$9 17 2 6 14 pmos_5p0 L=0.5U W=1U AS=0.4625P AD=0.14P PS=1.925U PD=1.28U
* device instance $10 r0 *1 11.45,3.365 pmos_5p0
M$10 14 7 17 14 pmos_5p0 L=0.5U W=1U AS=0.14P AD=0.5526P PS=1.28U PD=2.57U
* device instance $11 r0 *1 12.69,3.78 pmos_5p0
M$11 7 6 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.0284P AD=0.9516P PS=4.92U PD=4.7U
* device instance $13 r0 *1 14.73,3.78 pmos_5p0
M$13 8 7 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=2.2326P PS=9.4U PD=11.59U
* device instance $17 r0 *1 0.92,1.27 nmos_5p0
M$17 1 9 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $18 r0 *1 2.04,1.27 nmos_5p0
M$18 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $19 r0 *1 3.88,1.375 nmos_5p0
M$19 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.2552P AD=0.0696P PS=2.04U PD=0.82U
* device instance $20 r0 *1 4.72,1.375 nmos_5p0
M$20 4 10 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $21 r0 *1 5.84,1.375 nmos_5p0
M$21 12 2 4 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $22 r0 *1 6.68,1.375 nmos_5p0
M$22 12 5 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.0696P PS=2.35U PD=0.82U
* device instance $23 r0 *1 8.18,1.375 nmos_5p0
M$23 5 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3932P AD=0.1508P PS=2.35U PD=1.1U
* device instance $24 r0 *1 9.3,1.375 nmos_5p0
M$24 6 2 5 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $25 r0 *1 10.42,1.375 nmos_5p0
M$25 13 3 6 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $26 r0 *1 11.26,1.375 nmos_5p0
M$26 13 7 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $27 r0 *1 12.6,1.005 nmos_5p0
M$27 7 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7206P AD=0.6864P PS=3.9U PD=3.68U
* device instance $29 r0 *1 14.84,1.005 nmos_5p0
M$29 8 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A4
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_4 1 3 4 5 6 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A3
* net 4 A4
* net 5 A2
* net 6 A1
* net 16 ZN
* net 17 NWELL,VDD
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 16 3 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.5616P AD=1.3312P PS=8.84U PD=7.2U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 17 4 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $9 r0 *1 9.03,4.055 pmos_5p0
M$9 16 5 17 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.5616P PS=7.2U PD=8.84U
* device instance $10 r0 *1 10.05,4.055 pmos_5p0
M$10 17 6 16 17 pmos_5p0 L=0.5U W=5.12U AS=1.3312P AD=1.3312P PS=7.2U PD=7.2U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 7 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 1 4 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 9 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $24 r0 *1 8.01,1.005 nmos_5p0
M$24 11 3 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $25 r0 *1 9.03,1.005 nmos_5p0
M$25 14 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $26 r0 *1 10,1.005 nmos_5p0
M$26 16 6 14 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 11.12,1.005 nmos_5p0
M$27 15 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.04,1.005 nmos_5p0
M$28 2 5 15 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.16,1.005 nmos_5p0
M$29 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.08,1.005 nmos_5p0
M$30 16 6 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.2,1.005 nmos_5p0
M$31 13 6 16 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.12,1.005 nmos_5p0
M$32 2 5 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_3 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.552 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=2.75U AS=1.03125P AD=0.97625P PS=5.625U PD=4.17U
* device instance $3 r0 *1 3.29,3.552 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=5.5U AS=1.82875P AD=1.88375P PS=8.16U PD=9.615U
* device instance $7 r0 *1 0.92,1.34 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.1U AS=0.385P AD=0.3455P PS=3.05U PD=2.37U
* device instance $9 r0 *1 3.34,1.365 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=2.4U AS=0.6705P AD=0.732P PS=4.66U PD=5.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin ZN
* pin A2
* pin B1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_4 1 2 3 4 13 14 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 ZN
* net 4 A2
* net 13 B1
* net 14 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 16 2 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1228P PS=11.59U PD=9.64U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 15 13 16 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.27,3.78 pmos_5p0
M$9 3 4 15 16 pmos_5p0 L=0.5U W=7.32U AS=2.1228P AD=2.2326P PS=9.64U PD=11.59U
* device instance $10 r0 *1 10.29,3.78 pmos_5p0
M$10 15 14 3 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $18 r0 *1 1.84,1.005 nmos_5p0
M$18 3 13 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $19 r0 *1 2.96,1.005 nmos_5p0
M$19 7 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 3.88,1.005 nmos_5p0
M$20 1 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $21 r0 *1 5,1.005 nmos_5p0
M$21 6 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 5.92,1.005 nmos_5p0
M$22 3 13 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 7.04,1.005 nmos_5p0
M$23 9 13 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 7.96,1.005 nmos_5p0
M$24 1 2 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5016P PS=1.64U PD=2.08U
* device instance $25 r0 *1 9.32,1.005 nmos_5p0
M$25 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5016P AD=0.2112P PS=2.08U PD=1.64U
* device instance $26 r0 *1 10.24,1.005 nmos_5p0
M$26 3 14 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $27 r0 *1 11.36,1.005 nmos_5p0
M$27 11 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.28,1.005 nmos_5p0
M$28 1 4 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 13.4,1.005 nmos_5p0
M$29 10 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.32,1.005 nmos_5p0
M$30 3 14 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 15.44,1.005 nmos_5p0
M$31 8 14 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 16.36,1.005 nmos_5p0
M$32 1 4 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai33_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B3
* pin B2
* pin B1
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai33_2 1 3 4 5 6 7 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B3
* net 4 B2
* net 5 B1
* net 6 A3
* net 7 A2
* net 8 A1
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 3 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 11 4 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 5 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 14 5 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 13 4 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 9 3 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 15 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 16 7 15 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 8 16 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 11,3.78 pmos_5p0
M$10 17 8 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.12,3.78 pmos_5p0
M$11 18 7 17 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $12 r0 *1 13.19,3.78 pmos_5p0
M$12 9 6 18 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 1 3 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 2 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $15 r0 *1 3.16,1.005 nmos_5p0
M$15 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $19 r0 *1 7.64,1.005 nmos_5p0
M$19 10 6 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $20 r0 *1 8.76,1.005 nmos_5p0
M$20 2 7 10 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 10 8 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai33_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.3 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.8906P AD=0.8906P PS=6.09U PD=6.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai33_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A1
* pin ZN
* pin A3
* pin B2
* pin B3
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai33_4 1 2 3 5 6 7 8 9 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B1
* net 3 A1
* net 5 ZN
* net 6 A3
* net 7 B2
* net 8 B3
* net 9 A2
* net 11 NWELL,VDD
* device instance $1 r0 *1 14.93,3.78 pmos_5p0
M$1 5 3 12 11 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $4 r0 *1 18.24,3.78 pmos_5p0
M$4 18 3 5 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 19.36,3.78 pmos_5p0
M$5 20 9 18 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 20.48,3.78 pmos_5p0
M$6 11 6 20 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $7 r0 *1 21.65,3.78 pmos_5p0
M$7 19 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $8 r0 *1 22.72,3.78 pmos_5p0
M$8 12 9 19 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 23.84,3.78 pmos_5p0
M$9 21 9 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 24.96,3.78 pmos_5p0
M$10 11 6 21 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 26.08,3.78 pmos_5p0
M$11 22 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $12 r0 *1 27.15,3.78 pmos_5p0
M$12 12 9 22 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 13 7 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $14 r0 *1 1.99,3.78 pmos_5p0
M$14 11 8 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 3.16,3.78 pmos_5p0
M$15 15 8 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $16 r0 *1 4.28,3.78 pmos_5p0
M$16 10 7 15 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $17 r0 *1 5.4,3.78 pmos_5p0
M$17 14 7 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $18 r0 *1 6.47,3.78 pmos_5p0
M$18 11 8 14 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $19 r0 *1 7.64,3.78 pmos_5p0
M$19 16 8 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $20 r0 *1 8.76,3.78 pmos_5p0
M$20 17 7 16 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $21 r0 *1 9.88,3.78 pmos_5p0
M$21 5 2 17 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $22 r0 *1 10.95,3.78 pmos_5p0
M$22 10 2 5 11 pmos_5p0 L=0.5U W=5.49U AS=1.65615P AD=1.9398P PS=7.3U PD=9.44U
* device instance $25 r0 *1 0.92,1.005 nmos_5p0
M$25 1 7 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $26 r0 *1 2.04,1.005 nmos_5p0
M$26 4 8 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $33 r0 *1 9.88,1.005 nmos_5p0
M$33 1 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $37 r0 *1 14.88,1.005 nmos_5p0
M$37 5 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.3728P PS=7.88U PD=7.36U
* device instance $41 r0 *1 19.36,1.005 nmos_5p0
M$41 5 9 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $42 r0 *1 20.48,1.005 nmos_5p0
M$42 4 6 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai33_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin C
* pin ZN
* pin B1
* pin B2
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_4 1 2 5 6 7 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 C
* net 5 ZN
* net 6 B1
* net 7 B2
* net 8 A2
* net 9 A1
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 12 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 12 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 14 6 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 7 14 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 13 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 5 6 13 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=1.0157P PS=2.45U PD=3.12U
* device instance $9 r0 *1 10.55,3.965 pmos_5p0
M$9 10 2 5 10 pmos_5p0 L=0.5U W=5.84U AS=2.5205P AD=1.8104P PS=9.83U PD=8.32U
* device instance $13 r0 *1 15.13,3.78 pmos_5p0
M$13 16 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5996P AD=0.52155P PS=2.55U PD=2.4U
* device instance $14 r0 *1 16.2,3.78 pmos_5p0
M$14 10 8 16 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 17.37,3.78 pmos_5p0
M$15 15 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $16 r0 *1 18.44,3.78 pmos_5p0
M$16 5 9 15 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $17 r0 *1 19.56,3.78 pmos_5p0
M$17 17 9 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $18 r0 *1 20.68,3.78 pmos_5p0
M$18 10 8 17 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $19 r0 *1 21.8,3.78 pmos_5p0
M$19 18 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $20 r0 *1 22.87,3.78 pmos_5p0
M$20 5 9 18 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $21 r0 *1 10.6,1.005 nmos_5p0
M$21 3 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $25 r0 *1 15.08,1.005 nmos_5p0
M$25 5 9 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
* device instance $26 r0 *1 16.2,1.005 nmos_5p0
M$26 4 8 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $33 r0 *1 0.92,1.005 nmos_5p0
M$33 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $34 r0 *1 2.04,1.005 nmos_5p0
M$34 1 7 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_4 1 3 4 5 6 7 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 ZN
* net 4 A2
* net 5 A1
* net 6 B
* net 7 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 13 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 3 5 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 14 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 12 4 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 15 4 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 3 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 16 5 3 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 12 4 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $9 r0 *1 9.91,3.965 pmos_5p0
M$9 3 6 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7238P AD=1.7812P PS=8.47U PD=9.74U
* device instance $10 r0 *1 10.93,3.965 pmos_5p0
M$10 12 7 3 12 pmos_5p0 L=0.5U W=5.84U AS=1.5184P AD=1.5184P PS=7.92U PD=7.92U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 3 4 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3926P PS=9.04U PD=7.39U
* device instance $18 r0 *1 2.04,1.005 nmos_5p0
M$18 2 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $25 r0 *1 9.91,1.005 nmos_5p0
M$25 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $26 r0 *1 10.88,1.005 nmos_5p0
M$26 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $27 r0 *1 12,1.005 nmos_5p0
M$27 11 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $28 r0 *1 12.92,1.005 nmos_5p0
M$28 2 6 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $29 r0 *1 14.04,1.005 nmos_5p0
M$29 9 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $30 r0 *1 14.96,1.005 nmos_5p0
M$30 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $31 r0 *1 16.08,1.005 nmos_5p0
M$31 8 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $32 r0 *1 17,1.005 nmos_5p0
M$32 2 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_4

* cell gf180mcu_fd_sc_mcu9t5v0__or3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 2 6 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 4 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 3 5 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 9 5 3 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 6 2 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=2.73U
* device instance $7 r0 *1 7.87,3.78 pmos_5p0
M$7 7 3 6 6 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.4156P PS=9.98U PD=11.79U
* device instance $11 r0 *1 0.92,0.87 nmos_5p0
M$11 3 2 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.735P AD=0.6945P PS=4.55U PD=3.59U
* device instance $12 r0 *1 2.04,0.87 nmos_5p0
M$12 1 4 3 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $13 r0 *1 3.16,0.87 nmos_5p0
M$13 3 5 1 1 nmos_5p0 L=0.6U W=2.1U AS=0.546P AD=0.546P PS=3.14U PD=3.14U
* device instance $17 r0 *1 7.82,1.005 nmos_5p0
M$17 7 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4511P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_8
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_8 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7763P PS=21.69U PD=21.69U
* device instance $9 r0 *1 0.92,1.3 nmos_5p0
M$9 4 3 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.6498P AD=1.6498P PS=11.09U PD=11.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_8

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.2993P PS=6.99U PD=5.08U
* device instance $3 r0 *1 3.29,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.4339P AD=2.5071P PS=9.98U PD=11.89U
* device instance $7 r0 *1 0.92,1.23 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.4593P PS=3.59U PD=2.75U
* device instance $9 r0 *1 3.34,1.265 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=3.2U AS=0.8935P AD=0.976P PS=5.46U PD=6.44U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_20 1 2 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=36.6U AS=11.5839P AD=11.5839P PS=51.09U PD=51.09U
* device instance $21 r0 *1 0.92,1.3 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=14.6U AS=3.9274P AD=3.9274P PS=26.09U PD=26.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_20

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_12 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 4 4 pmos_5p0 L=0.5U W=21.96U AS=7.0455P AD=7.0455P PS=31.49U PD=31.49U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=8.76U AS=2.409P AD=2.409P PS=16.09U PD=16.09U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_12

* cell gf180mcu_fd_sc_mcu9t5v0__inv_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_4 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.5071P PS=11.89U PD=11.89U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_16 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.7031P PS=21.69U PD=19.78U
* device instance $9 r0 *1 10.01,3.78 pmos_5p0
M$9 4 3 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.2415P AD=9.3147P PS=39.38U PD=41.29U
* device instance $25 r0 *1 0.92,1.3 nmos_5p0
M$25 3 2 1 1 nmos_5p0 L=0.6U W=5.84U AS=1.7295P AD=1.5184P PS=11.34U PD=10U
* device instance $33 r0 *1 10.06,1.265 nmos_5p0
M$33 4 3 1 1 nmos_5p0 L=0.6U W=12.8U AS=3.3895P AD=3.472P PS=21.3U PD=22.28U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_16

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin A1
* pin B2
* pin B1
* pin NWELL,VDD
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_4 1 3 4 5 6 7 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A3
* net 5 A1
* net 6 B2
* net 7 B1
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 15.135,3.78 pmos_5p0
M$1 16 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 16.205,3.78 pmos_5p0
M$2 10 7 16 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 17.325,3.78 pmos_5p0
M$3 18 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 18.445,3.78 pmos_5p0
M$4 9 6 18 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 19.565,3.78 pmos_5p0
M$5 17 6 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 20.685,3.78 pmos_5p0
M$6 10 7 17 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 21.805,3.78 pmos_5p0
M$7 19 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 22.875,3.78 pmos_5p0
M$8 9 6 19 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8235P PS=2.4U PD=4.56U
* device instance $9 r0 *1 1.125,3.78 pmos_5p0
M$9 11 3 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $10 r0 *1 2.195,3.78 pmos_5p0
M$10 9 4 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $11 r0 *1 3.415,3.78 pmos_5p0
M$11 13 4 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $12 r0 *1 4.485,3.78 pmos_5p0
M$12 8 3 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $13 r0 *1 5.605,3.78 pmos_5p0
M$13 12 3 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $14 r0 *1 6.675,3.78 pmos_5p0
M$14 9 4 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $15 r0 *1 7.845,3.78 pmos_5p0
M$15 14 4 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $16 r0 *1 8.965,3.78 pmos_5p0
M$16 15 3 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $17 r0 *1 10.035,3.78 pmos_5p0
M$17 10 5 15 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $18 r0 *1 11.155,3.78 pmos_5p0
M$18 8 5 10 9 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $21 r0 *1 1.125,1.005 nmos_5p0
M$21 1 3 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $22 r0 *1 2.245,1.005 nmos_5p0
M$22 2 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 10.085,1.005 nmos_5p0
M$29 1 5 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $33 r0 *1 15.085,1.005 nmos_5p0
M$33 10 6 2 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
* device instance $34 r0 *1 16.205,1.005 nmos_5p0
M$34 2 7 10 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_4

* cell gf180mcu_fd_sc_mcu9t5v0__and3_4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_4 1 2 3 4 5 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS,gf180mcu_gnd
* net 5 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.87,3.595 pmos_5p0
M$1 6 1 5 5 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.0012P PS=5.78U PD=4.55U
* device instance $2 r0 *1 1.89,3.595 pmos_5p0
M$2 5 2 6 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.595 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 7 6 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.049P AD=2.2326P PS=9.62U PD=11.59U
* device instance $11 r0 *1 1,1.005 nmos_5p0
M$11 11 1 4 4 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $12 r0 *1 1.84,1.005 nmos_5p0
M$12 10 2 11 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.2772P PS=1.56U PD=1.74U
* device instance $13 r0 *1 2.86,1.005 nmos_5p0
M$13 6 3 10 4 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $14 r0 *1 3.98,1.005 nmos_5p0
M$14 9 3 6 4 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $15 r0 *1 4.9,1.005 nmos_5p0
M$15 8 2 9 4 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.1584P PS=1.64U PD=1.56U
* device instance $16 r0 *1 5.74,1.005 nmos_5p0
M$16 4 1 8 4 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 6.86,1.005 nmos_5p0
M$17 7 6 4 4 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A3
* pin ZN
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_4 1 2 4 5 11 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A3
* net 5 ZN
* net 11 A2
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.87,3.965 pmos_5p0
M$1 5 11 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.8542P AD=1.5914P PS=9.84U PD=8.02U
* device instance $2 r0 *1 1.89,3.965 pmos_5p0
M$2 12 4 5 12 pmos_5p0 L=0.5U W=5.84U AS=1.6644P AD=1.6644P PS=8.12U PD=8.12U
* device instance $9 r0 *1 9.33,3.965 pmos_5p0
M$9 5 2 12 12 pmos_5p0 L=0.5U W=5.84U AS=1.7374P AD=2.0002P PS=8.22U PD=10.04U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 6 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $14 r0 *1 1.94,1.005 nmos_5p0
M$14 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $15 r0 *1 3.06,1.005 nmos_5p0
M$15 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $16 r0 *1 4.08,1.005 nmos_5p0
M$16 3 11 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.2,1.005 nmos_5p0
M$17 9 11 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $18 r0 *1 6.22,1.005 nmos_5p0
M$18 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.34,1.005 nmos_5p0
M$19 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2772P PS=1.84U PD=1.74U
* device instance $20 r0 *1 8.36,1.005 nmos_5p0
M$20 10 11 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $21 r0 *1 9.38,1.005 nmos_5p0
M$21 5 2 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $22 r0 *1 10.5,1.005 nmos_5p0
M$22 3 2 5 1 nmos_5p0 L=0.6U W=3.96U AS=1.0296P AD=1.2672P PS=5.52U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_4

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_4 2 5 7 8 9
* net 2 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* net 7 A2
* net 8 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 7.27,3.78 pmos_5p0
M$1 5 4 9 9 pmos_5p0 L=0.5U W=7.32U AS=2.4156P AD=2.4156P PS=11.79U PD=11.79U
* device instance $5 r0 *1 0.87,3.962 pmos_5p0
M$5 3 7 9 9 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.1287P PS=1.87U PD=1.015U
* device instance $6 r0 *1 1.89,3.962 pmos_5p0
M$6 3 8 9 9 pmos_5p0 L=0.5U W=0.495U AS=0.465P AD=0.1287P PS=2.63U PD=1.015U
* device instance $7 r0 *1 3.19,3.78 pmos_5p0
M$7 4 3 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.465P AD=0.52155P PS=2.63U PD=2.4U
* device instance $8 r0 *1 4.26,3.78 pmos_5p0
M$8 10 8 4 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $9 r0 *1 5.33,3.78 pmos_5p0
M$9 9 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $10 r0 *1 7.22,1.005 nmos_5p0
M$10 5 4 2 2 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $14 r0 *1 0.92,1.48 nmos_5p0
M$14 6 7 3 2 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0576P PS=1.6U PD=0.68U
* device instance $15 r0 *1 1.84,1.48 nmos_5p0
M$15 6 8 2 2 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.0576P PS=2.02U PD=0.68U
* device instance $16 r0 *1 3.14,1 nmos_5p0
M$16 1 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.318P AD=0.3432P PS=2.02U PD=1.84U
* device instance $17 r0 *1 4.26,1 nmos_5p0
M$17 4 8 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $18 r0 *1 5.38,1 nmos_5p0
M$18 1 7 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin A4
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A3
* net 4 A2
* net 5 A1
* net 6 NWELL,VDD
* net 7 A4
* device instance $1 r0 *1 0.87,4.055 pmos_5p0
M$1 6 7 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.896P PS=5.24U PD=5.24U
* device instance $2 r0 *1 1.89,4.055 pmos_5p0
M$2 2 3 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.91,4.055 pmos_5p0
M$3 6 4 2 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.93,4.055 pmos_5p0
M$4 2 5 6 6 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 13 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2442P PS=3.52U PD=1.69U
* device instance $10 r0 *1 1.89,1.005 nmos_5p0
M$10 12 3 13 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2442P PS=1.69U PD=1.69U
* device instance $11 r0 *1 2.86,1.005 nmos_5p0
M$11 11 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 9 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2442P PS=1.84U PD=1.69U
* device instance $14 r0 *1 5.97,1.005 nmos_5p0
M$14 8 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.2772P PS=1.69U PD=1.74U
* device instance $15 r0 *1 6.99,1.005 nmos_5p0
M$15 10 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2442P PS=1.74U PD=1.69U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.5808P PS=1.69U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.4339P PS=11.89U PD=9.98U
* device instance $5 r0 *1 5.53,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7031P AD=4.7763P PS=19.78U PD=21.69U
* device instance $13 r0 *1 0.92,1.3 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=2.92U AS=0.9703P AD=0.7592P PS=6.34U PD=5U
* device instance $17 r0 *1 5.58,1.265 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=6.4U AS=1.7255P AD=1.808P PS=10.74U PD=11.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_8

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_4 1 4 5 6 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 7.27,3.78 pmos_5p0
M$1 4 3 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.4156P AD=2.4156P PS=11.79U PD=11.79U
* device instance $5 r0 *1 0.92,3.112 pmos_5p0
M$5 10 5 2 8 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.15345P PS=1.87U PD=1.115U
* device instance $6 r0 *1 2.04,3.112 pmos_5p0
M$6 8 6 10 8 pmos_5p0 L=0.5U W=0.495U AS=0.15345P AD=0.479325P PS=1.115U
+ PD=2.58U
* device instance $7 r0 *1 3.29,3.78 pmos_5p0
M$7 9 2 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.479325P AD=0.5673P PS=2.58U PD=2.45U
* device instance $8 r0 *1 4.41,3.78 pmos_5p0
M$8 3 6 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.4758P PS=2.45U PD=2.35U
* device instance $9 r0 *1 5.43,3.78 pmos_5p0
M$9 9 5 3 8 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 7.22,1.005 nmos_5p0
M$10 4 3 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.6104P PS=9.04U PD=9.04U
* device instance $14 r0 *1 0.92,0.85 nmos_5p0
M$14 2 5 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $15 r0 *1 2.04,0.85 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.318P AD=0.0936P PS=2.02U PD=0.88U
* device instance $16 r0 *1 3.34,1.005 nmos_5p0
M$16 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.318P AD=0.3432P PS=2.02U PD=1.84U
* device instance $17 r0 *1 4.46,1.005 nmos_5p0
M$17 7 6 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.38,1.005 nmos_5p0
M$18 1 5 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__addh_4
* pin PWELL,VSS,gf180mcu_gnd
* pin S
* pin A
* pin B
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_4 1 4 5 6 8 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 S
* net 5 A
* net 6 B
* net 8 CO
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 2 5 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.16205P PS=6.89U PD=4.93U
* device instance $2 r0 *1 1.94,3.78 pmos_5p0
M$2 11 6 2 11 pmos_5p0 L=0.5U W=3.66U AS=0.99735P AD=0.99735P PS=4.75U PD=4.75U
* device instance $5 r0 *1 5.28,3.78 pmos_5p0
M$5 7 2 11 11 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.25355P PS=5.03U PD=5.03U
* device instance $6 r0 *1 6.35,3.78 pmos_5p0
M$6 12 5 7 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 7.52,3.78 pmos_5p0
M$7 11 6 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.5673P PS=2.5U PD=2.45U
* device instance $8 r0 *1 8.64,3.78 pmos_5p0
M$8 13 6 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.76,3.78 pmos_5p0
M$9 7 5 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.18,3.78 pmos_5p0
M$11 8 2 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.22345P PS=9.93U PD=9.75U
* device instance $15 r0 *1 16.61,3.78 pmos_5p0
M$15 4 7 11 11 pmos_5p0 L=0.5U W=7.32U AS=2.24175P AD=2.47965P PS=9.77U
+ PD=11.86U
* device instance $19 r0 *1 0.92,1 nmos_5p0
M$19 9 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2772P PS=3.52U PD=1.74U
* device instance $20 r0 *1 1.94,1 nmos_5p0
M$20 2 6 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 3.06,1 nmos_5p0
M$21 10 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $22 r0 *1 3.98,1 nmos_5p0
M$22 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.396P PS=1.64U PD=2.02U
* device instance $23 r0 *1 5.28,1.22 nmos_5p0
M$23 3 2 1 1 nmos_5p0 L=0.6U W=1.76U AS=0.792P AD=0.4576P PS=4.04U PD=2.8U
* device instance $24 r0 *1 6.4,1.22 nmos_5p0
M$24 7 5 3 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $25 r0 *1 7.52,1.22 nmos_5p0
M$25 3 6 7 1 nmos_5p0 L=0.6U W=1.76U AS=0.4576P AD=0.4576P PS=2.8U PD=2.8U
* device instance $29 r0 *1 12.18,1 nmos_5p0
M$29 8 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4256P AD=1.3728P PS=7.54U PD=7.36U
* device instance $33 r0 *1 16.66,1 nmos_5p0
M$33 4 7 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai222_2
* pin PWELL,VSS,gf180mcu_gnd
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai222_2 1 4 5 6 7 8 9 10 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 4 C1
* net 5 C2
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 ZN
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 4 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 11 5 12 11 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 13 5 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 10 4 13 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=1.2261P PS=2.45U PD=3.17U
* device instance $5 r0 *1 6.12,3.78 pmos_5p0
M$5 14 6 10 11 pmos_5p0 L=0.5U W=1.83U AS=1.2261P AD=0.5673P PS=3.17U PD=2.45U
* device instance $6 r0 *1 7.24,3.78 pmos_5p0
M$6 11 7 14 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 8.36,3.78 pmos_5p0
M$7 15 7 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 9.48,3.78 pmos_5p0
M$8 10 6 15 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 10.6,3.78 pmos_5p0
M$9 17 8 10 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 11.72,3.78 pmos_5p0
M$10 11 9 17 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 12.84,3.78 pmos_5p0
M$11 16 9 11 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $12 r0 *1 13.96,3.78 pmos_5p0
M$12 10 8 16 11 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 6.12,1.005 nmos_5p0
M$17 2 6 3 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $18 r0 *1 7.24,1.005 nmos_5p0
M$18 3 7 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $21 r0 *1 10.6,1.005 nmos_5p0
M$21 10 8 3 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $22 r0 *1 11.72,1.005 nmos_5p0
M$22 3 9 10 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai222_2

* cell gf180mcu_fd_sc_mcu9t5v0__dffsnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin SETN
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffsnq_2 1 5 7 8 13 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 7 CLK
* net 8 D
* net 13 SETN
* net 17 NWELL,VDD
* device instance $1 r0 *1 18.73,3.78 pmos_5p0
M$1 5 4 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 14.48,3.365 pmos_5p0
M$3 12 13 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 15.5,3.365 pmos_5p0
M$4 17 4 12 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.536P PS=1.52U PD=2.57U
* device instance $5 r0 *1 16.74,3.78 pmos_5p0
M$5 4 3 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.536P AD=0.8052P PS=2.57U PD=4.54U
* device instance $6 r0 *1 0.97,3.555 pmos_5p0
M$6 17 7 6 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $7 r0 *1 1.99,3.555 pmos_5p0
M$7 2 6 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $8 r0 *1 11.4,3.365 pmos_5p0
M$8 3 6 11 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.42P PS=2.88U PD=1.84U
* device instance $9 r0 *1 12.74,3.365 pmos_5p0
M$9 12 2 3 17 pmos_5p0 L=0.5U W=1U AS=0.42P AD=0.44P PS=1.84U PD=2.88U
* device instance $10 r0 *1 3.93,3.465 pmos_5p0
M$10 9 8 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.3825P PS=2.88U PD=1.765U
* device instance $11 r0 *1 5.195,3.465 pmos_5p0
M$11 10 2 9 17 pmos_5p0 L=0.5U W=1U AS=0.3825P AD=0.26P PS=1.765U PD=1.52U
* device instance $12 r0 *1 6.215,3.465 pmos_5p0
M$12 18 6 10 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.1825P PS=1.52U PD=1.365U
* device instance $13 r0 *1 7.08,3.465 pmos_5p0
M$13 17 11 18 17 pmos_5p0 L=0.5U W=1U AS=0.1825P AD=0.3P PS=1.365U PD=1.6U
* device instance $14 r0 *1 8.18,3.465 pmos_5p0
M$14 11 10 17 17 pmos_5p0 L=0.5U W=1U AS=0.3P AD=0.29P PS=1.6U PD=1.58U
* device instance $15 r0 *1 9.26,3.465 pmos_5p0
M$15 17 13 11 17 pmos_5p0 L=0.5U W=1U AS=0.29P AD=0.7374P PS=1.58U PD=3.75U
* device instance $16 r0 *1 18.68,1.005 nmos_5p0
M$16 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $18 r0 *1 3.88,1.265 nmos_5p0
M$18 9 8 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $19 r0 *1 5,1.265 nmos_5p0
M$19 10 6 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1711P PS=1.11U PD=1.17U
* device instance $20 r0 *1 6.18,1.265 nmos_5p0
M$20 14 2 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.1711P AD=0.07375P PS=1.17U PD=0.84U
* device instance $21 r0 *1 7.03,1.265 nmos_5p0
M$21 1 11 14 1 nmos_5p0 L=0.6U W=0.59U AS=0.07375P AD=0.22355P PS=0.84U
+ PD=1.435U
* device instance $22 r0 *1 8.37,1.37 nmos_5p0
M$22 15 10 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.22355P AD=0.0708P PS=1.435U PD=0.83U
* device instance $23 r0 *1 9.21,1.37 nmos_5p0
M$23 11 13 15 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.1534P PS=0.83U PD=1.11U
* device instance $24 r0 *1 10.33,1.37 nmos_5p0
M$24 3 2 11 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $25 r0 *1 11.45,1.37 nmos_5p0
M$25 12 6 3 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
* device instance $26 r0 *1 0.92,1.27 nmos_5p0
M$26 1 7 6 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $27 r0 *1 2.04,1.27 nmos_5p0
M$27 2 6 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $28 r0 *1 14.61,1.37 nmos_5p0
M$28 16 13 12 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.0708P PS=2.06U PD=0.83U
* device instance $29 r0 *1 15.45,1.37 nmos_5p0
M$29 16 4 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $30 r0 *1 16.79,1.005 nmos_5p0
M$30 4 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3789P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffsnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.7385P PS=7.02U PD=7.39U
* device instance $3 r0 *1 0.92,1.005 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.9438P AD=0.9438P PS=5.39U PD=5.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 1.09,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.5685P PS=16.79U PD=14.88U
* device instance $7 r0 *1 7.99,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.9723P AD=7.0455P PS=29.58U PD=31.49U
* device instance $19 r0 *1 1.14,1.095 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=4.38U AS=1.5154P AD=1.2185P PS=9.5U PD=7.75U
* device instance $25 r0 *1 8.04,1.13 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=9.6U AS=2.5575P AD=2.64P PS=16.02U PD=17U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_12

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_4
* pin A2
* pin NWELL,VDD
* pin A3
* pin ZN
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_4 1 2 3 4 5 6
* net 1 A2
* net 2 NWELL,VDD
* net 3 A3
* net 4 ZN
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 12 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 2 3 12 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 11 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 7 1 11 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 9 1 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 3 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.59,3.78 pmos_5p0
M$7 8 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 10 1 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 4 6 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 7 6 4 2 pmos_5p0 L=0.5U W=5.49U AS=1.7019P AD=1.9398P PS=7.35U PD=9.44U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 4 1 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.9638P AD=0.8216P PS=6.39U PD=5.24U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 5 3 4 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.8216P PS=5.24U PD=5.24U
* device instance $21 r0 *1 9.88,0.74 nmos_5p0
M$21 4 6 5 5 nmos_5p0 L=0.6U W=3.16U AS=0.8216P AD=0.9638P PS=5.24U PD=6.39U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_4

* cell gf180mcu_fd_sc_mcu9t5v0__and2_4
* pin NWELL,VDD
* pin A2
* pin A1
* pin Z
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_4 1 2 3 5 6
* net 1 NWELL,VDD
* net 2 A2
* net 3 A1
* net 5 Z
* net 6 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.875 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.28U AS=1.3336P AD=0.8528P PS=6.69U PD=4.32U
* device instance $2 r0 *1 1.89,3.875 pmos_5p0
M$2 1 3 4 1 pmos_5p0 L=0.5U W=3.28U AS=0.8528P AD=0.8528P PS=4.32U PD=4.32U
* device instance $5 r0 *1 5.13,3.78 pmos_5p0
M$5 5 4 1 1 pmos_5p0 L=0.5U W=7.32U AS=2.0394P AD=2.2326P PS=9.58U PD=11.59U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 8 2 6 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 3 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 7 3 4 6 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 6 2 7 6 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 5 4 6 6 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_2 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.732P PS=4.54U PD=2.63U
* device instance $2 r0 *1 2.17,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.2993P AD=1.3725P PS=5.08U PD=6.99U
* device instance $4 r0 *1 0.92,1.23 nmos_5p0
M$4 3 1 4 3 nmos_5p0 L=0.6U W=0.73U AS=0.3212P AD=0.2695P PS=2.34U PD=1.5U
* device instance $5 r0 *1 2.22,1.265 nmos_5p0
M$5 5 4 3 3 nmos_5p0 L=0.6U W=1.6U AS=0.4775P AD=0.56P PS=2.82U PD=3.8U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_8
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_8 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=7.32U AS=2.5071P AD=2.2692P PS=11.89U PD=9.8U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 4 3 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.5384P AD=4.7763P PS=19.6U PD=21.69U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $17 r0 *1 5.4,1.005 nmos_5p0
M$17 4 3 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.7456P AD=2.9832P PS=14.72U PD=16.4U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_8

* cell gf180mcu_fd_sc_mcu9t5v0__buf_3
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_3 1 2 3 5
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 1 4 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.74115P PS=4.54U PD=2.64U
* device instance $2 r0 *1 2.18,3.78 pmos_5p0
M$2 5 4 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.87575P AD=1.9398P PS=7.54U PD=9.44U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 1 4 3 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.4686P PS=3.52U PD=2.03U
* device instance $6 r0 *1 2.23,1.005 nmos_5p0
M$6 5 4 3 3 nmos_5p0 L=0.6U W=3.96U AS=1.155P AD=1.2672P PS=5.71U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_3

* cell gf180mcu_fd_sc_mcu9t5v0__and4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin A1
* pin A2
* pin Z
* pin A4
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_4 1 2 3 5 6 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 A1
* net 5 A2
* net 6 Z
* net 13 A4
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.885,3.505 pmos_5p0
M$1 4 13 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.896P AD=0.8908P PS=5.24U PD=4.33U
* device instance $2 r0 *1 1.905,3.505 pmos_5p0
M$2 14 2 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $3 r0 *1 2.925,3.505 pmos_5p0
M$3 4 5 14 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $4 r0 *1 3.945,3.505 pmos_5p0
M$4 14 3 4 14 pmos_5p0 L=0.5U W=2.56U AS=0.6656P AD=0.6656P PS=3.6U PD=3.6U
* device instance $9 r0 *1 9.225,3.78 pmos_5p0
M$9 6 4 14 14 pmos_5p0 L=0.5U W=7.32U AS=1.9854P AD=2.2326P PS=9.58U PD=11.59U
* device instance $13 r0 *1 0.935,1.005 nmos_5p0
M$13 7 13 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.855,1.005 nmos_5p0
M$14 8 2 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $15 r0 *1 2.875,1.005 nmos_5p0
M$15 10 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $16 r0 *1 3.895,1.005 nmos_5p0
M$16 4 3 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $17 r0 *1 5.015,1.005 nmos_5p0
M$17 9 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 5.935,1.005 nmos_5p0
M$18 12 5 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $19 r0 *1 6.955,1.005 nmos_5p0
M$19 11 2 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $20 r0 *1 7.975,1.005 nmos_5p0
M$20 1 13 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $21 r0 *1 9.095,1.005 nmos_5p0
M$21 6 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_4

* cell gf180mcu_fd_sc_mcu9t5v0__or2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 2 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 6 3 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 7 3 6 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 4 2 7 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.7869P PS=2.4U PD=2.69U
* device instance $5 r0 *1 5.59,3.78 pmos_5p0
M$5 5 6 4 4 pmos_5p0 L=0.5U W=7.32U AS=2.3973P AD=2.4156P PS=9.94U PD=11.79U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 6 2 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7788P PS=5.36U PD=3.82U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 1 3 6 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.54,1.005 nmos_5p0
M$13 5 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4652P AD=1.6104P PS=7.5U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor3_2
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor3_2 1 2 3 4 5 6
* net 1 ZN
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A1
* net 6 A3
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 6 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 9 4 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 1 5 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 8 5 1 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 4 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 2 6 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 3 6 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.553P PS=3.77U PD=3.77U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 1 4 3 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 3 5 1 3 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_4 1 2 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 8 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 4 6 8 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 10 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 7 5 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 9 5 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 4 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 11 6 4 7 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 7 5 11 7 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6292P PS=2.4U PD=2.55U
* device instance $9 r0 *1 9.93,3.872 pmos_5p0
M$9 4 2 7 7 pmos_5p0 L=0.5U W=6.58U AS=2.117925P AD=2.212525P PS=9.295U
+ PD=10.915U
* device instance $13 r0 *1 0.92,1.005 nmos_5p0
M$13 4 5 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 2.04,1.005 nmos_5p0
M$14 3 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $21 r0 *1 9.88,1.005 nmos_5p0
M$21 1 2 3 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_4
* pin PWELL,VSS,gf180mcu_gnd
* pin A3
* pin B
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_4 1 2 3 5 6 7 9
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A3
* net 3 B
* net 5 ZN
* net 6 A2
* net 7 A1
* net 9 NWELL,VDD
* device instance $1 r0 *1 14.93,3.872 pmos_5p0
M$1 5 3 9 9 pmos_5p0 L=0.5U W=6.58U AS=2.212525P AD=2.212525P PS=10.915U
+ PD=10.915U
* device instance $5 r0 *1 0.97,3.78 pmos_5p0
M$5 9 2 8 9 pmos_5p0 L=0.5U W=5.49U AS=1.89405P AD=1.65615P PS=9.39U PD=7.3U
* device instance $8 r0 *1 4.28,3.78 pmos_5p0
M$8 11 2 9 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $9 r0 *1 5.4,3.78 pmos_5p0
M$9 10 6 11 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $10 r0 *1 6.52,3.78 pmos_5p0
M$10 5 7 10 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $11 r0 *1 7.64,3.78 pmos_5p0
M$11 13 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.61305P PS=2.45U PD=2.5U
* device instance $12 r0 *1 8.81,3.78 pmos_5p0
M$12 8 6 13 9 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $13 r0 *1 9.88,3.78 pmos_5p0
M$13 12 6 8 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $14 r0 *1 11,3.78 pmos_5p0
M$14 5 7 12 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $15 r0 *1 12.12,3.78 pmos_5p0
M$15 14 7 5 9 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $16 r0 *1 13.19,3.78 pmos_5p0
M$16 8 6 14 9 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $17 r0 *1 0.92,1.005 nmos_5p0
M$17 5 2 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $21 r0 *1 5.4,1.005 nmos_5p0
M$21 5 6 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.716P PS=7.36U PD=7.88U
* device instance $22 r0 *1 6.52,1.005 nmos_5p0
M$22 4 7 5 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.3728P PS=7.36U PD=7.36U
* device instance $29 r0 *1 14.88,1.005 nmos_5p0
M$29 1 3 4 1 nmos_5p0 L=0.6U W=5.28U AS=1.716P AD=1.6104P PS=7.88U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_4

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,0.995 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=2.19U AS=0.7008P AD=0.7008P PS=4.84U PD=4.84U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_3

* cell gf180mcu_fd_sc_mcu9t5v0__xnor3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin ZN
* pin A3
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor3_2 1 3 4 8 11 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 8 ZN
* net 11 A3
* net 12 NWELL,VDD
* device instance $1 r0 *1 13.64,3.78 pmos_5p0
M$1 12 7 8 12 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 1.09,3.772 pmos_5p0
M$3 15 3 2 12 pmos_5p0 L=0.5U W=0.495U AS=0.2178P AD=0.15345P PS=1.87U PD=1.115U
* device instance $4 r0 *1 2.21,3.772 pmos_5p0
M$4 15 4 12 12 pmos_5p0 L=0.5U W=0.495U AS=0.282P AD=0.15345P PS=1.715U
+ PD=1.115U
* device instance $5 r0 *1 3.51,3.967 pmos_5p0
M$5 13 2 12 12 pmos_5p0 L=0.5U W=0.915U AS=0.282P AD=0.2379P PS=1.715U PD=1.435U
* device instance $6 r0 *1 4.53,3.967 pmos_5p0
M$6 5 4 13 12 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.2379P PS=1.435U PD=1.435U
* device instance $7 r0 *1 5.55,3.967 pmos_5p0
M$7 13 3 5 12 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $8 r0 *1 7.39,3.977 pmos_5p0
M$8 16 5 6 12 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $9 r0 *1 8.41,3.977 pmos_5p0
M$9 16 11 12 12 pmos_5p0 L=0.5U W=0.915U AS=0.571875P AD=0.2379P PS=2.68U
+ PD=1.435U
* device instance $10 r0 *1 9.76,3.78 pmos_5p0
M$10 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.52155P PS=2.68U
+ PD=2.4U
* device instance $11 r0 *1 10.83,3.78 pmos_5p0
M$11 7 11 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $12 r0 *1 11.85,3.78 pmos_5p0
M$12 14 5 7 12 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $13 r0 *1 1.04,1.015 nmos_5p0
M$13 2 3 1 1 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.0936P PS=1.6U PD=0.88U
* device instance $14 r0 *1 2.16,1.015 nmos_5p0
M$14 1 4 2 1 nmos_5p0 L=0.6U W=0.36U AS=0.0936P AD=0.186P PS=0.88U PD=1.36U
* device instance $15 r0 *1 3.46,1.165 nmos_5p0
M$15 5 2 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.186P AD=0.1716P PS=1.36U PD=1.18U
* device instance $16 r0 *1 4.58,1.165 nmos_5p0
M$16 9 4 5 1 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1056P PS=1.18U PD=0.98U
* device instance $17 r0 *1 5.5,1.165 nmos_5p0
M$17 1 3 9 1 nmos_5p0 L=0.6U W=0.66U AS=0.1056P AD=0.2904P PS=0.98U PD=2.2U
* device instance $18 r0 *1 13.64,1.005 nmos_5p0
M$18 1 7 8 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $20 r0 *1 7.34,1.165 nmos_5p0
M$20 6 5 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $21 r0 *1 8.46,1.165 nmos_5p0
M$21 6 11 1 1 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $22 r0 *1 9.76,1 nmos_5p0
M$22 7 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $23 r0 *1 10.88,1 nmos_5p0
M$23 10 11 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 11.8,1 nmos_5p0
M$24 1 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor3_2

* cell gf180mcu_fd_sc_mcu9t5v0__xnor2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xnor2_2 1 5 6 7 8
* net 1 NWELL,VDD
* net 5 A1
* net 6 A2
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 ZN
* device instance $1 r0 *1 0.97,3.327 pmos_5p0
M$1 9 6 2 1 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.260775P PS=2.71U PD=1.485U
* device instance $2 r0 *1 2.04,3.327 pmos_5p0
M$2 1 5 9 1 pmos_5p0 L=0.5U W=0.915U AS=0.260775P AD=0.571875P PS=1.485U
+ PD=2.68U
* device instance $3 r0 *1 3.39,3.785 pmos_5p0
M$3 4 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.571875P AD=0.4758P PS=2.68U PD=2.35U
* device instance $4 r0 *1 4.41,3.785 pmos_5p0
M$4 3 5 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.4758P PS=2.35U PD=2.35U
* device instance $5 r0 *1 5.43,3.785 pmos_5p0
M$5 4 6 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.17,3.78 pmos_5p0
M$6 8 3 1 1 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 3 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,0.675 nmos_5p0
M$10 2 6 7 7 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $11 r0 *1 2.04,0.675 nmos_5p0
M$11 7 5 2 7 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.363P PS=1.18U PD=2.02U
* device instance $12 r0 *1 3.34,1.005 nmos_5p0
M$12 3 2 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.46,1.005 nmos_5p0
M$13 10 5 3 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 7 6 10 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xnor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__inv_3
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_3 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=5.49U AS=1.9398P AD=1.9398P PS=9.44U PD=9.44U
* device instance $4 r0 *1 0.92,1.005 nmos_5p0
M$4 4 3 1 1 nmos_5p0 L=0.6U W=3.96U AS=1.2672P AD=1.2672P PS=7.2U PD=7.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_3

* cell gf180mcu_fd_sc_mcu9t5v0__addh_2
* pin PWELL,VSS,gf180mcu_gnd
* pin CO
* pin S
* pin A
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_2 1 2 6 7 8 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 CO
* net 6 S
* net 7 A
* net 8 B
* net 10 NWELL,VDD
* device instance $1 r0 *1 5.99,3.78 pmos_5p0
M$1 11 8 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 7.06,3.78 pmos_5p0
M$2 5 7 11 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.52155P PS=2.4U PD=2.4U
* device instance $3 r0 *1 8.13,3.78 pmos_5p0
M$3 10 3 5 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8784P PS=2.4U PD=2.79U
* device instance $4 r0 *1 9.59,3.78 pmos_5p0
M$4 6 5 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.39995P AD=1.32675P PS=5.19U PD=6.94U
* device instance $6 r0 *1 0.94,3.78 pmos_5p0
M$6 2 3 10 10 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.08885P PS=6.99U PD=4.85U
* device instance $8 r0 *1 3.13,3.78 pmos_5p0
M$8 3 7 10 10 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.4758P PS=2.4U PD=2.35U
* device instance $9 r0 *1 4.15,3.78 pmos_5p0
M$9 10 8 3 10 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 5.94,1.005 nmos_5p0
M$10 5 8 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $11 r0 *1 7.06,1.005 nmos_5p0
M$11 4 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $12 r0 *1 8.18,1.005 nmos_5p0
M$12 1 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5016P PS=1.84U PD=2.08U
* device instance $13 r0 *1 9.54,1.005 nmos_5p0
M$13 6 5 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.8448P AD=0.924P PS=3.92U PD=5.36U
* device instance $15 r0 *1 0.94,1.005 nmos_5p0
M$15 2 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $17 r0 *1 3.18,1.005 nmos_5p0
M$17 9 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $18 r0 *1 4.1,1.005 nmos_5p0
M$18 3 8 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_2

* cell gf180mcu_fd_sc_mcu9t5v0__xor2_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__xor2_2 1 2 6 7 8
* net 1 A1
* net 2 PWELL,VSS,gf180mcu_gnd
* net 6 A2
* net 7 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.87,3.947 pmos_5p0
M$1 3 6 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 1.89,3.947 pmos_5p0
M$2 3 1 7 7 pmos_5p0 L=0.5U W=0.915U AS=0.526125P AD=0.2379P PS=2.58U PD=1.435U
* device instance $3 r0 *1 3.14,3.785 pmos_5p0
M$3 5 3 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.526125P AD=0.61305P PS=2.58U PD=2.5U
* device instance $4 r0 *1 4.31,3.785 pmos_5p0
M$4 9 1 5 7 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $5 r0 *1 5.33,3.785 pmos_5p0
M$5 7 6 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $6 r0 *1 7.27,3.78 pmos_5p0
M$6 8 5 7 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $8 r0 *1 7.22,1.005 nmos_5p0
M$8 8 5 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $10 r0 *1 0.92,1.16 nmos_5p0
M$10 10 6 3 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1056P PS=2.2U PD=0.98U
* device instance $11 r0 *1 1.84,1.16 nmos_5p0
M$11 10 1 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1056P PS=2.02U PD=0.98U
* device instance $12 r0 *1 3.14,1.005 nmos_5p0
M$12 4 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.3432P PS=2.02U PD=1.84U
* device instance $13 r0 *1 4.26,1.005 nmos_5p0
M$13 5 1 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $14 r0 *1 5.38,1.005 nmos_5p0
M$14 4 6 5 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__xor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__dlyb_2
* pin I
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dlyb_2 1 2 3 7
* net 1 I
* net 2 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 4.34,3.365 pmos_5p0
M$1 6 4 8 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $2 r0 *1 4.34,4.085 pmos_5p0
M$2 8 4 2 2 pmos_5p0 L=0.5U W=0.36U AS=0.528P AD=0.27P PS=3.13U PD=1.98U
* device instance $3 r0 *1 6.14,3.785 pmos_5p0
M$3 7 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.14105P AD=1.41825P PS=5.63U PD=7.04U
* device instance $5 r0 *1 2.18,3.365 pmos_5p0
M$5 9 5 4 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.27P PS=1.6U PD=1.98U
* device instance $6 r0 *1 0.87,4.085 pmos_5p0
M$6 2 1 5 2 pmos_5p0 L=0.5U W=0.36U AS=0.1584P AD=0.1458P PS=1.6U PD=1.17U
* device instance $7 r0 *1 2.18,4.085 pmos_5p0
M$7 2 5 9 2 pmos_5p0 L=0.5U W=0.36U AS=0.27P AD=0.1458P PS=1.98U PD=1.17U
* device instance $8 r0 *1 0.92,0.795 nmos_5p0
M$8 3 1 5 3 nmos_5p0 L=0.6U W=0.36U AS=0.1584P AD=0.1278P PS=1.6U PD=1.07U
* device instance $9 r0 *1 2.23,0.795 nmos_5p0
M$9 10 5 3 3 nmos_5p0 L=0.6U W=0.36U AS=0.1278P AD=0.27P PS=1.07U PD=1.98U
* device instance $10 r0 *1 2.23,1.515 nmos_5p0
M$10 4 5 10 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $11 r0 *1 4.39,0.525 nmos_5p0
M$11 3 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.408P PS=1.98U PD=2.52U
* device instance $12 r0 *1 4.39,1.245 nmos_5p0
M$12 6 4 11 3 nmos_5p0 L=0.6U W=0.36U AS=0.27P AD=0.1584P PS=1.98U PD=1.6U
* device instance $13 r0 *1 6.19,1.005 nmos_5p0
M$13 7 6 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7512P AD=0.924P PS=4.36U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dlyb_2

* cell gf180mcu_fd_sc_mcu9t5v0__addh_1
* pin CO
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A
* pin B
* pin S
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addh_1 1 2 3 4 5 9
* net 1 CO
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 NWELL,VDD
* net 4 A
* net 5 B
* net 9 S
* device instance $1 r0 *1 5.01,3.912 pmos_5p0
M$1 10 5 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.4026P AD=0.2379P PS=2.71U PD=1.435U
* device instance $2 r0 *1 6.03,3.912 pmos_5p0
M$2 8 4 10 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.3294P PS=1.435U PD=1.635U
* device instance $3 r0 *1 7.25,3.912 pmos_5p0
M$3 8 6 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.50325P AD=0.3294P PS=2.53U PD=1.635U
* device instance $4 r0 *1 8.45,3.78 pmos_5p0
M$4 9 8 3 3 pmos_5p0 L=0.5U W=1.83U AS=0.50325P AD=0.8052P PS=2.53U PD=4.54U
* device instance $5 r0 *1 2.23,3.912 pmos_5p0
M$5 6 4 3 3 pmos_5p0 L=0.5U W=0.915U AS=0.5307P AD=0.2379P PS=2.59U PD=1.435U
* device instance $6 r0 *1 3.25,3.912 pmos_5p0
M$6 3 5 6 3 pmos_5p0 L=0.5U W=0.915U AS=0.2379P AD=0.4026P PS=1.435U PD=2.71U
* device instance $7 r0 *1 0.97,3.78 pmos_5p0
M$7 3 6 1 3 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5307P PS=4.54U PD=2.59U
* device instance $8 r0 *1 4.96,1.335 nmos_5p0
M$8 8 5 7 2 nmos_5p0 L=0.6U W=0.66U AS=0.2904P AD=0.1716P PS=2.2U PD=1.18U
* device instance $9 r0 *1 6.08,1.335 nmos_5p0
M$9 7 4 8 2 nmos_5p0 L=0.6U W=0.66U AS=0.1716P AD=0.1716P PS=1.18U PD=1.18U
* device instance $10 r0 *1 7.2,1.335 nmos_5p0
M$10 7 6 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.363P AD=0.1716P PS=2.02U PD=1.18U
* device instance $11 r0 *1 8.5,1.005 nmos_5p0
M$11 9 8 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.5808P PS=2.02U PD=3.52U
* device instance $12 r0 *1 0.92,1.005 nmos_5p0
M$12 2 6 1 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3828P PS=3.52U PD=2.08U
* device instance $13 r0 *1 2.28,1.335 nmos_5p0
M$13 11 4 2 2 nmos_5p0 L=0.6U W=0.66U AS=0.3828P AD=0.0792P PS=2.08U PD=0.9U
* device instance $14 r0 *1 3.12,1.335 nmos_5p0
M$14 6 5 11 2 nmos_5p0 L=0.6U W=0.66U AS=0.0792P AD=0.2904P PS=0.9U PD=2.2U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addh_1

* cell gf180mcu_fd_sc_mcu9t5v0__addf_1
* pin PWELL,VSS,gf180mcu_gnd
* pin A
* pin S
* pin CO
* pin B
* pin CI
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addf_1 1 2 3 4 12 13 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A
* net 3 S
* net 4 CO
* net 12 B
* net 13 CI
* net 14 NWELL,VDD
* device instance $1 r0 *1 2.31,3.465 pmos_5p0
M$1 18 2 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.5985P AD=0.1683P PS=2.67U PD=1.33U
* device instance $2 r0 *1 3.15,3.465 pmos_5p0
M$2 17 12 18 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.1683P PS=1.33U PD=1.33U
* device instance $3 r0 *1 3.99,3.465 pmos_5p0
M$3 5 13 17 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.3069P PS=1.33U PD=1.61U
* device instance $4 r0 *1 5.11,3.465 pmos_5p0
M$4 15 8 5 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.3069P PS=1.61U PD=1.61U
* device instance $5 r0 *1 6.23,3.465 pmos_5p0
M$5 14 2 15 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.2574P PS=1.61U PD=1.51U
* device instance $6 r0 *1 7.25,3.465 pmos_5p0
M$6 15 12 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.2574P PS=1.51U PD=1.51U
* device instance $7 r0 *1 8.27,3.465 pmos_5p0
M$7 14 13 15 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.4356P PS=1.51U PD=2.86U
* device instance $8 r0 *1 0.97,3.78 pmos_5p0
M$8 14 5 3 14 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5985P PS=4.54U PD=2.67U
* device instance $9 r0 *1 10.31,3.36 pmos_5p0
M$9 14 12 16 14 pmos_5p0 L=0.5U W=0.99U AS=0.4356P AD=0.2574P PS=2.86U PD=1.51U
* device instance $10 r0 *1 11.33,3.36 pmos_5p0
M$10 16 2 14 14 pmos_5p0 L=0.5U W=0.99U AS=0.2574P AD=0.3069P PS=1.51U PD=1.61U
* device instance $11 r0 *1 12.45,3.36 pmos_5p0
M$11 8 13 16 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.3069P PS=1.61U PD=1.61U
* device instance $12 r0 *1 13.57,3.36 pmos_5p0
M$12 19 12 8 14 pmos_5p0 L=0.5U W=0.99U AS=0.3069P AD=0.1683P PS=1.61U PD=1.33U
* device instance $13 r0 *1 14.41,3.36 pmos_5p0
M$13 14 2 19 14 pmos_5p0 L=0.5U W=0.99U AS=0.1683P AD=0.6006P PS=1.33U PD=2.67U
* device instance $14 r0 *1 15.75,3.78 pmos_5p0
M$14 4 8 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6006P AD=0.8052P PS=2.67U PD=4.54U
* device instance $15 r0 *1 10.26,1.37 nmos_5p0
M$15 1 12 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.2596P AD=0.1534P PS=2.06U PD=1.11U
* device instance $16 r0 *1 11.38,1.37 nmos_5p0
M$16 7 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $17 r0 *1 12.5,1.37 nmos_5p0
M$17 8 13 7 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $18 r0 *1 13.62,1.37 nmos_5p0
M$18 11 12 8 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.0708P PS=1.11U PD=0.83U
* device instance $19 r0 *1 14.46,1.37 nmos_5p0
M$19 11 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3789P AD=0.0708P PS=2.06U PD=0.83U
* device instance $20 r0 *1 15.8,1.005 nmos_5p0
M$20 4 8 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3789P AD=0.5808P PS=2.06U PD=3.52U
* device instance $21 r0 *1 0.92,1.075 nmos_5p0
M$21 1 5 3 1 nmos_5p0 L=0.6U W=1.18U AS=0.5192P AD=0.3481P PS=3.24U PD=1.92U
* device instance $22 r0 *1 2.26,1.37 nmos_5p0
M$22 9 2 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.3481P AD=0.0708P PS=1.92U PD=0.83U
* device instance $23 r0 *1 3.1,1.37 nmos_5p0
M$23 10 12 9 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.0708P PS=0.83U PD=0.83U
* device instance $24 r0 *1 3.94,1.37 nmos_5p0
M$24 5 13 10 1 nmos_5p0 L=0.6U W=0.59U AS=0.0708P AD=0.1534P PS=0.83U PD=1.11U
* device instance $25 r0 *1 5.06,1.37 nmos_5p0
M$25 6 8 5 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $26 r0 *1 6.18,1.37 nmos_5p0
M$26 1 2 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $27 r0 *1 7.3,1.37 nmos_5p0
M$27 6 12 1 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.1534P PS=1.11U PD=1.11U
* device instance $28 r0 *1 8.42,1.37 nmos_5p0
M$28 1 13 6 1 nmos_5p0 L=0.6U W=0.59U AS=0.1534P AD=0.2596P PS=1.11U PD=2.06U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addf_1

* cell gf180mcu_fd_sc_mcu9t5v0__addf_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A
* pin S
* pin B
* pin CI
* pin CO
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__addf_2 1 2 3 5 6 10 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A
* net 3 S
* net 5 B
* net 6 CI
* net 10 CO
* net 14 NWELL,VDD
* device instance $1 r0 *1 11.37,3.56 pmos_5p0
M$1 14 5 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.6116P AD=0.4309P PS=3.66U PD=2.01U
* device instance $2 r0 *1 12.49,3.56 pmos_5p0
M$2 16 2 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.5004P PS=2.01U PD=2.11U
* device instance $3 r0 *1 13.71,3.56 pmos_5p0
M$3 9 6 16 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.4309P PS=2.11U PD=2.01U
* device instance $4 r0 *1 14.83,3.56 pmos_5p0
M$4 19 5 9 14 pmos_5p0 L=0.5U W=1.39U AS=0.4309P AD=0.1668P PS=2.01U PD=1.63U
* device instance $5 r0 *1 15.57,3.56 pmos_5p0
M$5 14 2 19 14 pmos_5p0 L=0.5U W=1.39U AS=0.1668P AD=0.5685P PS=1.63U PD=2.5U
* device instance $6 r0 *1 16.77,3.765 pmos_5p0
M$6 10 9 14 14 pmos_5p0 L=0.5U W=3.6U AS=1.0365P AD=1.26P PS=4.82U PD=6.8U
* device instance $8 r0 *1 3.57,3.56 pmos_5p0
M$8 18 2 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.6601P AD=0.1668P PS=2.62U PD=1.63U
* device instance $9 r0 *1 4.31,3.56 pmos_5p0
M$9 17 5 18 14 pmos_5p0 L=0.5U W=1.39U AS=0.1668P AD=0.2363P PS=1.63U PD=1.73U
* device instance $10 r0 *1 5.15,3.56 pmos_5p0
M$10 4 6 17 14 pmos_5p0 L=0.5U W=1.39U AS=0.2363P AD=0.3614P PS=1.73U PD=1.91U
* device instance $11 r0 *1 6.17,3.56 pmos_5p0
M$11 15 9 4 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.5004P PS=1.91U PD=2.11U
* device instance $12 r0 *1 7.39,3.56 pmos_5p0
M$12 14 2 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.3614P PS=2.11U PD=1.91U
* device instance $13 r0 *1 8.41,3.56 pmos_5p0
M$13 15 5 14 14 pmos_5p0 L=0.5U W=1.39U AS=0.3614P AD=0.5004P PS=1.91U PD=2.11U
* device instance $14 r0 *1 9.63,3.56 pmos_5p0
M$14 14 6 15 14 pmos_5p0 L=0.5U W=1.39U AS=0.5004P AD=0.6116P PS=2.11U PD=3.66U
* device instance $15 r0 *1 1.23,3.765 pmos_5p0
M$15 3 4 14 14 pmos_5p0 L=0.5U W=3.6U AS=1.26P AD=1.1281P PS=6.8U PD=4.94U
* device instance $17 r0 *1 11.42,1.265 nmos_5p0
M$17 1 5 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $18 r0 *1 12.54,1.265 nmos_5p0
M$18 8 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 13.66,1.265 nmos_5p0
M$19 9 6 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 14.78,1.265 nmos_5p0
M$20 13 5 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.096P PS=1.32U PD=1.04U
* device instance $21 r0 *1 15.62,1.265 nmos_5p0
M$21 13 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.3972P AD=0.096P PS=2.04U PD=1.04U
* device instance $22 r0 *1 16.94,1.005 nmos_5p0
M$22 10 9 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.7404P AD=0.924P PS=3.88U PD=5.36U
* device instance $24 r0 *1 0.96,1.005 nmos_5p0
M$24 3 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7536P PS=5.36U PD=3.9U
* device instance $26 r0 *1 3.42,1.265 nmos_5p0
M$26 11 2 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.4104P AD=0.096P PS=2.06U PD=1.04U
* device instance $27 r0 *1 4.26,1.265 nmos_5p0
M$27 12 5 11 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.096P PS=1.04U PD=1.04U
* device instance $28 r0 *1 5.1,1.265 nmos_5p0
M$28 4 6 12 1 nmos_5p0 L=0.6U W=0.8U AS=0.096P AD=0.208P PS=1.04U PD=1.32U
* device instance $29 r0 *1 6.22,1.265 nmos_5p0
M$29 7 9 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $30 r0 *1 7.34,1.265 nmos_5p0
M$30 1 2 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $31 r0 *1 8.46,1.265 nmos_5p0
M$31 7 5 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $32 r0 *1 9.58,1.265 nmos_5p0
M$32 1 6 7 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__addf_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin A2
* pin B
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_4 1 2 3 4 5 11
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 A2
* net 5 B
* net 11 NWELL,VDD
* device instance $1 r0 *1 1.07,3.785 pmos_5p0
M$1 2 4 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1594P PS=11.59U PD=9.68U
* device instance $2 r0 *1 2.09,3.785 pmos_5p0
M$2 10 3 2 11 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.51,3.785 pmos_5p0
M$9 11 5 10 11 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $13 r0 *1 1.14,1 nmos_5p0
M$13 7 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $14 r0 *1 1.98,1 nmos_5p0
M$14 2 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $15 r0 *1 3.1,1 nmos_5p0
M$15 6 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $16 r0 *1 3.94,1 nmos_5p0
M$16 1 4 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $17 r0 *1 5.06,1 nmos_5p0
M$17 8 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $18 r0 *1 5.9,1 nmos_5p0
M$18 2 3 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $19 r0 *1 7.02,1 nmos_5p0
M$19 9 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $20 r0 *1 7.86,1 nmos_5p0
M$20 1 4 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.402P PS=1.56U PD=2.02U
* device instance $21 r0 *1 9.16,1.2 nmos_5p0
M$21 2 5 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1196P AD=1.1224P PS=6.34U PD=7.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_4

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_4 1 2 3 4 5
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 ZN
* net 5 A1
* device instance $1 r0 *1 0.87,3.687 pmos_5p0
M$1 4 3 1 1 pmos_5p0 L=0.5U W=6.58U AS=2.0069P AD=2.0069P PS=10.665U PD=10.665U
* device instance $2 r0 *1 1.89,3.687 pmos_5p0
M$2 1 5 4 1 pmos_5p0 L=0.5U W=6.58U AS=1.7108P AD=1.7108P PS=8.66U PD=8.66U
* device instance $9 r0 *1 1,1.005 nmos_5p0
M$9 9 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1584P PS=3.52U PD=1.56U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 4 5 9 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3729P PS=1.56U PD=1.885U
* device instance $11 r0 *1 3.005,1.005 nmos_5p0
M$11 8 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3729P AD=0.1584P PS=1.885U PD=1.56U
* device instance $12 r0 *1 3.845,1.005 nmos_5p0
M$12 2 3 8 2 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3663P PS=1.56U PD=1.875U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 7 3 2 2 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.2112P PS=1.875U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 4 5 7 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 6 5 4 2 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 2 3 6 2 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.673P PS=26.59U PD=24.5U
* device instance $11 r0 *1 12.07,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.346P AD=11.5839P PS=49U PD=51.09U
* device instance $31 r0 *1 0.92,1.005 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=13.2U AS=3.6696P AD=3.432P PS=20.08U PD=18.4U
* device instance $41 r0 *1 12.12,1.005 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=6.864P AD=7.1016P PS=36.8U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_20

* cell gf180mcu_fd_sc_mcu9t5v0__buf_16
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_16 1 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 I
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 4 5 5 pmos_5p0 L=0.5U W=14.64U AS=4.7763P AD=4.5384P PS=21.69U PD=19.6U
* device instance $9 r0 *1 9.83,3.78 pmos_5p0
M$9 3 2 5 5 pmos_5p0 L=0.5U W=29.28U AS=9.0768P AD=9.3147P PS=39.2U PD=41.29U
* device instance $25 r0 *1 0.92,1.005 nmos_5p0
M$25 2 4 1 1 nmos_5p0 L=0.6U W=10.56U AS=2.9832P AD=2.7456P PS=16.4U PD=14.72U
* device instance $33 r0 *1 9.88,1.005 nmos_5p0
M$33 3 2 1 1 nmos_5p0 L=0.6U W=21.12U AS=5.4912P AD=5.7288P PS=29.44U PD=31.12U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_16

* cell gf180mcu_fd_sc_mcu9t5v0__dffq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffq_2 1 5 6 7 14
* net 1 PWELL,VSS,gf180mcu_gnd
* net 5 Q
* net 6 CLK
* net 7 D
* net 14 NWELL,VDD
* device instance $1 r0 *1 14.6,3.78 pmos_5p0
M$1 5 4 14 14 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 4.24,3.41 pmos_5p0
M$3 15 2 14 14 pmos_5p0 L=0.5U W=1U AS=0.9462P AD=0.12P PS=4.91U PD=1.24U
* device instance $4 r0 *1 4.98,3.41 pmos_5p0
M$4 8 7 15 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.31P PS=1.24U PD=1.62U
* device instance $5 r0 *1 6.1,3.41 pmos_5p0
M$5 16 3 8 14 pmos_5p0 L=0.5U W=1U AS=0.31P AD=0.12P PS=1.62U PD=1.24U
* device instance $6 r0 *1 6.84,3.41 pmos_5p0
M$6 14 9 16 14 pmos_5p0 L=0.5U W=1U AS=0.12P AD=0.35P PS=1.24U PD=1.7U
* device instance $7 r0 *1 8.04,3.41 pmos_5p0
M$7 9 8 14 14 pmos_5p0 L=0.5U W=1U AS=0.35P AD=0.46P PS=1.7U PD=1.92U
* device instance $8 r0 *1 9.46,3.41 pmos_5p0
M$8 10 3 9 14 pmos_5p0 L=0.5U W=1U AS=0.46P AD=0.4P PS=1.92U PD=1.8U
* device instance $9 r0 *1 10.76,3.41 pmos_5p0
M$9 17 2 10 14 pmos_5p0 L=0.5U W=1U AS=0.4P AD=0.13P PS=1.8U PD=1.26U
* device instance $10 r0 *1 11.52,3.41 pmos_5p0
M$10 17 4 14 14 pmos_5p0 L=0.5U W=1U AS=0.6017P AD=0.13P PS=2.67U PD=1.26U
* device instance $11 r0 *1 12.86,3.78 pmos_5p0
M$11 4 10 14 14 pmos_5p0 L=0.5U W=1.83U AS=0.6017P AD=0.8052P PS=2.67U PD=4.54U
* device instance $12 r0 *1 0.87,3.555 pmos_5p0
M$12 14 6 3 14 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.4278P PS=3.64U PD=2U
* device instance $13 r0 *1 1.99,3.555 pmos_5p0
M$13 2 3 14 14 pmos_5p0 L=0.5U W=1.38U AS=0.4278P AD=0.6072P PS=2U PD=3.64U
* device instance $14 r0 *1 14.65,1.005 nmos_5p0
M$14 5 4 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.924P PS=5.36U PD=5.36U
* device instance $16 r0 *1 0.92,1.125 nmos_5p0
M$16 1 6 3 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.125 nmos_5p0
M$17 2 3 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 4.09,1.365 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.6463P AD=0.0696P PS=4U PD=0.82U
* device instance $19 r0 *1 4.93,1.365 nmos_5p0
M$19 8 7 11 1 nmos_5p0 L=0.6U W=0.58U AS=0.0696P AD=0.1508P PS=0.82U PD=1.1U
* device instance $20 r0 *1 6.05,1.365 nmos_5p0
M$20 12 2 8 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $21 r0 *1 6.89,1.365 nmos_5p0
M$21 12 9 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.0696P PS=2.425U PD=0.82U
* device instance $22 r0 *1 8.39,1.37 nmos_5p0
M$22 9 8 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.40405P AD=0.1508P PS=2.425U PD=1.1U
* device instance $23 r0 *1 9.51,1.37 nmos_5p0
M$23 10 2 9 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.1508P PS=1.1U PD=1.1U
* device instance $24 r0 *1 10.63,1.37 nmos_5p0
M$24 13 3 10 1 nmos_5p0 L=0.6U W=0.58U AS=0.1508P AD=0.0696P PS=1.1U PD=0.82U
* device instance $25 r0 *1 11.47,1.37 nmos_5p0
M$25 13 4 1 1 nmos_5p0 L=0.6U W=0.58U AS=0.3774P AD=0.0696P PS=2.06U PD=0.82U
* device instance $26 r0 *1 12.81,1 nmos_5p0
M$26 4 10 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3774P AD=0.5808P PS=2.06U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffq_2

* cell gf180mcu_fd_sc_mcu9t5v0__buf_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_4 1 2 3 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 5 Z
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.1346P PS=6.99U PD=4.9U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 5 4 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.2692P AD=2.5071P PS=9.8U PD=11.89U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 4 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.3728P AD=1.6104P PS=7.36U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_4

* cell gf180mcu_fd_sc_mcu9t5v0__buf_12
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__buf_12 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=10.98U AS=3.6417P AD=3.4038P PS=16.79U PD=14.7U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 4 3 5 5 pmos_5p0 L=0.5U W=21.96U AS=6.8076P AD=7.0455P PS=29.4U PD=31.49U
* device instance $19 r0 *1 0.97,1.005 nmos_5p0
M$19 3 2 1 1 nmos_5p0 L=0.6U W=7.92U AS=2.2968P AD=2.0592P PS=12.72U PD=11.04U
* device instance $25 r0 *1 7.69,1.005 nmos_5p0
M$25 4 3 1 1 nmos_5p0 L=0.6U W=15.84U AS=4.1184P AD=4.356P PS=22.08U PD=23.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__buf_12

* cell gf180mcu_fd_sc_mcu9t5v0__inv_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__inv_20 1 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 I
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 2 3 4 4 pmos_5p0 L=0.5U W=36.6U AS=11.5839P AD=11.5839P PS=51.09U PD=51.09U
* device instance $21 r0 *1 0.92,1.005 nmos_5p0
M$21 2 3 1 1 nmos_5p0 L=0.6U W=26.4U AS=7.1016P AD=7.1016P PS=38.48U PD=38.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__inv_20

* cell gf180mcu_fd_sc_mcu9t5v0__clkbuf_20
* pin PWELL,VSS,gf180mcu_gnd
* pin I
* pin Z
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkbuf_20 1 2 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 I
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 5 5 pmos_5p0 L=0.5U W=18.3U AS=5.9109P AD=5.8377P PS=26.59U PD=24.68U
* device instance $11 r0 *1 12.25,3.78 pmos_5p0
M$11 4 3 5 5 pmos_5p0 L=0.5U W=36.6U AS=11.5107P AD=11.5839P PS=49.18U PD=51.09U
* device instance $31 r0 *1 0.92,1.3 nmos_5p0
M$31 3 2 1 1 nmos_5p0 L=0.6U W=7.3U AS=2.1091P AD=1.898P PS=13.84U PD=12.5U
* device instance $41 r0 *1 12.3,1.265 nmos_5p0
M$41 4 3 1 1 nmos_5p0 L=0.6U W=16U AS=4.2215P AD=4.304P PS=26.58U PD=27.56U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkbuf_20

* cell gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
* pin PWELL,VSS,gf180mcu_gnd
* pin RN
* pin Q
* pin CLK
* pin D
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__dffrnq_2 1 2 11 15 16 17
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 RN
* net 11 Q
* net 15 CLK
* net 16 D
* net 17 NWELL,VDD
* device instance $1 r0 *1 17.05,3.78 pmos_5p0
M$1 11 3 17 17 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $3 r0 *1 9.67,3.64 pmos_5p0
M$3 8 6 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $4 r0 *1 10.69,3.64 pmos_5p0
M$4 9 4 8 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $5 r0 *1 11.71,3.64 pmos_5p0
M$5 10 7 9 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $6 r0 *1 12.73,3.64 pmos_5p0
M$6 10 3 17 17 pmos_5p0 L=0.5U W=1U AS=0.5471P AD=0.26P PS=2.57U PD=1.52U
* device instance $7 r0 *1 13.97,3.78 pmos_5p0
M$7 3 2 17 17 pmos_5p0 L=0.5U W=1.83U AS=0.5471P AD=0.4758P PS=2.57U PD=2.35U
* device instance $8 r0 *1 14.99,3.78 pmos_5p0
M$8 17 9 3 17 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 3.85,3.465 pmos_5p0
M$9 5 16 17 17 pmos_5p0 L=0.5U W=1U AS=0.44P AD=0.26P PS=2.88U PD=1.52U
* device instance $10 r0 *1 4.87,3.465 pmos_5p0
M$10 6 7 5 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $11 r0 *1 5.89,3.465 pmos_5p0
M$11 18 4 6 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $12 r0 *1 6.91,3.465 pmos_5p0
M$12 17 8 18 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.26P PS=1.52U PD=1.52U
* device instance $13 r0 *1 7.93,3.465 pmos_5p0
M$13 18 2 17 17 pmos_5p0 L=0.5U W=1U AS=0.26P AD=0.44P PS=1.52U PD=2.88U
* device instance $14 r0 *1 0.97,3.555 pmos_5p0
M$14 17 15 4 17 pmos_5p0 L=0.5U W=1.38U AS=0.6072P AD=0.3588P PS=3.64U PD=1.9U
* device instance $15 r0 *1 1.99,3.555 pmos_5p0
M$15 7 4 17 17 pmos_5p0 L=0.5U W=1.38U AS=0.3588P AD=0.6072P PS=1.9U PD=3.64U
* device instance $16 r0 *1 0.92,1.245 nmos_5p0
M$16 1 15 4 1 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $17 r0 *1 2.04,1.245 nmos_5p0
M$17 7 4 1 1 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3476P PS=1.31U PD=2.46U
* device instance $18 r0 *1 17,1.04 nmos_5p0
M$18 11 3 1 1 nmos_5p0 L=0.6U W=2.5U AS=0.875P AD=0.875P PS=5.15U PD=5.15U
* device instance $20 r0 *1 3.88,1.195 nmos_5p0
M$20 5 16 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.308P AD=0.182P PS=2.28U PD=1.22U
* device instance $21 r0 *1 5,1.195 nmos_5p0
M$21 6 4 5 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $22 r0 *1 6.12,1.195 nmos_5p0
M$22 13 7 6 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.084P PS=1.22U PD=0.94U
* device instance $23 r0 *1 6.96,1.195 nmos_5p0
M$23 12 8 13 1 nmos_5p0 L=0.6U W=0.7U AS=0.084P AD=0.147P PS=0.94U PD=1.12U
* device instance $24 r0 *1 7.98,1.195 nmos_5p0
M$24 1 2 12 1 nmos_5p0 L=0.6U W=0.7U AS=0.147P AD=0.259P PS=1.12U PD=1.44U
* device instance $25 r0 *1 9.32,1.195 nmos_5p0
M$25 8 6 1 1 nmos_5p0 L=0.6U W=0.7U AS=0.259P AD=0.1855P PS=1.44U PD=1.23U
* device instance $26 r0 *1 10.45,1.195 nmos_5p0
M$26 9 7 8 1 nmos_5p0 L=0.6U W=0.7U AS=0.1855P AD=0.182P PS=1.23U PD=1.22U
* device instance $27 r0 *1 11.57,1.195 nmos_5p0
M$27 10 4 9 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $28 r0 *1 12.69,1.195 nmos_5p0
M$28 1 3 10 1 nmos_5p0 L=0.6U W=0.7U AS=0.182P AD=0.182P PS=1.22U PD=1.22U
* device instance $29 r0 *1 13.81,1.195 nmos_5p0
M$29 1 2 14 1 nmos_5p0 L=0.6U W=0.7U AS=0.341P AD=0.182P PS=1.88U PD=1.22U
* device instance $30 r0 *1 15.11,0.955 nmos_5p0
M$30 3 9 14 1 nmos_5p0 L=0.6U W=1.18U AS=0.341P AD=0.5192P PS=1.88U PD=3.24U
.ENDS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi222_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin C2
* pin B2
* pin B1
* pin A2
* pin C1
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi222_2 1 2 3 4 5 6 13 14 15
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 C2
* net 4 B2
* net 5 B1
* net 6 A2
* net 13 C1
* net 14 A1
* net 15 NWELL,VDD
* device instance $1 r0 *1 0.905,3.78 pmos_5p0
M$1 16 13 15 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.281P PS=6.89U PD=6.89U
* device instance $2 r0 *1 1.925,3.78 pmos_5p0
M$2 15 3 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.705,3.78 pmos_5p0
M$5 16 5 17 15 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.965325P PS=6.89U PD=4.715U
* device instance $6 r0 *1 6.725,3.78 pmos_5p0
M$6 17 4 16 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 9.8,3.78 pmos_5p0
M$9 2 14 17 15 pmos_5p0 L=0.5U W=3.66U AS=0.965325P AD=1.281P PS=4.715U PD=6.89U
* device instance $10 r0 *1 10.82,3.78 pmos_5p0
M$10 17 6 2 15 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $13 r0 *1 0.955,1.005 nmos_5p0
M$13 7 13 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $14 r0 *1 1.875,1.005 nmos_5p0
M$14 1 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 2.995,1.005 nmos_5p0
M$15 9 3 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 3.915,1.005 nmos_5p0
M$16 2 13 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.7524P PS=1.64U PD=2.46U
* device instance $17 r0 *1 5.655,1.005 nmos_5p0
M$17 10 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.7524P AD=0.2772P PS=2.46U PD=1.74U
* device instance $18 r0 *1 6.675,1.005 nmos_5p0
M$18 1 4 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $19 r0 *1 7.795,1.005 nmos_5p0
M$19 11 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $20 r0 *1 8.715,1.005 nmos_5p0
M$20 2 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3531P PS=1.64U PD=1.855U
* device instance $21 r0 *1 9.85,1.005 nmos_5p0
M$21 12 14 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3531P AD=0.2112P PS=1.855U PD=1.64U
* device instance $22 r0 *1 10.77,1.005 nmos_5p0
M$22 1 6 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $23 r0 *1 11.89,1.005 nmos_5p0
M$23 8 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $24 r0 *1 12.81,1.005 nmos_5p0
M$24 2 14 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi222_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_4 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=7.32U AS=2.46135P AD=2.31495P PS=11.84U PD=9.85U
* device instance $5 r0 *1 5.505,3.78 pmos_5p0
M$5 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $6 r0 *1 6.785,3.78 pmos_5p0
M$6 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $7 r0 *1 7.805,3.78 pmos_5p0
M$7 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $8 r0 *1 8.545,3.78 pmos_5p0
M$8 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $9 r0 *1 9.565,3.78 pmos_5p0
M$9 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $10 r0 *1 0.975,1.005 nmos_5p0
M$10 3 6 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.6104P AD=1.3728P PS=9.04U PD=7.36U
* device instance $14 r0 *1 5.455,1.005 nmos_5p0
M$14 11 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $15 r0 *1 6.295,1.005 nmos_5p0
M$15 6 5 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $16 r0 *1 7.415,1.005 nmos_5p0
M$16 12 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $17 r0 *1 8.495,1.005 nmos_5p0
M$17 1 7 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $18 r0 *1 9.615,1.005 nmos_5p0
M$18 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A4
* pin NWELL,VDD
* pin A3
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_2 1 2 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A4
* net 4 NWELL,VDD
* net 5 A3
* net 6 A1
* net 7 A2
* device instance $1 r0 *1 0.975,3.78 pmos_5p0
M$1 13 5 8 4 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.045,3.78 pmos_5p0
M$2 4 3 13 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.165,3.78 pmos_5p0
M$3 12 3 4 4 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.465,3.78 pmos_5p0
M$4 11 5 12 4 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.77775P PS=2.63U PD=2.68U
* device instance $5 r0 *1 5.815,3.78 pmos_5p0
M$5 10 7 11 4 pmos_5p0 L=0.5U W=1.83U AS=0.77775P AD=0.52155P PS=2.68U PD=2.4U
* device instance $6 r0 *1 6.885,3.78 pmos_5p0
M$6 2 6 10 4 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $7 r0 *1 8.055,3.78 pmos_5p0
M$7 9 6 2 4 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.4758P PS=2.5U PD=2.35U
* device instance $8 r0 *1 9.075,3.78 pmos_5p0
M$8 8 7 9 4 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $9 r0 *1 4.465,0.695 nmos_5p0
M$9 1 5 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.52165P AD=0.40285P PS=3.565U PD=2.545U
* device instance $11 r0 *1 2.045,0.7 nmos_5p0
M$11 1 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.3432P PS=2.545U PD=2.36U
* device instance $13 r0 *1 5.765,0.7 nmos_5p0
M$13 2 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.40285P AD=0.462P PS=2.545U PD=3.38U
* device instance $14 r0 *1 6.885,0.7 nmos_5p0
M$14 1 6 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=2.36U PD=2.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin C
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_2 1 3 4 5 6 8 9 10
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B2
* net 4 NWELL,VDD
* net 5 B1
* net 6 C
* net 8 A2
* net 9 ZN
* net 10 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 2 6 7 4 pmos_5p0 L=0.5U W=3.66U AS=1.4457P AD=0.983625P PS=7.07U PD=4.735U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.1163P PS=4.7U PD=4.88U
* device instance $3 r0 *1 3.01,3.78 pmos_5p0
M$3 2 5 4 4 pmos_5p0 L=0.5U W=3.66U AS=0.9699P AD=0.9699P PS=4.72U PD=4.72U
* device instance $7 r0 *1 7.325,3.78 pmos_5p0
M$7 9 10 7 4 pmos_5p0 L=0.5U W=3.66U AS=0.983625P AD=1.281P PS=4.735U PD=6.89U
* device instance $8 r0 *1 8.345,3.78 pmos_5p0
M$8 7 8 9 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $11 r0 *1 6.32,0.875 nmos_5p0
M$11 9 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.711P AD=0.709025P PS=3.77U PD=4.36U
* device instance $13 r0 *1 2.22,1.072 nmos_5p0
M$13 14 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1422P PS=1.885U PD=1.425U
* device instance $14 r0 *1 3.06,1.072 nmos_5p0
M$14 9 5 14 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 4.18,1.072 nmos_5p0
M$15 12 5 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 5.02,1.072 nmos_5p0
M$16 1 3 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
* device instance $17 r0 *1 7.635,1.072 nmos_5p0
M$17 13 10 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.361425P AD=0.1422P PS=1.9U
+ PD=1.425U
* device instance $18 r0 *1 8.475,1.072 nmos_5p0
M$18 1 8 13 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $19 r0 *1 9.595,1.072 nmos_5p0
M$19 11 8 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $20 r0 *1 10.435,1.072 nmos_5p0
M$20 9 10 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.5214P PS=1.425U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai31_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai31_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 ZN
* net 5 A2
* net 6 A1
* net 7 A3
* device instance $1 r0 *1 0.92,3.872 pmos_5p0
M$1 4 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.93765P PS=6.72U PD=4.43U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 11 5 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 4 6 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 10 6 4 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 9 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 7 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $11 r0 *1 3.16,1.005 nmos_5p0
M$11 4 7 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2342P PS=3.68U PD=5.83U
* device instance $12 r0 *1 4.28,1.005 nmos_5p0
M$12 8 5 4 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 4 6 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai31_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai32_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A1
* pin A3
* pin B2
* pin ZN
* pin B1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai32_2 1 2 3 4 5 7 8 9
* net 1 NWELL,VDD
* net 2 PWELL,VSS,gf180mcu_gnd
* net 3 A2
* net 4 A1
* net 5 A3
* net 7 B2
* net 8 ZN
* net 9 B1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 15 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 14 3 15 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 13 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $5 r0 *1 5.35,3.78 pmos_5p0
M$5 11 3 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 5 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.6588P PS=2.45U PD=2.55U
* device instance $7 r0 *1 7.69,3.78 pmos_5p0
M$7 12 7 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 9 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.88,3.78 pmos_5p0
M$9 10 9 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 10.95,3.78 pmos_5p0
M$10 1 7 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 5 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $12 r0 *1 2.04,1.005 nmos_5p0
M$12 6 3 2 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 3.16,1.005 nmos_5p0
M$13 2 4 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.64,1.005 nmos_5p0
M$17 8 7 6 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=1.2408P PS=3.68U PD=5.84U
* device instance $18 r0 *1 8.76,1.005 nmos_5p0
M$18 6 9 8 2 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai32_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A3
* pin A4
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor4_4 1 2 3 4 5 6 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 1.285,3.78 pmos_5p0
M$1 9 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.355,3.78 pmos_5p0
M$2 8 5 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.475,3.78 pmos_5p0
M$3 10 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.775,3.78 pmos_5p0
M$4 7 4 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $5 r0 *1 6.075,3.78 pmos_5p0
M$5 11 4 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.5673P PS=2.63U PD=2.45U
* device instance $6 r0 *1 7.195,3.78 pmos_5p0
M$6 8 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 8.315,3.78 pmos_5p0
M$7 14 5 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $8 r0 *1 9.615,3.78 pmos_5p0
M$8 13 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $9 r0 *1 10.915,3.78 pmos_5p0
M$9 12 3 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $10 r0 *1 12.215,3.78 pmos_5p0
M$10 2 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $11 r0 *1 13.515,3.78 pmos_5p0
M$11 15 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $12 r0 *1 14.815,3.78 pmos_5p0
M$12 7 3 15 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $13 r0 *1 16.115,3.78 pmos_5p0
M$13 16 3 7 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $14 r0 *1 17.415,3.78 pmos_5p0
M$14 2 6 16 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.732P PS=2.63U PD=2.63U
* device instance $15 r0 *1 18.715,3.78 pmos_5p0
M$15 17 6 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.732P AD=0.68625P PS=2.63U PD=2.58U
* device instance $16 r0 *1 19.965,3.78 pmos_5p0
M$16 7 3 17 8 pmos_5p0 L=0.5U W=1.83U AS=0.68625P AD=0.8052P PS=2.58U PD=4.54U
* device instance $17 r0 *1 4.775,0.695 nmos_5p0
M$17 1 4 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.98415P AD=0.8057P PS=6.295U PD=5.09U
* device instance $19 r0 *1 12.215,0.695 nmos_5p0
M$19 1 6 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.925P PS=5.46U PD=5.46U
* device instance $20 r0 *1 14.815,0.695 nmos_5p0
M$20 1 3 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.925P AD=0.98415P PS=5.46U PD=6.295U
* device instance $24 r0 *1 2.355,0.7 nmos_5p0
M$24 1 5 2 1 nmos_5p0 L=0.6U W=2.64U AS=0.8057P AD=0.6864P PS=5.09U PD=4.72U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor4_4

* cell gf180mcu_fd_sc_mcu9t5v0__aoi22_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B2
* pin NWELL,VDD
* pin B1
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi22_2 1 2 3 4 5 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 B2
* net 3 NWELL,VDD
* net 4 B1
* net 5 ZN
* net 7 A2
* net 8 A1
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 3 2 6 3 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=0.9516P PS=6.89U PD=4.7U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 6 4 3 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 4.95,3.78 pmos_5p0
M$5 5 7 6 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.281P PS=4.7U PD=6.89U
* device instance $6 r0 *1 5.97,3.78 pmos_5p0
M$6 6 8 5 3 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 12 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $10 r0 *1 1.84,1.005 nmos_5p0
M$10 5 4 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3663P PS=1.64U PD=1.875U
* device instance $11 r0 *1 2.995,1.005 nmos_5p0
M$11 11 4 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3663P AD=0.1881P PS=1.875U PD=1.605U
* device instance $12 r0 *1 3.88,1.005 nmos_5p0
M$12 1 2 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.1881P AD=0.3432P PS=1.605U PD=1.84U
* device instance $13 r0 *1 5,1.005 nmos_5p0
M$13 10 7 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $14 r0 *1 5.92,1.005 nmos_5p0
M$14 5 8 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $15 r0 *1 7.04,1.005 nmos_5p0
M$15 9 8 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 7.96,1.005 nmos_5p0
M$16 1 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi22_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_2
* pin A2
* pin A1
* pin B
* pin ZN
* pin C
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_2 1 2 4 5 6 7 8
* net 1 A2
* net 2 A1
* net 4 B
* net 5 ZN
* net 6 C
* net 7 NWELL,VDD
* net 8 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 5 1 3 7 pmos_5p0 L=0.5U W=3.66U AS=1.281P AD=1.3359P PS=6.89U PD=5.12U
* device instance $2 r0 *1 1.89,3.78 pmos_5p0
M$2 3 2 5 7 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=0.9516P PS=4.7U PD=4.7U
* device instance $5 r0 *1 5.37,3.78 pmos_5p0
M$5 10 4 3 7 pmos_5p0 L=0.5U W=1.83U AS=0.8601P AD=0.2196P PS=2.77U PD=2.07U
* device instance $6 r0 *1 6.11,3.78 pmos_5p0
M$6 7 6 10 7 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.549P PS=2.07U PD=2.43U
* device instance $7 r0 *1 7.21,3.78 pmos_5p0
M$7 9 6 7 7 pmos_5p0 L=0.5U W=1.83U AS=0.549P AD=0.4392P PS=2.43U PD=2.31U
* device instance $8 r0 *1 8.19,3.78 pmos_5p0
M$8 3 4 9 7 pmos_5p0 L=0.5U W=1.83U AS=0.4392P AD=0.8052P PS=2.31U PD=4.54U
* device instance $9 r0 *1 5.02,0.745 nmos_5p0
M$9 5 4 8 8 nmos_5p0 L=0.6U W=1.58U AS=0.5609P AD=0.553P PS=3.195U PD=3.77U
* device instance $10 r0 *1 6.14,0.745 nmos_5p0
M$10 8 6 5 8 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $13 r0 *1 0.92,0.942 nmos_5p0
M$13 12 1 8 8 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.1422P PS=3.25U PD=1.425U
* device instance $14 r0 *1 1.76,0.942 nmos_5p0
M$14 5 2 12 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3081P PS=1.425U PD=1.705U
* device instance $15 r0 *1 2.88,0.942 nmos_5p0
M$15 11 2 5 8 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1422P PS=1.705U PD=1.425U
* device instance $16 r0 *1 3.72,0.942 nmos_5p0
M$16 8 1 11 8 nmos_5p0 L=0.6U W=1.185U AS=0.1422P AD=0.3555P PS=1.425U PD=1.885U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi221_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin B1
* pin A1
* pin B2
* pin C
* pin A2
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi221_4 1 2 3 4 13 14 15 16
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 B1
* net 4 A1
* net 13 B2
* net 14 C
* net 15 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 9.8,3.78 pmos_5p0
M$1 17 14 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.27835P AD=2.20515P PS=11.64U
+ PD=9.73U
* device instance $5 r0 *1 14.21,3.78 pmos_5p0
M$5 2 4 18 16 pmos_5p0 L=0.5U W=7.32U AS=2.1594P AD=2.2326P PS=9.68U PD=11.59U
* device instance $6 r0 *1 15.23,3.78 pmos_5p0
M$6 18 15 2 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $13 r0 *1 0.92,3.78 pmos_5p0
M$13 17 3 16 16 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.2326P PS=11.59U
+ PD=11.59U
* device instance $14 r0 *1 1.94,3.78 pmos_5p0
M$14 16 13 17 16 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $21 r0 *1 9.6,0.74 nmos_5p0
M$21 1 14 2 1 nmos_5p0 L=0.6U W=3.16U AS=1.04675P AD=0.9717P PS=6.005U PD=5.815U
* device instance $25 r0 *1 0.92,0.937 nmos_5p0
M$25 5 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.5214P AD=0.219225P PS=3.25U PD=1.555U
* device instance $26 r0 *1 1.89,0.937 nmos_5p0
M$26 1 13 5 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.01,0.937 nmos_5p0
M$27 7 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 3.93,0.937 nmos_5p0
M$28 2 3 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.05,0.937 nmos_5p0
M$29 9 3 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 5.97,0.937 nmos_5p0
M$30 1 13 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.09,0.937 nmos_5p0
M$31 8 13 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.24885P PS=1.705U
+ PD=1.605U
* device instance $32 r0 *1 8.11,0.937 nmos_5p0
M$32 2 3 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.24885P AD=0.43055P PS=1.605U
+ PD=2.075U
* device instance $33 r0 *1 14.26,0.937 nmos_5p0
M$33 12 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3555P AD=0.1896P PS=1.885U PD=1.505U
* device instance $34 r0 *1 15.18,0.937 nmos_5p0
M$34 1 15 12 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $35 r0 *1 16.3,0.937 nmos_5p0
M$35 11 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U
+ PD=1.505U
* device instance $36 r0 *1 17.22,0.937 nmos_5p0
M$36 2 4 11 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $37 r0 *1 18.34,0.937 nmos_5p0
M$37 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $38 r0 *1 19.26,0.937 nmos_5p0
M$38 1 15 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U
+ PD=1.705U
* device instance $39 r0 *1 20.38,0.937 nmos_5p0
M$39 6 15 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $40 r0 *1 21.3,0.937 nmos_5p0
M$40 2 4 6 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.5214P PS=1.505U PD=3.25U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi221_4

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin ZN
* pin A1
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 ZN
* net 4 A1
* net 5 A2
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 7 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.5673P PS=4.54U PD=2.45U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $3 r0 *1 3.11,3.78 pmos_5p0
M$3 6 4 3 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.61305P PS=2.4U PD=2.5U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.8052P PS=2.5U PD=4.54U
* device instance $5 r0 *1 0.92,1.04 nmos_5p0
M$5 3 5 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.644P PS=4.16U PD=4.16U
* device instance $6 r0 *1 2.04,1.04 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.84U AS=0.4784P AD=0.4784P PS=2.88U PD=2.88U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_4
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_4 1 3 4 5 6 7 8
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 Z
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 4 8 8 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 5 11 8 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 6 10 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 7 9 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 12 7 2 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 13 6 12 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 14 5 13 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 8 4 14 8 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.77775P PS=2.45U PD=2.68U
* device instance $9 r0 *1 10.11,3.78 pmos_5p0
M$9 3 2 8 8 pmos_5p0 L=0.5U W=7.32U AS=2.38815P AD=2.4156P PS=9.93U PD=11.79U
* device instance $13 r0 *1 0.92,0.74 nmos_5p0
M$13 2 4 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.553P AD=0.5879P PS=3.77U PD=3.33U
* device instance $14 r0 *1 2.04,0.74 nmos_5p0
M$14 1 5 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $15 r0 *1 3.16,0.74 nmos_5p0
M$15 2 6 1 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $16 r0 *1 4.28,0.74 nmos_5p0
M$16 1 7 2 1 nmos_5p0 L=0.6U W=1.58U AS=0.4108P AD=0.4108P PS=2.62U PD=2.62U
* device instance $21 r0 *1 10.06,1.005 nmos_5p0
M$21 3 2 1 1 nmos_5p0 L=0.6U W=5.28U AS=1.4121P AD=1.6104P PS=7.54U PD=9.04U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai211_2
* pin NWELL,VDD
* pin A2
* pin ZN
* pin A1
* pin B
* pin C
* pin PWELL,VSS,gf180mcu_gnd
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai211_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 A2
* net 3 ZN
* net 4 A1
* net 5 B
* net 6 C
* net 7 PWELL,VSS,gf180mcu_gnd
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 10 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 3 4 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 3 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $5 r0 *1 5.43,3.965 pmos_5p0
M$5 3 5 1 1 pmos_5p0 L=0.5U W=2.92U AS=0.9646P AD=1.022P PS=4.51U PD=5.78U
* device instance $6 r0 *1 6.45,3.965 pmos_5p0
M$6 1 6 3 1 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 7 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7062P PS=5.36U PD=3.71U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 7 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.43,1.005 nmos_5p0
M$13 11 5 8 7 nmos_5p0 L=0.6U W=1.32U AS=0.363P AD=0.2442P PS=1.87U PD=1.69U
* device instance $14 r0 *1 6.4,1.005 nmos_5p0
M$14 7 6 11 7 nmos_5p0 L=0.6U W=1.32U AS=0.2442P AD=0.3432P PS=1.69U PD=1.84U
* device instance $15 r0 *1 7.52,1.005 nmos_5p0
M$15 12 6 7 7 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $16 r0 *1 8.44,1.005 nmos_5p0
M$16 8 5 12 7 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai211_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi211_4
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A2
* pin A1
* pin B
* pin C
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi211_4 1 2 3 4 5 6 12
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A2
* net 4 A1
* net 5 B
* net 6 C
* net 12 NWELL,VDD
* device instance $1 r0 *1 1.54,3.78 pmos_5p0
M$1 2 3 11 12 pmos_5p0 L=0.5U W=7.32U AS=2.2326P AD=2.1411P PS=11.59U PD=9.66U
* device instance $2 r0 *1 2.56,3.78 pmos_5p0
M$2 11 4 2 12 pmos_5p0 L=0.5U W=7.32U AS=1.9032P AD=1.9032P PS=9.4U PD=9.4U
* device instance $9 r0 *1 9.96,3.78 pmos_5p0
M$9 13 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.5673P PS=2.61U PD=2.45U
* device instance $10 r0 *1 11.08,3.78 pmos_5p0
M$10 12 6 13 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $11 r0 *1 12.62,3.78 pmos_5p0
M$11 14 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $12 r0 *1 13.74,3.78 pmos_5p0
M$12 11 5 14 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $13 r0 *1 15.28,3.78 pmos_5p0
M$13 16 5 11 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $14 r0 *1 16.4,3.78 pmos_5p0
M$14 12 6 16 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.9516P PS=2.45U PD=2.87U
* device instance $15 r0 *1 17.94,3.78 pmos_5p0
M$15 15 6 12 12 pmos_5p0 L=0.5U W=1.83U AS=0.9516P AD=0.5673P PS=2.87U PD=2.45U
* device instance $16 r0 *1 19.06,3.78 pmos_5p0
M$16 11 5 15 12 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $17 r0 *1 9.96,1.08 nmos_5p0
M$17 2 5 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.33065P AD=0.9638P PS=6.745U PD=6.39U
* device instance $18 r0 *1 11.08,1.08 nmos_5p0
M$18 2 6 1 1 nmos_5p0 L=0.6U W=3.16U AS=1.5056P AD=0.8216P PS=7.04U PD=5.24U
* device instance $25 r0 *1 1.54,0.937 nmos_5p0
M$25 7 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.74655P AD=0.219225P PS=3.63U
+ PD=1.555U
* device instance $26 r0 *1 2.51,0.937 nmos_5p0
M$26 2 4 7 1 nmos_5p0 L=0.6U W=1.185U AS=0.219225P AD=0.3081P PS=1.555U
+ PD=1.705U
* device instance $27 r0 *1 3.63,0.937 nmos_5p0
M$27 9 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $28 r0 *1 4.55,0.937 nmos_5p0
M$28 1 3 9 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $29 r0 *1 5.67,0.937 nmos_5p0
M$29 8 3 1 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $30 r0 *1 6.59,0.937 nmos_5p0
M$30 2 4 8 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.3081P PS=1.505U PD=1.705U
* device instance $31 r0 *1 7.71,0.937 nmos_5p0
M$31 10 4 2 1 nmos_5p0 L=0.6U W=1.185U AS=0.3081P AD=0.1896P PS=1.705U PD=1.505U
* device instance $32 r0 *1 8.63,0.937 nmos_5p0
M$32 1 3 10 1 nmos_5p0 L=0.6U W=1.185U AS=0.1896P AD=0.37245P PS=1.505U
+ PD=1.915U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi211_4

* cell gf180mcu_fd_sc_mcu9t5v0__and4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and4_2 1 2 3 4 5 6 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.925,4.055 pmos_5p0
M$1 7 1 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3328P PS=3.44U PD=1.8U
* device instance $2 r0 *1 1.945,4.055 pmos_5p0
M$2 6 2 7 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $3 r0 *1 2.965,4.055 pmos_5p0
M$3 7 3 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.3328P PS=1.8U PD=1.8U
* device instance $4 r0 *1 3.985,4.055 pmos_5p0
M$4 7 4 6 6 pmos_5p0 L=0.5U W=1.28U AS=0.558P AD=0.3328P PS=2.53U PD=1.8U
* device instance $5 r0 *1 5.185,3.78 pmos_5p0
M$5 8 7 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.0338P AD=1.281P PS=4.88U PD=6.89U
* device instance $7 r0 *1 0.975,1.005 nmos_5p0
M$7 11 1 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $8 r0 *1 1.895,1.005 nmos_5p0
M$8 10 2 11 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $9 r0 *1 2.915,1.005 nmos_5p0
M$9 9 3 10 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.2772P PS=1.74U PD=1.74U
* device instance $10 r0 *1 3.935,1.005 nmos_5p0
M$10 5 4 9 5 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $11 r0 *1 5.055,1.005 nmos_5p0
M$11 8 7 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and4_2

* cell gf180mcu_fd_sc_mcu9t5v0__and3_2
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and3_2 2 3 4 5 6 7
* net 2 A1
* net 3 NWELL,VDD
* net 4 A2
* net 5 A3
* net 6 PWELL,VSS,gf180mcu_gnd
* net 7 Z
* device instance $1 r0 *1 0.925,3.965 pmos_5p0
M$1 3 2 1 3 pmos_5p0 L=0.5U W=1.46U AS=0.6424P AD=0.3796P PS=3.8U PD=1.98U
* device instance $2 r0 *1 1.945,3.965 pmos_5p0
M$2 1 4 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.3796P AD=0.3796P PS=1.98U PD=1.98U
* device instance $3 r0 *1 2.965,3.965 pmos_5p0
M$3 1 5 3 3 pmos_5p0 L=0.5U W=1.46U AS=0.585P AD=0.3796P PS=2.53U PD=1.98U
* device instance $4 r0 *1 4.165,3.78 pmos_5p0
M$4 7 1 3 3 pmos_5p0 L=0.5U W=3.66U AS=1.0608P AD=1.281P PS=4.88U PD=6.89U
* device instance $6 r0 *1 0.975,1.005 nmos_5p0
M$6 9 2 1 6 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $7 r0 *1 1.895,1.005 nmos_5p0
M$7 8 4 9 6 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $8 r0 *1 2.915,1.005 nmos_5p0
M$8 6 5 8 6 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.3432P PS=1.74U PD=1.84U
* device instance $9 r0 *1 4.035,1.005 nmos_5p0
M$9 7 1 6 6 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and3_2

* cell gf180mcu_fd_sc_mcu9t5v0__or3_2
* pin A1
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin A3
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or3_2 2 3 4 5 6 7
* net 2 A1
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 A3
* net 6 NWELL,VDD
* net 7 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 9 2 1 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 8 4 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 5 8 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $4 r0 *1 4.46,3.78 pmos_5p0
M$4 7 1 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $6 r0 *1 0.92,0.87 nmos_5p0
M$6 3 2 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.462P AD=0.273P PS=2.98U PD=1.57U
* device instance $7 r0 *1 2.04,0.87 nmos_5p0
M$7 1 4 3 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.273P PS=1.57U PD=1.57U
* device instance $8 r0 *1 3.16,0.87 nmos_5p0
M$8 3 5 1 3 nmos_5p0 L=0.6U W=1.05U AS=0.273P AD=0.4215P PS=1.57U PD=2.02U
* device instance $9 r0 *1 4.46,1.005 nmos_5p0
M$9 7 1 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.7647P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or3_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai22_2
* pin NWELL,VDD
* pin B2
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai22_2 1 2 3 4 5 6 7
* net 1 NWELL,VDD
* net 2 B2
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 12 2 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.4758P PS=4.54U PD=2.35U
* device instance $2 r0 *1 1.99,3.78 pmos_5p0
M$2 6 4 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $4 r0 *1 4.23,3.78 pmos_5p0
M$4 1 2 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.6588P PS=2.4U PD=2.55U
* device instance $5 r0 *1 5.45,3.78 pmos_5p0
M$5 11 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.52155P PS=2.55U PD=2.4U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 6 7 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 10 7 6 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $8 r0 *1 8.71,3.78 pmos_5p0
M$8 1 5 10 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $9 r0 *1 0.92,1.005 nmos_5p0
M$9 3 2 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 2.04,1.005 nmos_5p0
M$10 8 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $13 r0 *1 5.4,1.005 nmos_5p0
M$13 6 5 8 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $14 r0 *1 6.52,1.005 nmos_5p0
M$14 8 7 6 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai22_2

* cell gf180mcu_fd_sc_mcu9t5v0__or4_2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or4_2 1 3 4 5 6 7 8
* net 1 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS,gf180mcu_gnd
* net 8 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 11 1 2 6 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 10 3 11 6 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 9 4 10 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 6 5 9 6 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.732P PS=2.45U PD=2.63U
* device instance $5 r0 *1 5.58,3.78 pmos_5p0
M$5 8 2 6 6 pmos_5p0 L=0.5U W=3.66U AS=1.25355P AD=1.32675P PS=5.03U PD=6.94U
* device instance $7 r0 *1 0.92,0.74 nmos_5p0
M$7 2 1 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.3476P AD=0.2054P PS=2.46U PD=1.31U
* device instance $8 r0 *1 2.04,0.74 nmos_5p0
M$8 7 3 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $9 r0 *1 3.16,0.74 nmos_5p0
M$9 2 4 7 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.2054P PS=1.31U PD=1.31U
* device instance $10 r0 *1 4.28,0.74 nmos_5p0
M$10 7 5 2 7 nmos_5p0 L=0.6U W=0.79U AS=0.2054P AD=0.3825P PS=1.31U PD=2.02U
* device instance $11 r0 *1 5.58,1.005 nmos_5p0
M$11 8 2 7 7 nmos_5p0 L=0.6U W=2.64U AS=0.7257P AD=0.924P PS=3.86U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or4_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand3_2
* pin PWELL,VSS,gf180mcu_gnd
* pin ZN
* pin A1
* pin NWELL,VDD
* pin A2
* pin A3
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand3_2 1 2 3 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 ZN
* net 3 A1
* net 4 NWELL,VDD
* net 5 A2
* net 6 A3
* device instance $1 r0 *1 0.87,3.85 pmos_5p0
M$1 2 6 4 4 pmos_5p0 L=0.5U W=2.92U AS=1.022P AD=1.022P PS=5.78U PD=5.78U
* device instance $2 r0 *1 1.89,3.85 pmos_5p0
M$2 4 5 2 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $3 r0 *1 2.91,3.85 pmos_5p0
M$3 2 3 4 4 pmos_5p0 L=0.5U W=2.92U AS=0.7592P AD=0.7592P PS=3.96U PD=3.96U
* device instance $7 r0 *1 1.06,1 nmos_5p0
M$7 10 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.1848P PS=3.52U PD=1.6U
* device instance $8 r0 *1 1.94,1 nmos_5p0
M$8 9 5 10 1 nmos_5p0 L=0.6U W=1.32U AS=0.1848P AD=0.2112P PS=1.6U PD=1.64U
* device instance $9 r0 *1 2.86,1 nmos_5p0
M$9 2 3 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $10 r0 *1 3.98,1 nmos_5p0
M$10 8 3 2 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $11 r0 *1 4.9,1 nmos_5p0
M$11 7 5 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.2772P PS=1.64U PD=1.74U
* device instance $12 r0 *1 5.92,1 nmos_5p0
M$12 1 6 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2772P AD=0.5808P PS=1.74U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand3_2

* cell gf180mcu_fd_sc_mcu9t5v0__aoi21_2
* pin PWELL,VSS,gf180mcu_gnd
* pin B
* pin NWELL,VDD
* pin ZN
* pin A2
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__aoi21_2 1 3 4 5 6 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 3 B
* net 4 NWELL,VDD
* net 5 ZN
* net 6 A2
* net 7 A1
* device instance $1 r0 *1 0.935,3.78 pmos_5p0
M$1 4 3 2 4 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.0431P PS=6.99U PD=4.8U
* device instance $3 r0 *1 3.075,3.78 pmos_5p0
M$3 5 6 2 4 pmos_5p0 L=0.5U W=3.66U AS=0.9516P AD=1.3908P PS=4.7U PD=7.01U
* device instance $4 r0 *1 4.215,3.78 pmos_5p0
M$4 2 7 5 4 pmos_5p0 L=0.5U W=3.66U AS=1.0614P AD=0.9516P PS=4.82U PD=4.7U
* device instance $7 r0 *1 0.985,0.805 nmos_5p0
M$7 5 3 1 1 nmos_5p0 L=0.6U W=1.84U AS=0.644P AD=0.6412P PS=4.16U PD=3.46U
* device instance $9 r0 *1 3.405,1.005 nmos_5p0
M$9 9 6 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.402P AD=0.1584P PS=2.02U PD=1.56U
* device instance $10 r0 *1 4.245,1.005 nmos_5p0
M$10 5 7 9 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $11 r0 *1 5.365,1.005 nmos_5p0
M$11 8 7 5 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $12 r0 *1 6.205,1.005 nmos_5p0
M$12 1 6 8 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.5808P PS=1.56U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__aoi21_2

* cell gf180mcu_fd_sc_mcu9t5v0__oai21_2
* pin NWELL,VDD
* pin B
* pin PWELL,VSS,gf180mcu_gnd
* pin A2
* pin ZN
* pin A1
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai21_2 1 2 3 4 5 6
* net 1 NWELL,VDD
* net 2 B
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 A2
* net 5 ZN
* net 6 A1
* device instance $1 r0 *1 0.97,3.872 pmos_5p0
M$1 5 2 1 1 pmos_5p0 L=0.5U W=3.29U AS=1.353P AD=0.8554P PS=6.72U PD=4.33U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 9 4 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.6292P AD=0.52155P PS=2.55U PD=2.4U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 5 6 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 8 6 5 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $6 r0 *1 6.47,3.78 pmos_5p0
M$6 1 4 8 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $7 r0 *1 0.92,1.005 nmos_5p0
M$7 3 2 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $9 r0 *1 3.16,1.005 nmos_5p0
M$9 5 4 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
* device instance $10 r0 *1 4.28,1.005 nmos_5p0
M$10 7 6 5 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai21_2

* cell gf180mcu_fd_sc_mcu9t5v0__nor2_4
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A2
* pin A1
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nor2_4 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A2
* net 4 A1
* net 5 ZN
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 9 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.61305P PS=4.54U PD=2.5U
* device instance $2 r0 *1 2.09,3.78 pmos_5p0
M$2 5 4 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 8 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $4 r0 *1 4.28,3.78 pmos_5p0
M$4 2 3 8 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $5 r0 *1 5.4,3.78 pmos_5p0
M$5 7 3 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $6 r0 *1 6.52,3.78 pmos_5p0
M$6 5 4 7 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $7 r0 *1 7.64,3.78 pmos_5p0
M$7 6 4 5 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.5673P PS=2.45U PD=2.45U
* device instance $8 r0 *1 8.76,3.78 pmos_5p0
M$8 2 3 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.8052P PS=2.45U PD=4.54U
* device instance $9 r0 *1 0.92,1.04 nmos_5p0
M$9 5 3 1 1 nmos_5p0 L=0.6U W=3.68U AS=1.1224P AD=1.1224P PS=7.04U PD=7.04U
* device instance $10 r0 *1 2.04,1.04 nmos_5p0
M$10 1 4 5 1 nmos_5p0 L=0.6U W=3.68U AS=0.9568P AD=0.9568P PS=5.76U PD=5.76U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nor2_4

* cell gf180mcu_fd_sc_mcu9t5v0__oai221_2
* pin NWELL,VDD
* pin PWELL,VSS,gf180mcu_gnd
* pin B1
* pin B2
* pin C
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__oai221_2 1 3 4 5 6 8 9 10
* net 1 NWELL,VDD
* net 3 PWELL,VSS,gf180mcu_gnd
* net 4 B1
* net 5 B2
* net 6 C
* net 8 A1
* net 9 ZN
* net 10 A2
* device instance $1 r0 *1 0.92,3.965 pmos_5p0
M$1 9 6 1 1 pmos_5p0 L=0.5U W=2.92U AS=1.17P AD=1.2274P PS=5.06U PD=6.33U
* device instance $2 r0 *1 2.12,3.78 pmos_5p0
M$2 14 5 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.4758P PS=2.53U PD=2.35U
* device instance $3 r0 *1 3.14,3.78 pmos_5p0
M$3 9 4 14 1 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.61305P PS=2.35U PD=2.5U
* device instance $4 r0 *1 4.31,3.78 pmos_5p0
M$4 13 4 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.61305P AD=0.52155P PS=2.5U PD=2.4U
* device instance $5 r0 *1 5.38,3.78 pmos_5p0
M$5 1 5 13 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.585P PS=2.4U PD=2.53U
* device instance $7 r0 *1 7.78,3.78 pmos_5p0
M$7 12 8 9 1 pmos_5p0 L=0.5U W=1.83U AS=0.585P AD=0.52155P PS=2.53U PD=2.4U
* device instance $8 r0 *1 8.85,3.78 pmos_5p0
M$8 1 10 12 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $9 r0 *1 9.97,3.78 pmos_5p0
M$9 11 10 1 1 pmos_5p0 L=0.5U W=1.83U AS=0.5673P AD=0.52155P PS=2.45U PD=2.4U
* device instance $10 r0 *1 11.04,3.78 pmos_5p0
M$10 9 8 11 1 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.8052P PS=2.4U PD=4.54U
* device instance $11 r0 *1 0.92,1.005 nmos_5p0
M$11 2 6 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.7458P PS=5.36U PD=3.77U
* device instance $12 r0 *1 2.07,1.005 nmos_5p0
M$12 3 5 2 3 nmos_5p0 L=0.6U W=2.64U AS=0.7062P AD=0.6864P PS=3.71U PD=3.68U
* device instance $13 r0 *1 3.19,1.005 nmos_5p0
M$13 2 4 3 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
* device instance $17 r0 *1 7.73,1.005 nmos_5p0
M$17 9 8 7 3 nmos_5p0 L=0.6U W=2.64U AS=0.726P AD=0.924P PS=3.74U PD=5.36U
* device instance $18 r0 *1 8.85,1.005 nmos_5p0
M$18 7 10 9 3 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.6864P PS=3.68U PD=3.68U
.ENDS gf180mcu_fd_sc_mcu9t5v0__oai221_2

* cell gf180mcu_fd_sc_mcu9t5v0__or2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin A1
* pin A2
* pin NWELL,VDD
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__or2_2 1 2 4 5 6
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 A1
* net 4 A2
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.97,3.78 pmos_5p0
M$1 7 2 3 5 pmos_5p0 L=0.5U W=1.83U AS=0.8052P AD=0.52155P PS=4.54U PD=2.4U
* device instance $2 r0 *1 2.04,3.78 pmos_5p0
M$2 5 4 7 5 pmos_5p0 L=0.5U W=1.83U AS=0.52155P AD=0.5673P PS=2.4U PD=2.45U
* device instance $3 r0 *1 3.16,3.78 pmos_5p0
M$3 6 3 5 5 pmos_5p0 L=0.5U W=3.66U AS=1.08885P AD=1.32675P PS=4.85U PD=6.94U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 3 2 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.3432P PS=3.52U PD=1.84U
* device instance $6 r0 *1 2.04,1.005 nmos_5p0
M$6 1 4 3 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3432P PS=1.84U PD=1.84U
* device instance $7 r0 *1 3.16,1.005 nmos_5p0
M$7 6 3 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__or2_2

* cell gf180mcu_fd_sc_mcu9t5v0__and2_2
* pin NWELL,VDD
* pin A1
* pin A2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__and2_2 2 3 4 5 6
* net 2 NWELL,VDD
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* device instance $1 r0 *1 0.885,3.685 pmos_5p0
M$1 1 3 2 2 pmos_5p0 L=0.5U W=1.64U AS=0.7216P AD=0.4264P PS=4.16U PD=2.16U
* device instance $2 r0 *1 1.905,3.685 pmos_5p0
M$2 2 4 1 2 pmos_5p0 L=0.5U W=1.64U AS=0.4264P AD=0.6486P PS=2.16U PD=2.57U
* device instance $3 r0 *1 3.145,3.78 pmos_5p0
M$3 6 1 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.1244P AD=1.281P PS=4.92U PD=6.89U
* device instance $5 r0 *1 0.935,1.005 nmos_5p0
M$5 7 3 1 5 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.855,1.005 nmos_5p0
M$6 5 4 7 5 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.975,1.005 nmos_5p0
M$7 6 1 5 5 nmos_5p0 L=0.6U W=2.64U AS=0.6864P AD=0.924P PS=3.68U PD=5.36U
.ENDS gf180mcu_fd_sc_mcu9t5v0__and2_2

* cell gf180mcu_fd_sc_mcu9t5v0__nand2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin A1
* pin ZN
* pin A2
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__nand2_2 1 2 3 4 5
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 A1
* net 4 ZN
* net 5 A2
* device instance $1 r0 *1 0.87,3.857 pmos_5p0
M$1 4 5 2 2 pmos_5p0 L=0.5U W=3.29U AS=1.1515P AD=1.1515P PS=6.335U PD=6.335U
* device instance $2 r0 *1 1.89,3.857 pmos_5p0
M$2 2 3 4 2 pmos_5p0 L=0.5U W=3.29U AS=0.8554P AD=0.8554P PS=4.33U PD=4.33U
* device instance $5 r0 *1 0.92,1.005 nmos_5p0
M$5 7 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.5808P AD=0.2112P PS=3.52U PD=1.64U
* device instance $6 r0 *1 1.84,1.005 nmos_5p0
M$6 4 3 7 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.3432P PS=1.64U PD=1.84U
* device instance $7 r0 *1 2.96,1.005 nmos_5p0
M$7 6 3 4 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.2112P PS=1.84U PD=1.64U
* device instance $8 r0 *1 3.88,1.005 nmos_5p0
M$8 1 5 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.2112P AD=0.5808P PS=1.64U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__nand2_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux2_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin Z
* pin I1
* pin S
* pin I0
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux2_2 1 2 3 4 5 7
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 Z
* net 4 I1
* net 5 S
* net 7 I0
* device instance $1 r0 *1 0.92,3.78 pmos_5p0
M$1 3 6 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.32675P AD=1.18035P PS=6.94U PD=4.95U
* device instance $3 r0 *1 3.21,3.78 pmos_5p0
M$3 10 4 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.6588P AD=0.7137P PS=2.55U PD=2.61U
* device instance $4 r0 *1 4.49,3.78 pmos_5p0
M$4 6 8 10 2 pmos_5p0 L=0.5U W=1.83U AS=0.7137P AD=0.4758P PS=2.61U PD=2.35U
* device instance $5 r0 *1 5.51,3.78 pmos_5p0
M$5 9 5 6 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.2196P PS=2.35U PD=2.07U
* device instance $6 r0 *1 6.25,3.78 pmos_5p0
M$6 2 7 9 2 pmos_5p0 L=0.5U W=1.83U AS=0.2196P AD=0.4758P PS=2.07U PD=2.35U
* device instance $7 r0 *1 7.27,3.78 pmos_5p0
M$7 8 5 2 2 pmos_5p0 L=0.5U W=1.83U AS=0.4758P AD=0.8052P PS=2.35U PD=4.54U
* device instance $8 r0 *1 0.92,1.005 nmos_5p0
M$8 3 6 1 1 nmos_5p0 L=0.6U W=2.64U AS=0.924P AD=0.6864P PS=5.36U PD=3.68U
* device instance $10 r0 *1 3.16,1.005 nmos_5p0
M$10 12 4 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.1584P PS=1.84U PD=1.56U
* device instance $11 r0 *1 4,1.005 nmos_5p0
M$11 6 5 12 1 nmos_5p0 L=0.6U W=1.32U AS=0.1584P AD=0.3432P PS=1.56U PD=1.84U
* device instance $12 r0 *1 5.12,1.005 nmos_5p0
M$12 11 8 6 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.3168P PS=1.84U PD=1.8U
* device instance $13 r0 *1 6.2,1.005 nmos_5p0
M$13 1 7 11 1 nmos_5p0 L=0.6U W=1.32U AS=0.3168P AD=0.3432P PS=1.8U PD=1.84U
* device instance $14 r0 *1 7.32,1.005 nmos_5p0
M$14 8 5 1 1 nmos_5p0 L=0.6U W=1.32U AS=0.3432P AD=0.5808P PS=1.84U PD=3.52U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux2_2

* cell gf180mcu_fd_sc_mcu9t5v0__mux4_2
* pin PWELL,VSS,gf180mcu_gnd
* pin Z
* pin S1
* pin I0
* pin I2
* pin S0
* pin I3
* pin I1
* pin NWELL,VDD
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__mux4_2 1 6 7 11 12 13 14 16 18
* net 1 PWELL,VSS,gf180mcu_gnd
* net 6 Z
* net 7 S1
* net 11 I0
* net 12 I2
* net 13 S0
* net 14 I3
* net 16 I1
* net 18 NWELL,VDD
* device instance $1 r0 *1 0.97,3.62 pmos_5p0
M$1 3 12 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.6848P AD=0.5504P PS=3.63U PD=2.14U
* device instance $2 r0 *1 2.33,3.62 pmos_5p0
M$2 4 13 3 18 pmos_5p0 L=0.5U W=1.28U AS=0.5504P AD=0.4544P PS=2.14U PD=1.99U
* device instance $3 r0 *1 3.54,3.62 pmos_5p0
M$3 5 17 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.4544P AD=0.4032P PS=1.99U PD=1.91U
* device instance $4 r0 *1 4.67,3.62 pmos_5p0
M$4 18 14 5 18 pmos_5p0 L=0.5U W=1.28U AS=0.4032P AD=0.6432P PS=1.91U PD=2.4U
* device instance $5 r0 *1 6.13,3.62 pmos_5p0
M$5 6 2 18 18 pmos_5p0 L=0.5U W=2.56U AS=0.976P AD=0.896P PS=4.2U PD=5.24U
* device instance $7 r0 *1 9.555,3.62 pmos_5p0
M$7 2 15 4 18 pmos_5p0 L=0.5U W=1.28U AS=0.7616P AD=0.4672P PS=3.75U PD=2.01U
* device instance $8 r0 *1 10.785,3.62 pmos_5p0
M$8 8 7 2 18 pmos_5p0 L=0.5U W=1.28U AS=0.4672P AD=0.5632P PS=2.01U PD=3.44U
* device instance $9 r0 *1 12.605,3.62 pmos_5p0
M$9 18 7 15 18 pmos_5p0 L=0.5U W=1.28U AS=0.5632P AD=0.3712P PS=3.44U PD=1.86U
* device instance $10 r0 *1 13.685,3.62 pmos_5p0
M$10 9 16 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3712P AD=0.3776P PS=1.86U PD=1.87U
* device instance $11 r0 *1 14.775,3.62 pmos_5p0
M$11 8 17 9 18 pmos_5p0 L=0.5U W=1.28U AS=0.3776P AD=0.3328P PS=1.87U PD=1.8U
* device instance $12 r0 *1 15.795,3.62 pmos_5p0
M$12 10 13 8 18 pmos_5p0 L=0.5U W=1.28U AS=0.3328P AD=0.416P PS=1.8U PD=1.93U
* device instance $13 r0 *1 16.945,3.62 pmos_5p0
M$13 18 11 10 18 pmos_5p0 L=0.5U W=1.28U AS=0.416P AD=0.3968P PS=1.93U PD=1.9U
* device instance $14 r0 *1 18.065,3.62 pmos_5p0
M$14 17 13 18 18 pmos_5p0 L=0.5U W=1.28U AS=0.3968P AD=0.5632P PS=1.9U PD=3.44U
* device instance $15 r0 *1 12.515,1.18 nmos_5p0
M$15 1 7 15 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.208P PS=2.48U PD=1.32U
* device instance $16 r0 *1 13.635,1.18 nmos_5p0
M$16 9 16 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $17 r0 *1 14.755,1.18 nmos_5p0
M$17 8 13 9 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $18 r0 *1 15.875,1.18 nmos_5p0
M$18 10 17 8 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $19 r0 *1 16.995,1.18 nmos_5p0
M$19 1 11 10 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $20 r0 *1 18.115,1.18 nmos_5p0
M$20 17 13 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
* device instance $21 r0 *1 0.92,1.18 nmos_5p0
M$21 3 12 1 1 nmos_5p0 L=0.6U W=0.8U AS=0.352P AD=0.48P PS=2.48U PD=2U
* device instance $22 r0 *1 2.72,1.18 nmos_5p0
M$22 4 17 3 1 nmos_5p0 L=0.6U W=0.8U AS=0.48P AD=0.208P PS=2U PD=1.32U
* device instance $23 r0 *1 3.84,1.18 nmos_5p0
M$23 5 13 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $24 r0 *1 4.96,1.18 nmos_5p0
M$24 1 14 5 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.208P PS=1.32U PD=1.32U
* device instance $25 r0 *1 6.08,1.18 nmos_5p0
M$25 6 2 1 1 nmos_5p0 L=0.6U W=1.6U AS=0.416P AD=0.56P PS=2.64U PD=3.8U
* device instance $27 r0 *1 9.555,1.18 nmos_5p0
M$27 2 7 4 1 nmos_5p0 L=0.6U W=0.8U AS=0.544P AD=0.208P PS=2.96U PD=1.32U
* device instance $28 r0 *1 10.675,1.18 nmos_5p0
M$28 8 15 2 1 nmos_5p0 L=0.6U W=0.8U AS=0.208P AD=0.352P PS=1.32U PD=2.48U
.ENDS gf180mcu_fd_sc_mcu9t5v0__mux4_2

* cell gf180mcu_fd_sc_mcu9t5v0__clkinv_2
* pin PWELL,VSS,gf180mcu_gnd
* pin NWELL,VDD
* pin I
* pin ZN
.SUBCKT gf180mcu_fd_sc_mcu9t5v0__clkinv_2 1 2 3 4
* net 1 PWELL,VSS,gf180mcu_gnd
* net 2 NWELL,VDD
* net 3 I
* net 4 ZN
* device instance $1 r0 *1 0.87,3.78 pmos_5p0
M$1 4 3 2 2 pmos_5p0 L=0.5U W=3.66U AS=1.3725P AD=1.3725P PS=6.99U PD=6.99U
* device instance $3 r0 *1 0.92,1.3 nmos_5p0
M$3 4 3 1 1 nmos_5p0 L=0.6U W=1.46U AS=0.511P AD=0.511P PS=3.59U PD=3.59U
.ENDS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
