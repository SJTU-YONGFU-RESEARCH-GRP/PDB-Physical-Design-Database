* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_johnson_updown_counter clk count[0]
+ count[1] count[2] count[3] enable rst_n up_down
X_15_ enable VSS VSS VDD VDD _04_ sky130_fd_sc_hd__clkbuf_2
X_16_ net5 net3 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand2_1
X_17_ net7 net3 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__or2_0
X_18_ net4 _04_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__nor2_1
X_19_ _04_ _05_ _06_ _07_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a31oi_1
X_20_ net4 net6 net3 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__mux2i_1
X_21_ net5 _04_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nor2_1
X_22_ _04_ _08_ _09_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a21oi_1
X_23_ net5 net7 net3 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2i_1
X_24_ net6 _04_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nor2_1
X_25_ _04_ _10_ _11_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a21oi_1
X_26_ net4 net3 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__nand2b_1
X_27_ net3 net6 VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nand2b_1
X_28_ net7 _04_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__nor2_1
X_29_ _04_ _12_ _13_ _14_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a31oi_1
Xcounter_reg\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net4 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net5 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net6 sky130_fd_sc_hd__dfrtp_1
Xcounter_reg\[3\]$_DFFE_PN1P_ clknet_1_1__leaf_clk _03_ net2
+ VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfstp_1
Xhold1 net2 VSS VSS VDD VDD net1 sky130_fd_sc_hd__clkdlybuf4s15_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 net8 VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 up_down VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xoutput3 net4 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput4 net5 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput5 net6 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net8 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_johnson_updown_counter
