* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT configurable_comparator a[0] a[10] a[11] a[12] a[13]
+ a[14] a[15] a[1] a[2] a[3] a[4] a[5] a[6] a[7] a[8] a[9] b[0]
+ b[10] b[11] b[12] b[13] b[14] b[15] b[1] b[2] b[3] b[4] b[5]
+ b[6] b[7] b[8] b[9] op_sel[0] op_sel[1] op_sel[2] result signed_mode
X_086_ net1 _083_ VDD VSS INV_X1
X_087_ net23 _038_ VDD VSS INV_X1
X_088_ net22 _041_ VDD VSS INV_X1
X_089_ net21 _044_ VDD VSS INV_X1
X_090_ net20 _047_ VDD VSS INV_X1
X_091_ net19 _050_ VDD VSS INV_X1
X_092_ net18 _053_ VDD VSS INV_X1
X_093_ net32 _056_ VDD VSS INV_X1
X_094_ net31 _059_ VDD VSS INV_X1
X_095_ net30 _062_ VDD VSS INV_X1
X_096_ net29 _065_ VDD VSS INV_X1
X_097_ net28 _068_ VDD VSS INV_X1
X_098_ net27 _071_ VDD VSS INV_X1
X_099_ net26 _074_ VDD VSS INV_X1
X_100_ net25 _077_ VDD VSS INV_X1
X_101_ net24 _080_ VDD VSS INV_X1
X_102_ net33 _024_ VDD VSS INV_X1
X_103_ _040_ _043_ _046_ _049_ _025_ VDD VSS NAND4_X4
X_104_ _052_ _058_ _055_ _061_ _026_ VDD VSS NAND4_X4
X_105_ _064_ _067_ _070_ _073_ _027_ VDD VSS NAND4_X2
X_106_ _076_ _085_ _082_ _079_ _028_ VDD VSS NAND4_X4
X_107_ _025_ _026_ _027_ _028_ _029_ VDD VSS NOR4_X4
X_108_ _024_ _029_ _030_ VDD VSS XNOR2_X1
X_109_ net35 net34 _030_ _031_ VDD VSS NOR3_X1
X_110_ _031_ net34 net35 _032_ VDD VSS AOI21_X1
X_111_ net33 _029_ _033_ VDD VSS NAND2_X1
X_112_ net34 _033_ _034_ VDD VSS NAND2_X1
X_113_ _025_ _026_ _035_ VDD VSS NOR2_X1
X_114_ _063_ _066_ _064_ _036_ VDD VSS AOI21_X2
X_115_ _069_ _072_ _070_ _037_ VDD VSS AOI21_X2
X_116_ _064_ _067_ _000_ VDD VSS NAND2_X1
X_117_ _036_ _037_ _000_ _001_ VDD VSS OAI21_X1
X_118_ _043_ _046_ _048_ _002_ VDD VSS NAND3_X1
X_119_ _042_ _045_ _043_ _003_ VDD VSS AOI21_X2
X_120_ _002_ _003_ _004_ VDD VSS NAND2_X1
X_121_ _039_ _035_ _001_ _004_ _040_ _005_ VDD VSS AOI221_X2
X_122_ _025_ _006_ VDD VSS INV_X1
X_123_ _051_ _054_ _052_ _007_ VDD VSS AOI21_X1
X_124_ _052_ _055_ _008_ VDD VSS NAND2_X1
X_125_ _057_ _060_ _058_ _009_ VDD VSS AOI21_X1
X_126_ _007_ _008_ _009_ _010_ VDD VSS OAI21_X2
X_127_ _006_ _010_ _011_ VDD VSS NAND2_X1
X_128_ _076_ _079_ _012_ VDD VSS AND2_X1
X_129_ _081_ _013_ VDD VSS INV_X1
X_130_ _082_ _014_ VDD VSS INV_X1
X_131_ _013_ _084_ _014_ _015_ VDD VSS OAI21_X1
X_132_ _075_ _012_ _015_ _078_ _076_ _016_ VDD VSS AOI221_X2
X_133_ _025_ _026_ _027_ _017_ VDD VSS OR3_X1
X_134_ _005_ _011_ _016_ _017_ _018_ VDD VSS OAI211_X2
X_135_ net36 _019_ VDD VSS INV_X1
X_136_ _040_ _019_ _020_ VDD VSS NOR2_X1
X_137_ _018_ _020_ _021_ VDD VSS XNOR2_X2
X_138_ _032_ _034_ _021_ _022_ VDD VSS OAI21_X1
X_139_ _021_ _024_ _029_ _023_ VDD VSS MUX2_X1
X_140_ _022_ _023_ net35 net37 VDD VSS AOI21_X1
X_141_ net7 _038_ _039_ _040_ VDD VSS HA_X1
X_142_ net6 _041_ _042_ _043_ VDD VSS HA_X1
X_143_ net5 _044_ _045_ _046_ VDD VSS HA_X1
X_144_ net4 _047_ _048_ _049_ VDD VSS HA_X1
X_145_ net3 _050_ _051_ _052_ VDD VSS HA_X1
X_146_ net2 _053_ _054_ _055_ VDD VSS HA_X1
X_147_ net16 _056_ _057_ _058_ VDD VSS HA_X1
X_148_ net15 _059_ _060_ _061_ VDD VSS HA_X1
X_149_ net14 _062_ _063_ _064_ VDD VSS HA_X1
X_150_ net13 _065_ _066_ _067_ VDD VSS HA_X1
X_151_ net12 _068_ _069_ _070_ VDD VSS HA_X1
X_152_ net11 _071_ _072_ _073_ VDD VSS HA_X1
X_153_ net10 _074_ _075_ _076_ VDD VSS HA_X1
X_154_ net9 _077_ _078_ _079_ VDD VSS HA_X1
X_155_ net8 _080_ _081_ _082_ VDD VSS HA_X1
X_156_ _083_ net17 _084_ _085_ VDD VSS HA_X1
XPHY_EDGE_ROW_0_Right_0 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Right_1 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Right_2 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Right_3 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Right_4 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Right_5 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Right_6 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Right_7 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Right_8 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Right_9 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Right_10 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Right_11 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Right_12 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Right_13 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Right_14 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Right_15 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Right_16 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Right_17 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Right_18 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Right_19 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Right_20 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Right_21 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Right_22 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Right_23 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Right_24 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Right_25 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Right_26 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Right_27 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Right_28 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Right_29 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Right_30 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Right_31 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Right_32 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Right_33 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Right_34 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Right_35 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Right_36 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Right_37 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Right_38 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Right_39 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Right_40 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Right_41 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Right_42 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Right_43 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Right_44 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Right_45 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Right_46 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Right_47 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Right_48 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Right_49 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Right_50 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Right_51 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Right_52 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Right_53 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Right_54 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Right_55 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Right_56 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Right_57 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Right_58 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Right_59 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Right_60 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Right_61 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Right_62 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Right_63 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Right_64 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Right_65 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Right_66 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Right_67 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Right_68 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Right_69 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Right_70 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Right_71 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Right_72 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Right_73 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Right_74 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Right_75 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Right_76 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Right_77 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Right_78 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Right_79 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Right_80 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Right_81 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Right_82 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Right_83 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Right_84 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Right_85 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Right_86 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Right_87 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Right_88 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Right_89 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Right_90 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Right_91 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Right_92 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Right_93 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Right_94 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Right_95 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Right_96 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Right_97 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Right_98 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Right_99 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Right_100 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Right_101 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Right_102 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Right_103 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Right_104 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Right_105 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Right_106 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_0_Left_107 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_1_Left_108 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_2_Left_109 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_3_Left_110 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_4_Left_111 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_5_Left_112 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_6_Left_113 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_7_Left_114 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_8_Left_115 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_9_Left_116 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_10_Left_117 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_11_Left_118 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_12_Left_119 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_13_Left_120 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_14_Left_121 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_15_Left_122 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_16_Left_123 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_17_Left_124 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_18_Left_125 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_19_Left_126 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_20_Left_127 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_21_Left_128 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_22_Left_129 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_23_Left_130 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_24_Left_131 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_25_Left_132 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_26_Left_133 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_27_Left_134 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_28_Left_135 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_29_Left_136 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_30_Left_137 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_31_Left_138 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_32_Left_139 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_33_Left_140 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_34_Left_141 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_35_Left_142 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_36_Left_143 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_37_Left_144 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_38_Left_145 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_39_Left_146 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_40_Left_147 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_41_Left_148 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_42_Left_149 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_43_Left_150 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_44_Left_151 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_45_Left_152 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_46_Left_153 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_47_Left_154 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_48_Left_155 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_49_Left_156 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_50_Left_157 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_51_Left_158 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_52_Left_159 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_53_Left_160 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_54_Left_161 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_55_Left_162 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_56_Left_163 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_57_Left_164 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_58_Left_165 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_59_Left_166 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_60_Left_167 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_61_Left_168 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_62_Left_169 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_63_Left_170 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_64_Left_171 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_65_Left_172 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_66_Left_173 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_67_Left_174 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_68_Left_175 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_69_Left_176 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_70_Left_177 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_71_Left_178 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_72_Left_179 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_73_Left_180 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_74_Left_181 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_75_Left_182 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_76_Left_183 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_77_Left_184 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_78_Left_185 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_79_Left_186 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_80_Left_187 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_81_Left_188 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_82_Left_189 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_83_Left_190 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_84_Left_191 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_85_Left_192 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_86_Left_193 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_87_Left_194 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_88_Left_195 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_89_Left_196 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_90_Left_197 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_91_Left_198 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_92_Left_199 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_93_Left_200 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_94_Left_201 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_95_Left_202 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_96_Left_203 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_97_Left_204 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_98_Left_205 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_99_Left_206 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_100_Left_207 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_101_Left_208 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_102_Left_209 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_103_Left_210 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_104_Left_211 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_105_Left_212 VDD VSS TAPCELL_X1
XPHY_EDGE_ROW_106_Left_213 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_0_214 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_2_215 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_4_216 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_6_217 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_8_218 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_10_219 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_12_220 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_14_221 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_16_222 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_18_223 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_20_224 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_22_225 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_24_226 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_26_227 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_28_228 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_30_229 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_32_230 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_34_231 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_36_232 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_38_233 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_40_234 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_42_235 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_44_236 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_46_237 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_48_238 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_50_239 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_52_240 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_54_241 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_56_242 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_58_243 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_60_244 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_62_245 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_64_246 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_66_247 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_68_248 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_70_249 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_72_250 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_74_251 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_76_252 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_78_253 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_80_254 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_82_255 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_84_256 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_86_257 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_88_258 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_90_259 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_92_260 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_94_261 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_96_262 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_98_263 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_100_264 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_102_265 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_104_266 VDD VSS TAPCELL_X1
XTAP_TAPCELL_ROW_106_267 VDD VSS TAPCELL_X1
Xinput1 a[0] net1 VDD VSS BUF_X1
Xinput2 a[10] net2 VDD VSS BUF_X1
Xinput3 a[11] net3 VDD VSS BUF_X1
Xinput4 a[12] net4 VDD VSS BUF_X1
Xinput5 a[13] net5 VDD VSS BUF_X1
Xinput6 a[14] net6 VDD VSS BUF_X1
Xinput7 a[15] net7 VDD VSS BUF_X1
Xinput8 a[1] net8 VDD VSS BUF_X1
Xinput9 a[2] net9 VDD VSS BUF_X1
Xinput10 a[3] net10 VDD VSS BUF_X2
Xinput11 a[4] net11 VDD VSS BUF_X1
Xinput12 a[5] net12 VDD VSS BUF_X1
Xinput13 a[6] net13 VDD VSS BUF_X1
Xinput14 a[7] net14 VDD VSS BUF_X1
Xinput15 a[8] net15 VDD VSS BUF_X2
Xinput16 a[9] net16 VDD VSS BUF_X1
Xinput17 b[0] net17 VDD VSS BUF_X1
Xinput18 b[10] net18 VDD VSS BUF_X1
Xinput19 b[11] net19 VDD VSS BUF_X1
Xinput20 b[12] net20 VDD VSS BUF_X1
Xinput21 b[13] net21 VDD VSS BUF_X1
Xinput22 b[14] net22 VDD VSS BUF_X1
Xinput23 b[15] net23 VDD VSS BUF_X1
Xinput24 b[1] net24 VDD VSS BUF_X1
Xinput25 b[2] net25 VDD VSS BUF_X1
Xinput26 b[3] net26 VDD VSS BUF_X1
Xinput27 b[4] net27 VDD VSS BUF_X1
Xinput28 b[5] net28 VDD VSS BUF_X1
Xinput29 b[6] net29 VDD VSS BUF_X1
Xinput30 b[7] net30 VDD VSS BUF_X1
Xinput31 b[8] net31 VDD VSS BUF_X1
Xinput32 b[9] net32 VDD VSS BUF_X1
Xinput33 op_sel[0] net33 VDD VSS BUF_X1
Xinput34 op_sel[1] net34 VDD VSS BUF_X1
Xinput35 op_sel[2] net35 VDD VSS BUF_X1
Xinput36 signed_mode net36 VDD VSS BUF_X1
Xoutput37 net37 result VDD VSS BUF_X1
.ENDS configurable_comparator
