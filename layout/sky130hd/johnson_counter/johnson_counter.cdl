* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT johnson_counter clk count[0] count[1] count[2] count[3]
+ enable load_en load_val[0] load_val[1] load_val[2] load_val[3]
+ rst_n
X_14_ enable VSS VSS VDD VDD _04_ sky130_fd_sc_hd__clkbuf_2
X_15_ net3 net2 VSS VSS VDD VDD _05_ sky130_fd_sc_hd__nand2_1
X_16_ net10 net2 VSS VSS VDD VDD _06_ sky130_fd_sc_hd__or2_0
X_17_ net7 _04_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__nor2_1
X_18_ _04_ _05_ _06_ _07_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a31oi_1
X_19_ net7 net4 net2 VSS VSS VDD VDD _08_ sky130_fd_sc_hd__mux2i_1
X_20_ net8 _04_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__nor2_1
X_21_ _04_ _08_ _09_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a21oi_1
X_22_ net8 net5 net2 VSS VSS VDD VDD _10_ sky130_fd_sc_hd__mux2i_1
X_23_ net9 _04_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__nor2_1
X_24_ _04_ _10_ _11_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a21oi_1
X_25_ net9 net6 net2 VSS VSS VDD VDD _12_ sky130_fd_sc_hd__mux2i_1
X_26_ net10 _04_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__nor2_1
X_27_ _04_ _12_ _13_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a21oi_1
Xcount\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1 VSS
+ VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xcount\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1 VSS
+ VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_1
Xcount\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _02_ net1 VSS
+ VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xcount\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1 VSS
+ VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xhold1 net11 VSS VSS VDD VDD net1 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 load_en VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 load_val[0] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 load_val[1] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 load_val[2] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 load_val[3] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xoutput6 net7 VSS VSS VDD VDD count[0] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net8 VSS VSS VDD VDD count[1] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD count[2] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD count[3] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xhold2 rst_n VSS VSS VDD VDD net11 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS johnson_counter
