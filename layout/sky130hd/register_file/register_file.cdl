* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT register_file clk read_addr1[0] read_addr1[1] read_addr1[2]
+ read_addr1[3] read_addr1[4] read_addr2[0] read_addr2[1] read_addr2[2]
+ read_addr2[3] read_addr2[4] read_data1[0] read_data1[10] read_data1[11]
+ read_data1[12] read_data1[13] read_data1[14] read_data1[15]
+ read_data1[16] read_data1[17] read_data1[18] read_data1[19]
+ read_data1[1] read_data1[20] read_data1[21] read_data1[22]
+ read_data1[23] read_data1[24] read_data1[25] read_data1[26]
+ read_data1[27] read_data1[28] read_data1[29] read_data1[2]
+ read_data1[30] read_data1[31] read_data1[3] read_data1[4]
+ read_data1[5] read_data1[6] read_data1[7] read_data1[8] read_data1[9]
+ read_data2[0] read_data2[10] read_data2[11] read_data2[12]
+ read_data2[13] read_data2[14] read_data2[15] read_data2[16]
+ read_data2[17] read_data2[18] read_data2[19] read_data2[1]
+ read_data2[20] read_data2[21] read_data2[22] read_data2[23]
+ read_data2[24] read_data2[25] read_data2[26] read_data2[27]
+ read_data2[28] read_data2[29] read_data2[2] read_data2[30]
+ read_data2[31] read_data2[3] read_data2[4] read_data2[5] read_data2[6]
+ read_data2[7] read_data2[8] read_data2[9] read_en1 read_en2
+ rst_n write_addr[0] write_addr[1] write_addr[2] write_addr[3]
+ write_addr[4] write_data[0] write_data[10] write_data[11]
+ write_data[12] write_data[13] write_data[14] write_data[15]
+ write_data[16] write_data[17] write_data[18] write_data[19]
+ write_data[1] write_data[20] write_data[21] write_data[22]
+ write_data[23] write_data[24] write_data[25] write_data[26]
+ write_data[27] write_data[28] write_data[29] write_data[2]
+ write_data[30] write_data[31] write_data[3] write_data[4]
+ write_data[5] write_data[6] write_data[7] write_data[8] write_data[9]
+ write_en
X_2566_ _1828_ _1910_ _1911_ _1832_ _1833_ VSS VSS VDD VDD
+ _1912_ sky130_fd_sc_hd__a221oi_2
X_2567_ _1800_ _1909_ _1912_ VSS VSS VDD VDD _1913_ sky130_fd_sc_hd__o21ai_0
X_2568_ registers\[24\]\[15\] registers\[26\]\[15\] registers\[28\]\[15\]
+ registers\[30\]\[15\] _1764_ _1877_ VSS VSS VDD VDD _1914_
+ sky130_fd_sc_hd__mux4_1
X_2569_ registers\[25\]\[15\] registers\[27\]\[15\] registers\[29\]\[15\]
+ registers\[31\]\[15\] _1839_ _1879_ VSS VSS VDD VDD _1915_
+ sky130_fd_sc_hd__mux4_1
X_2570_ _1836_ _1914_ _1915_ _1812_ VSS VSS VDD VDD _1916_
+ sky130_fd_sc_hd__a22oi_2
X_2571_ registers\[8\]\[15\] registers\[9\]\[15\] registers\[10\]\[15\]
+ registers\[11\]\[15\] _1900_ _1901_ VSS VSS VDD VDD _1917_
+ sky130_fd_sc_hd__mux4_1
X_2572_ registers\[12\]\[15\] registers\[13\]\[15\] registers\[14\]\[15\]
+ registers\[15\]\[15\] _1862_ _1816_ VSS VSS VDD VDD _1918_
+ sky130_fd_sc_hd__mux4_1
X_2573_ _1917_ _1918_ _1845_ VSS VSS VDD VDD _1919_ sky130_fd_sc_hd__mux2i_2
X_2574_ registers\[1\]\[15\] registers\[3\]\[15\] registers\[5\]\[15\]
+ registers\[7\]\[15\] _1865_ _1885_ VSS VSS VDD VDD _1920_
+ sky130_fd_sc_hd__mux4_1
X_2575_ registers\[0\]\[15\] registers\[2\]\[15\] registers\[4\]\[15\]
+ registers\[6\]\[15\] _1848_ _1867_ VSS VSS VDD VDD _1921_
+ sky130_fd_sc_hd__mux4_1
X_2576_ _1920_ _1921_ _1750_ VSS VSS VDD VDD _1922_ sky130_fd_sc_hd__mux2i_1
X_2577_ _1792_ VSS VSS VDD VDD _1923_ sky130_fd_sc_hd__buf_8
X_2578_ _1785_ _1919_ _1922_ _1923_ _1798_ VSS VSS VDD VDD
+ _1924_ sky130_fd_sc_hd__a221o_2
X_2579_ _1746_ _1913_ _1916_ _1924_ VSS VSS VDD VDD _0072_
+ sky130_fd_sc_hd__a31oi_1
X_2580_ registers\[17\]\[16\] registers\[19\]\[16\] registers\[21\]\[16\]
+ registers\[23\]\[16\] _1801_ _1871_ VSS VSS VDD VDD _1925_
+ sky130_fd_sc_hd__mux4_1
X_2581_ registers\[18\]\[16\] registers\[22\]\[16\] _1829_
+ VSS VSS VDD VDD _1926_ sky130_fd_sc_hd__mux2i_1
X_2582_ registers\[16\]\[16\] registers\[20\]\[16\] _1776_
+ VSS VSS VDD VDD _1927_ sky130_fd_sc_hd__mux2i_1
X_2583_ _1828_ _1926_ _1927_ _1832_ _1833_ VSS VSS VDD VDD
+ _1928_ sky130_fd_sc_hd__a221oi_1
X_2584_ _1800_ _1925_ _1928_ VSS VSS VDD VDD _1929_ sky130_fd_sc_hd__o21ai_0
X_2585_ registers\[24\]\[16\] registers\[26\]\[16\] registers\[28\]\[16\]
+ registers\[30\]\[16\] _1764_ _1877_ VSS VSS VDD VDD _1930_
+ sky130_fd_sc_hd__mux4_1
X_2586_ registers\[25\]\[16\] registers\[27\]\[16\] registers\[29\]\[16\]
+ registers\[31\]\[16\] _1839_ _1879_ VSS VSS VDD VDD _1931_
+ sky130_fd_sc_hd__mux4_1
X_2587_ _1836_ _1930_ _1931_ _1812_ VSS VSS VDD VDD _1932_
+ sky130_fd_sc_hd__a22oi_2
X_2588_ registers\[0\]\[16\] registers\[1\]\[16\] registers\[2\]\[16\]
+ registers\[3\]\[16\] _1900_ _1901_ VSS VSS VDD VDD _1933_
+ sky130_fd_sc_hd__mux4_1
X_2589_ registers\[4\]\[16\] registers\[5\]\[16\] registers\[6\]\[16\]
+ registers\[7\]\[16\] _1862_ _1816_ VSS VSS VDD VDD _1934_
+ sky130_fd_sc_hd__mux4_1
X_2590_ _1933_ _1934_ _1845_ VSS VSS VDD VDD _1935_ sky130_fd_sc_hd__mux2i_1
X_2591_ registers\[9\]\[16\] registers\[11\]\[16\] registers\[13\]\[16\]
+ registers\[15\]\[16\] _1865_ _1885_ VSS VSS VDD VDD _1936_
+ sky130_fd_sc_hd__mux4_1
X_2592_ registers\[8\]\[16\] registers\[10\]\[16\] registers\[12\]\[16\]
+ registers\[14\]\[16\] _1848_ _1867_ VSS VSS VDD VDD _1937_
+ sky130_fd_sc_hd__mux4_1
X_2593_ _1749_ VSS VSS VDD VDD _1938_ sky130_fd_sc_hd__buf_16
X_2594_ _1936_ _1937_ _1938_ VSS VSS VDD VDD _1939_ sky130_fd_sc_hd__mux2i_4
X_2595_ _1793_ _1935_ _1939_ _1825_ _1798_ VSS VSS VDD VDD
+ _1940_ sky130_fd_sc_hd__a221o_2
X_2596_ _1746_ _1929_ _1932_ _1940_ VSS VSS VDD VDD _0073_
+ sky130_fd_sc_hd__a31oi_1
X_2597_ registers\[17\]\[17\] registers\[19\]\[17\] registers\[21\]\[17\]
+ registers\[23\]\[17\] _1801_ _1871_ VSS VSS VDD VDD _1941_
+ sky130_fd_sc_hd__mux4_1
X_2598_ registers\[18\]\[17\] registers\[22\]\[17\] _1829_
+ VSS VSS VDD VDD _1942_ sky130_fd_sc_hd__mux2i_1
X_2599_ _1819_ VSS VSS VDD VDD _1943_ sky130_fd_sc_hd__buf_6
X_2600_ registers\[16\]\[17\] registers\[20\]\[17\] _1943_
+ VSS VSS VDD VDD _1944_ sky130_fd_sc_hd__mux2i_1
X_2601_ _1828_ _1942_ _1944_ _1832_ _1833_ VSS VSS VDD VDD
+ _1945_ sky130_fd_sc_hd__a221oi_2
X_2602_ _1800_ _1941_ _1945_ VSS VSS VDD VDD _1946_ sky130_fd_sc_hd__o21ai_0
X_2603_ registers\[24\]\[17\] registers\[26\]\[17\] registers\[28\]\[17\]
+ registers\[30\]\[17\] _1764_ _1877_ VSS VSS VDD VDD _1947_
+ sky130_fd_sc_hd__mux4_1
X_2604_ registers\[25\]\[17\] registers\[27\]\[17\] registers\[29\]\[17\]
+ registers\[31\]\[17\] _1839_ _1879_ VSS VSS VDD VDD _1948_
+ sky130_fd_sc_hd__mux4_1
X_2605_ _1836_ _1947_ _1948_ _1812_ VSS VSS VDD VDD _1949_
+ sky130_fd_sc_hd__a22oi_2
X_2606_ registers\[8\]\[17\] registers\[9\]\[17\] registers\[10\]\[17\]
+ registers\[11\]\[17\] _1900_ _1901_ VSS VSS VDD VDD _1950_
+ sky130_fd_sc_hd__mux4_1
X_2607_ registers\[12\]\[17\] registers\[13\]\[17\] registers\[14\]\[17\]
+ registers\[15\]\[17\] _1862_ _1816_ VSS VSS VDD VDD _1951_
+ sky130_fd_sc_hd__mux4_1
X_2608_ _1950_ _1951_ _1845_ VSS VSS VDD VDD _1952_ sky130_fd_sc_hd__mux2i_2
X_2609_ registers\[1\]\[17\] registers\[3\]\[17\] registers\[5\]\[17\]
+ registers\[7\]\[17\] _1865_ _1885_ VSS VSS VDD VDD _1953_
+ sky130_fd_sc_hd__mux4_1
X_2610_ registers\[0\]\[17\] registers\[2\]\[17\] registers\[4\]\[17\]
+ registers\[6\]\[17\] _1848_ _1867_ VSS VSS VDD VDD _1954_
+ sky130_fd_sc_hd__mux4_1
X_2611_ _1953_ _1954_ _1938_ VSS VSS VDD VDD _1955_ sky130_fd_sc_hd__mux2i_1
X_2612_ _1785_ _1952_ _1955_ _1923_ _1798_ VSS VSS VDD VDD
+ _1956_ sky130_fd_sc_hd__a221o_2
X_2613_ _1746_ _1946_ _1949_ _1956_ VSS VSS VDD VDD _0074_
+ sky130_fd_sc_hd__a31oi_2
X_2614_ registers\[17\]\[18\] registers\[19\]\[18\] registers\[21\]\[18\]
+ registers\[23\]\[18\] _1801_ _1871_ VSS VSS VDD VDD _1957_
+ sky130_fd_sc_hd__mux4_1
X_2615_ registers\[18\]\[18\] registers\[22\]\[18\] _1829_
+ VSS VSS VDD VDD _1958_ sky130_fd_sc_hd__mux2i_1
X_2616_ registers\[16\]\[18\] registers\[20\]\[18\] _1943_
+ VSS VSS VDD VDD _1959_ sky130_fd_sc_hd__mux2i_1
X_2617_ _1828_ _1958_ _1959_ _1832_ _1833_ VSS VSS VDD VDD
+ _1960_ sky130_fd_sc_hd__a221oi_1
X_2618_ _1800_ _1957_ _1960_ VSS VSS VDD VDD _1961_ sky130_fd_sc_hd__o21ai_0
X_2619_ _1753_ VSS VSS VDD VDD _1962_ sky130_fd_sc_hd__buf_8
X_2620_ registers\[24\]\[18\] registers\[26\]\[18\] registers\[28\]\[18\]
+ registers\[30\]\[18\] _1962_ _1877_ VSS VSS VDD VDD _1963_
+ sky130_fd_sc_hd__mux4_1
X_2621_ registers\[25\]\[18\] registers\[27\]\[18\] registers\[29\]\[18\]
+ registers\[31\]\[18\] _1839_ _1879_ VSS VSS VDD VDD _1964_
+ sky130_fd_sc_hd__mux4_1
X_2622_ _1836_ _1963_ _1964_ _1812_ VSS VSS VDD VDD _1965_
+ sky130_fd_sc_hd__a22oi_4
X_2623_ registers\[0\]\[18\] registers\[1\]\[18\] registers\[2\]\[18\]
+ registers\[3\]\[18\] _1900_ _1901_ VSS VSS VDD VDD _1966_
+ sky130_fd_sc_hd__mux4_1
X_2624_ registers\[4\]\[18\] registers\[5\]\[18\] registers\[6\]\[18\]
+ registers\[7\]\[18\] _1862_ _1816_ VSS VSS VDD VDD _1967_
+ sky130_fd_sc_hd__mux4_1
X_2625_ _1966_ _1967_ _1845_ VSS VSS VDD VDD _1968_ sky130_fd_sc_hd__mux2i_1
X_2626_ registers\[9\]\[18\] registers\[11\]\[18\] registers\[13\]\[18\]
+ registers\[15\]\[18\] _1865_ _1885_ VSS VSS VDD VDD _1969_
+ sky130_fd_sc_hd__mux4_1
X_2627_ registers\[8\]\[18\] registers\[10\]\[18\] registers\[12\]\[18\]
+ registers\[14\]\[18\] _1848_ _1867_ VSS VSS VDD VDD _1970_
+ sky130_fd_sc_hd__mux4_1
X_2628_ _1969_ _1970_ _1938_ VSS VSS VDD VDD _1971_ sky130_fd_sc_hd__mux2i_4
X_2629_ _1793_ _1968_ _1971_ _1825_ _1798_ VSS VSS VDD VDD
+ _1972_ sky130_fd_sc_hd__a221o_1
X_2630_ _1746_ _1961_ _1965_ _1972_ VSS VSS VDD VDD _0075_
+ sky130_fd_sc_hd__a31oi_1
X_2631_ _1745_ VSS VSS VDD VDD _1973_ sky130_fd_sc_hd__buf_8
X_2632_ registers\[25\]\[19\] registers\[27\]\[19\] registers\[29\]\[19\]
+ registers\[31\]\[19\] _1754_ _1757_ VSS VSS VDD VDD _1974_
+ sky130_fd_sc_hd__mux4_1
X_2633_ registers\[24\]\[19\] registers\[28\]\[19\] _1840_
+ VSS VSS VDD VDD _1975_ sky130_fd_sc_hd__mux2i_1
X_2634_ _1766_ _1975_ VSS VSS VDD VDD _1976_ sky130_fd_sc_hd__nand2_1
X_2635_ registers\[26\]\[19\] registers\[30\]\[19\] _1760_
+ VSS VSS VDD VDD _1977_ sky130_fd_sc_hd__mux2i_1
X_2636_ _1770_ _1977_ VSS VSS VDD VDD _1978_ sky130_fd_sc_hd__nand2_1
X_2637_ _1751_ _1974_ _1976_ _1978_ _1773_ VSS VSS VDD VDD
+ _1979_ sky130_fd_sc_hd__o2111ai_4
X_2638_ registers\[16\]\[19\] registers\[18\]\[19\] registers\[20\]\[19\]
+ registers\[22\]\[19\] _1962_ _1877_ VSS VSS VDD VDD _1980_
+ sky130_fd_sc_hd__mux4_1
X_2639_ registers\[17\]\[19\] registers\[19\]\[19\] registers\[21\]\[19\]
+ registers\[23\]\[19\] _1839_ _1879_ VSS VSS VDD VDD _1981_
+ sky130_fd_sc_hd__mux4_1
X_2640_ _1778_ _1980_ _1981_ _1779_ VSS VSS VDD VDD _1982_
+ sky130_fd_sc_hd__a22oi_1
X_2641_ registers\[8\]\[19\] registers\[9\]\[19\] registers\[10\]\[19\]
+ registers\[11\]\[19\] _1900_ _1901_ VSS VSS VDD VDD _1983_
+ sky130_fd_sc_hd__mux4_1
X_2642_ registers\[12\]\[19\] registers\[13\]\[19\] registers\[14\]\[19\]
+ registers\[15\]\[19\] _1862_ _1816_ VSS VSS VDD VDD _1984_
+ sky130_fd_sc_hd__mux4_1
X_2643_ _1983_ _1984_ _1845_ VSS VSS VDD VDD _1985_ sky130_fd_sc_hd__mux2i_2
X_2644_ registers\[1\]\[19\] registers\[3\]\[19\] registers\[5\]\[19\]
+ registers\[7\]\[19\] _1865_ _1885_ VSS VSS VDD VDD _1986_
+ sky130_fd_sc_hd__mux4_1
X_2645_ registers\[0\]\[19\] registers\[2\]\[19\] registers\[4\]\[19\]
+ registers\[6\]\[19\] _1848_ _1867_ VSS VSS VDD VDD _1987_
+ sky130_fd_sc_hd__mux4_1
X_2646_ _1986_ _1987_ _1938_ VSS VSS VDD VDD _1988_ sky130_fd_sc_hd__mux2i_1
X_2647_ _1797_ VSS VSS VDD VDD _1989_ sky130_fd_sc_hd__buf_6
X_2648_ _1785_ _1985_ _1988_ _1923_ _1989_ VSS VSS VDD VDD
+ _1990_ sky130_fd_sc_hd__a221o_4
X_2649_ _1973_ _1979_ _1982_ _1990_ VSS VSS VDD VDD _0076_
+ sky130_fd_sc_hd__a31oi_2
X_2650_ registers\[17\]\[1\] registers\[19\]\[1\] registers\[21\]\[1\]
+ registers\[23\]\[1\] _1801_ _1871_ VSS VSS VDD VDD _1991_
+ sky130_fd_sc_hd__mux4_1
X_2651_ registers\[18\]\[1\] registers\[22\]\[1\] _1829_ VSS
+ VSS VDD VDD _1992_ sky130_fd_sc_hd__mux2i_1
X_2652_ registers\[16\]\[1\] registers\[20\]\[1\] _1943_ VSS
+ VSS VDD VDD _1993_ sky130_fd_sc_hd__mux2i_1
X_2653_ _1828_ _1992_ _1993_ _1832_ _1833_ VSS VSS VDD VDD
+ _1994_ sky130_fd_sc_hd__a221oi_2
X_2654_ _1800_ _1991_ _1994_ VSS VSS VDD VDD _1995_ sky130_fd_sc_hd__o21ai_1
X_2655_ registers\[24\]\[1\] registers\[26\]\[1\] registers\[28\]\[1\]
+ registers\[30\]\[1\] _1962_ _1877_ VSS VSS VDD VDD _1996_
+ sky130_fd_sc_hd__mux4_1
X_2656_ registers\[25\]\[1\] registers\[27\]\[1\] registers\[29\]\[1\]
+ registers\[31\]\[1\] _1839_ _1879_ VSS VSS VDD VDD _1997_
+ sky130_fd_sc_hd__mux4_1
X_2657_ _1836_ _1996_ _1997_ _1812_ VSS VSS VDD VDD _1998_
+ sky130_fd_sc_hd__a22oi_4
X_2658_ registers\[8\]\[1\] registers\[9\]\[1\] registers\[10\]\[1\]
+ registers\[11\]\[1\] _1900_ _1901_ VSS VSS VDD VDD _1999_
+ sky130_fd_sc_hd__mux4_1
X_2659_ _1753_ VSS VSS VDD VDD _2000_ sky130_fd_sc_hd__buf_6
X_2660_ registers\[12\]\[1\] registers\[13\]\[1\] registers\[14\]\[1\]
+ registers\[15\]\[1\] _1862_ _2000_ VSS VSS VDD VDD _2001_
+ sky130_fd_sc_hd__mux4_1
X_2661_ _1999_ _2001_ _1845_ VSS VSS VDD VDD _2002_ sky130_fd_sc_hd__mux2i_2
X_2662_ registers\[1\]\[1\] registers\[3\]\[1\] registers\[5\]\[1\]
+ registers\[7\]\[1\] _1865_ _1885_ VSS VSS VDD VDD _2003_ sky130_fd_sc_hd__mux4_1
X_2663_ registers\[0\]\[1\] registers\[2\]\[1\] registers\[4\]\[1\]
+ registers\[6\]\[1\] _1848_ _1867_ VSS VSS VDD VDD _2004_ sky130_fd_sc_hd__mux4_1
X_2664_ _2003_ _2004_ _1938_ VSS VSS VDD VDD _2005_ sky130_fd_sc_hd__mux2i_1
X_2665_ _1785_ _2002_ _2005_ _1923_ _1989_ VSS VSS VDD VDD
+ _2006_ sky130_fd_sc_hd__a221o_4
X_2666_ _1973_ _1995_ _1998_ _2006_ VSS VSS VDD VDD _0077_
+ sky130_fd_sc_hd__a31oi_4
X_2667_ registers\[17\]\[20\] registers\[19\]\[20\] registers\[21\]\[20\]
+ registers\[23\]\[20\] _1801_ _1871_ VSS VSS VDD VDD _2007_
+ sky130_fd_sc_hd__mux4_1
X_2668_ registers\[18\]\[20\] registers\[22\]\[20\] _1829_
+ VSS VSS VDD VDD _2008_ sky130_fd_sc_hd__mux2i_1
X_2669_ registers\[16\]\[20\] registers\[20\]\[20\] _1943_
+ VSS VSS VDD VDD _2009_ sky130_fd_sc_hd__mux2i_1
X_2670_ _1828_ _2008_ _2009_ _1832_ _1833_ VSS VSS VDD VDD
+ _2010_ sky130_fd_sc_hd__a221oi_2
X_2671_ _1800_ _2007_ _2010_ VSS VSS VDD VDD _2011_ sky130_fd_sc_hd__o21ai_1
X_2672_ registers\[24\]\[20\] registers\[26\]\[20\] registers\[28\]\[20\]
+ registers\[30\]\[20\] _1962_ _1877_ VSS VSS VDD VDD _2012_
+ sky130_fd_sc_hd__mux4_1
X_2673_ _1763_ VSS VSS VDD VDD _2013_ sky130_fd_sc_hd__buf_8
X_2674_ registers\[25\]\[20\] registers\[27\]\[20\] registers\[29\]\[20\]
+ registers\[31\]\[20\] _2013_ _1879_ VSS VSS VDD VDD _2014_
+ sky130_fd_sc_hd__mux4_1
X_2675_ _1836_ _2012_ _2014_ _1812_ VSS VSS VDD VDD _2015_
+ sky130_fd_sc_hd__a22oi_4
X_2676_ registers\[0\]\[20\] registers\[1\]\[20\] registers\[2\]\[20\]
+ registers\[3\]\[20\] _1900_ _1901_ VSS VSS VDD VDD _2016_
+ sky130_fd_sc_hd__mux4_1
X_2677_ registers\[4\]\[20\] registers\[5\]\[20\] registers\[6\]\[20\]
+ registers\[7\]\[20\] _1862_ _2000_ VSS VSS VDD VDD _2017_
+ sky130_fd_sc_hd__mux4_1
X_2678_ _1819_ VSS VSS VDD VDD _2018_ sky130_fd_sc_hd__buf_8
X_2679_ _2016_ _2017_ _2018_ VSS VSS VDD VDD _2019_ sky130_fd_sc_hd__mux2i_1
X_2680_ registers\[9\]\[20\] registers\[11\]\[20\] registers\[13\]\[20\]
+ registers\[15\]\[20\] _1865_ _1885_ VSS VSS VDD VDD _2020_
+ sky130_fd_sc_hd__mux4_1
X_2681_ _1752_ VSS VSS VDD VDD _2021_ sky130_fd_sc_hd__buf_6
X_2682_ registers\[8\]\[20\] registers\[10\]\[20\] registers\[12\]\[20\]
+ registers\[14\]\[20\] _2021_ _1867_ VSS VSS VDD VDD _2022_
+ sky130_fd_sc_hd__mux4_1
X_2683_ _2020_ _2022_ _1938_ VSS VSS VDD VDD _2023_ sky130_fd_sc_hd__mux2i_4
X_2684_ _1793_ _2019_ _2023_ _1825_ _1989_ VSS VSS VDD VDD
+ _2024_ sky130_fd_sc_hd__a221o_2
X_2685_ _1973_ _2011_ _2015_ _2024_ VSS VSS VDD VDD _0078_
+ sky130_fd_sc_hd__a31oi_4
X_2686_ registers\[17\]\[21\] registers\[19\]\[21\] registers\[21\]\[21\]
+ registers\[23\]\[21\] _1801_ _1871_ VSS VSS VDD VDD _2025_
+ sky130_fd_sc_hd__mux4_1
X_2687_ registers\[18\]\[21\] registers\[22\]\[21\] _1829_
+ VSS VSS VDD VDD _2026_ sky130_fd_sc_hd__mux2i_1
X_2688_ registers\[16\]\[21\] registers\[20\]\[21\] _1943_
+ VSS VSS VDD VDD _2027_ sky130_fd_sc_hd__mux2i_1
X_2689_ _1828_ _2026_ _2027_ _1832_ _1833_ VSS VSS VDD VDD
+ _2028_ sky130_fd_sc_hd__a221oi_2
X_2690_ _1800_ _2025_ _2028_ VSS VSS VDD VDD _2029_ sky130_fd_sc_hd__o21ai_1
X_2691_ registers\[24\]\[21\] registers\[26\]\[21\] registers\[28\]\[21\]
+ registers\[30\]\[21\] _1962_ _1877_ VSS VSS VDD VDD _2030_
+ sky130_fd_sc_hd__mux4_1
X_2692_ registers\[25\]\[21\] registers\[27\]\[21\] registers\[29\]\[21\]
+ registers\[31\]\[21\] _2013_ _1879_ VSS VSS VDD VDD _2031_
+ sky130_fd_sc_hd__mux4_1
X_2693_ _1836_ _2030_ _2031_ _1812_ VSS VSS VDD VDD _2032_
+ sky130_fd_sc_hd__a22oi_4
X_2694_ registers\[0\]\[21\] registers\[1\]\[21\] registers\[2\]\[21\]
+ registers\[3\]\[21\] _1900_ _1901_ VSS VSS VDD VDD _2033_
+ sky130_fd_sc_hd__mux4_1
X_2695_ _1747_ VSS VSS VDD VDD _2034_ sky130_fd_sc_hd__buf_6
X_2696_ registers\[4\]\[21\] registers\[5\]\[21\] registers\[6\]\[21\]
+ registers\[7\]\[21\] _2034_ _2000_ VSS VSS VDD VDD _2035_
+ sky130_fd_sc_hd__mux4_1
X_2697_ _2033_ _2035_ _2018_ VSS VSS VDD VDD _2036_ sky130_fd_sc_hd__mux2i_2
X_2698_ _1752_ VSS VSS VDD VDD _2037_ sky130_fd_sc_hd__buf_6
X_2699_ registers\[9\]\[21\] registers\[11\]\[21\] registers\[13\]\[21\]
+ registers\[15\]\[21\] _2037_ _1885_ VSS VSS VDD VDD _2038_
+ sky130_fd_sc_hd__mux4_1
X_2700_ _1755_ VSS VSS VDD VDD _2039_ sky130_fd_sc_hd__buf_4
X_2701_ registers\[8\]\[21\] registers\[10\]\[21\] registers\[12\]\[21\]
+ registers\[14\]\[21\] _2021_ _2039_ VSS VSS VDD VDD _2040_
+ sky130_fd_sc_hd__mux4_1
X_2702_ _2038_ _2040_ _1938_ VSS VSS VDD VDD _2041_ sky130_fd_sc_hd__mux2i_4
X_2703_ _1793_ _2036_ _2041_ _1825_ _1989_ VSS VSS VDD VDD
+ _2042_ sky130_fd_sc_hd__a221o_4
X_2704_ _1973_ _2029_ _2032_ _2042_ VSS VSS VDD VDD _0079_
+ sky130_fd_sc_hd__a31oi_4
X_2705_ registers\[25\]\[22\] registers\[27\]\[22\] registers\[29\]\[22\]
+ registers\[31\]\[22\] _1754_ _1757_ VSS VSS VDD VDD _2043_
+ sky130_fd_sc_hd__mux4_1
X_2706_ registers\[24\]\[22\] registers\[28\]\[22\] _1840_
+ VSS VSS VDD VDD _2044_ sky130_fd_sc_hd__mux2i_1
X_2707_ _1766_ _2044_ VSS VSS VDD VDD _2045_ sky130_fd_sc_hd__nand2_1
X_2708_ registers\[26\]\[22\] registers\[30\]\[22\] _1760_
+ VSS VSS VDD VDD _2046_ sky130_fd_sc_hd__mux2i_1
X_2709_ _1770_ _2046_ VSS VSS VDD VDD _2047_ sky130_fd_sc_hd__nand2_1
X_2710_ _1751_ _2043_ _2045_ _2047_ _1773_ VSS VSS VDD VDD
+ _2048_ sky130_fd_sc_hd__o2111ai_4
X_2711_ _1819_ VSS VSS VDD VDD _2049_ sky130_fd_sc_hd__buf_6
X_2712_ registers\[16\]\[22\] registers\[18\]\[22\] registers\[20\]\[22\]
+ registers\[22\]\[22\] _1962_ _2049_ VSS VSS VDD VDD _2050_
+ sky130_fd_sc_hd__mux4_1
X_2713_ _1759_ VSS VSS VDD VDD _2051_ sky130_fd_sc_hd__buf_6
X_2714_ registers\[17\]\[22\] registers\[19\]\[22\] registers\[21\]\[22\]
+ registers\[23\]\[22\] _2013_ _2051_ VSS VSS VDD VDD _2052_
+ sky130_fd_sc_hd__mux4_1
X_2715_ _1778_ _2050_ _2052_ _1779_ VSS VSS VDD VDD _2053_
+ sky130_fd_sc_hd__a22oi_1
X_2716_ _1792_ VSS VSS VDD VDD _2054_ sky130_fd_sc_hd__buf_6
X_2717_ registers\[0\]\[22\] registers\[1\]\[22\] registers\[2\]\[22\]
+ registers\[3\]\[22\] _1900_ _1901_ VSS VSS VDD VDD _2055_
+ sky130_fd_sc_hd__mux4_1
X_2718_ registers\[4\]\[22\] registers\[5\]\[22\] registers\[6\]\[22\]
+ registers\[7\]\[22\] _2034_ _2000_ VSS VSS VDD VDD _2056_
+ sky130_fd_sc_hd__mux4_1
X_2719_ _2055_ _2056_ _2018_ VSS VSS VDD VDD _2057_ sky130_fd_sc_hd__mux2i_1
X_2720_ _1756_ VSS VSS VDD VDD _2058_ sky130_fd_sc_hd__buf_6
X_2721_ registers\[9\]\[22\] registers\[11\]\[22\] registers\[13\]\[22\]
+ registers\[15\]\[22\] _2037_ _2058_ VSS VSS VDD VDD _2059_
+ sky130_fd_sc_hd__mux4_1
X_2722_ registers\[8\]\[22\] registers\[10\]\[22\] registers\[12\]\[22\]
+ registers\[14\]\[22\] _2021_ _2039_ VSS VSS VDD VDD _2060_
+ sky130_fd_sc_hd__mux4_1
X_2723_ _2059_ _2060_ _1938_ VSS VSS VDD VDD _2061_ sky130_fd_sc_hd__mux2i_2
X_2724_ _1784_ VSS VSS VDD VDD _2062_ sky130_fd_sc_hd__buf_6
X_2725_ _2054_ _2057_ _2061_ _2062_ _1989_ VSS VSS VDD VDD
+ _2063_ sky130_fd_sc_hd__a221o_4
X_2726_ _1973_ _2048_ _2053_ _2063_ VSS VSS VDD VDD _0080_
+ sky130_fd_sc_hd__a31oi_2
X_2727_ _1748_ VSS VSS VDD VDD _2064_ sky130_fd_sc_hd__buf_4
X_2728_ _1763_ VSS VSS VDD VDD _2065_ sky130_fd_sc_hd__buf_4
X_2729_ registers\[17\]\[23\] registers\[19\]\[23\] registers\[21\]\[23\]
+ registers\[23\]\[23\] _2065_ _1871_ VSS VSS VDD VDD _2066_
+ sky130_fd_sc_hd__mux4_1
X_2730_ registers\[18\]\[23\] registers\[22\]\[23\] _1829_
+ VSS VSS VDD VDD _2067_ sky130_fd_sc_hd__mux2i_2
X_2731_ registers\[16\]\[23\] registers\[20\]\[23\] _1943_
+ VSS VSS VDD VDD _2068_ sky130_fd_sc_hd__mux2i_2
X_2732_ _1828_ _2067_ _2068_ _1832_ _1833_ VSS VSS VDD VDD
+ _2069_ sky130_fd_sc_hd__a221oi_4
X_2733_ _2064_ _2066_ _2069_ VSS VSS VDD VDD _2070_ sky130_fd_sc_hd__o21ai_1
X_2734_ registers\[24\]\[23\] registers\[26\]\[23\] registers\[28\]\[23\]
+ registers\[30\]\[23\] _1962_ _2049_ VSS VSS VDD VDD _2071_
+ sky130_fd_sc_hd__mux4_1
X_2735_ registers\[25\]\[23\] registers\[27\]\[23\] registers\[29\]\[23\]
+ registers\[31\]\[23\] _2013_ _2051_ VSS VSS VDD VDD _2072_
+ sky130_fd_sc_hd__mux4_1
X_2736_ _1811_ VSS VSS VDD VDD _2073_ sky130_fd_sc_hd__buf_8
X_2737_ _1836_ _2071_ _2072_ _2073_ VSS VSS VDD VDD _2074_
+ sky130_fd_sc_hd__a22oi_4
X_2738_ _1747_ VSS VSS VDD VDD _2075_ sky130_fd_sc_hd__buf_6
X_2739_ _1763_ VSS VSS VDD VDD _2076_ sky130_fd_sc_hd__buf_6
X_2740_ registers\[0\]\[23\] registers\[1\]\[23\] registers\[2\]\[23\]
+ registers\[3\]\[23\] _2075_ _2076_ VSS VSS VDD VDD _2077_
+ sky130_fd_sc_hd__mux4_1
X_2741_ registers\[4\]\[23\] registers\[5\]\[23\] registers\[6\]\[23\]
+ registers\[7\]\[23\] _2034_ _2000_ VSS VSS VDD VDD _2078_
+ sky130_fd_sc_hd__mux4_1
X_2742_ _2077_ _2078_ _2018_ VSS VSS VDD VDD _2079_ sky130_fd_sc_hd__mux2i_1
X_2743_ registers\[9\]\[23\] registers\[11\]\[23\] registers\[13\]\[23\]
+ registers\[15\]\[23\] _2037_ _2058_ VSS VSS VDD VDD _2080_
+ sky130_fd_sc_hd__mux4_1
X_2744_ registers\[8\]\[23\] registers\[10\]\[23\] registers\[12\]\[23\]
+ registers\[14\]\[23\] _2021_ _2039_ VSS VSS VDD VDD _2081_
+ sky130_fd_sc_hd__mux4_1
X_2745_ _2080_ _2081_ _1938_ VSS VSS VDD VDD _2082_ sky130_fd_sc_hd__mux2i_2
X_2746_ _2054_ _2079_ _2082_ _2062_ _1989_ VSS VSS VDD VDD
+ _2083_ sky130_fd_sc_hd__a221o_4
X_2747_ _1973_ _2070_ _2074_ _2083_ VSS VSS VDD VDD _0081_
+ sky130_fd_sc_hd__a31oi_4
X_2748_ registers\[25\]\[24\] registers\[27\]\[24\] registers\[29\]\[24\]
+ registers\[31\]\[24\] _1754_ _1757_ VSS VSS VDD VDD _2084_
+ sky130_fd_sc_hd__mux4_1
X_2749_ registers\[24\]\[24\] registers\[28\]\[24\] _1840_
+ VSS VSS VDD VDD _2085_ sky130_fd_sc_hd__mux2i_1
X_2750_ _1766_ _2085_ VSS VSS VDD VDD _2086_ sky130_fd_sc_hd__nand2_1
X_2751_ registers\[26\]\[24\] registers\[30\]\[24\] _1760_
+ VSS VSS VDD VDD _2087_ sky130_fd_sc_hd__mux2i_1
X_2752_ _1770_ _2087_ VSS VSS VDD VDD _2088_ sky130_fd_sc_hd__nand2_1
X_2753_ _1751_ _2084_ _2086_ _2088_ _1773_ VSS VSS VDD VDD
+ _2089_ sky130_fd_sc_hd__o2111ai_4
X_2754_ registers\[16\]\[24\] registers\[18\]\[24\] registers\[20\]\[24\]
+ registers\[22\]\[24\] _1962_ _2049_ VSS VSS VDD VDD _2090_
+ sky130_fd_sc_hd__mux4_2
X_2755_ registers\[17\]\[24\] registers\[19\]\[24\] registers\[21\]\[24\]
+ registers\[23\]\[24\] _2013_ _2051_ VSS VSS VDD VDD _2091_
+ sky130_fd_sc_hd__mux4_1
X_2756_ _1778_ _2090_ _2091_ _1779_ VSS VSS VDD VDD _2092_
+ sky130_fd_sc_hd__a22oi_2
X_2757_ registers\[0\]\[24\] registers\[1\]\[24\] registers\[2\]\[24\]
+ registers\[3\]\[24\] _2075_ _2076_ VSS VSS VDD VDD _2093_
+ sky130_fd_sc_hd__mux4_1
X_2758_ registers\[4\]\[24\] registers\[5\]\[24\] registers\[6\]\[24\]
+ registers\[7\]\[24\] _2034_ _2000_ VSS VSS VDD VDD _2094_
+ sky130_fd_sc_hd__mux4_1
X_2759_ _2093_ _2094_ _2018_ VSS VSS VDD VDD _2095_ sky130_fd_sc_hd__mux2i_1
X_2760_ registers\[9\]\[24\] registers\[11\]\[24\] registers\[13\]\[24\]
+ registers\[15\]\[24\] _2037_ _2058_ VSS VSS VDD VDD _2096_
+ sky130_fd_sc_hd__mux4_1
X_2761_ registers\[8\]\[24\] registers\[10\]\[24\] registers\[12\]\[24\]
+ registers\[14\]\[24\] _2021_ _2039_ VSS VSS VDD VDD _2097_
+ sky130_fd_sc_hd__mux4_1
X_2762_ _2096_ _2097_ _1938_ VSS VSS VDD VDD _2098_ sky130_fd_sc_hd__mux2i_4
X_2763_ _2054_ _2095_ _2098_ _2062_ _1989_ VSS VSS VDD VDD
+ _2099_ sky130_fd_sc_hd__a221o_4
X_2764_ _1973_ _2089_ _2092_ _2099_ VSS VSS VDD VDD _0082_
+ sky130_fd_sc_hd__a31oi_4
X_2765_ registers\[17\]\[25\] registers\[19\]\[25\] registers\[21\]\[25\]
+ registers\[23\]\[25\] _2065_ _1871_ VSS VSS VDD VDD _2100_
+ sky130_fd_sc_hd__mux4_1
X_2766_ _1769_ VSS VSS VDD VDD _2101_ sky130_fd_sc_hd__buf_4
X_2767_ _1756_ VSS VSS VDD VDD _2102_ sky130_fd_sc_hd__buf_6
X_2768_ registers\[18\]\[25\] registers\[22\]\[25\] _2102_
+ VSS VSS VDD VDD _2103_ sky130_fd_sc_hd__mux2i_1
X_2769_ registers\[16\]\[25\] registers\[20\]\[25\] _1943_
+ VSS VSS VDD VDD _2104_ sky130_fd_sc_hd__mux2i_1
X_2770_ _1765_ VSS VSS VDD VDD _2105_ sky130_fd_sc_hd__buf_6
X_2771_ _1772_ VSS VSS VDD VDD _2106_ sky130_fd_sc_hd__buf_4
X_2772_ _2101_ _2103_ _2104_ _2105_ _2106_ VSS VSS VDD VDD
+ _2107_ sky130_fd_sc_hd__a221oi_2
X_2773_ _2064_ _2100_ _2107_ VSS VSS VDD VDD _2108_ sky130_fd_sc_hd__o21ai_1
X_2774_ _1809_ VSS VSS VDD VDD _2109_ sky130_fd_sc_hd__buf_8
X_2775_ registers\[24\]\[25\] registers\[26\]\[25\] registers\[28\]\[25\]
+ registers\[30\]\[25\] _1962_ _2049_ VSS VSS VDD VDD _2110_
+ sky130_fd_sc_hd__mux4_1
X_2776_ registers\[25\]\[25\] registers\[27\]\[25\] registers\[29\]\[25\]
+ registers\[31\]\[25\] _2013_ _2051_ VSS VSS VDD VDD _2111_
+ sky130_fd_sc_hd__mux4_1
X_2777_ _2109_ _2110_ _2111_ _2073_ VSS VSS VDD VDD _2112_
+ sky130_fd_sc_hd__a22oi_4
X_2778_ registers\[8\]\[25\] registers\[9\]\[25\] registers\[10\]\[25\]
+ registers\[11\]\[25\] _2075_ _2076_ VSS VSS VDD VDD _2113_
+ sky130_fd_sc_hd__mux4_1
X_2779_ registers\[12\]\[25\] registers\[13\]\[25\] registers\[14\]\[25\]
+ registers\[15\]\[25\] _2034_ _2000_ VSS VSS VDD VDD _2114_
+ sky130_fd_sc_hd__mux4_1
X_2780_ _2113_ _2114_ _2018_ VSS VSS VDD VDD _2115_ sky130_fd_sc_hd__mux2i_2
X_2781_ registers\[1\]\[25\] registers\[3\]\[25\] registers\[5\]\[25\]
+ registers\[7\]\[25\] _2037_ _2058_ VSS VSS VDD VDD _2116_
+ sky130_fd_sc_hd__mux4_1
X_2782_ registers\[0\]\[25\] registers\[2\]\[25\] registers\[4\]\[25\]
+ registers\[6\]\[25\] _2021_ _2039_ VSS VSS VDD VDD _2117_
+ sky130_fd_sc_hd__mux4_1
X_2783_ _1749_ VSS VSS VDD VDD _2118_ sky130_fd_sc_hd__buf_8
X_2784_ _2116_ _2117_ _2118_ VSS VSS VDD VDD _2119_ sky130_fd_sc_hd__mux2i_1
X_2785_ _1785_ _2115_ _2119_ _1923_ _1989_ VSS VSS VDD VDD
+ _2120_ sky130_fd_sc_hd__a221o_4
X_2786_ _1973_ _2108_ _2112_ _2120_ VSS VSS VDD VDD _0083_
+ sky130_fd_sc_hd__a31oi_4
X_2787_ _1759_ VSS VSS VDD VDD _2121_ sky130_fd_sc_hd__buf_4
X_2788_ registers\[17\]\[26\] registers\[19\]\[26\] registers\[21\]\[26\]
+ registers\[23\]\[26\] _2065_ _2121_ VSS VSS VDD VDD _2122_
+ sky130_fd_sc_hd__mux4_1
X_2789_ registers\[18\]\[26\] registers\[22\]\[26\] _2102_
+ VSS VSS VDD VDD _2123_ sky130_fd_sc_hd__mux2i_1
X_2790_ registers\[16\]\[26\] registers\[20\]\[26\] _1943_
+ VSS VSS VDD VDD _2124_ sky130_fd_sc_hd__mux2i_1
X_2791_ _2101_ _2123_ _2124_ _2105_ _2106_ VSS VSS VDD VDD
+ _2125_ sky130_fd_sc_hd__a221oi_2
X_2792_ _2064_ _2122_ _2125_ VSS VSS VDD VDD _2126_ sky130_fd_sc_hd__o21ai_1
X_2793_ registers\[24\]\[26\] registers\[26\]\[26\] registers\[28\]\[26\]
+ registers\[30\]\[26\] _1962_ _2049_ VSS VSS VDD VDD _2127_
+ sky130_fd_sc_hd__mux4_1
X_2794_ registers\[25\]\[26\] registers\[27\]\[26\] registers\[29\]\[26\]
+ registers\[31\]\[26\] _2013_ _2051_ VSS VSS VDD VDD _2128_
+ sky130_fd_sc_hd__mux4_1
X_2795_ _2109_ _2127_ _2128_ _2073_ VSS VSS VDD VDD _2129_
+ sky130_fd_sc_hd__a22oi_4
X_2796_ registers\[0\]\[26\] registers\[1\]\[26\] registers\[2\]\[26\]
+ registers\[3\]\[26\] _2075_ _2076_ VSS VSS VDD VDD _2130_
+ sky130_fd_sc_hd__mux4_1
X_2797_ registers\[4\]\[26\] registers\[5\]\[26\] registers\[6\]\[26\]
+ registers\[7\]\[26\] _2034_ _2000_ VSS VSS VDD VDD _2131_
+ sky130_fd_sc_hd__mux4_1
X_2798_ _2130_ _2131_ _2018_ VSS VSS VDD VDD _2132_ sky130_fd_sc_hd__mux2i_1
X_2799_ registers\[9\]\[26\] registers\[11\]\[26\] registers\[13\]\[26\]
+ registers\[15\]\[26\] _2037_ _2058_ VSS VSS VDD VDD _2133_
+ sky130_fd_sc_hd__mux4_1
X_2800_ registers\[8\]\[26\] registers\[10\]\[26\] registers\[12\]\[26\]
+ registers\[14\]\[26\] _2021_ _2039_ VSS VSS VDD VDD _2134_
+ sky130_fd_sc_hd__mux4_1
X_2801_ _2133_ _2134_ _2118_ VSS VSS VDD VDD _2135_ sky130_fd_sc_hd__mux2i_4
X_2802_ _2054_ _2132_ _2135_ _2062_ _1989_ VSS VSS VDD VDD
+ _2136_ sky130_fd_sc_hd__a221o_2
X_2803_ _1973_ _2126_ _2129_ _2136_ VSS VSS VDD VDD _0084_
+ sky130_fd_sc_hd__a31oi_4
X_2804_ registers\[17\]\[27\] registers\[19\]\[27\] registers\[21\]\[27\]
+ registers\[23\]\[27\] _2065_ _2121_ VSS VSS VDD VDD _2137_
+ sky130_fd_sc_hd__mux4_1
X_2805_ registers\[18\]\[27\] registers\[22\]\[27\] _2102_
+ VSS VSS VDD VDD _2138_ sky130_fd_sc_hd__mux2i_1
X_2806_ registers\[16\]\[27\] registers\[20\]\[27\] _1943_
+ VSS VSS VDD VDD _2139_ sky130_fd_sc_hd__mux2i_1
X_2807_ _2101_ _2138_ _2139_ _2105_ _2106_ VSS VSS VDD VDD
+ _2140_ sky130_fd_sc_hd__a221oi_2
X_2808_ _2064_ _2137_ _2140_ VSS VSS VDD VDD _2141_ sky130_fd_sc_hd__o21ai_1
X_2809_ _1753_ VSS VSS VDD VDD _2142_ sky130_fd_sc_hd__buf_6
X_2810_ registers\[24\]\[27\] registers\[26\]\[27\] registers\[28\]\[27\]
+ registers\[30\]\[27\] _2142_ _2049_ VSS VSS VDD VDD _2143_
+ sky130_fd_sc_hd__mux4_1
X_2811_ registers\[25\]\[27\] registers\[27\]\[27\] registers\[29\]\[27\]
+ registers\[31\]\[27\] _2013_ _2051_ VSS VSS VDD VDD _2144_
+ sky130_fd_sc_hd__mux4_1
X_2812_ _2109_ _2143_ _2144_ _2073_ VSS VSS VDD VDD _2145_
+ sky130_fd_sc_hd__a22oi_4
X_2813_ registers\[8\]\[27\] registers\[9\]\[27\] registers\[10\]\[27\]
+ registers\[11\]\[27\] _2075_ _2076_ VSS VSS VDD VDD _2146_
+ sky130_fd_sc_hd__mux4_1
X_2814_ registers\[12\]\[27\] registers\[13\]\[27\] registers\[14\]\[27\]
+ registers\[15\]\[27\] _2034_ _2000_ VSS VSS VDD VDD _2147_
+ sky130_fd_sc_hd__mux4_1
X_2815_ _2146_ _2147_ _2018_ VSS VSS VDD VDD _2148_ sky130_fd_sc_hd__mux2i_2
X_2816_ registers\[1\]\[27\] registers\[3\]\[27\] registers\[5\]\[27\]
+ registers\[7\]\[27\] _2037_ _2058_ VSS VSS VDD VDD _2149_
+ sky130_fd_sc_hd__mux4_1
X_2817_ registers\[0\]\[27\] registers\[2\]\[27\] registers\[4\]\[27\]
+ registers\[6\]\[27\] _2021_ _2039_ VSS VSS VDD VDD _2150_
+ sky130_fd_sc_hd__mux4_1
X_2818_ _2149_ _2150_ _2118_ VSS VSS VDD VDD _2151_ sky130_fd_sc_hd__mux2i_1
X_2819_ _1785_ _2148_ _2151_ _1923_ _1989_ VSS VSS VDD VDD
+ _2152_ sky130_fd_sc_hd__a221o_4
X_2820_ _1973_ _2141_ _2145_ _2152_ VSS VSS VDD VDD _0085_
+ sky130_fd_sc_hd__a31oi_4
X_2821_ _1745_ VSS VSS VDD VDD _2153_ sky130_fd_sc_hd__buf_4
X_2822_ registers\[17\]\[28\] registers\[19\]\[28\] registers\[21\]\[28\]
+ registers\[23\]\[28\] _2065_ _2121_ VSS VSS VDD VDD _2154_
+ sky130_fd_sc_hd__mux4_1
X_2823_ registers\[18\]\[28\] registers\[22\]\[28\] _2102_
+ VSS VSS VDD VDD _2155_ sky130_fd_sc_hd__mux2i_1
X_2824_ registers\[16\]\[28\] registers\[20\]\[28\] _1943_
+ VSS VSS VDD VDD _2156_ sky130_fd_sc_hd__mux2i_1
X_2825_ _2101_ _2155_ _2156_ _2105_ _2106_ VSS VSS VDD VDD
+ _2157_ sky130_fd_sc_hd__a221oi_1
X_2826_ _2064_ _2154_ _2157_ VSS VSS VDD VDD _2158_ sky130_fd_sc_hd__o21ai_0
X_2827_ registers\[24\]\[28\] registers\[26\]\[28\] registers\[28\]\[28\]
+ registers\[30\]\[28\] _2142_ _2049_ VSS VSS VDD VDD _2159_
+ sky130_fd_sc_hd__mux4_1
X_2828_ registers\[25\]\[28\] registers\[27\]\[28\] registers\[29\]\[28\]
+ registers\[31\]\[28\] _2013_ _2051_ VSS VSS VDD VDD _2160_
+ sky130_fd_sc_hd__mux4_1
X_2829_ _2109_ _2159_ _2160_ _2073_ VSS VSS VDD VDD _2161_
+ sky130_fd_sc_hd__a22oi_4
X_2830_ registers\[0\]\[28\] registers\[1\]\[28\] registers\[2\]\[28\]
+ registers\[3\]\[28\] _2075_ _2076_ VSS VSS VDD VDD _2162_
+ sky130_fd_sc_hd__mux4_1
X_2831_ registers\[4\]\[28\] registers\[5\]\[28\] registers\[6\]\[28\]
+ registers\[7\]\[28\] _2034_ _2000_ VSS VSS VDD VDD _2163_
+ sky130_fd_sc_hd__mux4_1
X_2832_ _2162_ _2163_ _2018_ VSS VSS VDD VDD _2164_ sky130_fd_sc_hd__mux2i_1
X_2833_ registers\[9\]\[28\] registers\[11\]\[28\] registers\[13\]\[28\]
+ registers\[15\]\[28\] _2037_ _2058_ VSS VSS VDD VDD _2165_
+ sky130_fd_sc_hd__mux4_1
X_2834_ registers\[8\]\[28\] registers\[10\]\[28\] registers\[12\]\[28\]
+ registers\[14\]\[28\] _2021_ _2039_ VSS VSS VDD VDD _2166_
+ sky130_fd_sc_hd__mux4_1
X_2835_ _2165_ _2166_ _2118_ VSS VSS VDD VDD _2167_ sky130_fd_sc_hd__mux2i_2
X_2836_ _1797_ VSS VSS VDD VDD _2168_ sky130_fd_sc_hd__buf_4
X_2837_ _2054_ _2164_ _2167_ _2062_ _2168_ VSS VSS VDD VDD
+ _2169_ sky130_fd_sc_hd__a221o_2
X_2838_ _2153_ _2158_ _2161_ _2169_ VSS VSS VDD VDD _0086_
+ sky130_fd_sc_hd__a31oi_2
X_2839_ registers\[25\]\[29\] registers\[27\]\[29\] registers\[29\]\[29\]
+ registers\[31\]\[29\] _1754_ _1757_ VSS VSS VDD VDD _2170_
+ sky130_fd_sc_hd__mux4_1
X_2840_ registers\[24\]\[29\] registers\[28\]\[29\] _1840_
+ VSS VSS VDD VDD _2171_ sky130_fd_sc_hd__mux2i_1
X_2841_ _1766_ _2171_ VSS VSS VDD VDD _2172_ sky130_fd_sc_hd__nand2_1
X_2842_ registers\[26\]\[29\] registers\[30\]\[29\] _1760_
+ VSS VSS VDD VDD _2173_ sky130_fd_sc_hd__mux2i_1
X_2843_ _1770_ _2173_ VSS VSS VDD VDD _2174_ sky130_fd_sc_hd__nand2_1
X_2844_ _1751_ _2170_ _2172_ _2174_ _1773_ VSS VSS VDD VDD
+ _2175_ sky130_fd_sc_hd__o2111ai_4
X_2845_ registers\[16\]\[29\] registers\[18\]\[29\] registers\[20\]\[29\]
+ registers\[22\]\[29\] _2142_ _2049_ VSS VSS VDD VDD _2176_
+ sky130_fd_sc_hd__mux4_1
X_2846_ registers\[17\]\[29\] registers\[19\]\[29\] registers\[21\]\[29\]
+ registers\[23\]\[29\] _2013_ _2051_ VSS VSS VDD VDD _2177_
+ sky130_fd_sc_hd__mux4_1
X_2847_ _1778_ _2176_ _2177_ _1779_ VSS VSS VDD VDD _2178_
+ sky130_fd_sc_hd__a22oi_1
X_2848_ registers\[8\]\[29\] registers\[9\]\[29\] registers\[10\]\[29\]
+ registers\[11\]\[29\] _2075_ _2076_ VSS VSS VDD VDD _2179_
+ sky130_fd_sc_hd__mux4_1
X_2849_ _1753_ VSS VSS VDD VDD _2180_ sky130_fd_sc_hd__buf_6
X_2850_ registers\[12\]\[29\] registers\[13\]\[29\] registers\[14\]\[29\]
+ registers\[15\]\[29\] _2034_ _2180_ VSS VSS VDD VDD _2181_
+ sky130_fd_sc_hd__mux4_1
X_2851_ _2179_ _2181_ _2018_ VSS VSS VDD VDD _2182_ sky130_fd_sc_hd__mux2i_2
X_2852_ registers\[1\]\[29\] registers\[3\]\[29\] registers\[5\]\[29\]
+ registers\[7\]\[29\] _2037_ _2058_ VSS VSS VDD VDD _2183_
+ sky130_fd_sc_hd__mux4_1
X_2853_ registers\[0\]\[29\] registers\[2\]\[29\] registers\[4\]\[29\]
+ registers\[6\]\[29\] _2021_ _2039_ VSS VSS VDD VDD _2184_
+ sky130_fd_sc_hd__mux4_1
X_2854_ _2183_ _2184_ _2118_ VSS VSS VDD VDD _2185_ sky130_fd_sc_hd__mux2i_1
X_2855_ _1785_ _2182_ _2185_ _1923_ _2168_ VSS VSS VDD VDD
+ _2186_ sky130_fd_sc_hd__a221o_2
X_2856_ _2153_ _2175_ _2178_ _2186_ VSS VSS VDD VDD _0087_
+ sky130_fd_sc_hd__a31oi_2
X_2857_ registers\[17\]\[2\] registers\[19\]\[2\] registers\[21\]\[2\]
+ registers\[23\]\[2\] _2065_ _2121_ VSS VSS VDD VDD _2187_
+ sky130_fd_sc_hd__mux4_1
X_2858_ registers\[18\]\[2\] registers\[22\]\[2\] _2102_ VSS
+ VSS VDD VDD _2188_ sky130_fd_sc_hd__mux2i_1
X_2859_ registers\[16\]\[2\] registers\[20\]\[2\] _1837_ VSS
+ VSS VDD VDD _2189_ sky130_fd_sc_hd__mux2i_1
X_2860_ _2101_ _2188_ _2189_ _2105_ _2106_ VSS VSS VDD VDD
+ _2190_ sky130_fd_sc_hd__a221oi_1
X_2861_ _2064_ _2187_ _2190_ VSS VSS VDD VDD _2191_ sky130_fd_sc_hd__o21ai_0
X_2862_ registers\[24\]\[2\] registers\[26\]\[2\] registers\[28\]\[2\]
+ registers\[30\]\[2\] _2142_ _2049_ VSS VSS VDD VDD _2192_
+ sky130_fd_sc_hd__mux4_1
X_2863_ _1763_ VSS VSS VDD VDD _2193_ sky130_fd_sc_hd__buf_6
X_2864_ registers\[25\]\[2\] registers\[27\]\[2\] registers\[29\]\[2\]
+ registers\[31\]\[2\] _2193_ _2051_ VSS VSS VDD VDD _2194_
+ sky130_fd_sc_hd__mux4_1
X_2865_ _2109_ _2192_ _2194_ _2073_ VSS VSS VDD VDD _2195_
+ sky130_fd_sc_hd__a22oi_4
X_2866_ registers\[8\]\[2\] registers\[9\]\[2\] registers\[10\]\[2\]
+ registers\[11\]\[2\] _2075_ _2076_ VSS VSS VDD VDD _2196_
+ sky130_fd_sc_hd__mux4_1
X_2867_ registers\[12\]\[2\] registers\[13\]\[2\] registers\[14\]\[2\]
+ registers\[15\]\[2\] _2034_ _2180_ VSS VSS VDD VDD _2197_
+ sky130_fd_sc_hd__mux4_1
X_2868_ _1819_ VSS VSS VDD VDD _2198_ sky130_fd_sc_hd__buf_8
X_2869_ _2196_ _2197_ _2198_ VSS VSS VDD VDD _2199_ sky130_fd_sc_hd__mux2i_2
X_2870_ registers\[1\]\[2\] registers\[3\]\[2\] registers\[5\]\[2\]
+ registers\[7\]\[2\] _2037_ _2058_ VSS VSS VDD VDD _2200_ sky130_fd_sc_hd__mux4_1
X_2871_ _1752_ VSS VSS VDD VDD _2201_ sky130_fd_sc_hd__buf_8
X_2872_ registers\[0\]\[2\] registers\[2\]\[2\] registers\[4\]\[2\]
+ registers\[6\]\[2\] _2201_ _2039_ VSS VSS VDD VDD _2202_ sky130_fd_sc_hd__mux4_1
X_2873_ _2200_ _2202_ _2118_ VSS VSS VDD VDD _2203_ sky130_fd_sc_hd__mux2i_1
X_2874_ _1785_ _2199_ _2203_ _1923_ _2168_ VSS VSS VDD VDD
+ _2204_ sky130_fd_sc_hd__a221o_2
X_2875_ _2153_ _2191_ _2195_ _2204_ VSS VSS VDD VDD _0088_
+ sky130_fd_sc_hd__a31oi_1
X_2876_ registers\[17\]\[30\] registers\[19\]\[30\] registers\[21\]\[30\]
+ registers\[23\]\[30\] _2065_ _2121_ VSS VSS VDD VDD _2205_
+ sky130_fd_sc_hd__mux4_1
X_2877_ registers\[18\]\[30\] registers\[22\]\[30\] _2102_
+ VSS VSS VDD VDD _2206_ sky130_fd_sc_hd__mux2i_2
X_2878_ registers\[16\]\[30\] registers\[20\]\[30\] _1837_
+ VSS VSS VDD VDD _2207_ sky130_fd_sc_hd__mux2i_1
X_2879_ _2101_ _2206_ _2207_ _2105_ _2106_ VSS VSS VDD VDD
+ _2208_ sky130_fd_sc_hd__a221oi_2
X_2880_ _2064_ _2205_ _2208_ VSS VSS VDD VDD _2209_ sky130_fd_sc_hd__o21ai_0
X_2881_ registers\[24\]\[30\] registers\[26\]\[30\] registers\[28\]\[30\]
+ registers\[30\]\[30\] _2142_ _2049_ VSS VSS VDD VDD _2210_
+ sky130_fd_sc_hd__mux4_1
X_2882_ registers\[25\]\[30\] registers\[27\]\[30\] registers\[29\]\[30\]
+ registers\[31\]\[30\] _2193_ _2051_ VSS VSS VDD VDD _2211_
+ sky130_fd_sc_hd__mux4_1
X_2883_ _2109_ _2210_ _2211_ _2073_ VSS VSS VDD VDD _2212_
+ sky130_fd_sc_hd__a22oi_2
X_2884_ registers\[0\]\[30\] registers\[1\]\[30\] registers\[2\]\[30\]
+ registers\[3\]\[30\] _2075_ _2076_ VSS VSS VDD VDD _2213_
+ sky130_fd_sc_hd__mux4_1
X_2885_ registers\[4\]\[30\] registers\[5\]\[30\] registers\[6\]\[30\]
+ registers\[7\]\[30\] _1899_ _2180_ VSS VSS VDD VDD _2214_
+ sky130_fd_sc_hd__mux4_1
X_2886_ _2213_ _2214_ _2198_ VSS VSS VDD VDD _2215_ sky130_fd_sc_hd__mux2i_1
X_2887_ registers\[9\]\[30\] registers\[11\]\[30\] registers\[13\]\[30\]
+ registers\[15\]\[30\] _1821_ _2058_ VSS VSS VDD VDD _2216_
+ sky130_fd_sc_hd__mux4_1
X_2888_ registers\[8\]\[30\] registers\[10\]\[30\] registers\[12\]\[30\]
+ registers\[14\]\[30\] _2201_ _1789_ VSS VSS VDD VDD _2217_
+ sky130_fd_sc_hd__mux4_1
X_2889_ _2216_ _2217_ _2118_ VSS VSS VDD VDD _2218_ sky130_fd_sc_hd__mux2i_2
X_2890_ _2054_ _2215_ _2218_ _2062_ _2168_ VSS VSS VDD VDD
+ _2219_ sky130_fd_sc_hd__a221o_2
X_2891_ _2153_ _2209_ _2212_ _2219_ VSS VSS VDD VDD _0089_
+ sky130_fd_sc_hd__a31oi_1
X_2892_ registers\[17\]\[31\] registers\[19\]\[31\] registers\[21\]\[31\]
+ registers\[23\]\[31\] _2065_ _2121_ VSS VSS VDD VDD _2220_
+ sky130_fd_sc_hd__mux4_1
X_2893_ registers\[18\]\[31\] registers\[22\]\[31\] _2102_
+ VSS VSS VDD VDD _2221_ sky130_fd_sc_hd__mux2i_2
X_2894_ registers\[16\]\[31\] registers\[20\]\[31\] _1837_
+ VSS VSS VDD VDD _2222_ sky130_fd_sc_hd__mux2i_1
X_2895_ _2101_ _2221_ _2222_ _2105_ _2106_ VSS VSS VDD VDD
+ _2223_ sky130_fd_sc_hd__a221oi_2
X_2896_ _2064_ _2220_ _2223_ VSS VSS VDD VDD _2224_ sky130_fd_sc_hd__o21ai_0
X_2897_ registers\[24\]\[31\] registers\[26\]\[31\] registers\[28\]\[31\]
+ registers\[30\]\[31\] _2142_ _1790_ VSS VSS VDD VDD _2225_
+ sky130_fd_sc_hd__mux4_1
X_2898_ registers\[25\]\[31\] registers\[27\]\[31\] registers\[29\]\[31\]
+ registers\[31\]\[31\] _2193_ _1802_ VSS VSS VDD VDD _2226_
+ sky130_fd_sc_hd__mux4_1
X_2899_ _2109_ _2225_ _2226_ _2073_ VSS VSS VDD VDD _2227_
+ sky130_fd_sc_hd__a22oi_2
X_2900_ registers\[0\]\[31\] registers\[1\]\[31\] registers\[2\]\[31\]
+ registers\[3\]\[31\] _2075_ _2076_ VSS VSS VDD VDD _2228_
+ sky130_fd_sc_hd__mux4_1
X_2901_ registers\[4\]\[31\] registers\[5\]\[31\] registers\[6\]\[31\]
+ registers\[7\]\[31\] _1899_ _2180_ VSS VSS VDD VDD _2229_
+ sky130_fd_sc_hd__mux4_1
X_2902_ _2228_ _2229_ _2198_ VSS VSS VDD VDD _2230_ sky130_fd_sc_hd__mux2i_1
X_2903_ registers\[9\]\[31\] registers\[11\]\[31\] registers\[13\]\[31\]
+ registers\[15\]\[31\] _1821_ _1822_ VSS VSS VDD VDD _2231_
+ sky130_fd_sc_hd__mux4_1
X_2904_ registers\[8\]\[31\] registers\[10\]\[31\] registers\[12\]\[31\]
+ registers\[14\]\[31\] _2201_ _1789_ VSS VSS VDD VDD _2232_
+ sky130_fd_sc_hd__mux4_1
X_2905_ _2231_ _2232_ _2118_ VSS VSS VDD VDD _2233_ sky130_fd_sc_hd__mux2i_2
X_2906_ _2054_ _2230_ _2233_ _2062_ _2168_ VSS VSS VDD VDD
+ _2234_ sky130_fd_sc_hd__a221o_2
X_2907_ _2153_ _2224_ _2227_ _2234_ VSS VSS VDD VDD _0090_
+ sky130_fd_sc_hd__a31oi_1
X_2908_ registers\[25\]\[3\] registers\[27\]\[3\] registers\[29\]\[3\]
+ registers\[31\]\[3\] _1763_ _1757_ VSS VSS VDD VDD _2235_
+ sky130_fd_sc_hd__mux4_1
X_2909_ registers\[24\]\[3\] registers\[28\]\[3\] _1840_ VSS
+ VSS VDD VDD _2236_ sky130_fd_sc_hd__mux2i_1
X_2910_ _1766_ _2236_ VSS VSS VDD VDD _2237_ sky130_fd_sc_hd__nand2_1
X_2911_ registers\[26\]\[3\] registers\[30\]\[3\] _1760_ VSS
+ VSS VDD VDD _2238_ sky130_fd_sc_hd__mux2i_1
X_2912_ _1770_ _2238_ VSS VSS VDD VDD _2239_ sky130_fd_sc_hd__nand2_1
X_2913_ _1750_ _2235_ _2237_ _2239_ _1773_ VSS VSS VDD VDD
+ _2240_ sky130_fd_sc_hd__o2111ai_4
X_2914_ registers\[16\]\[3\] registers\[18\]\[3\] registers\[20\]\[3\]
+ registers\[22\]\[3\] _2142_ _1790_ VSS VSS VDD VDD _2241_
+ sky130_fd_sc_hd__mux4_1
X_2915_ registers\[17\]\[3\] registers\[19\]\[3\] registers\[21\]\[3\]
+ registers\[23\]\[3\] _2193_ _1802_ VSS VSS VDD VDD _2242_
+ sky130_fd_sc_hd__mux4_1
X_2916_ _1778_ _2241_ _2242_ _1779_ VSS VSS VDD VDD _2243_
+ sky130_fd_sc_hd__a22oi_1
X_2917_ registers\[0\]\[3\] registers\[1\]\[3\] registers\[2\]\[3\]
+ registers\[3\]\[3\] _1787_ _1775_ VSS VSS VDD VDD _2244_ sky130_fd_sc_hd__mux4_1
X_2918_ registers\[4\]\[3\] registers\[5\]\[3\] registers\[6\]\[3\]
+ registers\[7\]\[3\] _1899_ _2180_ VSS VSS VDD VDD _2245_ sky130_fd_sc_hd__mux4_1
X_2919_ _2244_ _2245_ _2198_ VSS VSS VDD VDD _2246_ sky130_fd_sc_hd__mux2i_1
X_2920_ registers\[9\]\[3\] registers\[11\]\[3\] registers\[13\]\[3\]
+ registers\[15\]\[3\] _1821_ _1822_ VSS VSS VDD VDD _2247_
+ sky130_fd_sc_hd__mux4_1
X_2921_ registers\[8\]\[3\] registers\[10\]\[3\] registers\[12\]\[3\]
+ registers\[14\]\[3\] _2201_ _1789_ VSS VSS VDD VDD _2248_
+ sky130_fd_sc_hd__mux4_1
X_2922_ _2247_ _2248_ _2118_ VSS VSS VDD VDD _2249_ sky130_fd_sc_hd__mux2i_4
X_2923_ _2054_ _2246_ _2249_ _2062_ _2168_ VSS VSS VDD VDD
+ _2250_ sky130_fd_sc_hd__a221o_2
X_2924_ _2153_ _2240_ _2243_ _2250_ VSS VSS VDD VDD _0091_
+ sky130_fd_sc_hd__a31oi_2
X_2925_ registers\[17\]\[4\] registers\[19\]\[4\] registers\[21\]\[4\]
+ registers\[23\]\[4\] _2065_ _2121_ VSS VSS VDD VDD _2251_
+ sky130_fd_sc_hd__mux4_1
X_2926_ registers\[18\]\[4\] registers\[22\]\[4\] _2102_ VSS
+ VSS VDD VDD _2252_ sky130_fd_sc_hd__mux2i_1
X_2927_ registers\[16\]\[4\] registers\[20\]\[4\] _1837_ VSS
+ VSS VDD VDD _2253_ sky130_fd_sc_hd__mux2i_1
X_2928_ _2101_ _2252_ _2253_ _2105_ _2106_ VSS VSS VDD VDD
+ _2254_ sky130_fd_sc_hd__a221oi_1
X_2929_ _2064_ _2251_ _2254_ VSS VSS VDD VDD _2255_ sky130_fd_sc_hd__o21ai_0
X_2930_ registers\[24\]\[4\] registers\[26\]\[4\] registers\[28\]\[4\]
+ registers\[30\]\[4\] _2142_ _1790_ VSS VSS VDD VDD _2256_
+ sky130_fd_sc_hd__mux4_1
X_2931_ registers\[25\]\[4\] registers\[27\]\[4\] registers\[29\]\[4\]
+ registers\[31\]\[4\] _2193_ _1802_ VSS VSS VDD VDD _2257_
+ sky130_fd_sc_hd__mux4_1
X_2932_ _2109_ _2256_ _2257_ _2073_ VSS VSS VDD VDD _2258_
+ sky130_fd_sc_hd__a22oi_2
X_2933_ registers\[0\]\[4\] registers\[1\]\[4\] registers\[2\]\[4\]
+ registers\[3\]\[4\] _1787_ _1775_ VSS VSS VDD VDD _2259_ sky130_fd_sc_hd__mux4_1
X_2934_ registers\[4\]\[4\] registers\[5\]\[4\] registers\[6\]\[4\]
+ registers\[7\]\[4\] _1899_ _2180_ VSS VSS VDD VDD _2260_ sky130_fd_sc_hd__mux4_1
X_2935_ _2259_ _2260_ _2198_ VSS VSS VDD VDD _2261_ sky130_fd_sc_hd__mux2i_1
X_2936_ registers\[9\]\[4\] registers\[11\]\[4\] registers\[13\]\[4\]
+ registers\[15\]\[4\] _1821_ _1822_ VSS VSS VDD VDD _2262_
+ sky130_fd_sc_hd__mux4_1
X_2937_ registers\[8\]\[4\] registers\[10\]\[4\] registers\[12\]\[4\]
+ registers\[14\]\[4\] _2201_ _1789_ VSS VSS VDD VDD _2263_
+ sky130_fd_sc_hd__mux4_1
X_2938_ _2262_ _2263_ _2118_ VSS VSS VDD VDD _2264_ sky130_fd_sc_hd__mux2i_2
X_2939_ _2054_ _2261_ _2264_ _2062_ _2168_ VSS VSS VDD VDD
+ _2265_ sky130_fd_sc_hd__a221o_1
X_2940_ _2153_ _2255_ _2258_ _2265_ VSS VSS VDD VDD _0092_
+ sky130_fd_sc_hd__a31oi_1
X_2941_ registers\[25\]\[5\] registers\[27\]\[5\] registers\[29\]\[5\]
+ registers\[31\]\[5\] _1763_ _1757_ VSS VSS VDD VDD _2266_
+ sky130_fd_sc_hd__mux4_1
X_2942_ registers\[24\]\[5\] registers\[28\]\[5\] _1840_ VSS
+ VSS VDD VDD _2267_ sky130_fd_sc_hd__mux2i_1
X_2943_ _1766_ _2267_ VSS VSS VDD VDD _2268_ sky130_fd_sc_hd__nand2_1
X_2944_ registers\[26\]\[5\] registers\[30\]\[5\] _1760_ VSS
+ VSS VDD VDD _2269_ sky130_fd_sc_hd__mux2i_1
X_2945_ _1770_ _2269_ VSS VSS VDD VDD _2270_ sky130_fd_sc_hd__nand2_1
X_2946_ _1750_ _2266_ _2268_ _2270_ _1773_ VSS VSS VDD VDD
+ _2271_ sky130_fd_sc_hd__o2111ai_4
X_2947_ registers\[16\]\[5\] registers\[18\]\[5\] registers\[20\]\[5\]
+ registers\[22\]\[5\] _2142_ _1790_ VSS VSS VDD VDD _2272_
+ sky130_fd_sc_hd__mux4_1
X_2948_ registers\[17\]\[5\] registers\[19\]\[5\] registers\[21\]\[5\]
+ registers\[23\]\[5\] _2193_ _1802_ VSS VSS VDD VDD _2273_
+ sky130_fd_sc_hd__mux4_1
X_2949_ _1778_ _2272_ _2273_ _1779_ VSS VSS VDD VDD _2274_
+ sky130_fd_sc_hd__a22oi_1
X_2950_ registers\[0\]\[5\] registers\[1\]\[5\] registers\[2\]\[5\]
+ registers\[3\]\[5\] _1787_ _1775_ VSS VSS VDD VDD _2275_ sky130_fd_sc_hd__mux4_1
X_2951_ registers\[4\]\[5\] registers\[5\]\[5\] registers\[6\]\[5\]
+ registers\[7\]\[5\] _1899_ _2180_ VSS VSS VDD VDD _2276_ sky130_fd_sc_hd__mux4_1
X_2952_ _2275_ _2276_ _2198_ VSS VSS VDD VDD _2277_ sky130_fd_sc_hd__mux2i_1
X_2953_ registers\[9\]\[5\] registers\[11\]\[5\] registers\[13\]\[5\]
+ registers\[15\]\[5\] _1821_ _1822_ VSS VSS VDD VDD _2278_
+ sky130_fd_sc_hd__mux4_1
X_2954_ registers\[8\]\[5\] registers\[10\]\[5\] registers\[12\]\[5\]
+ registers\[14\]\[5\] _2201_ _1789_ VSS VSS VDD VDD _2279_
+ sky130_fd_sc_hd__mux4_1
X_2955_ _2278_ _2279_ _1749_ VSS VSS VDD VDD _2280_ sky130_fd_sc_hd__mux2i_2
X_2956_ _2054_ _2277_ _2280_ _2062_ _2168_ VSS VSS VDD VDD
+ _2281_ sky130_fd_sc_hd__a221o_2
X_2957_ _2153_ _2271_ _2274_ _2281_ VSS VSS VDD VDD _0093_
+ sky130_fd_sc_hd__a31oi_2
X_2958_ registers\[17\]\[6\] registers\[19\]\[6\] registers\[21\]\[6\]
+ registers\[23\]\[6\] _2065_ _2121_ VSS VSS VDD VDD _2282_
+ sky130_fd_sc_hd__mux4_1
X_2959_ registers\[18\]\[6\] registers\[22\]\[6\] _2102_ VSS
+ VSS VDD VDD _2283_ sky130_fd_sc_hd__mux2i_1
X_2960_ registers\[16\]\[6\] registers\[20\]\[6\] _1837_ VSS
+ VSS VDD VDD _2284_ sky130_fd_sc_hd__mux2i_1
X_2961_ _2101_ _2283_ _2284_ _2105_ _2106_ VSS VSS VDD VDD
+ _2285_ sky130_fd_sc_hd__a221oi_1
X_2962_ _2064_ _2282_ _2285_ VSS VSS VDD VDD _2286_ sky130_fd_sc_hd__o21ai_0
X_2963_ registers\[24\]\[6\] registers\[26\]\[6\] registers\[28\]\[6\]
+ registers\[30\]\[6\] _2142_ _1790_ VSS VSS VDD VDD _2287_
+ sky130_fd_sc_hd__mux4_1
X_2964_ registers\[25\]\[6\] registers\[27\]\[6\] registers\[29\]\[6\]
+ registers\[31\]\[6\] _2193_ _1802_ VSS VSS VDD VDD _2288_
+ sky130_fd_sc_hd__mux4_1
X_2965_ _2109_ _2287_ _2288_ _2073_ VSS VSS VDD VDD _2289_
+ sky130_fd_sc_hd__a22oi_2
X_2966_ registers\[8\]\[6\] registers\[9\]\[6\] registers\[10\]\[6\]
+ registers\[11\]\[6\] _1787_ _1775_ VSS VSS VDD VDD _2290_
+ sky130_fd_sc_hd__mux4_1
X_2967_ registers\[12\]\[6\] registers\[13\]\[6\] registers\[14\]\[6\]
+ registers\[15\]\[6\] _1899_ _2180_ VSS VSS VDD VDD _2291_
+ sky130_fd_sc_hd__mux4_1
X_2968_ _2290_ _2291_ _2198_ VSS VSS VDD VDD _2292_ sky130_fd_sc_hd__mux2i_1
X_2969_ registers\[1\]\[6\] registers\[3\]\[6\] registers\[5\]\[6\]
+ registers\[7\]\[6\] _1821_ _1822_ VSS VSS VDD VDD _2293_ sky130_fd_sc_hd__mux4_1
X_2970_ registers\[0\]\[6\] registers\[2\]\[6\] registers\[4\]\[6\]
+ registers\[6\]\[6\] _2201_ _1789_ VSS VSS VDD VDD _2294_ sky130_fd_sc_hd__mux4_1
X_2971_ _2293_ _2294_ _1749_ VSS VSS VDD VDD _2295_ sky130_fd_sc_hd__mux2i_1
X_2972_ _1785_ _2292_ _2295_ _1792_ _2168_ VSS VSS VDD VDD
+ _2296_ sky130_fd_sc_hd__a221o_1
X_2973_ _2153_ _2286_ _2289_ _2296_ VSS VSS VDD VDD _0094_
+ sky130_fd_sc_hd__a31oi_1
X_2974_ registers\[17\]\[7\] registers\[19\]\[7\] registers\[21\]\[7\]
+ registers\[23\]\[7\] _1780_ _2121_ VSS VSS VDD VDD _2297_
+ sky130_fd_sc_hd__mux4_1
X_2975_ registers\[18\]\[7\] registers\[22\]\[7\] _2102_ VSS
+ VSS VDD VDD _2298_ sky130_fd_sc_hd__mux2i_1
X_2976_ registers\[16\]\[7\] registers\[20\]\[7\] _1837_ VSS
+ VSS VDD VDD _2299_ sky130_fd_sc_hd__mux2i_1
X_2977_ _2101_ _2298_ _2299_ _2105_ _2106_ VSS VSS VDD VDD
+ _2300_ sky130_fd_sc_hd__a221oi_1
X_2978_ _1751_ _2297_ _2300_ VSS VSS VDD VDD _2301_ sky130_fd_sc_hd__o21ai_1
X_2979_ registers\[24\]\[7\] registers\[26\]\[7\] registers\[28\]\[7\]
+ registers\[30\]\[7\] _1754_ _1790_ VSS VSS VDD VDD _2302_
+ sky130_fd_sc_hd__mux4_1
X_2980_ registers\[25\]\[7\] registers\[27\]\[7\] registers\[29\]\[7\]
+ registers\[31\]\[7\] _2193_ _1802_ VSS VSS VDD VDD _2303_
+ sky130_fd_sc_hd__mux4_1
X_2981_ _2109_ _2302_ _2303_ _1811_ VSS VSS VDD VDD _2304_
+ sky130_fd_sc_hd__a22oi_4
X_2982_ registers\[0\]\[7\] registers\[1\]\[7\] registers\[2\]\[7\]
+ registers\[3\]\[7\] _1787_ _1775_ VSS VSS VDD VDD _2305_ sky130_fd_sc_hd__mux4_1
X_2983_ registers\[4\]\[7\] registers\[5\]\[7\] registers\[6\]\[7\]
+ registers\[7\]\[7\] _1899_ _2180_ VSS VSS VDD VDD _2306_ sky130_fd_sc_hd__mux4_1
X_2984_ _2305_ _2306_ _2198_ VSS VSS VDD VDD _2307_ sky130_fd_sc_hd__mux2i_1
X_2985_ registers\[9\]\[7\] registers\[11\]\[7\] registers\[13\]\[7\]
+ registers\[15\]\[7\] _1821_ _1822_ VSS VSS VDD VDD _2308_
+ sky130_fd_sc_hd__mux4_1
X_2986_ registers\[8\]\[7\] registers\[10\]\[7\] registers\[12\]\[7\]
+ registers\[14\]\[7\] _2201_ _1789_ VSS VSS VDD VDD _2309_
+ sky130_fd_sc_hd__mux4_1
X_2987_ _2308_ _2309_ _1749_ VSS VSS VDD VDD _2310_ sky130_fd_sc_hd__mux2i_1
X_2988_ _1923_ _2307_ _2310_ _1784_ _2168_ VSS VSS VDD VDD
+ _2311_ sky130_fd_sc_hd__a221o_2
X_2989_ _2153_ _2301_ _2304_ _2311_ VSS VSS VDD VDD _0095_
+ sky130_fd_sc_hd__a31oi_4
X_2990_ registers\[17\]\[8\] registers\[19\]\[8\] registers\[21\]\[8\]
+ registers\[23\]\[8\] _1780_ _2121_ VSS VSS VDD VDD _2312_
+ sky130_fd_sc_hd__mux4_1
X_2991_ registers\[18\]\[8\] registers\[22\]\[8\] _1759_ VSS
+ VSS VDD VDD _2313_ sky130_fd_sc_hd__mux2i_1
X_2992_ registers\[16\]\[8\] registers\[20\]\[8\] _1837_ VSS
+ VSS VDD VDD _2314_ sky130_fd_sc_hd__mux2i_1
X_2993_ _1769_ _2313_ _2314_ _1765_ _1772_ VSS VSS VDD VDD
+ _2315_ sky130_fd_sc_hd__a221oi_1
X_2994_ _1751_ _2312_ _2315_ VSS VSS VDD VDD _2316_ sky130_fd_sc_hd__o21ai_1
X_2995_ registers\[24\]\[8\] registers\[26\]\[8\] registers\[28\]\[8\]
+ registers\[30\]\[8\] _1754_ _1790_ VSS VSS VDD VDD _2317_
+ sky130_fd_sc_hd__mux4_1
X_2996_ registers\[25\]\[8\] registers\[27\]\[8\] registers\[29\]\[8\]
+ registers\[31\]\[8\] _2193_ _1802_ VSS VSS VDD VDD _2318_
+ sky130_fd_sc_hd__mux4_1
X_2997_ _1809_ _2317_ _2318_ _1811_ VSS VSS VDD VDD _2319_
+ sky130_fd_sc_hd__a22oi_4
X_2998_ registers\[8\]\[8\] registers\[9\]\[8\] registers\[10\]\[8\]
+ registers\[11\]\[8\] _1787_ _1775_ VSS VSS VDD VDD _2320_
+ sky130_fd_sc_hd__mux4_1
X_2999_ registers\[12\]\[8\] registers\[13\]\[8\] registers\[14\]\[8\]
+ registers\[15\]\[8\] _1899_ _2180_ VSS VSS VDD VDD _2321_
+ sky130_fd_sc_hd__mux4_1
X_3000_ _2320_ _2321_ _2198_ VSS VSS VDD VDD _2322_ sky130_fd_sc_hd__mux2i_1
X_3001_ registers\[1\]\[8\] registers\[3\]\[8\] registers\[5\]\[8\]
+ registers\[7\]\[8\] _1821_ _1822_ VSS VSS VDD VDD _2323_ sky130_fd_sc_hd__mux4_1
X_3002_ registers\[0\]\[8\] registers\[2\]\[8\] registers\[4\]\[8\]
+ registers\[6\]\[8\] _2201_ _1789_ VSS VSS VDD VDD _2324_ sky130_fd_sc_hd__mux4_1
X_3003_ _2323_ _2324_ _1749_ VSS VSS VDD VDD _2325_ sky130_fd_sc_hd__mux2i_1
X_3004_ _1825_ _2322_ _2325_ _1792_ _1797_ VSS VSS VDD VDD
+ _2326_ sky130_fd_sc_hd__a221o_2
X_3005_ _1745_ _2316_ _2319_ _2326_ VSS VSS VDD VDD _0096_
+ sky130_fd_sc_hd__a31oi_4
X_3006_ registers\[17\]\[9\] registers\[19\]\[9\] registers\[21\]\[9\]
+ registers\[23\]\[9\] _1780_ _1776_ VSS VSS VDD VDD _2327_
+ sky130_fd_sc_hd__mux4_1
X_3007_ registers\[18\]\[9\] registers\[22\]\[9\] _1759_ VSS
+ VSS VDD VDD _2328_ sky130_fd_sc_hd__mux2i_1
X_3008_ registers\[16\]\[9\] registers\[20\]\[9\] _1837_ VSS
+ VSS VDD VDD _2329_ sky130_fd_sc_hd__mux2i_1
X_3009_ _1769_ _2328_ _2329_ _1765_ _1772_ VSS VSS VDD VDD
+ _2330_ sky130_fd_sc_hd__a221oi_1
X_3010_ _1751_ _2327_ _2330_ VSS VSS VDD VDD _2331_ sky130_fd_sc_hd__o21ai_1
X_3011_ registers\[24\]\[9\] registers\[26\]\[9\] registers\[28\]\[9\]
+ registers\[30\]\[9\] _1754_ _1790_ VSS VSS VDD VDD _2332_
+ sky130_fd_sc_hd__mux4_1
X_3012_ registers\[25\]\[9\] registers\[27\]\[9\] registers\[29\]\[9\]
+ registers\[31\]\[9\] _2193_ _1802_ VSS VSS VDD VDD _2333_
+ sky130_fd_sc_hd__mux4_1
X_3013_ _1809_ _2332_ _2333_ _1811_ VSS VSS VDD VDD _2334_
+ sky130_fd_sc_hd__a22oi_4
X_3014_ registers\[0\]\[9\] registers\[1\]\[9\] registers\[2\]\[9\]
+ registers\[3\]\[9\] _1787_ _1775_ VSS VSS VDD VDD _2335_ sky130_fd_sc_hd__mux4_1
X_3015_ registers\[4\]\[9\] registers\[5\]\[9\] registers\[6\]\[9\]
+ registers\[7\]\[9\] _1899_ _1764_ VSS VSS VDD VDD _2336_ sky130_fd_sc_hd__mux4_1
X_3016_ _2335_ _2336_ _2198_ VSS VSS VDD VDD _2337_ sky130_fd_sc_hd__mux2i_1
X_3017_ registers\[9\]\[9\] registers\[11\]\[9\] registers\[13\]\[9\]
+ registers\[15\]\[9\] _1821_ _1822_ VSS VSS VDD VDD _2338_
+ sky130_fd_sc_hd__mux4_1
X_3018_ registers\[8\]\[9\] registers\[10\]\[9\] registers\[12\]\[9\]
+ registers\[14\]\[9\] _2201_ _1789_ VSS VSS VDD VDD _2339_
+ sky130_fd_sc_hd__mux4_1
X_3019_ _2338_ _2339_ _1749_ VSS VSS VDD VDD _2340_ sky130_fd_sc_hd__mux2i_1
X_3020_ _1923_ _2337_ _2340_ _1784_ _1797_ VSS VSS VDD VDD
+ _2341_ sky130_fd_sc_hd__a221o_2
X_3021_ _1745_ _2331_ _2334_ _2341_ VSS VSS VDD VDD _0097_
+ sky130_fd_sc_hd__a31oi_4
X_3022_ net11 VSS VSS VDD VDD _2342_ sky130_fd_sc_hd__buf_2
X_3023_ _1124_ _1128_ VSS VSS VDD VDD _2343_ sky130_fd_sc_hd__nor2_4
X_3024_ _2343_ VSS VSS VDD VDD _2344_ sky130_fd_sc_hd__clkbuf_4
X_3025_ _2342_ _2344_ VSS VSS VDD VDD _0098_ sky130_fd_sc_hd__and2_0
X_3026_ net12 VSS VSS VDD VDD _2345_ sky130_fd_sc_hd__buf_2
X_3027_ _2345_ _2344_ VSS VSS VDD VDD _0099_ sky130_fd_sc_hd__and2_0
X_3028_ net13 VSS VSS VDD VDD _2346_ sky130_fd_sc_hd__buf_2
X_3029_ _2346_ _2344_ VSS VSS VDD VDD _0100_ sky130_fd_sc_hd__and2_0
X_3030_ net14 VSS VSS VDD VDD _2347_ sky130_fd_sc_hd__clkbuf_4
X_3031_ _2347_ _2344_ VSS VSS VDD VDD _0101_ sky130_fd_sc_hd__and2_0
X_3032_ net15 VSS VSS VDD VDD _2348_ sky130_fd_sc_hd__clkbuf_4
X_3033_ _2348_ _2344_ VSS VSS VDD VDD _0102_ sky130_fd_sc_hd__and2_0
X_3034_ net16 VSS VSS VDD VDD _2349_ sky130_fd_sc_hd__clkbuf_4
X_3035_ _2349_ _2344_ VSS VSS VDD VDD _0103_ sky130_fd_sc_hd__and2_0
X_3036_ net17 VSS VSS VDD VDD _2350_ sky130_fd_sc_hd__buf_4
X_3037_ _2350_ _2344_ VSS VSS VDD VDD _0104_ sky130_fd_sc_hd__and2_0
X_3038_ net18 VSS VSS VDD VDD _2351_ sky130_fd_sc_hd__buf_4
X_3039_ _2351_ _2344_ VSS VSS VDD VDD _0105_ sky130_fd_sc_hd__and2_0
X_3040_ net19 VSS VSS VDD VDD _2352_ sky130_fd_sc_hd__clkbuf_4
X_3041_ _2352_ _2344_ VSS VSS VDD VDD _0106_ sky130_fd_sc_hd__and2_0
X_3042_ net20 VSS VSS VDD VDD _2353_ sky130_fd_sc_hd__buf_4
X_3043_ _2353_ _2344_ VSS VSS VDD VDD _0107_ sky130_fd_sc_hd__and2_0
X_3044_ net21 VSS VSS VDD VDD _2354_ sky130_fd_sc_hd__clkbuf_4
X_3045_ _2343_ VSS VSS VDD VDD _2355_ sky130_fd_sc_hd__buf_4
X_3046_ _2354_ _2355_ VSS VSS VDD VDD _0108_ sky130_fd_sc_hd__and2_0
X_3047_ net22 VSS VSS VDD VDD _2356_ sky130_fd_sc_hd__clkbuf_4
X_3048_ _2356_ _2355_ VSS VSS VDD VDD _0109_ sky130_fd_sc_hd__and2_0
X_3049_ net23 VSS VSS VDD VDD _2357_ sky130_fd_sc_hd__clkbuf_4
X_3050_ _2357_ _2355_ VSS VSS VDD VDD _0110_ sky130_fd_sc_hd__and2_0
X_3051_ net24 VSS VSS VDD VDD _2358_ sky130_fd_sc_hd__clkbuf_4
X_3052_ _2358_ _2355_ VSS VSS VDD VDD _0111_ sky130_fd_sc_hd__and2_0
X_3053_ net25 VSS VSS VDD VDD _2359_ sky130_fd_sc_hd__clkbuf_4
X_3054_ _2359_ _2355_ VSS VSS VDD VDD _0112_ sky130_fd_sc_hd__and2_0
X_3055_ net26 VSS VSS VDD VDD _2360_ sky130_fd_sc_hd__clkbuf_4
X_3056_ _2360_ _2355_ VSS VSS VDD VDD _0113_ sky130_fd_sc_hd__and2_0
X_3057_ net27 VSS VSS VDD VDD _2361_ sky130_fd_sc_hd__clkbuf_4
X_3058_ _2361_ _2355_ VSS VSS VDD VDD _0114_ sky130_fd_sc_hd__and2_0
X_3059_ net28 VSS VSS VDD VDD _2362_ sky130_fd_sc_hd__clkbuf_4
X_3060_ _2362_ _2355_ VSS VSS VDD VDD _0115_ sky130_fd_sc_hd__and2_0
X_3061_ net29 VSS VSS VDD VDD _2363_ sky130_fd_sc_hd__clkbuf_4
X_3062_ _2363_ _2355_ VSS VSS VDD VDD _0116_ sky130_fd_sc_hd__and2_0
X_3063_ net30 VSS VSS VDD VDD _2364_ sky130_fd_sc_hd__clkbuf_4
X_3064_ _2364_ _2355_ VSS VSS VDD VDD _0117_ sky130_fd_sc_hd__and2_0
X_3065_ net31 VSS VSS VDD VDD _2365_ sky130_fd_sc_hd__clkbuf_4
X_3066_ _2343_ VSS VSS VDD VDD _2366_ sky130_fd_sc_hd__buf_4
X_3067_ _2365_ _2366_ VSS VSS VDD VDD _0118_ sky130_fd_sc_hd__and2_0
X_3068_ net32 VSS VSS VDD VDD _2367_ sky130_fd_sc_hd__clkbuf_4
X_3069_ _2367_ _2366_ VSS VSS VDD VDD _0119_ sky130_fd_sc_hd__and2_0
X_3070_ net33 VSS VSS VDD VDD _2368_ sky130_fd_sc_hd__buf_4
X_3071_ _2368_ _2366_ VSS VSS VDD VDD _0120_ sky130_fd_sc_hd__and2_0
X_3072_ net34 VSS VSS VDD VDD _2369_ sky130_fd_sc_hd__buf_4
X_3073_ _2369_ _2366_ VSS VSS VDD VDD _0121_ sky130_fd_sc_hd__and2_0
X_3074_ net35 VSS VSS VDD VDD _2370_ sky130_fd_sc_hd__clkbuf_4
X_3075_ _2370_ _2366_ VSS VSS VDD VDD _0122_ sky130_fd_sc_hd__and2_0
X_3076_ net36 VSS VSS VDD VDD _2371_ sky130_fd_sc_hd__clkbuf_4
X_3077_ _2371_ _2366_ VSS VSS VDD VDD _0123_ sky130_fd_sc_hd__and2_0
X_3078_ net37 VSS VSS VDD VDD _2372_ sky130_fd_sc_hd__clkbuf_4
X_3079_ _2372_ _2366_ VSS VSS VDD VDD _0124_ sky130_fd_sc_hd__and2_0
X_3080_ net38 VSS VSS VDD VDD _2373_ sky130_fd_sc_hd__clkbuf_4
X_3081_ _2373_ _2366_ VSS VSS VDD VDD _0125_ sky130_fd_sc_hd__and2_0
X_3082_ net39 VSS VSS VDD VDD _2374_ sky130_fd_sc_hd__clkbuf_4
X_3083_ _2374_ _2366_ VSS VSS VDD VDD _0126_ sky130_fd_sc_hd__and2_0
X_3084_ net40 VSS VSS VDD VDD _2375_ sky130_fd_sc_hd__buf_2
X_3085_ _2375_ _2366_ VSS VSS VDD VDD _0127_ sky130_fd_sc_hd__and2_0
X_3086_ net41 VSS VSS VDD VDD _2376_ sky130_fd_sc_hd__buf_2
X_3087_ _2376_ _2343_ VSS VSS VDD VDD _0128_ sky130_fd_sc_hd__and2_0
X_3088_ net42 VSS VSS VDD VDD _2377_ sky130_fd_sc_hd__buf_2
X_3089_ _2377_ _2343_ VSS VSS VDD VDD _0129_ sky130_fd_sc_hd__and2_0
X_3090_ _1131_ _1133_ VSS VSS VDD VDD _2378_ sky130_fd_sc_hd__nor2_4
X_3091_ _2378_ VSS VSS VDD VDD _2379_ sky130_fd_sc_hd__buf_4
X_3092_ _2342_ _2379_ VSS VSS VDD VDD _0130_ sky130_fd_sc_hd__and2_0
X_3093_ _2345_ _2379_ VSS VSS VDD VDD _0131_ sky130_fd_sc_hd__and2_0
X_3094_ _2346_ _2379_ VSS VSS VDD VDD _0132_ sky130_fd_sc_hd__and2_0
X_3095_ _2347_ _2379_ VSS VSS VDD VDD _0133_ sky130_fd_sc_hd__and2_0
X_3096_ _2348_ _2379_ VSS VSS VDD VDD _0134_ sky130_fd_sc_hd__and2_0
X_3097_ _2349_ _2379_ VSS VSS VDD VDD _0135_ sky130_fd_sc_hd__and2_0
X_3098_ _2350_ _2379_ VSS VSS VDD VDD _0136_ sky130_fd_sc_hd__and2_0
X_3099_ _2351_ _2379_ VSS VSS VDD VDD _0137_ sky130_fd_sc_hd__and2_0
X_3100_ _2352_ _2379_ VSS VSS VDD VDD _0138_ sky130_fd_sc_hd__and2_0
X_3101_ _2353_ _2379_ VSS VSS VDD VDD _0139_ sky130_fd_sc_hd__and2_0
X_3102_ _2378_ VSS VSS VDD VDD _2380_ sky130_fd_sc_hd__clkbuf_4
X_3103_ _2354_ _2380_ VSS VSS VDD VDD _0140_ sky130_fd_sc_hd__and2_0
X_3104_ _2356_ _2380_ VSS VSS VDD VDD _0141_ sky130_fd_sc_hd__and2_0
X_3105_ _2357_ _2380_ VSS VSS VDD VDD _0142_ sky130_fd_sc_hd__and2_0
X_3106_ _2358_ _2380_ VSS VSS VDD VDD _0143_ sky130_fd_sc_hd__and2_0
X_3107_ _2359_ _2380_ VSS VSS VDD VDD _0144_ sky130_fd_sc_hd__and2_0
X_3108_ _2360_ _2380_ VSS VSS VDD VDD _0145_ sky130_fd_sc_hd__and2_0
X_3109_ _2361_ _2380_ VSS VSS VDD VDD _0146_ sky130_fd_sc_hd__and2_0
X_3110_ _2362_ _2380_ VSS VSS VDD VDD _0147_ sky130_fd_sc_hd__and2_0
X_3111_ _2363_ _2380_ VSS VSS VDD VDD _0148_ sky130_fd_sc_hd__and2_0
X_3112_ _2364_ _2380_ VSS VSS VDD VDD _0149_ sky130_fd_sc_hd__and2_0
X_3113_ _2378_ VSS VSS VDD VDD _2381_ sky130_fd_sc_hd__buf_4
X_3114_ _2365_ _2381_ VSS VSS VDD VDD _0150_ sky130_fd_sc_hd__and2_0
X_3115_ _2367_ _2381_ VSS VSS VDD VDD _0151_ sky130_fd_sc_hd__and2_0
X_3116_ _2368_ _2381_ VSS VSS VDD VDD _0152_ sky130_fd_sc_hd__and2_0
X_3117_ _2369_ _2381_ VSS VSS VDD VDD _0153_ sky130_fd_sc_hd__and2_0
X_3118_ _2370_ _2381_ VSS VSS VDD VDD _0154_ sky130_fd_sc_hd__and2_0
X_3119_ _2371_ _2381_ VSS VSS VDD VDD _0155_ sky130_fd_sc_hd__and2_0
X_3120_ _2372_ _2381_ VSS VSS VDD VDD _0156_ sky130_fd_sc_hd__and2_0
X_3121_ _2373_ _2381_ VSS VSS VDD VDD _0157_ sky130_fd_sc_hd__and2_0
X_3122_ _2374_ _2381_ VSS VSS VDD VDD _0158_ sky130_fd_sc_hd__and2_0
X_3123_ _2375_ _2381_ VSS VSS VDD VDD _0159_ sky130_fd_sc_hd__and2_0
X_3124_ _2376_ _2378_ VSS VSS VDD VDD _0160_ sky130_fd_sc_hd__and2_0
X_3125_ _2377_ _2378_ VSS VSS VDD VDD _0161_ sky130_fd_sc_hd__and2_0
X_3126_ _1131_ _1135_ VSS VSS VDD VDD _2382_ sky130_fd_sc_hd__nor2_4
X_3127_ _2382_ VSS VSS VDD VDD _2383_ sky130_fd_sc_hd__clkbuf_8
X_3128_ _2342_ _2383_ VSS VSS VDD VDD _0162_ sky130_fd_sc_hd__and2_0
X_3129_ _2345_ _2383_ VSS VSS VDD VDD _0163_ sky130_fd_sc_hd__and2_0
X_3130_ _2346_ _2383_ VSS VSS VDD VDD _0164_ sky130_fd_sc_hd__and2_0
X_3131_ _2347_ _2383_ VSS VSS VDD VDD _0165_ sky130_fd_sc_hd__and2_0
X_3132_ _2348_ _2383_ VSS VSS VDD VDD _0166_ sky130_fd_sc_hd__and2_0
X_3133_ _2349_ _2383_ VSS VSS VDD VDD _0167_ sky130_fd_sc_hd__and2_0
X_3134_ _2350_ _2383_ VSS VSS VDD VDD _0168_ sky130_fd_sc_hd__and2_0
X_3135_ _2351_ _2383_ VSS VSS VDD VDD _0169_ sky130_fd_sc_hd__and2_0
X_3136_ _2352_ _2383_ VSS VSS VDD VDD _0170_ sky130_fd_sc_hd__and2_0
X_3137_ _2353_ _2383_ VSS VSS VDD VDD _0171_ sky130_fd_sc_hd__and2_0
X_3138_ _2382_ VSS VSS VDD VDD _2384_ sky130_fd_sc_hd__buf_2
X_3139_ _2354_ _2384_ VSS VSS VDD VDD _0172_ sky130_fd_sc_hd__and2_0
X_3140_ _2356_ _2384_ VSS VSS VDD VDD _0173_ sky130_fd_sc_hd__and2_0
X_3141_ _2357_ _2384_ VSS VSS VDD VDD _0174_ sky130_fd_sc_hd__and2_0
X_3142_ _2358_ _2384_ VSS VSS VDD VDD _0175_ sky130_fd_sc_hd__and2_0
X_3143_ _2359_ _2384_ VSS VSS VDD VDD _0176_ sky130_fd_sc_hd__and2_0
X_3144_ _2360_ _2384_ VSS VSS VDD VDD _0177_ sky130_fd_sc_hd__and2_0
X_3145_ _2361_ _2384_ VSS VSS VDD VDD _0178_ sky130_fd_sc_hd__and2_0
X_3146_ _2362_ _2384_ VSS VSS VDD VDD _0179_ sky130_fd_sc_hd__and2_0
X_3147_ _2363_ _2384_ VSS VSS VDD VDD _0180_ sky130_fd_sc_hd__and2_0
X_3148_ _2364_ _2384_ VSS VSS VDD VDD _0181_ sky130_fd_sc_hd__and2_0
X_3149_ _2382_ VSS VSS VDD VDD _2385_ sky130_fd_sc_hd__buf_4
X_3150_ _2365_ _2385_ VSS VSS VDD VDD _0182_ sky130_fd_sc_hd__and2_0
X_3151_ _2367_ _2385_ VSS VSS VDD VDD _0183_ sky130_fd_sc_hd__and2_0
X_3152_ _2368_ _2385_ VSS VSS VDD VDD _0184_ sky130_fd_sc_hd__and2_0
X_3153_ _2369_ _2385_ VSS VSS VDD VDD _0185_ sky130_fd_sc_hd__and2_0
X_3154_ _2370_ _2385_ VSS VSS VDD VDD _0186_ sky130_fd_sc_hd__and2_0
X_3155_ _2371_ _2385_ VSS VSS VDD VDD _0187_ sky130_fd_sc_hd__and2_0
X_3156_ _2372_ _2385_ VSS VSS VDD VDD _0188_ sky130_fd_sc_hd__and2_0
X_3157_ _2373_ _2385_ VSS VSS VDD VDD _0189_ sky130_fd_sc_hd__and2_0
X_3158_ _2374_ _2385_ VSS VSS VDD VDD _0190_ sky130_fd_sc_hd__and2_0
X_3159_ _2375_ _2385_ VSS VSS VDD VDD _0191_ sky130_fd_sc_hd__and2_0
X_3160_ _2376_ _2382_ VSS VSS VDD VDD _0192_ sky130_fd_sc_hd__and2_0
X_3161_ _2377_ _2382_ VSS VSS VDD VDD _0193_ sky130_fd_sc_hd__and2_0
X_3162_ _1128_ _1136_ VSS VSS VDD VDD _2386_ sky130_fd_sc_hd__nor2_8
X_3163_ _2386_ VSS VSS VDD VDD _2387_ sky130_fd_sc_hd__buf_4
X_3164_ _2342_ _2387_ VSS VSS VDD VDD _0194_ sky130_fd_sc_hd__and2_0
X_3165_ _2345_ _2387_ VSS VSS VDD VDD _0195_ sky130_fd_sc_hd__and2_0
X_3166_ _2346_ _2387_ VSS VSS VDD VDD _0196_ sky130_fd_sc_hd__and2_0
X_3167_ _2347_ _2387_ VSS VSS VDD VDD _0197_ sky130_fd_sc_hd__and2_0
X_3168_ _2348_ _2387_ VSS VSS VDD VDD _0198_ sky130_fd_sc_hd__and2_0
X_3169_ _2349_ _2387_ VSS VSS VDD VDD _0199_ sky130_fd_sc_hd__and2_0
X_3170_ _2350_ _2387_ VSS VSS VDD VDD _0200_ sky130_fd_sc_hd__and2_0
X_3171_ _2351_ _2387_ VSS VSS VDD VDD _0201_ sky130_fd_sc_hd__and2_0
X_3172_ _2352_ _2387_ VSS VSS VDD VDD _0202_ sky130_fd_sc_hd__and2_0
X_3173_ _2353_ _2387_ VSS VSS VDD VDD _0203_ sky130_fd_sc_hd__and2_0
X_3174_ _2386_ VSS VSS VDD VDD _2388_ sky130_fd_sc_hd__clkbuf_4
X_3175_ _2354_ _2388_ VSS VSS VDD VDD _0204_ sky130_fd_sc_hd__and2_0
X_3176_ _2356_ _2388_ VSS VSS VDD VDD _0205_ sky130_fd_sc_hd__and2_0
X_3177_ _2357_ _2388_ VSS VSS VDD VDD _0206_ sky130_fd_sc_hd__and2_0
X_3178_ _2358_ _2388_ VSS VSS VDD VDD _0207_ sky130_fd_sc_hd__and2_0
X_3179_ _2359_ _2388_ VSS VSS VDD VDD _0208_ sky130_fd_sc_hd__and2_0
X_3180_ _2360_ _2388_ VSS VSS VDD VDD _0209_ sky130_fd_sc_hd__and2_0
X_3181_ _2361_ _2388_ VSS VSS VDD VDD _0210_ sky130_fd_sc_hd__and2_0
X_3182_ _2362_ _2388_ VSS VSS VDD VDD _0211_ sky130_fd_sc_hd__and2_0
X_3183_ _2363_ _2388_ VSS VSS VDD VDD _0212_ sky130_fd_sc_hd__and2_0
X_3184_ _2364_ _2388_ VSS VSS VDD VDD _0213_ sky130_fd_sc_hd__and2_0
X_3185_ _2386_ VSS VSS VDD VDD _2389_ sky130_fd_sc_hd__buf_4
X_3186_ _2365_ _2389_ VSS VSS VDD VDD _0214_ sky130_fd_sc_hd__and2_0
X_3187_ _2367_ _2389_ VSS VSS VDD VDD _0215_ sky130_fd_sc_hd__and2_0
X_3188_ _2368_ _2389_ VSS VSS VDD VDD _0216_ sky130_fd_sc_hd__and2_0
X_3189_ _2369_ _2389_ VSS VSS VDD VDD _0217_ sky130_fd_sc_hd__and2_0
X_3190_ _2370_ _2389_ VSS VSS VDD VDD _0218_ sky130_fd_sc_hd__and2_0
X_3191_ _2371_ _2389_ VSS VSS VDD VDD _0219_ sky130_fd_sc_hd__and2_0
X_3192_ _2372_ _2389_ VSS VSS VDD VDD _0220_ sky130_fd_sc_hd__and2_0
X_3193_ _2373_ _2389_ VSS VSS VDD VDD _0221_ sky130_fd_sc_hd__and2_0
X_3194_ _2374_ _2389_ VSS VSS VDD VDD _0222_ sky130_fd_sc_hd__and2_0
X_3195_ _2375_ _2389_ VSS VSS VDD VDD _0223_ sky130_fd_sc_hd__and2_0
X_3196_ _2376_ _2386_ VSS VSS VDD VDD _0224_ sky130_fd_sc_hd__and2_0
X_3197_ _2377_ _2386_ VSS VSS VDD VDD _0225_ sky130_fd_sc_hd__and2_0
X_3198_ _1136_ _1138_ VSS VSS VDD VDD _2390_ sky130_fd_sc_hd__nor2_8
X_3199_ _2390_ VSS VSS VDD VDD _2391_ sky130_fd_sc_hd__buf_4
X_3200_ _2342_ _2391_ VSS VSS VDD VDD _0226_ sky130_fd_sc_hd__and2_0
X_3201_ _2345_ _2391_ VSS VSS VDD VDD _0227_ sky130_fd_sc_hd__and2_0
X_3202_ _2346_ _2391_ VSS VSS VDD VDD _0228_ sky130_fd_sc_hd__and2_0
X_3203_ _2347_ _2391_ VSS VSS VDD VDD _0229_ sky130_fd_sc_hd__and2_0
X_3204_ _2348_ _2391_ VSS VSS VDD VDD _0230_ sky130_fd_sc_hd__and2_0
X_3205_ _2349_ _2391_ VSS VSS VDD VDD _0231_ sky130_fd_sc_hd__and2_0
X_3206_ _2350_ _2391_ VSS VSS VDD VDD _0232_ sky130_fd_sc_hd__and2_0
X_3207_ _2351_ _2391_ VSS VSS VDD VDD _0233_ sky130_fd_sc_hd__and2_0
X_3208_ _2352_ _2391_ VSS VSS VDD VDD _0234_ sky130_fd_sc_hd__and2_0
X_3209_ _2353_ _2391_ VSS VSS VDD VDD _0235_ sky130_fd_sc_hd__and2_0
X_3210_ _2390_ VSS VSS VDD VDD _2392_ sky130_fd_sc_hd__buf_2
X_3211_ _2354_ _2392_ VSS VSS VDD VDD _0236_ sky130_fd_sc_hd__and2_0
X_3212_ _2356_ _2392_ VSS VSS VDD VDD _0237_ sky130_fd_sc_hd__and2_0
X_3213_ _2357_ _2392_ VSS VSS VDD VDD _0238_ sky130_fd_sc_hd__and2_0
X_3214_ _2358_ _2392_ VSS VSS VDD VDD _0239_ sky130_fd_sc_hd__and2_0
X_3215_ _2359_ _2392_ VSS VSS VDD VDD _0240_ sky130_fd_sc_hd__and2_0
X_3216_ _2360_ _2392_ VSS VSS VDD VDD _0241_ sky130_fd_sc_hd__and2_0
X_3217_ _2361_ _2392_ VSS VSS VDD VDD _0242_ sky130_fd_sc_hd__and2_0
X_3218_ _2362_ _2392_ VSS VSS VDD VDD _0243_ sky130_fd_sc_hd__and2_0
X_3219_ _2363_ _2392_ VSS VSS VDD VDD _0244_ sky130_fd_sc_hd__and2_0
X_3220_ _2364_ _2392_ VSS VSS VDD VDD _0245_ sky130_fd_sc_hd__and2_0
X_3221_ _2390_ VSS VSS VDD VDD _2393_ sky130_fd_sc_hd__buf_4
X_3222_ _2365_ _2393_ VSS VSS VDD VDD _0246_ sky130_fd_sc_hd__and2_0
X_3223_ _2367_ _2393_ VSS VSS VDD VDD _0247_ sky130_fd_sc_hd__and2_0
X_3224_ _2368_ _2393_ VSS VSS VDD VDD _0248_ sky130_fd_sc_hd__and2_0
X_3225_ _2369_ _2393_ VSS VSS VDD VDD _0249_ sky130_fd_sc_hd__and2_0
X_3226_ _2370_ _2393_ VSS VSS VDD VDD _0250_ sky130_fd_sc_hd__and2_0
X_3227_ _2371_ _2393_ VSS VSS VDD VDD _0251_ sky130_fd_sc_hd__and2_0
X_3228_ _2372_ _2393_ VSS VSS VDD VDD _0252_ sky130_fd_sc_hd__and2_0
X_3229_ _2373_ _2393_ VSS VSS VDD VDD _0253_ sky130_fd_sc_hd__and2_0
X_3230_ _2374_ _2393_ VSS VSS VDD VDD _0254_ sky130_fd_sc_hd__and2_0
X_3231_ _2375_ _2393_ VSS VSS VDD VDD _0255_ sky130_fd_sc_hd__and2_0
X_3232_ _2376_ _2390_ VSS VSS VDD VDD _0256_ sky130_fd_sc_hd__and2_0
X_3233_ _2377_ _2390_ VSS VSS VDD VDD _0257_ sky130_fd_sc_hd__and2_0
X_3234_ _1132_ _1136_ VSS VSS VDD VDD _2394_ sky130_fd_sc_hd__nor2_8
X_3235_ _2394_ VSS VSS VDD VDD _2395_ sky130_fd_sc_hd__buf_4
X_3236_ _2342_ _2395_ VSS VSS VDD VDD _0258_ sky130_fd_sc_hd__and2_0
X_3237_ _2345_ _2395_ VSS VSS VDD VDD _0259_ sky130_fd_sc_hd__and2_0
X_3238_ _2346_ _2395_ VSS VSS VDD VDD _0260_ sky130_fd_sc_hd__and2_0
X_3239_ _2347_ _2395_ VSS VSS VDD VDD _0261_ sky130_fd_sc_hd__and2_0
X_3240_ _2348_ _2395_ VSS VSS VDD VDD _0262_ sky130_fd_sc_hd__and2_0
X_3241_ _2349_ _2395_ VSS VSS VDD VDD _0263_ sky130_fd_sc_hd__and2_0
X_3242_ _2350_ _2395_ VSS VSS VDD VDD _0264_ sky130_fd_sc_hd__and2_0
X_3243_ _2351_ _2395_ VSS VSS VDD VDD _0265_ sky130_fd_sc_hd__and2_0
X_3244_ _2352_ _2395_ VSS VSS VDD VDD _0266_ sky130_fd_sc_hd__and2_0
X_3245_ _2353_ _2395_ VSS VSS VDD VDD _0267_ sky130_fd_sc_hd__and2_0
X_3246_ _2394_ VSS VSS VDD VDD _2396_ sky130_fd_sc_hd__buf_2
X_3247_ _2354_ _2396_ VSS VSS VDD VDD _0268_ sky130_fd_sc_hd__and2_0
X_3248_ _2356_ _2396_ VSS VSS VDD VDD _0269_ sky130_fd_sc_hd__and2_0
X_3249_ _2357_ _2396_ VSS VSS VDD VDD _0270_ sky130_fd_sc_hd__and2_0
X_3250_ _2358_ _2396_ VSS VSS VDD VDD _0271_ sky130_fd_sc_hd__and2_0
X_3251_ _2359_ _2396_ VSS VSS VDD VDD _0272_ sky130_fd_sc_hd__and2_0
X_3252_ _2360_ _2396_ VSS VSS VDD VDD _0273_ sky130_fd_sc_hd__and2_0
X_3253_ _2361_ _2396_ VSS VSS VDD VDD _0274_ sky130_fd_sc_hd__and2_0
X_3254_ _2362_ _2396_ VSS VSS VDD VDD _0275_ sky130_fd_sc_hd__and2_0
X_3255_ _2363_ _2396_ VSS VSS VDD VDD _0276_ sky130_fd_sc_hd__and2_0
X_3256_ _2364_ _2396_ VSS VSS VDD VDD _0277_ sky130_fd_sc_hd__and2_0
X_3257_ _2394_ VSS VSS VDD VDD _2397_ sky130_fd_sc_hd__clkbuf_8
X_3258_ _2365_ _2397_ VSS VSS VDD VDD _0278_ sky130_fd_sc_hd__and2_0
X_3259_ _2367_ _2397_ VSS VSS VDD VDD _0279_ sky130_fd_sc_hd__and2_0
X_3260_ _2368_ _2397_ VSS VSS VDD VDD _0280_ sky130_fd_sc_hd__and2_0
X_3261_ _2369_ _2397_ VSS VSS VDD VDD _0281_ sky130_fd_sc_hd__and2_0
X_3262_ _2370_ _2397_ VSS VSS VDD VDD _0282_ sky130_fd_sc_hd__and2_0
X_3263_ _2371_ _2397_ VSS VSS VDD VDD _0283_ sky130_fd_sc_hd__and2_0
X_3264_ _2372_ _2397_ VSS VSS VDD VDD _0284_ sky130_fd_sc_hd__and2_0
X_3265_ _2373_ _2397_ VSS VSS VDD VDD _0285_ sky130_fd_sc_hd__and2_0
X_3266_ _2374_ _2397_ VSS VSS VDD VDD _0286_ sky130_fd_sc_hd__and2_0
X_3267_ _2375_ _2397_ VSS VSS VDD VDD _0287_ sky130_fd_sc_hd__and2_0
X_3268_ _2376_ _2394_ VSS VSS VDD VDD _0288_ sky130_fd_sc_hd__and2_0
X_3269_ _2377_ _2394_ VSS VSS VDD VDD _0289_ sky130_fd_sc_hd__and2_0
X_3270_ _1134_ _1136_ VSS VSS VDD VDD _2398_ sky130_fd_sc_hd__nor2_8
X_3271_ _2398_ VSS VSS VDD VDD _2399_ sky130_fd_sc_hd__buf_4
X_3272_ _2342_ _2399_ VSS VSS VDD VDD _0290_ sky130_fd_sc_hd__and2_0
X_3273_ _2345_ _2399_ VSS VSS VDD VDD _0291_ sky130_fd_sc_hd__and2_0
X_3274_ _2346_ _2399_ VSS VSS VDD VDD _0292_ sky130_fd_sc_hd__and2_0
X_3275_ _2347_ _2399_ VSS VSS VDD VDD _0293_ sky130_fd_sc_hd__and2_0
X_3276_ _2348_ _2399_ VSS VSS VDD VDD _0294_ sky130_fd_sc_hd__and2_0
X_3277_ _2349_ _2399_ VSS VSS VDD VDD _0295_ sky130_fd_sc_hd__and2_0
X_3278_ _2350_ _2399_ VSS VSS VDD VDD _0296_ sky130_fd_sc_hd__and2_0
X_3279_ _2351_ _2399_ VSS VSS VDD VDD _0297_ sky130_fd_sc_hd__and2_0
X_3280_ _2352_ _2399_ VSS VSS VDD VDD _0298_ sky130_fd_sc_hd__and2_0
X_3281_ _2353_ _2399_ VSS VSS VDD VDD _0299_ sky130_fd_sc_hd__and2_0
X_3282_ _2398_ VSS VSS VDD VDD _2400_ sky130_fd_sc_hd__buf_2
X_3283_ _2354_ _2400_ VSS VSS VDD VDD _0300_ sky130_fd_sc_hd__and2_0
X_3284_ _2356_ _2400_ VSS VSS VDD VDD _0301_ sky130_fd_sc_hd__and2_0
X_3285_ _2357_ _2400_ VSS VSS VDD VDD _0302_ sky130_fd_sc_hd__and2_0
X_3286_ _2358_ _2400_ VSS VSS VDD VDD _0303_ sky130_fd_sc_hd__and2_0
X_3287_ _2359_ _2400_ VSS VSS VDD VDD _0304_ sky130_fd_sc_hd__and2_0
X_3288_ _2360_ _2400_ VSS VSS VDD VDD _0305_ sky130_fd_sc_hd__and2_0
X_3289_ _2361_ _2400_ VSS VSS VDD VDD _0306_ sky130_fd_sc_hd__and2_0
X_3290_ _2362_ _2400_ VSS VSS VDD VDD _0307_ sky130_fd_sc_hd__and2_0
X_3291_ _2363_ _2400_ VSS VSS VDD VDD _0308_ sky130_fd_sc_hd__and2_0
X_3292_ _2364_ _2400_ VSS VSS VDD VDD _0309_ sky130_fd_sc_hd__and2_0
X_3293_ _2398_ VSS VSS VDD VDD _2401_ sky130_fd_sc_hd__buf_4
X_3294_ _2365_ _2401_ VSS VSS VDD VDD _0310_ sky130_fd_sc_hd__and2_0
X_3295_ _2367_ _2401_ VSS VSS VDD VDD _0311_ sky130_fd_sc_hd__and2_0
X_3296_ _2368_ _2401_ VSS VSS VDD VDD _0312_ sky130_fd_sc_hd__and2_0
X_3297_ _2369_ _2401_ VSS VSS VDD VDD _0313_ sky130_fd_sc_hd__and2_0
X_3298_ _2370_ _2401_ VSS VSS VDD VDD _0314_ sky130_fd_sc_hd__and2_0
X_3299_ _2371_ _2401_ VSS VSS VDD VDD _0315_ sky130_fd_sc_hd__and2_0
X_3300_ _2372_ _2401_ VSS VSS VDD VDD _0316_ sky130_fd_sc_hd__and2_0
X_3301_ _2373_ _2401_ VSS VSS VDD VDD _0317_ sky130_fd_sc_hd__and2_0
X_3302_ _2374_ _2401_ VSS VSS VDD VDD _0318_ sky130_fd_sc_hd__and2_0
X_3303_ _2375_ _2401_ VSS VSS VDD VDD _0319_ sky130_fd_sc_hd__and2_0
X_3304_ _2376_ _2398_ VSS VSS VDD VDD _0320_ sky130_fd_sc_hd__and2_0
X_3305_ _2377_ _2398_ VSS VSS VDD VDD _0321_ sky130_fd_sc_hd__and2_0
X_3306_ _1127_ _1140_ VSS VSS VDD VDD _2402_ sky130_fd_sc_hd__nor2_4
X_3307_ _2402_ VSS VSS VDD VDD _2403_ sky130_fd_sc_hd__buf_2
X_3308_ _2342_ _2403_ VSS VSS VDD VDD _0322_ sky130_fd_sc_hd__and2_0
X_3309_ _2345_ _2403_ VSS VSS VDD VDD _0323_ sky130_fd_sc_hd__and2_0
X_3310_ _2346_ _2403_ VSS VSS VDD VDD _0324_ sky130_fd_sc_hd__and2_0
X_3311_ _2347_ _2403_ VSS VSS VDD VDD _0325_ sky130_fd_sc_hd__and2_0
X_3312_ _2348_ _2403_ VSS VSS VDD VDD _0326_ sky130_fd_sc_hd__and2_0
X_3313_ _2349_ _2403_ VSS VSS VDD VDD _0327_ sky130_fd_sc_hd__and2_0
X_3314_ _2350_ _2403_ VSS VSS VDD VDD _0328_ sky130_fd_sc_hd__and2_0
X_3315_ _2351_ _2403_ VSS VSS VDD VDD _0329_ sky130_fd_sc_hd__and2_0
X_3316_ _2352_ _2403_ VSS VSS VDD VDD _0330_ sky130_fd_sc_hd__and2_0
X_3317_ _2353_ _2403_ VSS VSS VDD VDD _0331_ sky130_fd_sc_hd__and2_0
X_3318_ _2402_ VSS VSS VDD VDD _2404_ sky130_fd_sc_hd__clkbuf_4
X_3319_ _2354_ _2404_ VSS VSS VDD VDD _0332_ sky130_fd_sc_hd__and2_0
X_3320_ _2356_ _2404_ VSS VSS VDD VDD _0333_ sky130_fd_sc_hd__and2_0
X_3321_ _2357_ _2404_ VSS VSS VDD VDD _0334_ sky130_fd_sc_hd__and2_0
X_3322_ _2358_ _2404_ VSS VSS VDD VDD _0335_ sky130_fd_sc_hd__and2_0
X_3323_ _2359_ _2404_ VSS VSS VDD VDD _0336_ sky130_fd_sc_hd__and2_0
X_3324_ _2360_ _2404_ VSS VSS VDD VDD _0337_ sky130_fd_sc_hd__and2_0
X_3325_ _2361_ _2404_ VSS VSS VDD VDD _0338_ sky130_fd_sc_hd__and2_0
X_3326_ _2362_ _2404_ VSS VSS VDD VDD _0339_ sky130_fd_sc_hd__and2_0
X_3327_ _2363_ _2404_ VSS VSS VDD VDD _0340_ sky130_fd_sc_hd__and2_0
X_3328_ _2364_ _2404_ VSS VSS VDD VDD _0341_ sky130_fd_sc_hd__and2_0
X_3329_ _2402_ VSS VSS VDD VDD _2405_ sky130_fd_sc_hd__buf_2
X_3330_ _2365_ _2405_ VSS VSS VDD VDD _0342_ sky130_fd_sc_hd__and2_0
X_3331_ _2367_ _2405_ VSS VSS VDD VDD _0343_ sky130_fd_sc_hd__and2_0
X_3332_ _2368_ _2405_ VSS VSS VDD VDD _0344_ sky130_fd_sc_hd__and2_0
X_3333_ _2369_ _2405_ VSS VSS VDD VDD _0345_ sky130_fd_sc_hd__and2_0
X_3334_ _2370_ _2405_ VSS VSS VDD VDD _0346_ sky130_fd_sc_hd__and2_0
X_3335_ _2371_ _2405_ VSS VSS VDD VDD _0347_ sky130_fd_sc_hd__and2_0
X_3336_ _2372_ _2405_ VSS VSS VDD VDD _0348_ sky130_fd_sc_hd__and2_0
X_3337_ _2373_ _2405_ VSS VSS VDD VDD _0349_ sky130_fd_sc_hd__and2_0
X_3338_ _2374_ _2405_ VSS VSS VDD VDD _0350_ sky130_fd_sc_hd__and2_0
X_3339_ _2375_ _2405_ VSS VSS VDD VDD _0351_ sky130_fd_sc_hd__and2_0
X_3340_ _2376_ _2402_ VSS VSS VDD VDD _0352_ sky130_fd_sc_hd__and2_0
X_3341_ _2377_ _2402_ VSS VSS VDD VDD _0353_ sky130_fd_sc_hd__and2_0
X_3342_ _1137_ _1140_ VSS VSS VDD VDD _2406_ sky130_fd_sc_hd__nor2_2
X_3343_ _2406_ VSS VSS VDD VDD _2407_ sky130_fd_sc_hd__buf_2
X_3344_ _2342_ _2407_ VSS VSS VDD VDD _0354_ sky130_fd_sc_hd__and2_0
X_3345_ _2345_ _2407_ VSS VSS VDD VDD _0355_ sky130_fd_sc_hd__and2_0
X_3346_ _2346_ _2407_ VSS VSS VDD VDD _0356_ sky130_fd_sc_hd__and2_0
X_3347_ _2347_ _2407_ VSS VSS VDD VDD _0357_ sky130_fd_sc_hd__and2_0
X_3348_ _2348_ _2407_ VSS VSS VDD VDD _0358_ sky130_fd_sc_hd__and2_0
X_3349_ _2349_ _2407_ VSS VSS VDD VDD _0359_ sky130_fd_sc_hd__and2_0
X_3350_ _2350_ _2407_ VSS VSS VDD VDD _0360_ sky130_fd_sc_hd__and2_0
X_3351_ _2351_ _2407_ VSS VSS VDD VDD _0361_ sky130_fd_sc_hd__and2_0
X_3352_ _2352_ _2407_ VSS VSS VDD VDD _0362_ sky130_fd_sc_hd__and2_0
X_3353_ _2353_ _2407_ VSS VSS VDD VDD _0363_ sky130_fd_sc_hd__and2_0
X_3354_ _2406_ VSS VSS VDD VDD _2408_ sky130_fd_sc_hd__buf_2
X_3355_ _2354_ _2408_ VSS VSS VDD VDD _0364_ sky130_fd_sc_hd__and2_0
X_3356_ _2356_ _2408_ VSS VSS VDD VDD _0365_ sky130_fd_sc_hd__and2_0
X_3357_ _2357_ _2408_ VSS VSS VDD VDD _0366_ sky130_fd_sc_hd__and2_0
X_3358_ _2358_ _2408_ VSS VSS VDD VDD _0367_ sky130_fd_sc_hd__and2_0
X_3359_ _2359_ _2408_ VSS VSS VDD VDD _0368_ sky130_fd_sc_hd__and2_0
X_3360_ _2360_ _2408_ VSS VSS VDD VDD _0369_ sky130_fd_sc_hd__and2_0
X_3361_ _2361_ _2408_ VSS VSS VDD VDD _0370_ sky130_fd_sc_hd__and2_0
X_3362_ _2362_ _2408_ VSS VSS VDD VDD _0371_ sky130_fd_sc_hd__and2_0
X_3363_ _2363_ _2408_ VSS VSS VDD VDD _0372_ sky130_fd_sc_hd__and2_0
X_3364_ _2364_ _2408_ VSS VSS VDD VDD _0373_ sky130_fd_sc_hd__and2_0
X_3365_ _2406_ VSS VSS VDD VDD _2409_ sky130_fd_sc_hd__buf_2
X_3366_ _2365_ _2409_ VSS VSS VDD VDD _0374_ sky130_fd_sc_hd__and2_0
X_3367_ _2367_ _2409_ VSS VSS VDD VDD _0375_ sky130_fd_sc_hd__and2_0
X_3368_ _2368_ _2409_ VSS VSS VDD VDD _0376_ sky130_fd_sc_hd__and2_0
X_3369_ _2369_ _2409_ VSS VSS VDD VDD _0377_ sky130_fd_sc_hd__and2_0
X_3370_ _2370_ _2409_ VSS VSS VDD VDD _0378_ sky130_fd_sc_hd__and2_0
X_3371_ _2371_ _2409_ VSS VSS VDD VDD _0379_ sky130_fd_sc_hd__and2_0
X_3372_ _2372_ _2409_ VSS VSS VDD VDD _0380_ sky130_fd_sc_hd__and2_0
X_3373_ _2373_ _2409_ VSS VSS VDD VDD _0381_ sky130_fd_sc_hd__and2_0
X_3374_ _2374_ _2409_ VSS VSS VDD VDD _0382_ sky130_fd_sc_hd__and2_0
X_3375_ _2375_ _2409_ VSS VSS VDD VDD _0383_ sky130_fd_sc_hd__and2_0
X_3376_ _2376_ _2406_ VSS VSS VDD VDD _0384_ sky130_fd_sc_hd__and2_0
X_3377_ _2377_ _2406_ VSS VSS VDD VDD _0385_ sky130_fd_sc_hd__and2_0
X_3378_ _1132_ _1140_ VSS VSS VDD VDD _2410_ sky130_fd_sc_hd__nor2_4
X_3379_ _2410_ VSS VSS VDD VDD _2411_ sky130_fd_sc_hd__clkbuf_4
X_3380_ _2342_ _2411_ VSS VSS VDD VDD _0386_ sky130_fd_sc_hd__and2_0
X_3381_ _2345_ _2411_ VSS VSS VDD VDD _0387_ sky130_fd_sc_hd__and2_0
X_3382_ _2346_ _2411_ VSS VSS VDD VDD _0388_ sky130_fd_sc_hd__and2_0
X_3383_ _2347_ _2411_ VSS VSS VDD VDD _0389_ sky130_fd_sc_hd__and2_0
X_3384_ _2348_ _2411_ VSS VSS VDD VDD _0390_ sky130_fd_sc_hd__and2_0
X_3385_ _2349_ _2411_ VSS VSS VDD VDD _0391_ sky130_fd_sc_hd__and2_0
X_3386_ _2350_ _2411_ VSS VSS VDD VDD _0392_ sky130_fd_sc_hd__and2_0
X_3387_ _2351_ _2411_ VSS VSS VDD VDD _0393_ sky130_fd_sc_hd__and2_0
X_3388_ _2352_ _2411_ VSS VSS VDD VDD _0394_ sky130_fd_sc_hd__and2_0
X_3389_ _2353_ _2411_ VSS VSS VDD VDD _0395_ sky130_fd_sc_hd__and2_0
X_3390_ _2410_ VSS VSS VDD VDD _2412_ sky130_fd_sc_hd__clkbuf_4
X_3391_ _2354_ _2412_ VSS VSS VDD VDD _0396_ sky130_fd_sc_hd__and2_0
X_3392_ _2356_ _2412_ VSS VSS VDD VDD _0397_ sky130_fd_sc_hd__and2_0
X_3393_ _2357_ _2412_ VSS VSS VDD VDD _0398_ sky130_fd_sc_hd__and2_0
X_3394_ _2358_ _2412_ VSS VSS VDD VDD _0399_ sky130_fd_sc_hd__and2_0
X_3395_ _2359_ _2412_ VSS VSS VDD VDD _0400_ sky130_fd_sc_hd__and2_0
X_3396_ _2360_ _2412_ VSS VSS VDD VDD _0401_ sky130_fd_sc_hd__and2_0
X_3397_ _2361_ _2412_ VSS VSS VDD VDD _0402_ sky130_fd_sc_hd__and2_0
X_3398_ _2362_ _2412_ VSS VSS VDD VDD _0403_ sky130_fd_sc_hd__and2_0
X_3399_ _2363_ _2412_ VSS VSS VDD VDD _0404_ sky130_fd_sc_hd__and2_0
X_3400_ _2364_ _2412_ VSS VSS VDD VDD _0405_ sky130_fd_sc_hd__and2_0
X_3401_ _2410_ VSS VSS VDD VDD _2413_ sky130_fd_sc_hd__buf_2
X_3402_ _2365_ _2413_ VSS VSS VDD VDD _0406_ sky130_fd_sc_hd__and2_0
X_3403_ _2367_ _2413_ VSS VSS VDD VDD _0407_ sky130_fd_sc_hd__and2_0
X_3404_ _2368_ _2413_ VSS VSS VDD VDD _0408_ sky130_fd_sc_hd__and2_0
X_3405_ _2369_ _2413_ VSS VSS VDD VDD _0409_ sky130_fd_sc_hd__and2_0
X_3406_ _2370_ _2413_ VSS VSS VDD VDD _0410_ sky130_fd_sc_hd__and2_0
X_3407_ _2371_ _2413_ VSS VSS VDD VDD _0411_ sky130_fd_sc_hd__and2_0
X_3408_ _2372_ _2413_ VSS VSS VDD VDD _0412_ sky130_fd_sc_hd__and2_0
X_3409_ _2373_ _2413_ VSS VSS VDD VDD _0413_ sky130_fd_sc_hd__and2_0
X_3410_ _2374_ _2413_ VSS VSS VDD VDD _0414_ sky130_fd_sc_hd__and2_0
X_3411_ _2375_ _2413_ VSS VSS VDD VDD _0415_ sky130_fd_sc_hd__and2_0
X_3412_ _2376_ _2410_ VSS VSS VDD VDD _0416_ sky130_fd_sc_hd__and2_0
X_3413_ _2377_ _2410_ VSS VSS VDD VDD _0417_ sky130_fd_sc_hd__and2_0
X_3414_ net11 VSS VSS VDD VDD _2414_ sky130_fd_sc_hd__clkbuf_4
X_3415_ _1134_ _1140_ VSS VSS VDD VDD _2415_ sky130_fd_sc_hd__nor2_4
X_3416_ _2415_ VSS VSS VDD VDD _2416_ sky130_fd_sc_hd__clkbuf_4
X_3417_ _2414_ _2416_ VSS VSS VDD VDD _0418_ sky130_fd_sc_hd__and2_0
X_3418_ net12 VSS VSS VDD VDD _2417_ sky130_fd_sc_hd__buf_2
X_3419_ _2417_ _2416_ VSS VSS VDD VDD _0419_ sky130_fd_sc_hd__and2_0
X_3420_ net13 VSS VSS VDD VDD _2418_ sky130_fd_sc_hd__clkbuf_4
X_3421_ _2418_ _2416_ VSS VSS VDD VDD _0420_ sky130_fd_sc_hd__and2_0
X_3422_ net14 VSS VSS VDD VDD _2419_ sky130_fd_sc_hd__clkbuf_4
X_3423_ _2419_ _2416_ VSS VSS VDD VDD _0421_ sky130_fd_sc_hd__and2_0
X_3424_ net15 VSS VSS VDD VDD _2420_ sky130_fd_sc_hd__buf_4
X_3425_ _2420_ _2416_ VSS VSS VDD VDD _0422_ sky130_fd_sc_hd__and2_0
X_3426_ net16 VSS VSS VDD VDD _2421_ sky130_fd_sc_hd__buf_4
X_3427_ _2421_ _2416_ VSS VSS VDD VDD _0423_ sky130_fd_sc_hd__and2_0
X_3428_ net17 VSS VSS VDD VDD _2422_ sky130_fd_sc_hd__buf_4
X_3429_ _2422_ _2416_ VSS VSS VDD VDD _0424_ sky130_fd_sc_hd__and2_0
X_3430_ net18 VSS VSS VDD VDD _2423_ sky130_fd_sc_hd__buf_4
X_3431_ _2423_ _2416_ VSS VSS VDD VDD _0425_ sky130_fd_sc_hd__and2_0
X_3432_ net19 VSS VSS VDD VDD _2424_ sky130_fd_sc_hd__buf_4
X_3433_ _2424_ _2416_ VSS VSS VDD VDD _0426_ sky130_fd_sc_hd__and2_0
X_3434_ net20 VSS VSS VDD VDD _2425_ sky130_fd_sc_hd__buf_4
X_3435_ _2425_ _2416_ VSS VSS VDD VDD _0427_ sky130_fd_sc_hd__and2_0
X_3436_ net21 VSS VSS VDD VDD _2426_ sky130_fd_sc_hd__buf_4
X_3437_ _2415_ VSS VSS VDD VDD _2427_ sky130_fd_sc_hd__clkbuf_4
X_3438_ _2426_ _2427_ VSS VSS VDD VDD _0428_ sky130_fd_sc_hd__and2_0
X_3439_ net22 VSS VSS VDD VDD _2428_ sky130_fd_sc_hd__clkbuf_4
X_3440_ _2428_ _2427_ VSS VSS VDD VDD _0429_ sky130_fd_sc_hd__and2_0
X_3441_ net23 VSS VSS VDD VDD _2429_ sky130_fd_sc_hd__buf_4
X_3442_ _2429_ _2427_ VSS VSS VDD VDD _0430_ sky130_fd_sc_hd__and2_0
X_3443_ net24 VSS VSS VDD VDD _2430_ sky130_fd_sc_hd__buf_4
X_3444_ _2430_ _2427_ VSS VSS VDD VDD _0431_ sky130_fd_sc_hd__and2_0
X_3445_ net25 VSS VSS VDD VDD _2431_ sky130_fd_sc_hd__buf_4
X_3446_ _2431_ _2427_ VSS VSS VDD VDD _0432_ sky130_fd_sc_hd__and2_0
X_3447_ net26 VSS VSS VDD VDD _2432_ sky130_fd_sc_hd__buf_4
X_3448_ _2432_ _2427_ VSS VSS VDD VDD _0433_ sky130_fd_sc_hd__and2_0
X_3449_ net27 VSS VSS VDD VDD _2433_ sky130_fd_sc_hd__buf_4
X_3450_ _2433_ _2427_ VSS VSS VDD VDD _0434_ sky130_fd_sc_hd__and2_0
X_3451_ net28 VSS VSS VDD VDD _2434_ sky130_fd_sc_hd__buf_4
X_3452_ _2434_ _2427_ VSS VSS VDD VDD _0435_ sky130_fd_sc_hd__and2_0
X_3453_ net29 VSS VSS VDD VDD _2435_ sky130_fd_sc_hd__clkbuf_4
X_3454_ _2435_ _2427_ VSS VSS VDD VDD _0436_ sky130_fd_sc_hd__and2_0
X_3455_ net30 VSS VSS VDD VDD _2436_ sky130_fd_sc_hd__buf_4
X_3456_ _2436_ _2427_ VSS VSS VDD VDD _0437_ sky130_fd_sc_hd__and2_0
X_3457_ net31 VSS VSS VDD VDD _2437_ sky130_fd_sc_hd__buf_4
X_3458_ _2415_ VSS VSS VDD VDD _2438_ sky130_fd_sc_hd__buf_2
X_3459_ _2437_ _2438_ VSS VSS VDD VDD _0438_ sky130_fd_sc_hd__and2_0
X_3460_ net32 VSS VSS VDD VDD _2439_ sky130_fd_sc_hd__buf_4
X_3461_ _2439_ _2438_ VSS VSS VDD VDD _0439_ sky130_fd_sc_hd__and2_0
X_3462_ net33 VSS VSS VDD VDD _2440_ sky130_fd_sc_hd__buf_6
X_3463_ _2440_ _2438_ VSS VSS VDD VDD _0440_ sky130_fd_sc_hd__and2_0
X_3464_ net34 VSS VSS VDD VDD _2441_ sky130_fd_sc_hd__buf_6
X_3465_ _2441_ _2438_ VSS VSS VDD VDD _0441_ sky130_fd_sc_hd__and2_0
X_3466_ net35 VSS VSS VDD VDD _2442_ sky130_fd_sc_hd__clkbuf_8
X_3467_ _2442_ _2438_ VSS VSS VDD VDD _0442_ sky130_fd_sc_hd__and2_0
X_3468_ net36 VSS VSS VDD VDD _2443_ sky130_fd_sc_hd__clkbuf_4
X_3469_ _2443_ _2438_ VSS VSS VDD VDD _0443_ sky130_fd_sc_hd__and2_0
X_3470_ net37 VSS VSS VDD VDD _2444_ sky130_fd_sc_hd__buf_4
X_3471_ _2444_ _2438_ VSS VSS VDD VDD _0444_ sky130_fd_sc_hd__and2_0
X_3472_ net38 VSS VSS VDD VDD _2445_ sky130_fd_sc_hd__clkbuf_4
X_3473_ _2445_ _2438_ VSS VSS VDD VDD _0445_ sky130_fd_sc_hd__and2_0
X_3474_ net39 VSS VSS VDD VDD _2446_ sky130_fd_sc_hd__buf_4
X_3475_ _2446_ _2438_ VSS VSS VDD VDD _0446_ sky130_fd_sc_hd__and2_0
X_3476_ net40 VSS VSS VDD VDD _2447_ sky130_fd_sc_hd__buf_2
X_3477_ _2447_ _2438_ VSS VSS VDD VDD _0447_ sky130_fd_sc_hd__and2_0
X_3478_ net41 VSS VSS VDD VDD _2448_ sky130_fd_sc_hd__buf_2
X_3479_ _2448_ _2415_ VSS VSS VDD VDD _0448_ sky130_fd_sc_hd__and2_0
X_3480_ net42 VSS VSS VDD VDD _2449_ sky130_fd_sc_hd__clkbuf_4
X_3481_ _2449_ _2415_ VSS VSS VDD VDD _0449_ sky130_fd_sc_hd__and2_0
X_3482_ _1124_ _1138_ VSS VSS VDD VDD _2450_ sky130_fd_sc_hd__nor2_4
X_3483_ _2450_ VSS VSS VDD VDD _2451_ sky130_fd_sc_hd__buf_4
X_3484_ _2414_ _2451_ VSS VSS VDD VDD _0450_ sky130_fd_sc_hd__and2_0
X_3485_ _2417_ _2451_ VSS VSS VDD VDD _0451_ sky130_fd_sc_hd__and2_0
X_3486_ _2418_ _2451_ VSS VSS VDD VDD _0452_ sky130_fd_sc_hd__and2_0
X_3487_ _2419_ _2451_ VSS VSS VDD VDD _0453_ sky130_fd_sc_hd__and2_0
X_3488_ _2420_ _2451_ VSS VSS VDD VDD _0454_ sky130_fd_sc_hd__and2_0
X_3489_ _2421_ _2451_ VSS VSS VDD VDD _0455_ sky130_fd_sc_hd__and2_0
X_3490_ _2422_ _2451_ VSS VSS VDD VDD _0456_ sky130_fd_sc_hd__and2_0
X_3491_ _2423_ _2451_ VSS VSS VDD VDD _0457_ sky130_fd_sc_hd__and2_0
X_3492_ _2424_ _2451_ VSS VSS VDD VDD _0458_ sky130_fd_sc_hd__and2_0
X_3493_ _2425_ _2451_ VSS VSS VDD VDD _0459_ sky130_fd_sc_hd__and2_0
X_3494_ _2450_ VSS VSS VDD VDD _2452_ sky130_fd_sc_hd__buf_4
X_3495_ _2426_ _2452_ VSS VSS VDD VDD _0460_ sky130_fd_sc_hd__and2_0
X_3496_ _2428_ _2452_ VSS VSS VDD VDD _0461_ sky130_fd_sc_hd__and2_0
X_3497_ _2429_ _2452_ VSS VSS VDD VDD _0462_ sky130_fd_sc_hd__and2_0
X_3498_ _2430_ _2452_ VSS VSS VDD VDD _0463_ sky130_fd_sc_hd__and2_0
X_3499_ _2431_ _2452_ VSS VSS VDD VDD _0464_ sky130_fd_sc_hd__and2_0
X_3500_ _2432_ _2452_ VSS VSS VDD VDD _0465_ sky130_fd_sc_hd__and2_0
X_3501_ _2433_ _2452_ VSS VSS VDD VDD _0466_ sky130_fd_sc_hd__and2_0
X_3502_ _2434_ _2452_ VSS VSS VDD VDD _0467_ sky130_fd_sc_hd__and2_0
X_3503_ _2435_ _2452_ VSS VSS VDD VDD _0468_ sky130_fd_sc_hd__and2_0
X_3504_ _2436_ _2452_ VSS VSS VDD VDD _0469_ sky130_fd_sc_hd__and2_0
X_3505_ _2450_ VSS VSS VDD VDD _2453_ sky130_fd_sc_hd__buf_4
X_3506_ _2437_ _2453_ VSS VSS VDD VDD _0470_ sky130_fd_sc_hd__and2_0
X_3507_ _2439_ _2453_ VSS VSS VDD VDD _0471_ sky130_fd_sc_hd__and2_0
X_3508_ _2440_ _2453_ VSS VSS VDD VDD _0472_ sky130_fd_sc_hd__and2_0
X_3509_ _2441_ _2453_ VSS VSS VDD VDD _0473_ sky130_fd_sc_hd__and2_0
X_3510_ _2442_ _2453_ VSS VSS VDD VDD _0474_ sky130_fd_sc_hd__and2_0
X_3511_ _2443_ _2453_ VSS VSS VDD VDD _0475_ sky130_fd_sc_hd__and2_0
X_3512_ _2444_ _2453_ VSS VSS VDD VDD _0476_ sky130_fd_sc_hd__and2_0
X_3513_ _2445_ _2453_ VSS VSS VDD VDD _0477_ sky130_fd_sc_hd__and2_0
X_3514_ _2446_ _2453_ VSS VSS VDD VDD _0478_ sky130_fd_sc_hd__and2_0
X_3515_ _2447_ _2453_ VSS VSS VDD VDD _0479_ sky130_fd_sc_hd__and2_0
X_3516_ _2448_ _2450_ VSS VSS VDD VDD _0480_ sky130_fd_sc_hd__and2_0
X_3517_ _2449_ _2450_ VSS VSS VDD VDD _0481_ sky130_fd_sc_hd__and2_0
X_3518_ _1127_ _1142_ VSS VSS VDD VDD _2454_ sky130_fd_sc_hd__nor2_4
X_3519_ _2454_ VSS VSS VDD VDD _2455_ sky130_fd_sc_hd__buf_2
X_3520_ _2414_ _2455_ VSS VSS VDD VDD _0482_ sky130_fd_sc_hd__and2_0
X_3521_ _2417_ _2455_ VSS VSS VDD VDD _0483_ sky130_fd_sc_hd__and2_0
X_3522_ _2418_ _2455_ VSS VSS VDD VDD _0484_ sky130_fd_sc_hd__and2_0
X_3523_ _2419_ _2455_ VSS VSS VDD VDD _0485_ sky130_fd_sc_hd__and2_0
X_3524_ _2420_ _2455_ VSS VSS VDD VDD _0486_ sky130_fd_sc_hd__and2_0
X_3525_ _2421_ _2455_ VSS VSS VDD VDD _0487_ sky130_fd_sc_hd__and2_0
X_3526_ _2422_ _2455_ VSS VSS VDD VDD _0488_ sky130_fd_sc_hd__and2_0
X_3527_ _2423_ _2455_ VSS VSS VDD VDD _0489_ sky130_fd_sc_hd__and2_0
X_3528_ _2424_ _2455_ VSS VSS VDD VDD _0490_ sky130_fd_sc_hd__and2_0
X_3529_ _2425_ _2455_ VSS VSS VDD VDD _0491_ sky130_fd_sc_hd__and2_0
X_3530_ _2454_ VSS VSS VDD VDD _2456_ sky130_fd_sc_hd__buf_2
X_3531_ _2426_ _2456_ VSS VSS VDD VDD _0492_ sky130_fd_sc_hd__and2_0
X_3532_ _2428_ _2456_ VSS VSS VDD VDD _0493_ sky130_fd_sc_hd__and2_0
X_3533_ _2429_ _2456_ VSS VSS VDD VDD _0494_ sky130_fd_sc_hd__and2_0
X_3534_ _2430_ _2456_ VSS VSS VDD VDD _0495_ sky130_fd_sc_hd__and2_0
X_3535_ _2431_ _2456_ VSS VSS VDD VDD _0496_ sky130_fd_sc_hd__and2_0
X_3536_ _2432_ _2456_ VSS VSS VDD VDD _0497_ sky130_fd_sc_hd__and2_0
X_3537_ _2433_ _2456_ VSS VSS VDD VDD _0498_ sky130_fd_sc_hd__and2_0
X_3538_ _2434_ _2456_ VSS VSS VDD VDD _0499_ sky130_fd_sc_hd__and2_0
X_3539_ _2435_ _2456_ VSS VSS VDD VDD _0500_ sky130_fd_sc_hd__and2_0
X_3540_ _2436_ _2456_ VSS VSS VDD VDD _0501_ sky130_fd_sc_hd__and2_0
X_3541_ _2454_ VSS VSS VDD VDD _2457_ sky130_fd_sc_hd__clkbuf_2
X_3542_ _2437_ _2457_ VSS VSS VDD VDD _0502_ sky130_fd_sc_hd__and2_0
X_3543_ _2439_ _2457_ VSS VSS VDD VDD _0503_ sky130_fd_sc_hd__and2_0
X_3544_ _2440_ _2457_ VSS VSS VDD VDD _0504_ sky130_fd_sc_hd__and2_0
X_3545_ _2441_ _2457_ VSS VSS VDD VDD _0505_ sky130_fd_sc_hd__and2_0
X_3546_ _2442_ _2457_ VSS VSS VDD VDD _0506_ sky130_fd_sc_hd__and2_0
X_3547_ _2443_ _2457_ VSS VSS VDD VDD _0507_ sky130_fd_sc_hd__and2_0
X_3548_ _2444_ _2457_ VSS VSS VDD VDD _0508_ sky130_fd_sc_hd__and2_0
X_3549_ _2445_ _2457_ VSS VSS VDD VDD _0509_ sky130_fd_sc_hd__and2_0
X_3550_ _2446_ _2457_ VSS VSS VDD VDD _0510_ sky130_fd_sc_hd__and2_0
X_3551_ _2447_ _2457_ VSS VSS VDD VDD _0511_ sky130_fd_sc_hd__and2_0
X_3552_ _2448_ _2454_ VSS VSS VDD VDD _0512_ sky130_fd_sc_hd__and2_0
X_3553_ _2449_ _2454_ VSS VSS VDD VDD _0513_ sky130_fd_sc_hd__and2_0
X_3554_ _1137_ _1142_ VSS VSS VDD VDD _2458_ sky130_fd_sc_hd__nor2_2
X_3555_ _2458_ VSS VSS VDD VDD _2459_ sky130_fd_sc_hd__buf_2
X_3556_ _2414_ _2459_ VSS VSS VDD VDD _0514_ sky130_fd_sc_hd__and2_0
X_3557_ _2417_ _2459_ VSS VSS VDD VDD _0515_ sky130_fd_sc_hd__and2_0
X_3558_ _2418_ _2459_ VSS VSS VDD VDD _0516_ sky130_fd_sc_hd__and2_0
X_3559_ _2419_ _2459_ VSS VSS VDD VDD _0517_ sky130_fd_sc_hd__and2_0
X_3560_ _2420_ _2459_ VSS VSS VDD VDD _0518_ sky130_fd_sc_hd__and2_0
X_3561_ _2421_ _2459_ VSS VSS VDD VDD _0519_ sky130_fd_sc_hd__and2_0
X_3562_ _2422_ _2459_ VSS VSS VDD VDD _0520_ sky130_fd_sc_hd__and2_0
X_3563_ _2423_ _2459_ VSS VSS VDD VDD _0521_ sky130_fd_sc_hd__and2_0
X_3564_ _2424_ _2459_ VSS VSS VDD VDD _0522_ sky130_fd_sc_hd__and2_0
X_3565_ _2425_ _2459_ VSS VSS VDD VDD _0523_ sky130_fd_sc_hd__and2_0
X_3566_ _2458_ VSS VSS VDD VDD _2460_ sky130_fd_sc_hd__clkbuf_4
X_3567_ _2426_ _2460_ VSS VSS VDD VDD _0524_ sky130_fd_sc_hd__and2_0
X_3568_ _2428_ _2460_ VSS VSS VDD VDD _0525_ sky130_fd_sc_hd__and2_0
X_3569_ _2429_ _2460_ VSS VSS VDD VDD _0526_ sky130_fd_sc_hd__and2_0
X_3570_ _2430_ _2460_ VSS VSS VDD VDD _0527_ sky130_fd_sc_hd__and2_0
X_3571_ _2431_ _2460_ VSS VSS VDD VDD _0528_ sky130_fd_sc_hd__and2_0
X_3572_ _2432_ _2460_ VSS VSS VDD VDD _0529_ sky130_fd_sc_hd__and2_0
X_3573_ _2433_ _2460_ VSS VSS VDD VDD _0530_ sky130_fd_sc_hd__and2_0
X_3574_ _2434_ _2460_ VSS VSS VDD VDD _0531_ sky130_fd_sc_hd__and2_0
X_3575_ _2435_ _2460_ VSS VSS VDD VDD _0532_ sky130_fd_sc_hd__and2_0
X_3576_ _2436_ _2460_ VSS VSS VDD VDD _0533_ sky130_fd_sc_hd__and2_0
X_3577_ _2458_ VSS VSS VDD VDD _2461_ sky130_fd_sc_hd__buf_2
X_3578_ _2437_ _2461_ VSS VSS VDD VDD _0534_ sky130_fd_sc_hd__and2_0
X_3579_ _2439_ _2461_ VSS VSS VDD VDD _0535_ sky130_fd_sc_hd__and2_0
X_3580_ _2440_ _2461_ VSS VSS VDD VDD _0536_ sky130_fd_sc_hd__and2_0
X_3581_ _2441_ _2461_ VSS VSS VDD VDD _0537_ sky130_fd_sc_hd__and2_0
X_3582_ _2442_ _2461_ VSS VSS VDD VDD _0538_ sky130_fd_sc_hd__and2_0
X_3583_ _2443_ _2461_ VSS VSS VDD VDD _0539_ sky130_fd_sc_hd__and2_0
X_3584_ _2444_ _2461_ VSS VSS VDD VDD _0540_ sky130_fd_sc_hd__and2_0
X_3585_ _2445_ _2461_ VSS VSS VDD VDD _0541_ sky130_fd_sc_hd__and2_0
X_3586_ _2446_ _2461_ VSS VSS VDD VDD _0542_ sky130_fd_sc_hd__and2_0
X_3587_ _2447_ _2461_ VSS VSS VDD VDD _0543_ sky130_fd_sc_hd__and2_0
X_3588_ _2448_ _2458_ VSS VSS VDD VDD _0544_ sky130_fd_sc_hd__and2_0
X_3589_ _2449_ _2458_ VSS VSS VDD VDD _0545_ sky130_fd_sc_hd__and2_0
X_3590_ _1132_ _1142_ VSS VSS VDD VDD _2462_ sky130_fd_sc_hd__nor2_4
X_3591_ _2462_ VSS VSS VDD VDD _2463_ sky130_fd_sc_hd__clkbuf_4
X_3592_ _2414_ _2463_ VSS VSS VDD VDD _0546_ sky130_fd_sc_hd__and2_0
X_3593_ _2417_ _2463_ VSS VSS VDD VDD _0547_ sky130_fd_sc_hd__and2_0
X_3594_ _2418_ _2463_ VSS VSS VDD VDD _0548_ sky130_fd_sc_hd__and2_0
X_3595_ _2419_ _2463_ VSS VSS VDD VDD _0549_ sky130_fd_sc_hd__and2_0
X_3596_ _2420_ _2463_ VSS VSS VDD VDD _0550_ sky130_fd_sc_hd__and2_0
X_3597_ _2421_ _2463_ VSS VSS VDD VDD _0551_ sky130_fd_sc_hd__and2_0
X_3598_ _2422_ _2463_ VSS VSS VDD VDD _0552_ sky130_fd_sc_hd__and2_0
X_3599_ _2423_ _2463_ VSS VSS VDD VDD _0553_ sky130_fd_sc_hd__and2_0
X_3600_ _2424_ _2463_ VSS VSS VDD VDD _0554_ sky130_fd_sc_hd__and2_0
X_3601_ _2425_ _2463_ VSS VSS VDD VDD _0555_ sky130_fd_sc_hd__and2_0
X_3602_ _2462_ VSS VSS VDD VDD _2464_ sky130_fd_sc_hd__clkbuf_4
X_3603_ _2426_ _2464_ VSS VSS VDD VDD _0556_ sky130_fd_sc_hd__and2_0
X_3604_ _2428_ _2464_ VSS VSS VDD VDD _0557_ sky130_fd_sc_hd__and2_0
X_3605_ _2429_ _2464_ VSS VSS VDD VDD _0558_ sky130_fd_sc_hd__and2_0
X_3606_ _2430_ _2464_ VSS VSS VDD VDD _0559_ sky130_fd_sc_hd__and2_0
X_3607_ _2431_ _2464_ VSS VSS VDD VDD _0560_ sky130_fd_sc_hd__and2_0
X_3608_ _2432_ _2464_ VSS VSS VDD VDD _0561_ sky130_fd_sc_hd__and2_0
X_3609_ _2433_ _2464_ VSS VSS VDD VDD _0562_ sky130_fd_sc_hd__and2_0
X_3610_ _2434_ _2464_ VSS VSS VDD VDD _0563_ sky130_fd_sc_hd__and2_0
X_3611_ _2435_ _2464_ VSS VSS VDD VDD _0564_ sky130_fd_sc_hd__and2_0
X_3612_ _2436_ _2464_ VSS VSS VDD VDD _0565_ sky130_fd_sc_hd__and2_0
X_3613_ _2462_ VSS VSS VDD VDD _2465_ sky130_fd_sc_hd__buf_2
X_3614_ _2437_ _2465_ VSS VSS VDD VDD _0566_ sky130_fd_sc_hd__and2_0
X_3615_ _2439_ _2465_ VSS VSS VDD VDD _0567_ sky130_fd_sc_hd__and2_0
X_3616_ _2440_ _2465_ VSS VSS VDD VDD _0568_ sky130_fd_sc_hd__and2_0
X_3617_ _2441_ _2465_ VSS VSS VDD VDD _0569_ sky130_fd_sc_hd__and2_0
X_3618_ _2442_ _2465_ VSS VSS VDD VDD _0570_ sky130_fd_sc_hd__and2_0
X_3619_ _2443_ _2465_ VSS VSS VDD VDD _0571_ sky130_fd_sc_hd__and2_0
X_3620_ _2444_ _2465_ VSS VSS VDD VDD _0572_ sky130_fd_sc_hd__and2_0
X_3621_ _2445_ _2465_ VSS VSS VDD VDD _0573_ sky130_fd_sc_hd__and2_0
X_3622_ _2446_ _2465_ VSS VSS VDD VDD _0574_ sky130_fd_sc_hd__and2_0
X_3623_ _2447_ _2465_ VSS VSS VDD VDD _0575_ sky130_fd_sc_hd__and2_0
X_3624_ _2448_ _2462_ VSS VSS VDD VDD _0576_ sky130_fd_sc_hd__and2_0
X_3625_ _2449_ _2462_ VSS VSS VDD VDD _0577_ sky130_fd_sc_hd__and2_0
X_3626_ _1134_ _1142_ VSS VSS VDD VDD _2466_ sky130_fd_sc_hd__nor2_2
X_3627_ _2466_ VSS VSS VDD VDD _2467_ sky130_fd_sc_hd__buf_2
X_3628_ _2414_ _2467_ VSS VSS VDD VDD _0578_ sky130_fd_sc_hd__and2_0
X_3629_ _2417_ _2467_ VSS VSS VDD VDD _0579_ sky130_fd_sc_hd__and2_0
X_3630_ _2418_ _2467_ VSS VSS VDD VDD _0580_ sky130_fd_sc_hd__and2_0
X_3631_ _2419_ _2467_ VSS VSS VDD VDD _0581_ sky130_fd_sc_hd__and2_0
X_3632_ _2420_ _2467_ VSS VSS VDD VDD _0582_ sky130_fd_sc_hd__and2_0
X_3633_ _2421_ _2467_ VSS VSS VDD VDD _0583_ sky130_fd_sc_hd__and2_0
X_3634_ _2422_ _2467_ VSS VSS VDD VDD _0584_ sky130_fd_sc_hd__and2_0
X_3635_ _2423_ _2467_ VSS VSS VDD VDD _0585_ sky130_fd_sc_hd__and2_0
X_3636_ _2424_ _2467_ VSS VSS VDD VDD _0586_ sky130_fd_sc_hd__and2_0
X_3637_ _2425_ _2467_ VSS VSS VDD VDD _0587_ sky130_fd_sc_hd__and2_0
X_3638_ _2466_ VSS VSS VDD VDD _2468_ sky130_fd_sc_hd__clkbuf_4
X_3639_ _2426_ _2468_ VSS VSS VDD VDD _0588_ sky130_fd_sc_hd__and2_0
X_3640_ _2428_ _2468_ VSS VSS VDD VDD _0589_ sky130_fd_sc_hd__and2_0
X_3641_ _2429_ _2468_ VSS VSS VDD VDD _0590_ sky130_fd_sc_hd__and2_0
X_3642_ _2430_ _2468_ VSS VSS VDD VDD _0591_ sky130_fd_sc_hd__and2_0
X_3643_ _2431_ _2468_ VSS VSS VDD VDD _0592_ sky130_fd_sc_hd__and2_0
X_3644_ _2432_ _2468_ VSS VSS VDD VDD _0593_ sky130_fd_sc_hd__and2_0
X_3645_ _2433_ _2468_ VSS VSS VDD VDD _0594_ sky130_fd_sc_hd__and2_0
X_3646_ _2434_ _2468_ VSS VSS VDD VDD _0595_ sky130_fd_sc_hd__and2_0
X_3647_ _2435_ _2468_ VSS VSS VDD VDD _0596_ sky130_fd_sc_hd__and2_0
X_3648_ _2436_ _2468_ VSS VSS VDD VDD _0597_ sky130_fd_sc_hd__and2_0
X_3649_ _2466_ VSS VSS VDD VDD _2469_ sky130_fd_sc_hd__clkbuf_4
X_3650_ _2437_ _2469_ VSS VSS VDD VDD _0598_ sky130_fd_sc_hd__and2_0
X_3651_ _2439_ _2469_ VSS VSS VDD VDD _0599_ sky130_fd_sc_hd__and2_0
X_3652_ _2440_ _2469_ VSS VSS VDD VDD _0600_ sky130_fd_sc_hd__and2_0
X_3653_ _2441_ _2469_ VSS VSS VDD VDD _0601_ sky130_fd_sc_hd__and2_0
X_3654_ _2442_ _2469_ VSS VSS VDD VDD _0602_ sky130_fd_sc_hd__and2_0
X_3655_ _2443_ _2469_ VSS VSS VDD VDD _0603_ sky130_fd_sc_hd__and2_0
X_3656_ _2444_ _2469_ VSS VSS VDD VDD _0604_ sky130_fd_sc_hd__and2_0
X_3657_ _2445_ _2469_ VSS VSS VDD VDD _0605_ sky130_fd_sc_hd__and2_0
X_3658_ _2446_ _2469_ VSS VSS VDD VDD _0606_ sky130_fd_sc_hd__and2_0
X_3659_ _2447_ _2469_ VSS VSS VDD VDD _0607_ sky130_fd_sc_hd__and2_0
X_3660_ _2448_ _2466_ VSS VSS VDD VDD _0608_ sky130_fd_sc_hd__and2_0
X_3661_ _2449_ _2466_ VSS VSS VDD VDD _0609_ sky130_fd_sc_hd__and2_0
X_3662_ _1127_ _1143_ VSS VSS VDD VDD _2470_ sky130_fd_sc_hd__nor2_4
X_3663_ _2470_ VSS VSS VDD VDD _2471_ sky130_fd_sc_hd__clkbuf_4
X_3664_ _2414_ _2471_ VSS VSS VDD VDD _0610_ sky130_fd_sc_hd__and2_0
X_3665_ _2417_ _2471_ VSS VSS VDD VDD _0611_ sky130_fd_sc_hd__and2_0
X_3666_ _2418_ _2471_ VSS VSS VDD VDD _0612_ sky130_fd_sc_hd__and2_0
X_3667_ _2419_ _2471_ VSS VSS VDD VDD _0613_ sky130_fd_sc_hd__and2_0
X_3668_ _2420_ _2471_ VSS VSS VDD VDD _0614_ sky130_fd_sc_hd__and2_0
X_3669_ _2421_ _2471_ VSS VSS VDD VDD _0615_ sky130_fd_sc_hd__and2_0
X_3670_ _2422_ _2471_ VSS VSS VDD VDD _0616_ sky130_fd_sc_hd__and2_0
X_3671_ _2423_ _2471_ VSS VSS VDD VDD _0617_ sky130_fd_sc_hd__and2_0
X_3672_ _2424_ _2471_ VSS VSS VDD VDD _0618_ sky130_fd_sc_hd__and2_0
X_3673_ _2425_ _2471_ VSS VSS VDD VDD _0619_ sky130_fd_sc_hd__and2_0
X_3674_ _2470_ VSS VSS VDD VDD _2472_ sky130_fd_sc_hd__clkbuf_4
X_3675_ _2426_ _2472_ VSS VSS VDD VDD _0620_ sky130_fd_sc_hd__and2_0
X_3676_ _2428_ _2472_ VSS VSS VDD VDD _0621_ sky130_fd_sc_hd__and2_0
X_3677_ _2429_ _2472_ VSS VSS VDD VDD _0622_ sky130_fd_sc_hd__and2_0
X_3678_ _2430_ _2472_ VSS VSS VDD VDD _0623_ sky130_fd_sc_hd__and2_0
X_3679_ _2431_ _2472_ VSS VSS VDD VDD _0624_ sky130_fd_sc_hd__and2_0
X_3680_ _2432_ _2472_ VSS VSS VDD VDD _0625_ sky130_fd_sc_hd__and2_0
X_3681_ _2433_ _2472_ VSS VSS VDD VDD _0626_ sky130_fd_sc_hd__and2_0
X_3682_ _2434_ _2472_ VSS VSS VDD VDD _0627_ sky130_fd_sc_hd__and2_0
X_3683_ _2435_ _2472_ VSS VSS VDD VDD _0628_ sky130_fd_sc_hd__and2_0
X_3684_ _2436_ _2472_ VSS VSS VDD VDD _0629_ sky130_fd_sc_hd__and2_0
X_3685_ _2470_ VSS VSS VDD VDD _2473_ sky130_fd_sc_hd__clkbuf_4
X_3686_ _2437_ _2473_ VSS VSS VDD VDD _0630_ sky130_fd_sc_hd__and2_0
X_3687_ _2439_ _2473_ VSS VSS VDD VDD _0631_ sky130_fd_sc_hd__and2_0
X_3688_ _2440_ _2473_ VSS VSS VDD VDD _0632_ sky130_fd_sc_hd__and2_0
X_3689_ _2441_ _2473_ VSS VSS VDD VDD _0633_ sky130_fd_sc_hd__and2_0
X_3690_ _2442_ _2473_ VSS VSS VDD VDD _0634_ sky130_fd_sc_hd__and2_0
X_3691_ _2443_ _2473_ VSS VSS VDD VDD _0635_ sky130_fd_sc_hd__and2_0
X_3692_ _2444_ _2473_ VSS VSS VDD VDD _0636_ sky130_fd_sc_hd__and2_0
X_3693_ _2445_ _2473_ VSS VSS VDD VDD _0637_ sky130_fd_sc_hd__and2_0
X_3694_ _2446_ _2473_ VSS VSS VDD VDD _0638_ sky130_fd_sc_hd__and2_0
X_3695_ _2447_ _2473_ VSS VSS VDD VDD _0639_ sky130_fd_sc_hd__and2_0
X_3696_ _2448_ _2470_ VSS VSS VDD VDD _0640_ sky130_fd_sc_hd__and2_0
X_3697_ _2449_ _2470_ VSS VSS VDD VDD _0641_ sky130_fd_sc_hd__and2_0
X_3698_ _1137_ _1143_ VSS VSS VDD VDD _2474_ sky130_fd_sc_hd__nor2_4
X_3699_ _2474_ VSS VSS VDD VDD _2475_ sky130_fd_sc_hd__buf_4
X_3700_ _2414_ _2475_ VSS VSS VDD VDD _0642_ sky130_fd_sc_hd__and2_0
X_3701_ _2417_ _2475_ VSS VSS VDD VDD _0643_ sky130_fd_sc_hd__and2_0
X_3702_ _2418_ _2475_ VSS VSS VDD VDD _0644_ sky130_fd_sc_hd__and2_0
X_3703_ _2419_ _2475_ VSS VSS VDD VDD _0645_ sky130_fd_sc_hd__and2_0
X_3704_ _2420_ _2475_ VSS VSS VDD VDD _0646_ sky130_fd_sc_hd__and2_0
X_3705_ _2421_ _2475_ VSS VSS VDD VDD _0647_ sky130_fd_sc_hd__and2_0
X_3706_ _2422_ _2475_ VSS VSS VDD VDD _0648_ sky130_fd_sc_hd__and2_0
X_3707_ _2423_ _2475_ VSS VSS VDD VDD _0649_ sky130_fd_sc_hd__and2_0
X_3708_ _2424_ _2475_ VSS VSS VDD VDD _0650_ sky130_fd_sc_hd__and2_0
X_3709_ _2425_ _2475_ VSS VSS VDD VDD _0651_ sky130_fd_sc_hd__and2_0
X_3710_ _2474_ VSS VSS VDD VDD _2476_ sky130_fd_sc_hd__buf_4
X_3711_ _2426_ _2476_ VSS VSS VDD VDD _0652_ sky130_fd_sc_hd__and2_0
X_3712_ _2428_ _2476_ VSS VSS VDD VDD _0653_ sky130_fd_sc_hd__and2_0
X_3713_ _2429_ _2476_ VSS VSS VDD VDD _0654_ sky130_fd_sc_hd__and2_0
X_3714_ _2430_ _2476_ VSS VSS VDD VDD _0655_ sky130_fd_sc_hd__and2_0
X_3715_ _2431_ _2476_ VSS VSS VDD VDD _0656_ sky130_fd_sc_hd__and2_0
X_3716_ _2432_ _2476_ VSS VSS VDD VDD _0657_ sky130_fd_sc_hd__and2_0
X_3717_ _2433_ _2476_ VSS VSS VDD VDD _0658_ sky130_fd_sc_hd__and2_0
X_3718_ _2434_ _2476_ VSS VSS VDD VDD _0659_ sky130_fd_sc_hd__and2_0
X_3719_ _2435_ _2476_ VSS VSS VDD VDD _0660_ sky130_fd_sc_hd__and2_0
X_3720_ _2436_ _2476_ VSS VSS VDD VDD _0661_ sky130_fd_sc_hd__and2_0
X_3721_ _2474_ VSS VSS VDD VDD _2477_ sky130_fd_sc_hd__buf_4
X_3722_ _2437_ _2477_ VSS VSS VDD VDD _0662_ sky130_fd_sc_hd__and2_0
X_3723_ _2439_ _2477_ VSS VSS VDD VDD _0663_ sky130_fd_sc_hd__and2_0
X_3724_ _2440_ _2477_ VSS VSS VDD VDD _0664_ sky130_fd_sc_hd__and2_0
X_3725_ _2441_ _2477_ VSS VSS VDD VDD _0665_ sky130_fd_sc_hd__and2_0
X_3726_ _2442_ _2477_ VSS VSS VDD VDD _0666_ sky130_fd_sc_hd__and2_0
X_3727_ _2443_ _2477_ VSS VSS VDD VDD _0667_ sky130_fd_sc_hd__and2_0
X_3728_ _2444_ _2477_ VSS VSS VDD VDD _0668_ sky130_fd_sc_hd__and2_0
X_3729_ _2445_ _2477_ VSS VSS VDD VDD _0669_ sky130_fd_sc_hd__and2_0
X_3730_ _2446_ _2477_ VSS VSS VDD VDD _0670_ sky130_fd_sc_hd__and2_0
X_3731_ _2447_ _2477_ VSS VSS VDD VDD _0671_ sky130_fd_sc_hd__and2_0
X_3732_ _2448_ _2474_ VSS VSS VDD VDD _0672_ sky130_fd_sc_hd__and2_0
X_3733_ _2449_ _2474_ VSS VSS VDD VDD _0673_ sky130_fd_sc_hd__and2_0
X_3734_ _1132_ _1143_ VSS VSS VDD VDD _2478_ sky130_fd_sc_hd__nor2_2
X_3735_ _2478_ VSS VSS VDD VDD _2479_ sky130_fd_sc_hd__buf_4
X_3736_ _2414_ _2479_ VSS VSS VDD VDD _0674_ sky130_fd_sc_hd__and2_0
X_3737_ _2417_ _2479_ VSS VSS VDD VDD _0675_ sky130_fd_sc_hd__and2_0
X_3738_ _2418_ _2479_ VSS VSS VDD VDD _0676_ sky130_fd_sc_hd__and2_0
X_3739_ _2419_ _2479_ VSS VSS VDD VDD _0677_ sky130_fd_sc_hd__and2_0
X_3740_ _2420_ _2479_ VSS VSS VDD VDD _0678_ sky130_fd_sc_hd__and2_0
X_3741_ _2421_ _2479_ VSS VSS VDD VDD _0679_ sky130_fd_sc_hd__and2_0
X_3742_ _2422_ _2479_ VSS VSS VDD VDD _0680_ sky130_fd_sc_hd__and2_0
X_3743_ _2423_ _2479_ VSS VSS VDD VDD _0681_ sky130_fd_sc_hd__and2_0
X_3744_ _2424_ _2479_ VSS VSS VDD VDD _0682_ sky130_fd_sc_hd__and2_0
X_3745_ _2425_ _2479_ VSS VSS VDD VDD _0683_ sky130_fd_sc_hd__and2_0
X_3746_ _2478_ VSS VSS VDD VDD _2480_ sky130_fd_sc_hd__clkbuf_4
X_3747_ _2426_ _2480_ VSS VSS VDD VDD _0684_ sky130_fd_sc_hd__and2_0
X_3748_ _2428_ _2480_ VSS VSS VDD VDD _0685_ sky130_fd_sc_hd__and2_0
X_3749_ _2429_ _2480_ VSS VSS VDD VDD _0686_ sky130_fd_sc_hd__and2_0
X_3750_ _2430_ _2480_ VSS VSS VDD VDD _0687_ sky130_fd_sc_hd__and2_0
X_3751_ _2431_ _2480_ VSS VSS VDD VDD _0688_ sky130_fd_sc_hd__and2_0
X_3752_ _2432_ _2480_ VSS VSS VDD VDD _0689_ sky130_fd_sc_hd__and2_0
X_3753_ _2433_ _2480_ VSS VSS VDD VDD _0690_ sky130_fd_sc_hd__and2_0
X_3754_ _2434_ _2480_ VSS VSS VDD VDD _0691_ sky130_fd_sc_hd__and2_0
X_3755_ _2435_ _2480_ VSS VSS VDD VDD _0692_ sky130_fd_sc_hd__and2_0
X_3756_ _2436_ _2480_ VSS VSS VDD VDD _0693_ sky130_fd_sc_hd__and2_0
X_3757_ _2478_ VSS VSS VDD VDD _2481_ sky130_fd_sc_hd__clkbuf_4
X_3758_ _2437_ _2481_ VSS VSS VDD VDD _0694_ sky130_fd_sc_hd__and2_0
X_3759_ _2439_ _2481_ VSS VSS VDD VDD _0695_ sky130_fd_sc_hd__and2_0
X_3760_ _2440_ _2481_ VSS VSS VDD VDD _0696_ sky130_fd_sc_hd__and2_0
X_3761_ _2441_ _2481_ VSS VSS VDD VDD _0697_ sky130_fd_sc_hd__and2_0
X_3762_ _2442_ _2481_ VSS VSS VDD VDD _0698_ sky130_fd_sc_hd__and2_0
X_3763_ _2443_ _2481_ VSS VSS VDD VDD _0699_ sky130_fd_sc_hd__and2_0
X_3764_ _2444_ _2481_ VSS VSS VDD VDD _0700_ sky130_fd_sc_hd__and2_0
X_3765_ _2445_ _2481_ VSS VSS VDD VDD _0701_ sky130_fd_sc_hd__and2_0
X_3766_ _2446_ _2481_ VSS VSS VDD VDD _0702_ sky130_fd_sc_hd__and2_0
X_3767_ _2447_ _2481_ VSS VSS VDD VDD _0703_ sky130_fd_sc_hd__and2_0
X_3768_ _2448_ _2478_ VSS VSS VDD VDD _0704_ sky130_fd_sc_hd__and2_0
X_3769_ _2449_ _2478_ VSS VSS VDD VDD _0705_ sky130_fd_sc_hd__and2_0
X_3770_ _1134_ _1143_ VSS VSS VDD VDD _2482_ sky130_fd_sc_hd__nor2_4
X_3771_ _2482_ VSS VSS VDD VDD _2483_ sky130_fd_sc_hd__buf_4
X_3772_ _2414_ _2483_ VSS VSS VDD VDD _0706_ sky130_fd_sc_hd__and2_0
X_3773_ _2417_ _2483_ VSS VSS VDD VDD _0707_ sky130_fd_sc_hd__and2_0
X_3774_ _2418_ _2483_ VSS VSS VDD VDD _0708_ sky130_fd_sc_hd__and2_0
X_3775_ _2419_ _2483_ VSS VSS VDD VDD _0709_ sky130_fd_sc_hd__and2_0
X_3776_ _2420_ _2483_ VSS VSS VDD VDD _0710_ sky130_fd_sc_hd__and2_0
X_3777_ _2421_ _2483_ VSS VSS VDD VDD _0711_ sky130_fd_sc_hd__and2_0
X_3778_ _2422_ _2483_ VSS VSS VDD VDD _0712_ sky130_fd_sc_hd__and2_0
X_3779_ _2423_ _2483_ VSS VSS VDD VDD _0713_ sky130_fd_sc_hd__and2_0
X_3780_ _2424_ _2483_ VSS VSS VDD VDD _0714_ sky130_fd_sc_hd__and2_0
X_3781_ _2425_ _2483_ VSS VSS VDD VDD _0715_ sky130_fd_sc_hd__and2_0
X_3782_ _2482_ VSS VSS VDD VDD _2484_ sky130_fd_sc_hd__buf_4
X_3783_ _2426_ _2484_ VSS VSS VDD VDD _0716_ sky130_fd_sc_hd__and2_0
X_3784_ _2428_ _2484_ VSS VSS VDD VDD _0717_ sky130_fd_sc_hd__and2_0
X_3785_ _2429_ _2484_ VSS VSS VDD VDD _0718_ sky130_fd_sc_hd__and2_0
X_3786_ _2430_ _2484_ VSS VSS VDD VDD _0719_ sky130_fd_sc_hd__and2_0
X_3787_ _2431_ _2484_ VSS VSS VDD VDD _0720_ sky130_fd_sc_hd__and2_0
X_3788_ _2432_ _2484_ VSS VSS VDD VDD _0721_ sky130_fd_sc_hd__and2_0
X_3789_ _2433_ _2484_ VSS VSS VDD VDD _0722_ sky130_fd_sc_hd__and2_0
X_3790_ _2434_ _2484_ VSS VSS VDD VDD _0723_ sky130_fd_sc_hd__and2_0
X_3791_ _2435_ _2484_ VSS VSS VDD VDD _0724_ sky130_fd_sc_hd__and2_0
X_3792_ _2436_ _2484_ VSS VSS VDD VDD _0725_ sky130_fd_sc_hd__and2_0
X_3793_ _2482_ VSS VSS VDD VDD _2485_ sky130_fd_sc_hd__buf_4
X_3794_ _2437_ _2485_ VSS VSS VDD VDD _0726_ sky130_fd_sc_hd__and2_0
X_3795_ _2439_ _2485_ VSS VSS VDD VDD _0727_ sky130_fd_sc_hd__and2_0
X_3796_ _2440_ _2485_ VSS VSS VDD VDD _0728_ sky130_fd_sc_hd__and2_0
X_3797_ _2441_ _2485_ VSS VSS VDD VDD _0729_ sky130_fd_sc_hd__and2_0
X_3798_ _2442_ _2485_ VSS VSS VDD VDD _0730_ sky130_fd_sc_hd__and2_0
X_3799_ _2443_ _2485_ VSS VSS VDD VDD _0731_ sky130_fd_sc_hd__and2_0
X_3800_ _2444_ _2485_ VSS VSS VDD VDD _0732_ sky130_fd_sc_hd__and2_0
X_3801_ _2445_ _2485_ VSS VSS VDD VDD _0733_ sky130_fd_sc_hd__and2_0
X_3802_ _2446_ _2485_ VSS VSS VDD VDD _0734_ sky130_fd_sc_hd__and2_0
X_3803_ _2447_ _2485_ VSS VSS VDD VDD _0735_ sky130_fd_sc_hd__and2_0
X_3804_ _2448_ _2482_ VSS VSS VDD VDD _0736_ sky130_fd_sc_hd__and2_0
X_3805_ _2449_ _2482_ VSS VSS VDD VDD _0737_ sky130_fd_sc_hd__and2_0
X_3806_ net11 VSS VSS VDD VDD _2486_ sky130_fd_sc_hd__clkbuf_4
X_3807_ _1127_ _1144_ VSS VSS VDD VDD _2487_ sky130_fd_sc_hd__nor2_2
X_3808_ _2487_ VSS VSS VDD VDD _2488_ sky130_fd_sc_hd__clkbuf_4
X_3809_ _2486_ _2488_ VSS VSS VDD VDD _0738_ sky130_fd_sc_hd__and2_0
X_3810_ net12 VSS VSS VDD VDD _2489_ sky130_fd_sc_hd__buf_2
X_3811_ _2489_ _2488_ VSS VSS VDD VDD _0739_ sky130_fd_sc_hd__and2_0
X_3812_ net13 VSS VSS VDD VDD _2490_ sky130_fd_sc_hd__clkbuf_4
X_3813_ _2490_ _2488_ VSS VSS VDD VDD _0740_ sky130_fd_sc_hd__and2_0
X_3814_ net14 VSS VSS VDD VDD _2491_ sky130_fd_sc_hd__buf_4
X_3815_ _2491_ _2488_ VSS VSS VDD VDD _0741_ sky130_fd_sc_hd__and2_0
X_3816_ net15 VSS VSS VDD VDD _2492_ sky130_fd_sc_hd__clkbuf_4
X_3817_ _2492_ _2488_ VSS VSS VDD VDD _0742_ sky130_fd_sc_hd__and2_0
X_3818_ net16 VSS VSS VDD VDD _2493_ sky130_fd_sc_hd__buf_4
X_3819_ _2493_ _2488_ VSS VSS VDD VDD _0743_ sky130_fd_sc_hd__and2_0
X_3820_ net17 VSS VSS VDD VDD _2494_ sky130_fd_sc_hd__buf_4
X_3821_ _2494_ _2488_ VSS VSS VDD VDD _0744_ sky130_fd_sc_hd__and2_0
X_3822_ net18 VSS VSS VDD VDD _2495_ sky130_fd_sc_hd__clkbuf_4
X_3823_ _2495_ _2488_ VSS VSS VDD VDD _0745_ sky130_fd_sc_hd__and2_0
X_3824_ net19 VSS VSS VDD VDD _2496_ sky130_fd_sc_hd__buf_4
X_3825_ _2496_ _2488_ VSS VSS VDD VDD _0746_ sky130_fd_sc_hd__and2_0
X_3826_ net20 VSS VSS VDD VDD _2497_ sky130_fd_sc_hd__clkbuf_4
X_3827_ _2497_ _2488_ VSS VSS VDD VDD _0747_ sky130_fd_sc_hd__and2_0
X_3828_ net21 VSS VSS VDD VDD _2498_ sky130_fd_sc_hd__buf_4
X_3829_ _2487_ VSS VSS VDD VDD _2499_ sky130_fd_sc_hd__clkbuf_4
X_3830_ _2498_ _2499_ VSS VSS VDD VDD _0748_ sky130_fd_sc_hd__and2_0
X_3831_ net22 VSS VSS VDD VDD _2500_ sky130_fd_sc_hd__buf_4
X_3832_ _2500_ _2499_ VSS VSS VDD VDD _0749_ sky130_fd_sc_hd__and2_0
X_3833_ net23 VSS VSS VDD VDD _2501_ sky130_fd_sc_hd__buf_4
X_3834_ _2501_ _2499_ VSS VSS VDD VDD _0750_ sky130_fd_sc_hd__and2_0
X_3835_ net24 VSS VSS VDD VDD _2502_ sky130_fd_sc_hd__buf_4
X_3836_ _2502_ _2499_ VSS VSS VDD VDD _0751_ sky130_fd_sc_hd__and2_0
X_3837_ net25 VSS VSS VDD VDD _2503_ sky130_fd_sc_hd__buf_4
X_3838_ _2503_ _2499_ VSS VSS VDD VDD _0752_ sky130_fd_sc_hd__and2_0
X_3839_ net26 VSS VSS VDD VDD _2504_ sky130_fd_sc_hd__buf_4
X_3840_ _2504_ _2499_ VSS VSS VDD VDD _0753_ sky130_fd_sc_hd__and2_0
X_3841_ net27 VSS VSS VDD VDD _2505_ sky130_fd_sc_hd__buf_4
X_3842_ _2505_ _2499_ VSS VSS VDD VDD _0754_ sky130_fd_sc_hd__and2_0
X_3843_ net28 VSS VSS VDD VDD _2506_ sky130_fd_sc_hd__buf_4
X_3844_ _2506_ _2499_ VSS VSS VDD VDD _0755_ sky130_fd_sc_hd__and2_0
X_3845_ net29 VSS VSS VDD VDD _2507_ sky130_fd_sc_hd__clkbuf_4
X_3846_ _2507_ _2499_ VSS VSS VDD VDD _0756_ sky130_fd_sc_hd__and2_0
X_3847_ net30 VSS VSS VDD VDD _2508_ sky130_fd_sc_hd__buf_4
X_3848_ _2508_ _2499_ VSS VSS VDD VDD _0757_ sky130_fd_sc_hd__and2_0
X_3849_ net31 VSS VSS VDD VDD _2509_ sky130_fd_sc_hd__buf_4
X_3850_ _2487_ VSS VSS VDD VDD _2510_ sky130_fd_sc_hd__clkbuf_4
X_3851_ _2509_ _2510_ VSS VSS VDD VDD _0758_ sky130_fd_sc_hd__and2_0
X_3852_ net32 VSS VSS VDD VDD _2511_ sky130_fd_sc_hd__buf_4
X_3853_ _2511_ _2510_ VSS VSS VDD VDD _0759_ sky130_fd_sc_hd__and2_0
X_3854_ net33 VSS VSS VDD VDD _2512_ sky130_fd_sc_hd__buf_4
X_3855_ _2512_ _2510_ VSS VSS VDD VDD _0760_ sky130_fd_sc_hd__and2_0
X_3856_ net34 VSS VSS VDD VDD _2513_ sky130_fd_sc_hd__buf_4
X_3857_ _2513_ _2510_ VSS VSS VDD VDD _0761_ sky130_fd_sc_hd__and2_0
X_3858_ net35 VSS VSS VDD VDD _2514_ sky130_fd_sc_hd__buf_4
X_3859_ _2514_ _2510_ VSS VSS VDD VDD _0762_ sky130_fd_sc_hd__and2_0
X_3860_ net36 VSS VSS VDD VDD _2515_ sky130_fd_sc_hd__clkbuf_4
X_3861_ _2515_ _2510_ VSS VSS VDD VDD _0763_ sky130_fd_sc_hd__and2_0
X_3862_ net37 VSS VSS VDD VDD _2516_ sky130_fd_sc_hd__buf_4
X_3863_ _2516_ _2510_ VSS VSS VDD VDD _0764_ sky130_fd_sc_hd__and2_0
X_3864_ net38 VSS VSS VDD VDD _2517_ sky130_fd_sc_hd__clkbuf_4
X_3865_ _2517_ _2510_ VSS VSS VDD VDD _0765_ sky130_fd_sc_hd__and2_0
X_3866_ net39 VSS VSS VDD VDD _2518_ sky130_fd_sc_hd__clkbuf_4
X_3867_ _2518_ _2510_ VSS VSS VDD VDD _0766_ sky130_fd_sc_hd__and2_0
X_3868_ net40 VSS VSS VDD VDD _2519_ sky130_fd_sc_hd__clkbuf_4
X_3869_ _2519_ _2510_ VSS VSS VDD VDD _0767_ sky130_fd_sc_hd__and2_0
X_3870_ net41 VSS VSS VDD VDD _2520_ sky130_fd_sc_hd__clkbuf_4
X_3871_ _2520_ _2487_ VSS VSS VDD VDD _0768_ sky130_fd_sc_hd__and2_0
X_3872_ net42 VSS VSS VDD VDD _2521_ sky130_fd_sc_hd__clkbuf_4
X_3873_ _2521_ _2487_ VSS VSS VDD VDD _0769_ sky130_fd_sc_hd__and2_0
X_3874_ _1137_ _1144_ VSS VSS VDD VDD _2522_ sky130_fd_sc_hd__nor2_2
X_3875_ _2522_ VSS VSS VDD VDD _2523_ sky130_fd_sc_hd__buf_4
X_3876_ _2486_ _2523_ VSS VSS VDD VDD _0770_ sky130_fd_sc_hd__and2_0
X_3877_ _2489_ _2523_ VSS VSS VDD VDD _0771_ sky130_fd_sc_hd__and2_0
X_3878_ _2490_ _2523_ VSS VSS VDD VDD _0772_ sky130_fd_sc_hd__and2_0
X_3879_ _2491_ _2523_ VSS VSS VDD VDD _0773_ sky130_fd_sc_hd__and2_0
X_3880_ _2492_ _2523_ VSS VSS VDD VDD _0774_ sky130_fd_sc_hd__and2_0
X_3881_ _2493_ _2523_ VSS VSS VDD VDD _0775_ sky130_fd_sc_hd__and2_0
X_3882_ _2494_ _2523_ VSS VSS VDD VDD _0776_ sky130_fd_sc_hd__and2_0
X_3883_ _2495_ _2523_ VSS VSS VDD VDD _0777_ sky130_fd_sc_hd__and2_0
X_3884_ _2496_ _2523_ VSS VSS VDD VDD _0778_ sky130_fd_sc_hd__and2_0
X_3885_ _2497_ _2523_ VSS VSS VDD VDD _0779_ sky130_fd_sc_hd__and2_0
X_3886_ _2522_ VSS VSS VDD VDD _2524_ sky130_fd_sc_hd__buf_4
X_3887_ _2498_ _2524_ VSS VSS VDD VDD _0780_ sky130_fd_sc_hd__and2_0
X_3888_ _2500_ _2524_ VSS VSS VDD VDD _0781_ sky130_fd_sc_hd__and2_0
X_3889_ _2501_ _2524_ VSS VSS VDD VDD _0782_ sky130_fd_sc_hd__and2_0
X_3890_ _2502_ _2524_ VSS VSS VDD VDD _0783_ sky130_fd_sc_hd__and2_0
X_3891_ _2503_ _2524_ VSS VSS VDD VDD _0784_ sky130_fd_sc_hd__and2_0
X_3892_ _2504_ _2524_ VSS VSS VDD VDD _0785_ sky130_fd_sc_hd__and2_0
X_3893_ _2505_ _2524_ VSS VSS VDD VDD _0786_ sky130_fd_sc_hd__and2_0
X_3894_ _2506_ _2524_ VSS VSS VDD VDD _0787_ sky130_fd_sc_hd__and2_0
X_3895_ _2507_ _2524_ VSS VSS VDD VDD _0788_ sky130_fd_sc_hd__and2_0
X_3896_ _2508_ _2524_ VSS VSS VDD VDD _0789_ sky130_fd_sc_hd__and2_0
X_3897_ _2522_ VSS VSS VDD VDD _2525_ sky130_fd_sc_hd__buf_4
X_3898_ _2509_ _2525_ VSS VSS VDD VDD _0790_ sky130_fd_sc_hd__and2_0
X_3899_ _2511_ _2525_ VSS VSS VDD VDD _0791_ sky130_fd_sc_hd__and2_0
X_3900_ _2512_ _2525_ VSS VSS VDD VDD _0792_ sky130_fd_sc_hd__and2_0
X_3901_ _2513_ _2525_ VSS VSS VDD VDD _0793_ sky130_fd_sc_hd__and2_0
X_3902_ _2514_ _2525_ VSS VSS VDD VDD _0794_ sky130_fd_sc_hd__and2_0
X_3903_ _2515_ _2525_ VSS VSS VDD VDD _0795_ sky130_fd_sc_hd__and2_0
X_3904_ _2516_ _2525_ VSS VSS VDD VDD _0796_ sky130_fd_sc_hd__and2_0
X_3905_ _2517_ _2525_ VSS VSS VDD VDD _0797_ sky130_fd_sc_hd__and2_0
X_3906_ _2518_ _2525_ VSS VSS VDD VDD _0798_ sky130_fd_sc_hd__and2_0
X_3907_ _2519_ _2525_ VSS VSS VDD VDD _0799_ sky130_fd_sc_hd__and2_0
X_3908_ _2520_ _2522_ VSS VSS VDD VDD _0800_ sky130_fd_sc_hd__and2_0
X_3909_ _2521_ _2522_ VSS VSS VDD VDD _0801_ sky130_fd_sc_hd__and2_0
X_3910_ _1124_ _1133_ VSS VSS VDD VDD _2526_ sky130_fd_sc_hd__nor2_4
X_3911_ _2526_ VSS VSS VDD VDD _2527_ sky130_fd_sc_hd__buf_4
X_3912_ _2486_ _2527_ VSS VSS VDD VDD _0802_ sky130_fd_sc_hd__and2_0
X_3913_ _2489_ _2527_ VSS VSS VDD VDD _0803_ sky130_fd_sc_hd__and2_0
X_3914_ _2490_ _2527_ VSS VSS VDD VDD _0804_ sky130_fd_sc_hd__and2_0
X_3915_ _2491_ _2527_ VSS VSS VDD VDD _0805_ sky130_fd_sc_hd__and2_0
X_3916_ _2492_ _2527_ VSS VSS VDD VDD _0806_ sky130_fd_sc_hd__and2_0
X_3917_ _2493_ _2527_ VSS VSS VDD VDD _0807_ sky130_fd_sc_hd__and2_0
X_3918_ _2494_ _2527_ VSS VSS VDD VDD _0808_ sky130_fd_sc_hd__and2_0
X_3919_ _2495_ _2527_ VSS VSS VDD VDD _0809_ sky130_fd_sc_hd__and2_0
X_3920_ _2496_ _2527_ VSS VSS VDD VDD _0810_ sky130_fd_sc_hd__and2_0
X_3921_ _2497_ _2527_ VSS VSS VDD VDD _0811_ sky130_fd_sc_hd__and2_0
X_3922_ _2526_ VSS VSS VDD VDD _2528_ sky130_fd_sc_hd__buf_4
X_3923_ _2498_ _2528_ VSS VSS VDD VDD _0812_ sky130_fd_sc_hd__and2_0
X_3924_ _2500_ _2528_ VSS VSS VDD VDD _0813_ sky130_fd_sc_hd__and2_0
X_3925_ _2501_ _2528_ VSS VSS VDD VDD _0814_ sky130_fd_sc_hd__and2_0
X_3926_ _2502_ _2528_ VSS VSS VDD VDD _0815_ sky130_fd_sc_hd__and2_0
X_3927_ _2503_ _2528_ VSS VSS VDD VDD _0816_ sky130_fd_sc_hd__and2_0
X_3928_ _2504_ _2528_ VSS VSS VDD VDD _0817_ sky130_fd_sc_hd__and2_0
X_3929_ _2505_ _2528_ VSS VSS VDD VDD _0818_ sky130_fd_sc_hd__and2_0
X_3930_ _2506_ _2528_ VSS VSS VDD VDD _0819_ sky130_fd_sc_hd__and2_0
X_3931_ _2507_ _2528_ VSS VSS VDD VDD _0820_ sky130_fd_sc_hd__and2_0
X_3932_ _2508_ _2528_ VSS VSS VDD VDD _0821_ sky130_fd_sc_hd__and2_0
X_3933_ _2526_ VSS VSS VDD VDD _2529_ sky130_fd_sc_hd__buf_4
X_3934_ _2509_ _2529_ VSS VSS VDD VDD _0822_ sky130_fd_sc_hd__and2_0
X_3935_ _2511_ _2529_ VSS VSS VDD VDD _0823_ sky130_fd_sc_hd__and2_0
X_3936_ _2512_ _2529_ VSS VSS VDD VDD _0824_ sky130_fd_sc_hd__and2_0
X_3937_ _2513_ _2529_ VSS VSS VDD VDD _0825_ sky130_fd_sc_hd__and2_0
X_3938_ _2514_ _2529_ VSS VSS VDD VDD _0826_ sky130_fd_sc_hd__and2_0
X_3939_ _2515_ _2529_ VSS VSS VDD VDD _0827_ sky130_fd_sc_hd__and2_0
X_3940_ _2516_ _2529_ VSS VSS VDD VDD _0828_ sky130_fd_sc_hd__and2_0
X_3941_ _2517_ _2529_ VSS VSS VDD VDD _0829_ sky130_fd_sc_hd__and2_0
X_3942_ _2518_ _2529_ VSS VSS VDD VDD _0830_ sky130_fd_sc_hd__and2_0
X_3943_ _2519_ _2529_ VSS VSS VDD VDD _0831_ sky130_fd_sc_hd__and2_0
X_3944_ _2520_ _2526_ VSS VSS VDD VDD _0832_ sky130_fd_sc_hd__and2_0
X_3945_ _2521_ _2526_ VSS VSS VDD VDD _0833_ sky130_fd_sc_hd__and2_0
X_3946_ _1132_ _1144_ VSS VSS VDD VDD _2530_ sky130_fd_sc_hd__nor2_2
X_3947_ _2530_ VSS VSS VDD VDD _2531_ sky130_fd_sc_hd__clkbuf_4
X_3948_ _2486_ _2531_ VSS VSS VDD VDD _0834_ sky130_fd_sc_hd__and2_0
X_3949_ _2489_ _2531_ VSS VSS VDD VDD _0835_ sky130_fd_sc_hd__and2_0
X_3950_ _2490_ _2531_ VSS VSS VDD VDD _0836_ sky130_fd_sc_hd__and2_0
X_3951_ _2491_ _2531_ VSS VSS VDD VDD _0837_ sky130_fd_sc_hd__and2_0
X_3952_ _2492_ _2531_ VSS VSS VDD VDD _0838_ sky130_fd_sc_hd__and2_0
X_3953_ _2493_ _2531_ VSS VSS VDD VDD _0839_ sky130_fd_sc_hd__and2_0
X_3954_ _2494_ _2531_ VSS VSS VDD VDD _0840_ sky130_fd_sc_hd__and2_0
X_3955_ _2495_ _2531_ VSS VSS VDD VDD _0841_ sky130_fd_sc_hd__and2_0
X_3956_ _2496_ _2531_ VSS VSS VDD VDD _0842_ sky130_fd_sc_hd__and2_0
X_3957_ _2497_ _2531_ VSS VSS VDD VDD _0843_ sky130_fd_sc_hd__and2_0
X_3958_ _2530_ VSS VSS VDD VDD _2532_ sky130_fd_sc_hd__buf_4
X_3959_ _2498_ _2532_ VSS VSS VDD VDD _0844_ sky130_fd_sc_hd__and2_0
X_3960_ _2500_ _2532_ VSS VSS VDD VDD _0845_ sky130_fd_sc_hd__and2_0
X_3961_ _2501_ _2532_ VSS VSS VDD VDD _0846_ sky130_fd_sc_hd__and2_0
X_3962_ _2502_ _2532_ VSS VSS VDD VDD _0847_ sky130_fd_sc_hd__and2_0
X_3963_ _2503_ _2532_ VSS VSS VDD VDD _0848_ sky130_fd_sc_hd__and2_0
X_3964_ _2504_ _2532_ VSS VSS VDD VDD _0849_ sky130_fd_sc_hd__and2_0
X_3965_ _2505_ _2532_ VSS VSS VDD VDD _0850_ sky130_fd_sc_hd__and2_0
X_3966_ _2506_ _2532_ VSS VSS VDD VDD _0851_ sky130_fd_sc_hd__and2_0
X_3967_ _2507_ _2532_ VSS VSS VDD VDD _0852_ sky130_fd_sc_hd__and2_0
X_3968_ _2508_ _2532_ VSS VSS VDD VDD _0853_ sky130_fd_sc_hd__and2_0
X_3969_ _2530_ VSS VSS VDD VDD _2533_ sky130_fd_sc_hd__clkbuf_4
X_3970_ _2509_ _2533_ VSS VSS VDD VDD _0854_ sky130_fd_sc_hd__and2_0
X_3971_ _2511_ _2533_ VSS VSS VDD VDD _0855_ sky130_fd_sc_hd__and2_0
X_3972_ _2512_ _2533_ VSS VSS VDD VDD _0856_ sky130_fd_sc_hd__and2_0
X_3973_ _2513_ _2533_ VSS VSS VDD VDD _0857_ sky130_fd_sc_hd__and2_0
X_3974_ _2514_ _2533_ VSS VSS VDD VDD _0858_ sky130_fd_sc_hd__and2_0
X_3975_ _2515_ _2533_ VSS VSS VDD VDD _0859_ sky130_fd_sc_hd__and2_0
X_3976_ _2516_ _2533_ VSS VSS VDD VDD _0860_ sky130_fd_sc_hd__and2_0
X_3977_ _2517_ _2533_ VSS VSS VDD VDD _0861_ sky130_fd_sc_hd__and2_0
X_3978_ _2518_ _2533_ VSS VSS VDD VDD _0862_ sky130_fd_sc_hd__and2_0
X_3979_ _2519_ _2533_ VSS VSS VDD VDD _0863_ sky130_fd_sc_hd__and2_0
X_3980_ _2520_ _2530_ VSS VSS VDD VDD _0864_ sky130_fd_sc_hd__and2_0
X_3981_ _2521_ _2530_ VSS VSS VDD VDD _0865_ sky130_fd_sc_hd__and2_0
X_3982_ _1134_ _1144_ VSS VSS VDD VDD _2534_ sky130_fd_sc_hd__nor2_2
X_3983_ _2534_ VSS VSS VDD VDD _2535_ sky130_fd_sc_hd__buf_4
X_3984_ _2486_ _2535_ VSS VSS VDD VDD _0866_ sky130_fd_sc_hd__and2_0
X_3985_ _2489_ _2535_ VSS VSS VDD VDD _0867_ sky130_fd_sc_hd__and2_0
X_3986_ _2490_ _2535_ VSS VSS VDD VDD _0868_ sky130_fd_sc_hd__and2_0
X_3987_ _2491_ _2535_ VSS VSS VDD VDD _0869_ sky130_fd_sc_hd__and2_0
X_3988_ _2492_ _2535_ VSS VSS VDD VDD _0870_ sky130_fd_sc_hd__and2_0
X_3989_ _2493_ _2535_ VSS VSS VDD VDD _0871_ sky130_fd_sc_hd__and2_0
X_3990_ _2494_ _2535_ VSS VSS VDD VDD _0872_ sky130_fd_sc_hd__and2_0
X_3991_ _2495_ _2535_ VSS VSS VDD VDD _0873_ sky130_fd_sc_hd__and2_0
X_3992_ _2496_ _2535_ VSS VSS VDD VDD _0874_ sky130_fd_sc_hd__and2_0
X_3993_ _2497_ _2535_ VSS VSS VDD VDD _0875_ sky130_fd_sc_hd__and2_0
X_3994_ _2534_ VSS VSS VDD VDD _2536_ sky130_fd_sc_hd__buf_4
X_3995_ _2498_ _2536_ VSS VSS VDD VDD _0876_ sky130_fd_sc_hd__and2_0
X_3996_ _2500_ _2536_ VSS VSS VDD VDD _0877_ sky130_fd_sc_hd__and2_0
X_3997_ _2501_ _2536_ VSS VSS VDD VDD _0878_ sky130_fd_sc_hd__and2_0
X_3998_ _2502_ _2536_ VSS VSS VDD VDD _0879_ sky130_fd_sc_hd__and2_0
X_3999_ _2503_ _2536_ VSS VSS VDD VDD _0880_ sky130_fd_sc_hd__and2_0
X_4000_ _2504_ _2536_ VSS VSS VDD VDD _0881_ sky130_fd_sc_hd__and2_0
X_4001_ _2505_ _2536_ VSS VSS VDD VDD _0882_ sky130_fd_sc_hd__and2_0
X_4002_ _2506_ _2536_ VSS VSS VDD VDD _0883_ sky130_fd_sc_hd__and2_0
X_4003_ _2507_ _2536_ VSS VSS VDD VDD _0884_ sky130_fd_sc_hd__and2_0
X_4004_ _2508_ _2536_ VSS VSS VDD VDD _0885_ sky130_fd_sc_hd__and2_0
X_4005_ _2534_ VSS VSS VDD VDD _2537_ sky130_fd_sc_hd__buf_4
X_4006_ _2509_ _2537_ VSS VSS VDD VDD _0886_ sky130_fd_sc_hd__and2_0
X_4007_ _2511_ _2537_ VSS VSS VDD VDD _0887_ sky130_fd_sc_hd__and2_0
X_4008_ _2512_ _2537_ VSS VSS VDD VDD _0888_ sky130_fd_sc_hd__and2_0
X_4009_ _2513_ _2537_ VSS VSS VDD VDD _0889_ sky130_fd_sc_hd__and2_0
X_4010_ _2514_ _2537_ VSS VSS VDD VDD _0890_ sky130_fd_sc_hd__and2_0
X_4011_ _2515_ _2537_ VSS VSS VDD VDD _0891_ sky130_fd_sc_hd__and2_0
X_4012_ _2516_ _2537_ VSS VSS VDD VDD _0892_ sky130_fd_sc_hd__and2_0
X_4013_ _2517_ _2537_ VSS VSS VDD VDD _0893_ sky130_fd_sc_hd__and2_0
X_4014_ _2518_ _2537_ VSS VSS VDD VDD _0894_ sky130_fd_sc_hd__and2_0
X_4015_ _2519_ _2537_ VSS VSS VDD VDD _0895_ sky130_fd_sc_hd__and2_0
X_4016_ _2520_ _2534_ VSS VSS VDD VDD _0896_ sky130_fd_sc_hd__and2_0
X_4017_ _2521_ _2534_ VSS VSS VDD VDD _0897_ sky130_fd_sc_hd__and2_0
X_4018_ _1124_ _1135_ VSS VSS VDD VDD _2538_ sky130_fd_sc_hd__nor2_4
X_4019_ _2538_ VSS VSS VDD VDD _2539_ sky130_fd_sc_hd__buf_4
X_4020_ _2486_ _2539_ VSS VSS VDD VDD _0898_ sky130_fd_sc_hd__and2_0
X_4021_ _2489_ _2539_ VSS VSS VDD VDD _0899_ sky130_fd_sc_hd__and2_0
X_4022_ _2490_ _2539_ VSS VSS VDD VDD _0900_ sky130_fd_sc_hd__and2_0
X_4023_ _2491_ _2539_ VSS VSS VDD VDD _0901_ sky130_fd_sc_hd__and2_0
X_4024_ _2492_ _2539_ VSS VSS VDD VDD _0902_ sky130_fd_sc_hd__and2_0
X_4025_ _2493_ _2539_ VSS VSS VDD VDD _0903_ sky130_fd_sc_hd__and2_0
X_4026_ _2494_ _2539_ VSS VSS VDD VDD _0904_ sky130_fd_sc_hd__and2_0
X_4027_ _2495_ _2539_ VSS VSS VDD VDD _0905_ sky130_fd_sc_hd__and2_0
X_4028_ _2496_ _2539_ VSS VSS VDD VDD _0906_ sky130_fd_sc_hd__and2_0
X_4029_ _2497_ _2539_ VSS VSS VDD VDD _0907_ sky130_fd_sc_hd__and2_0
X_4030_ _2538_ VSS VSS VDD VDD _2540_ sky130_fd_sc_hd__buf_4
X_4031_ _2498_ _2540_ VSS VSS VDD VDD _0908_ sky130_fd_sc_hd__and2_0
X_4032_ _2500_ _2540_ VSS VSS VDD VDD _0909_ sky130_fd_sc_hd__and2_0
X_4033_ _2501_ _2540_ VSS VSS VDD VDD _0910_ sky130_fd_sc_hd__and2_0
X_4034_ _2502_ _2540_ VSS VSS VDD VDD _0911_ sky130_fd_sc_hd__and2_0
X_4035_ _2503_ _2540_ VSS VSS VDD VDD _0912_ sky130_fd_sc_hd__and2_0
X_4036_ _2504_ _2540_ VSS VSS VDD VDD _0913_ sky130_fd_sc_hd__and2_0
X_4037_ _2505_ _2540_ VSS VSS VDD VDD _0914_ sky130_fd_sc_hd__and2_0
X_4038_ _2506_ _2540_ VSS VSS VDD VDD _0915_ sky130_fd_sc_hd__and2_0
X_4039_ _2507_ _2540_ VSS VSS VDD VDD _0916_ sky130_fd_sc_hd__and2_0
X_4040_ _2508_ _2540_ VSS VSS VDD VDD _0917_ sky130_fd_sc_hd__and2_0
X_4041_ _2538_ VSS VSS VDD VDD _2541_ sky130_fd_sc_hd__buf_4
X_4042_ _2509_ _2541_ VSS VSS VDD VDD _0918_ sky130_fd_sc_hd__and2_0
X_4043_ _2511_ _2541_ VSS VSS VDD VDD _0919_ sky130_fd_sc_hd__and2_0
X_4044_ _2512_ _2541_ VSS VSS VDD VDD _0920_ sky130_fd_sc_hd__and2_0
X_4045_ _2513_ _2541_ VSS VSS VDD VDD _0921_ sky130_fd_sc_hd__and2_0
X_4046_ _2514_ _2541_ VSS VSS VDD VDD _0922_ sky130_fd_sc_hd__and2_0
X_4047_ _2515_ _2541_ VSS VSS VDD VDD _0923_ sky130_fd_sc_hd__and2_0
X_4048_ _2516_ _2541_ VSS VSS VDD VDD _0924_ sky130_fd_sc_hd__and2_0
X_4049_ _2517_ _2541_ VSS VSS VDD VDD _0925_ sky130_fd_sc_hd__and2_0
X_4050_ _2518_ _2541_ VSS VSS VDD VDD _0926_ sky130_fd_sc_hd__and2_0
X_4051_ _2519_ _2541_ VSS VSS VDD VDD _0927_ sky130_fd_sc_hd__and2_0
X_4052_ _2520_ _2538_ VSS VSS VDD VDD _0928_ sky130_fd_sc_hd__and2_0
X_4053_ _2521_ _2538_ VSS VSS VDD VDD _0929_ sky130_fd_sc_hd__and2_0
X_4054_ _1127_ _1147_ VSS VSS VDD VDD _2542_ sky130_fd_sc_hd__nor2_2
X_4055_ _2542_ VSS VSS VDD VDD _2543_ sky130_fd_sc_hd__buf_4
X_4056_ _2486_ _2543_ VSS VSS VDD VDD _0930_ sky130_fd_sc_hd__and2_0
X_4057_ _2489_ _2543_ VSS VSS VDD VDD _0931_ sky130_fd_sc_hd__and2_0
X_4058_ _2490_ _2543_ VSS VSS VDD VDD _0932_ sky130_fd_sc_hd__and2_0
X_4059_ _2491_ _2543_ VSS VSS VDD VDD _0933_ sky130_fd_sc_hd__and2_0
X_4060_ _2492_ _2543_ VSS VSS VDD VDD _0934_ sky130_fd_sc_hd__and2_0
X_4061_ _2493_ _2543_ VSS VSS VDD VDD _0935_ sky130_fd_sc_hd__and2_0
X_4062_ _2494_ _2543_ VSS VSS VDD VDD _0936_ sky130_fd_sc_hd__and2_0
X_4063_ _2495_ _2543_ VSS VSS VDD VDD _0937_ sky130_fd_sc_hd__and2_0
X_4064_ _2496_ _2543_ VSS VSS VDD VDD _0938_ sky130_fd_sc_hd__and2_0
X_4065_ _2497_ _2543_ VSS VSS VDD VDD _0939_ sky130_fd_sc_hd__and2_0
X_4066_ _2542_ VSS VSS VDD VDD _2544_ sky130_fd_sc_hd__buf_4
X_4067_ _2498_ _2544_ VSS VSS VDD VDD _0940_ sky130_fd_sc_hd__and2_0
X_4068_ _2500_ _2544_ VSS VSS VDD VDD _0941_ sky130_fd_sc_hd__and2_0
X_4069_ _2501_ _2544_ VSS VSS VDD VDD _0942_ sky130_fd_sc_hd__and2_0
X_4070_ _2502_ _2544_ VSS VSS VDD VDD _0943_ sky130_fd_sc_hd__and2_0
X_4071_ _2503_ _2544_ VSS VSS VDD VDD _0944_ sky130_fd_sc_hd__and2_0
X_4072_ _2504_ _2544_ VSS VSS VDD VDD _0945_ sky130_fd_sc_hd__and2_0
X_4073_ _2505_ _2544_ VSS VSS VDD VDD _0946_ sky130_fd_sc_hd__and2_0
X_4074_ _2506_ _2544_ VSS VSS VDD VDD _0947_ sky130_fd_sc_hd__and2_0
X_4075_ _2507_ _2544_ VSS VSS VDD VDD _0948_ sky130_fd_sc_hd__and2_0
X_4076_ _2508_ _2544_ VSS VSS VDD VDD _0949_ sky130_fd_sc_hd__and2_0
X_4077_ _2542_ VSS VSS VDD VDD _2545_ sky130_fd_sc_hd__buf_4
X_4078_ _2509_ _2545_ VSS VSS VDD VDD _0950_ sky130_fd_sc_hd__and2_0
X_4079_ _2511_ _2545_ VSS VSS VDD VDD _0951_ sky130_fd_sc_hd__and2_0
X_4080_ _2512_ _2545_ VSS VSS VDD VDD _0952_ sky130_fd_sc_hd__and2_0
X_4081_ _2513_ _2545_ VSS VSS VDD VDD _0953_ sky130_fd_sc_hd__and2_0
X_4082_ _2514_ _2545_ VSS VSS VDD VDD _0954_ sky130_fd_sc_hd__and2_0
X_4083_ _2515_ _2545_ VSS VSS VDD VDD _0955_ sky130_fd_sc_hd__and2_0
X_4084_ _2516_ _2545_ VSS VSS VDD VDD _0956_ sky130_fd_sc_hd__and2_0
X_4085_ _2517_ _2545_ VSS VSS VDD VDD _0957_ sky130_fd_sc_hd__and2_0
X_4086_ _2518_ _2545_ VSS VSS VDD VDD _0958_ sky130_fd_sc_hd__and2_0
X_4087_ _2519_ _2545_ VSS VSS VDD VDD _0959_ sky130_fd_sc_hd__and2_0
X_4088_ _2520_ _2542_ VSS VSS VDD VDD _0960_ sky130_fd_sc_hd__and2_0
X_4089_ _2521_ _2542_ VSS VSS VDD VDD _0961_ sky130_fd_sc_hd__and2_0
X_4090_ _1137_ _1147_ VSS VSS VDD VDD _2546_ sky130_fd_sc_hd__nor2_2
X_4091_ _2546_ VSS VSS VDD VDD _2547_ sky130_fd_sc_hd__buf_4
X_4092_ _2486_ _2547_ VSS VSS VDD VDD _0962_ sky130_fd_sc_hd__and2_0
X_4093_ _2489_ _2547_ VSS VSS VDD VDD _0963_ sky130_fd_sc_hd__and2_0
X_4094_ _2490_ _2547_ VSS VSS VDD VDD _0964_ sky130_fd_sc_hd__and2_0
X_4095_ _2491_ _2547_ VSS VSS VDD VDD _0965_ sky130_fd_sc_hd__and2_0
X_4096_ _2492_ _2547_ VSS VSS VDD VDD _0966_ sky130_fd_sc_hd__and2_0
X_4097_ _2493_ _2547_ VSS VSS VDD VDD _0967_ sky130_fd_sc_hd__and2_0
X_4098_ _2494_ _2547_ VSS VSS VDD VDD _0968_ sky130_fd_sc_hd__and2_0
X_4099_ _2495_ _2547_ VSS VSS VDD VDD _0969_ sky130_fd_sc_hd__and2_0
X_4100_ _2496_ _2547_ VSS VSS VDD VDD _0970_ sky130_fd_sc_hd__and2_0
X_4101_ _2497_ _2547_ VSS VSS VDD VDD _0971_ sky130_fd_sc_hd__and2_0
X_4102_ _2546_ VSS VSS VDD VDD _2548_ sky130_fd_sc_hd__buf_4
X_4103_ _2498_ _2548_ VSS VSS VDD VDD _0972_ sky130_fd_sc_hd__and2_0
X_4104_ _2500_ _2548_ VSS VSS VDD VDD _0973_ sky130_fd_sc_hd__and2_0
X_4105_ _2501_ _2548_ VSS VSS VDD VDD _0974_ sky130_fd_sc_hd__and2_0
X_4106_ _2502_ _2548_ VSS VSS VDD VDD _0975_ sky130_fd_sc_hd__and2_0
X_4107_ _2503_ _2548_ VSS VSS VDD VDD _0976_ sky130_fd_sc_hd__and2_0
X_4108_ _2504_ _2548_ VSS VSS VDD VDD _0977_ sky130_fd_sc_hd__and2_0
X_4109_ _2505_ _2548_ VSS VSS VDD VDD _0978_ sky130_fd_sc_hd__and2_0
X_4110_ _2506_ _2548_ VSS VSS VDD VDD _0979_ sky130_fd_sc_hd__and2_0
X_4111_ _2507_ _2548_ VSS VSS VDD VDD _0980_ sky130_fd_sc_hd__and2_0
X_4112_ _2508_ _2548_ VSS VSS VDD VDD _0981_ sky130_fd_sc_hd__and2_0
X_4113_ _2546_ VSS VSS VDD VDD _2549_ sky130_fd_sc_hd__buf_4
X_4114_ _2509_ _2549_ VSS VSS VDD VDD _0982_ sky130_fd_sc_hd__and2_0
X_4115_ _2511_ _2549_ VSS VSS VDD VDD _0983_ sky130_fd_sc_hd__and2_0
X_4116_ _2512_ _2549_ VSS VSS VDD VDD _0984_ sky130_fd_sc_hd__and2_0
X_4117_ _2513_ _2549_ VSS VSS VDD VDD _0985_ sky130_fd_sc_hd__and2_0
X_4118_ _2514_ _2549_ VSS VSS VDD VDD _0986_ sky130_fd_sc_hd__and2_0
X_4119_ _2515_ _2549_ VSS VSS VDD VDD _0987_ sky130_fd_sc_hd__and2_0
X_4120_ _2516_ _2549_ VSS VSS VDD VDD _0988_ sky130_fd_sc_hd__and2_0
X_4121_ _2517_ _2549_ VSS VSS VDD VDD _0989_ sky130_fd_sc_hd__and2_0
X_4122_ _2518_ _2549_ VSS VSS VDD VDD _0990_ sky130_fd_sc_hd__and2_0
X_4123_ _2519_ _2549_ VSS VSS VDD VDD _0991_ sky130_fd_sc_hd__and2_0
X_4124_ _2520_ _2546_ VSS VSS VDD VDD _0992_ sky130_fd_sc_hd__and2_0
X_4125_ _2521_ _2546_ VSS VSS VDD VDD _0993_ sky130_fd_sc_hd__and2_0
X_4126_ _1132_ _1147_ VSS VSS VDD VDD _2550_ sky130_fd_sc_hd__nor2_2
X_4127_ _2550_ VSS VSS VDD VDD _2551_ sky130_fd_sc_hd__buf_4
X_4128_ _2486_ _2551_ VSS VSS VDD VDD _0994_ sky130_fd_sc_hd__and2_0
X_4129_ _2489_ _2551_ VSS VSS VDD VDD _0995_ sky130_fd_sc_hd__and2_0
X_4130_ _2490_ _2551_ VSS VSS VDD VDD _0996_ sky130_fd_sc_hd__and2_0
X_4131_ _2491_ _2551_ VSS VSS VDD VDD _0997_ sky130_fd_sc_hd__and2_0
X_4132_ _2492_ _2551_ VSS VSS VDD VDD _0998_ sky130_fd_sc_hd__and2_0
X_4133_ _2493_ _2551_ VSS VSS VDD VDD _0999_ sky130_fd_sc_hd__and2_0
X_4134_ _2494_ _2551_ VSS VSS VDD VDD _1000_ sky130_fd_sc_hd__and2_0
X_4135_ _2495_ _2551_ VSS VSS VDD VDD _1001_ sky130_fd_sc_hd__and2_0
X_4136_ _2496_ _2551_ VSS VSS VDD VDD _1002_ sky130_fd_sc_hd__and2_0
X_4137_ _2497_ _2551_ VSS VSS VDD VDD _1003_ sky130_fd_sc_hd__and2_0
X_4138_ _2550_ VSS VSS VDD VDD _2552_ sky130_fd_sc_hd__buf_4
X_4139_ _2498_ _2552_ VSS VSS VDD VDD _1004_ sky130_fd_sc_hd__and2_0
X_4140_ _2500_ _2552_ VSS VSS VDD VDD _1005_ sky130_fd_sc_hd__and2_0
X_4141_ _2501_ _2552_ VSS VSS VDD VDD _1006_ sky130_fd_sc_hd__and2_0
X_4142_ _2502_ _2552_ VSS VSS VDD VDD _1007_ sky130_fd_sc_hd__and2_0
X_4143_ _2503_ _2552_ VSS VSS VDD VDD _1008_ sky130_fd_sc_hd__and2_0
X_4144_ _2504_ _2552_ VSS VSS VDD VDD _1009_ sky130_fd_sc_hd__and2_0
X_4145_ _2505_ _2552_ VSS VSS VDD VDD _1010_ sky130_fd_sc_hd__and2_0
X_4146_ _2506_ _2552_ VSS VSS VDD VDD _1011_ sky130_fd_sc_hd__and2_0
X_4147_ _2507_ _2552_ VSS VSS VDD VDD _1012_ sky130_fd_sc_hd__and2_0
X_4148_ _2508_ _2552_ VSS VSS VDD VDD _1013_ sky130_fd_sc_hd__and2_0
X_4149_ _2550_ VSS VSS VDD VDD _2553_ sky130_fd_sc_hd__buf_4
X_4150_ _2509_ _2553_ VSS VSS VDD VDD _1014_ sky130_fd_sc_hd__and2_0
X_4151_ _2511_ _2553_ VSS VSS VDD VDD _1015_ sky130_fd_sc_hd__and2_0
X_4152_ _2512_ _2553_ VSS VSS VDD VDD _1016_ sky130_fd_sc_hd__and2_0
X_4153_ _2513_ _2553_ VSS VSS VDD VDD _1017_ sky130_fd_sc_hd__and2_0
X_4154_ _2514_ _2553_ VSS VSS VDD VDD _1018_ sky130_fd_sc_hd__and2_0
X_4155_ _2515_ _2553_ VSS VSS VDD VDD _1019_ sky130_fd_sc_hd__and2_0
X_4156_ _2516_ _2553_ VSS VSS VDD VDD _1020_ sky130_fd_sc_hd__and2_0
X_4157_ _2517_ _2553_ VSS VSS VDD VDD _1021_ sky130_fd_sc_hd__and2_0
X_4158_ _2518_ _2553_ VSS VSS VDD VDD _1022_ sky130_fd_sc_hd__and2_0
X_4159_ _2519_ _2553_ VSS VSS VDD VDD _1023_ sky130_fd_sc_hd__and2_0
X_4160_ _2520_ _2550_ VSS VSS VDD VDD _1024_ sky130_fd_sc_hd__and2_0
X_4161_ _2521_ _2550_ VSS VSS VDD VDD _1025_ sky130_fd_sc_hd__and2_0
X_4162_ _1134_ _1147_ VSS VSS VDD VDD _2554_ sky130_fd_sc_hd__nor2_2
X_4163_ _2554_ VSS VSS VDD VDD _2555_ sky130_fd_sc_hd__buf_4
X_4164_ _2486_ _2555_ VSS VSS VDD VDD _1026_ sky130_fd_sc_hd__and2_0
X_4165_ _2489_ _2555_ VSS VSS VDD VDD _1027_ sky130_fd_sc_hd__and2_0
X_4166_ _2490_ _2555_ VSS VSS VDD VDD _1028_ sky130_fd_sc_hd__and2_0
X_4167_ _2491_ _2555_ VSS VSS VDD VDD _1029_ sky130_fd_sc_hd__and2_0
X_4168_ _2492_ _2555_ VSS VSS VDD VDD _1030_ sky130_fd_sc_hd__and2_0
X_4169_ _2493_ _2555_ VSS VSS VDD VDD _1031_ sky130_fd_sc_hd__and2_0
X_4170_ _2494_ _2555_ VSS VSS VDD VDD _1032_ sky130_fd_sc_hd__and2_0
X_4171_ _2495_ _2555_ VSS VSS VDD VDD _1033_ sky130_fd_sc_hd__and2_0
X_4172_ _2496_ _2555_ VSS VSS VDD VDD _1034_ sky130_fd_sc_hd__and2_0
X_4173_ _2497_ _2555_ VSS VSS VDD VDD _1035_ sky130_fd_sc_hd__and2_0
X_4174_ _2554_ VSS VSS VDD VDD _2556_ sky130_fd_sc_hd__buf_4
X_4175_ _2498_ _2556_ VSS VSS VDD VDD _1036_ sky130_fd_sc_hd__and2_0
X_4176_ _2500_ _2556_ VSS VSS VDD VDD _1037_ sky130_fd_sc_hd__and2_0
X_4177_ _2501_ _2556_ VSS VSS VDD VDD _1038_ sky130_fd_sc_hd__and2_0
X_4178_ _2502_ _2556_ VSS VSS VDD VDD _1039_ sky130_fd_sc_hd__and2_0
X_4179_ _2503_ _2556_ VSS VSS VDD VDD _1040_ sky130_fd_sc_hd__and2_0
X_4180_ _2504_ _2556_ VSS VSS VDD VDD _1041_ sky130_fd_sc_hd__and2_0
X_4181_ _2505_ _2556_ VSS VSS VDD VDD _1042_ sky130_fd_sc_hd__and2_0
X_4182_ _2506_ _2556_ VSS VSS VDD VDD _1043_ sky130_fd_sc_hd__and2_0
X_4183_ _2507_ _2556_ VSS VSS VDD VDD _1044_ sky130_fd_sc_hd__and2_0
X_4184_ _2508_ _2556_ VSS VSS VDD VDD _1045_ sky130_fd_sc_hd__and2_0
X_4185_ _2554_ VSS VSS VDD VDD _2557_ sky130_fd_sc_hd__buf_4
X_4186_ _2509_ _2557_ VSS VSS VDD VDD _1046_ sky130_fd_sc_hd__and2_0
X_4187_ _2511_ _2557_ VSS VSS VDD VDD _1047_ sky130_fd_sc_hd__and2_0
X_4188_ _2512_ _2557_ VSS VSS VDD VDD _1048_ sky130_fd_sc_hd__and2_0
X_4189_ _2513_ _2557_ VSS VSS VDD VDD _1049_ sky130_fd_sc_hd__and2_0
X_4190_ _2514_ _2557_ VSS VSS VDD VDD _1050_ sky130_fd_sc_hd__and2_0
X_4191_ _2515_ _2557_ VSS VSS VDD VDD _1051_ sky130_fd_sc_hd__and2_0
X_4192_ _2516_ _2557_ VSS VSS VDD VDD _1052_ sky130_fd_sc_hd__and2_0
X_4193_ _2517_ _2557_ VSS VSS VDD VDD _1053_ sky130_fd_sc_hd__and2_0
X_4194_ _2518_ _2557_ VSS VSS VDD VDD _1054_ sky130_fd_sc_hd__and2_0
X_4195_ _2519_ _2557_ VSS VSS VDD VDD _1055_ sky130_fd_sc_hd__and2_0
X_4196_ _2520_ _2554_ VSS VSS VDD VDD _1056_ sky130_fd_sc_hd__and2_0
X_4197_ _2521_ _2554_ VSS VSS VDD VDD _1057_ sky130_fd_sc_hd__and2_0
X_4198_ _1127_ _1131_ VSS VSS VDD VDD _2558_ sky130_fd_sc_hd__nor2_8
X_4199_ _2558_ VSS VSS VDD VDD _2559_ sky130_fd_sc_hd__buf_4
X_4200_ net11 _2559_ VSS VSS VDD VDD _1058_ sky130_fd_sc_hd__and2_0
X_4201_ net12 _2559_ VSS VSS VDD VDD _1059_ sky130_fd_sc_hd__and2_0
X_4202_ net13 _2559_ VSS VSS VDD VDD _1060_ sky130_fd_sc_hd__and2_0
X_4203_ net14 _2559_ VSS VSS VDD VDD _1061_ sky130_fd_sc_hd__and2_0
X_4204_ net15 _2559_ VSS VSS VDD VDD _1062_ sky130_fd_sc_hd__and2_0
X_4205_ net16 _2559_ VSS VSS VDD VDD _1063_ sky130_fd_sc_hd__and2_0
X_4206_ net17 _2559_ VSS VSS VDD VDD _1064_ sky130_fd_sc_hd__and2_0
X_4207_ net18 _2559_ VSS VSS VDD VDD _1065_ sky130_fd_sc_hd__and2_0
X_4208_ net19 _2559_ VSS VSS VDD VDD _1066_ sky130_fd_sc_hd__and2_0
X_4209_ net20 _2559_ VSS VSS VDD VDD _1067_ sky130_fd_sc_hd__and2_0
X_4210_ _2558_ VSS VSS VDD VDD _2560_ sky130_fd_sc_hd__clkbuf_4
X_4211_ net21 _2560_ VSS VSS VDD VDD _1068_ sky130_fd_sc_hd__and2_0
X_4212_ net22 _2560_ VSS VSS VDD VDD _1069_ sky130_fd_sc_hd__and2_0
X_4213_ net23 _2560_ VSS VSS VDD VDD _1070_ sky130_fd_sc_hd__and2_0
X_4214_ net24 _2560_ VSS VSS VDD VDD _1071_ sky130_fd_sc_hd__and2_0
X_4215_ net25 _2560_ VSS VSS VDD VDD _1072_ sky130_fd_sc_hd__and2_0
X_4216_ net26 _2560_ VSS VSS VDD VDD _1073_ sky130_fd_sc_hd__and2_0
X_4217_ net27 _2560_ VSS VSS VDD VDD _1074_ sky130_fd_sc_hd__and2_0
X_4218_ net28 _2560_ VSS VSS VDD VDD _1075_ sky130_fd_sc_hd__and2_0
X_4219_ net29 _2560_ VSS VSS VDD VDD _1076_ sky130_fd_sc_hd__and2_0
X_4220_ net30 _2560_ VSS VSS VDD VDD _1077_ sky130_fd_sc_hd__and2_0
X_4221_ _2558_ VSS VSS VDD VDD _2561_ sky130_fd_sc_hd__buf_4
X_4222_ net31 _2561_ VSS VSS VDD VDD _1078_ sky130_fd_sc_hd__and2_0
X_4223_ net32 _2561_ VSS VSS VDD VDD _1079_ sky130_fd_sc_hd__and2_0
X_4224_ net33 _2561_ VSS VSS VDD VDD _1080_ sky130_fd_sc_hd__and2_0
X_4225_ net34 _2561_ VSS VSS VDD VDD _1081_ sky130_fd_sc_hd__and2_0
X_4226_ net35 _2561_ VSS VSS VDD VDD _1082_ sky130_fd_sc_hd__and2_0
X_4227_ net36 _2561_ VSS VSS VDD VDD _1083_ sky130_fd_sc_hd__and2_0
X_4228_ net37 _2561_ VSS VSS VDD VDD _1084_ sky130_fd_sc_hd__and2_0
X_4229_ net38 _2561_ VSS VSS VDD VDD _1085_ sky130_fd_sc_hd__and2_0
X_4230_ net39 _2561_ VSS VSS VDD VDD _1086_ sky130_fd_sc_hd__and2_0
X_4231_ net40 _2561_ VSS VSS VDD VDD _1087_ sky130_fd_sc_hd__and2_0
X_4232_ net41 _2558_ VSS VSS VDD VDD _1088_ sky130_fd_sc_hd__and2_0
X_4233_ net42 _2558_ VSS VSS VDD VDD _1089_ sky130_fd_sc_hd__and2_0
X_4234_ _1131_ _1137_ VSS VSS VDD VDD _2562_ sky130_fd_sc_hd__nor2_8
X_4235_ _2562_ VSS VSS VDD VDD _2563_ sky130_fd_sc_hd__buf_4
X_4236_ net11 _2563_ VSS VSS VDD VDD _1090_ sky130_fd_sc_hd__and2_0
X_4237_ net12 _2563_ VSS VSS VDD VDD _1091_ sky130_fd_sc_hd__and2_0
X_4238_ net13 _2563_ VSS VSS VDD VDD _1092_ sky130_fd_sc_hd__and2_0
X_4239_ net14 _2563_ VSS VSS VDD VDD _1093_ sky130_fd_sc_hd__and2_0
X_4240_ net15 _2563_ VSS VSS VDD VDD _1094_ sky130_fd_sc_hd__and2_0
X_4241_ net16 _2563_ VSS VSS VDD VDD _1095_ sky130_fd_sc_hd__and2_0
X_4242_ net17 _2563_ VSS VSS VDD VDD _1096_ sky130_fd_sc_hd__and2_0
X_4243_ net18 _2563_ VSS VSS VDD VDD _1097_ sky130_fd_sc_hd__and2_0
X_4244_ net19 _2563_ VSS VSS VDD VDD _1098_ sky130_fd_sc_hd__and2_0
X_4245_ net20 _2563_ VSS VSS VDD VDD _1099_ sky130_fd_sc_hd__and2_0
X_4246_ _2562_ VSS VSS VDD VDD _2564_ sky130_fd_sc_hd__clkbuf_4
X_4247_ net21 _2564_ VSS VSS VDD VDD _1100_ sky130_fd_sc_hd__and2_0
X_4248_ net22 _2564_ VSS VSS VDD VDD _1101_ sky130_fd_sc_hd__and2_0
X_4249_ net23 _2564_ VSS VSS VDD VDD _1102_ sky130_fd_sc_hd__and2_0
X_4250_ net24 _2564_ VSS VSS VDD VDD _1103_ sky130_fd_sc_hd__and2_0
X_4251_ net25 _2564_ VSS VSS VDD VDD _1104_ sky130_fd_sc_hd__and2_0
X_4252_ net26 _2564_ VSS VSS VDD VDD _1105_ sky130_fd_sc_hd__and2_0
X_4253_ net27 _2564_ VSS VSS VDD VDD _1106_ sky130_fd_sc_hd__and2_0
X_4254_ net28 _2564_ VSS VSS VDD VDD _1107_ sky130_fd_sc_hd__and2_0
X_4255_ net29 _2564_ VSS VSS VDD VDD _1108_ sky130_fd_sc_hd__and2_0
X_4256_ net30 _2564_ VSS VSS VDD VDD _1109_ sky130_fd_sc_hd__and2_0
X_4257_ _2562_ VSS VSS VDD VDD _2565_ sky130_fd_sc_hd__buf_4
X_4258_ net31 _2565_ VSS VSS VDD VDD _1110_ sky130_fd_sc_hd__and2_0
X_4259_ net32 _2565_ VSS VSS VDD VDD _1111_ sky130_fd_sc_hd__and2_0
X_4260_ net33 _2565_ VSS VSS VDD VDD _1112_ sky130_fd_sc_hd__and2_0
X_4261_ net34 _2565_ VSS VSS VDD VDD _1113_ sky130_fd_sc_hd__and2_0
X_4262_ net35 _2565_ VSS VSS VDD VDD _1114_ sky130_fd_sc_hd__and2_0
X_4263_ net36 _2565_ VSS VSS VDD VDD _1115_ sky130_fd_sc_hd__and2_0
X_4264_ net37 _2565_ VSS VSS VDD VDD _1116_ sky130_fd_sc_hd__and2_0
X_4265_ net38 _2565_ VSS VSS VDD VDD _1117_ sky130_fd_sc_hd__and2_0
X_4266_ net39 _2565_ VSS VSS VDD VDD _1118_ sky130_fd_sc_hd__and2_0
X_4267_ net40 _2565_ VSS VSS VDD VDD _1119_ sky130_fd_sc_hd__and2_0
X_4268_ net41 _2562_ VSS VSS VDD VDD _1120_ sky130_fd_sc_hd__and2_0
X_4269_ net42 _2562_ VSS VSS VDD VDD _1121_ sky130_fd_sc_hd__and2_0
X_4270_ net5 VSS VSS VDD VDD _1122_ sky130_fd_sc_hd__buf_8
X_4271_ net3 _1122_ VSS VSS VDD VDD _0032_ sky130_fd_sc_hd__nand2b_4
X_4272_ net4 _1122_ VSS VSS VDD VDD _0033_ sky130_fd_sc_hd__nand2b_4
X_4273_ net9 net10 net8 VSS VSS VDD VDD _1123_ sky130_fd_sc_hd__or3_1
X_4274_ _1123_ VSS VSS VDD VDD _1124_ sky130_fd_sc_hd__buf_6
X_4275_ net5 net43 VSS VSS VDD VDD _1125_ sky130_fd_sc_hd__nand2_1
X_4276_ net6 net7 _1125_ VSS VSS VDD VDD _1126_ sky130_fd_sc_hd__or3_1
X_4277_ _1126_ VSS VSS VDD VDD _1127_ sky130_fd_sc_hd__buf_8
X_4278_ _1127_ VSS VSS VDD VDD _1128_ sky130_fd_sc_hd__buf_16
X_4279_ _1122_ VSS VSS VDD VDD _1129_ sky130_fd_sc_hd__buf_8
X_4280_ _1124_ _1128_ _1129_ VSS VSS VDD VDD _0031_ sky130_fd_sc_hd__o21ai_4
X_4281_ net10 net8 VSS VSS VDD VDD _1130_ sky130_fd_sc_hd__nor2_2
X_4282_ net9 _1130_ VSS VSS VDD VDD _1131_ sky130_fd_sc_hd__nand2_8
X_4283_ net6 net7 net43 net5 VSS VSS VDD VDD _1132_ sky130_fd_sc_hd__nand4b_4
X_4284_ _1132_ VSS VSS VDD VDD _1133_ sky130_fd_sc_hd__buf_8
X_4285_ _1131_ _1133_ _1129_ VSS VSS VDD VDD _0030_ sky130_fd_sc_hd__o21ai_4
X_4286_ _1122_ net6 net7 net43 VSS VSS VDD VDD _1134_ sky130_fd_sc_hd__nand4_4
X_4287_ _1134_ VSS VSS VDD VDD _1135_ sky130_fd_sc_hd__buf_8
X_4288_ _1131_ _1135_ _1129_ VSS VSS VDD VDD _0029_ sky130_fd_sc_hd__o21ai_4
X_4289_ net10 net8 net9 VSS VSS VDD VDD _1136_ sky130_fd_sc_hd__nand3b_4
X_4290_ _1128_ _1136_ _1129_ VSS VSS VDD VDD _0028_ sky130_fd_sc_hd__o21ai_4
X_4291_ net7 net43 net5 net6 VSS VSS VDD VDD _1137_ sky130_fd_sc_hd__nand4b_4
X_4292_ _1137_ VSS VSS VDD VDD _1138_ sky130_fd_sc_hd__clkbuf_16
X_4293_ _1136_ _1138_ _1129_ VSS VSS VDD VDD _0027_ sky130_fd_sc_hd__o21ai_4
X_4294_ _1133_ _1136_ _1129_ VSS VSS VDD VDD _0026_ sky130_fd_sc_hd__o21ai_4
X_4295_ _1135_ _1136_ _1129_ VSS VSS VDD VDD _0025_ sky130_fd_sc_hd__o21ai_4
X_4296_ net9 net8 VSS VSS VDD VDD _1139_ sky130_fd_sc_hd__nor2_2
X_4297_ net10 _1139_ VSS VSS VDD VDD _1140_ sky130_fd_sc_hd__nand2_8
X_4298_ _1128_ _1140_ _1129_ VSS VSS VDD VDD _0024_ sky130_fd_sc_hd__o21ai_4
X_4299_ _1138_ _1140_ _1129_ VSS VSS VDD VDD _0023_ sky130_fd_sc_hd__o21ai_4
X_4300_ _1133_ _1140_ _1129_ VSS VSS VDD VDD _0022_ sky130_fd_sc_hd__o21ai_4
X_4301_ _1122_ VSS VSS VDD VDD _1141_ sky130_fd_sc_hd__buf_8
X_4302_ _1135_ _1140_ _1141_ VSS VSS VDD VDD _0021_ sky130_fd_sc_hd__o21ai_4
X_4303_ _1124_ _1138_ _1141_ VSS VSS VDD VDD _0020_ sky130_fd_sc_hd__o21ai_4
X_4304_ net9 net10 net8 VSS VSS VDD VDD _1142_ sky130_fd_sc_hd__nand3b_4
X_4305_ _1128_ _1142_ _1141_ VSS VSS VDD VDD _0019_ sky130_fd_sc_hd__o21ai_4
X_4306_ _1138_ _1142_ _1141_ VSS VSS VDD VDD _0018_ sky130_fd_sc_hd__o21ai_4
X_4307_ _1133_ _1142_ _1141_ VSS VSS VDD VDD _0017_ sky130_fd_sc_hd__o21ai_4
X_4308_ _1135_ _1142_ _1141_ VSS VSS VDD VDD _0016_ sky130_fd_sc_hd__o21ai_4
X_4309_ net8 net10 net9 VSS VSS VDD VDD _1143_ sky130_fd_sc_hd__nand3b_4
X_4310_ _1128_ _1143_ _1141_ VSS VSS VDD VDD _0015_ sky130_fd_sc_hd__o21ai_4
X_4311_ _1138_ _1143_ _1141_ VSS VSS VDD VDD _0014_ sky130_fd_sc_hd__o21ai_4
X_4312_ _1133_ _1143_ _1141_ VSS VSS VDD VDD _0013_ sky130_fd_sc_hd__o21ai_4
X_4313_ _1135_ _1143_ _1141_ VSS VSS VDD VDD _0012_ sky130_fd_sc_hd__o21ai_4
X_4314_ net9 net10 net8 VSS VSS VDD VDD _1144_ sky130_fd_sc_hd__nand3_4
X_4315_ _1122_ VSS VSS VDD VDD _1145_ sky130_fd_sc_hd__buf_8
X_4316_ _1128_ _1144_ _1145_ VSS VSS VDD VDD _0011_ sky130_fd_sc_hd__o21ai_4
X_4317_ _1138_ _1144_ _1145_ VSS VSS VDD VDD _0010_ sky130_fd_sc_hd__o21ai_4
X_4318_ _1124_ _1133_ _1145_ VSS VSS VDD VDD _0009_ sky130_fd_sc_hd__o21ai_4
X_4319_ _1133_ _1144_ _1145_ VSS VSS VDD VDD _0008_ sky130_fd_sc_hd__o21ai_4
X_4320_ _1135_ _1144_ _1145_ VSS VSS VDD VDD _0007_ sky130_fd_sc_hd__o21ai_4
X_4321_ _1124_ _1135_ _1145_ VSS VSS VDD VDD _0006_ sky130_fd_sc_hd__o21ai_4
X_4322_ net9 net10 net8 VSS VSS VDD VDD _1146_ sky130_fd_sc_hd__or3b_1
X_4323_ _1146_ VSS VSS VDD VDD _1147_ sky130_fd_sc_hd__buf_4
X_4324_ _1128_ _1147_ _1145_ VSS VSS VDD VDD _0005_ sky130_fd_sc_hd__o21ai_4
X_4325_ _1138_ _1147_ _1145_ VSS VSS VDD VDD _0004_ sky130_fd_sc_hd__o21ai_4
X_4326_ _1133_ _1147_ _1145_ VSS VSS VDD VDD _0003_ sky130_fd_sc_hd__o21ai_4
X_4327_ _1135_ _1147_ _1145_ VSS VSS VDD VDD _0002_ sky130_fd_sc_hd__o21ai_4
X_4328_ _1128_ _1131_ _1122_ VSS VSS VDD VDD _0001_ sky130_fd_sc_hd__o21ai_4
X_4329_ _1131_ _1138_ _1122_ VSS VSS VDD VDD _0000_ sky130_fd_sc_hd__o21ai_4
X_4330_ net168 VSS VSS VDD VDD _1148_ sky130_fd_sc_hd__buf_8
X_4331_ _1148_ VSS VSS VDD VDD _1149_ sky130_fd_sc_hd__buf_4
X_4332_ read_addr1[0] VSS VSS VDD VDD _1150_ sky130_fd_sc_hd__buf_6
X_4333_ _1150_ VSS VSS VDD VDD _1151_ sky130_fd_sc_hd__clkinvlp_4
X_4334_ _1151_ VSS VSS VDD VDD _1152_ sky130_fd_sc_hd__buf_16
X_4335_ _1152_ VSS VSS VDD VDD _1153_ sky130_fd_sc_hd__buf_12
X_4336_ _1153_ VSS VSS VDD VDD _1154_ sky130_fd_sc_hd__buf_16
X_4337_ read_addr1[1] VSS VSS VDD VDD _1155_ sky130_fd_sc_hd__buf_8
X_4338_ _1155_ VSS VSS VDD VDD _1156_ sky130_fd_sc_hd__buf_16
X_4339_ _1156_ VSS VSS VDD VDD _1157_ sky130_fd_sc_hd__buf_8
X_4340_ read_addr1[2] VSS VSS VDD VDD _1158_ sky130_fd_sc_hd__buf_2
X_4341_ _1158_ VSS VSS VDD VDD _1159_ sky130_fd_sc_hd__buf_6
X_4342_ _1159_ VSS VSS VDD VDD _1160_ sky130_fd_sc_hd__buf_6
X_4343_ registers\[25\]\[0\] registers\[27\]\[0\] registers\[29\]\[0\]
+ registers\[31\]\[0\] _1157_ _1160_ VSS VSS VDD VDD _1161_
+ sky130_fd_sc_hd__mux4_1
X_4344_ _1159_ VSS VSS VDD VDD _1162_ sky130_fd_sc_hd__buf_6
X_4345_ _1162_ VSS VSS VDD VDD _1163_ sky130_fd_sc_hd__buf_6
X_4346_ registers\[24\]\[0\] registers\[28\]\[0\] _1163_ VSS
+ VSS VDD VDD _1164_ sky130_fd_sc_hd__mux2i_1
X_4347_ _1150_ VSS VSS VDD VDD _1165_ sky130_fd_sc_hd__buf_6
X_4348_ _1155_ VSS VSS VDD VDD _1166_ sky130_fd_sc_hd__buf_8
X_4349_ _1166_ VSS VSS VDD VDD _1167_ sky130_fd_sc_hd__buf_8
X_4350_ _1165_ _1167_ VSS VSS VDD VDD _1168_ sky130_fd_sc_hd__nor2_2
X_4351_ _1168_ VSS VSS VDD VDD _1169_ sky130_fd_sc_hd__buf_6
X_4352_ _1164_ _1169_ VSS VSS VDD VDD _1170_ sky130_fd_sc_hd__nand2_1
X_4353_ registers\[26\]\[0\] registers\[30\]\[0\] _1163_ VSS
+ VSS VDD VDD _1171_ sky130_fd_sc_hd__mux2i_1
X_4354_ _1165_ _1167_ VSS VSS VDD VDD _1172_ sky130_fd_sc_hd__nor2b_2
X_4355_ _1172_ VSS VSS VDD VDD _1173_ sky130_fd_sc_hd__buf_6
X_4356_ _1171_ _1173_ VSS VSS VDD VDD _1174_ sky130_fd_sc_hd__nand2_1
X_4357_ net1 VSS VSS VDD VDD _1175_ sky130_fd_sc_hd__buf_8
X_4358_ _1175_ VSS VSS VDD VDD _1176_ sky130_fd_sc_hd__buf_16
X_4359_ _1154_ _1161_ _1170_ _1174_ _1176_ VSS VSS VDD VDD
+ _1177_ sky130_fd_sc_hd__o2111ai_4
X_4360_ _1156_ VSS VSS VDD VDD _1178_ sky130_fd_sc_hd__buf_6
X_4361_ _1162_ VSS VSS VDD VDD _1179_ sky130_fd_sc_hd__buf_6
X_4362_ registers\[16\]\[0\] registers\[18\]\[0\] registers\[20\]\[0\]
+ registers\[22\]\[0\] _1178_ _1179_ VSS VSS VDD VDD _1180_
+ sky130_fd_sc_hd__mux4_1
X_4363_ _1165_ _1175_ VSS VSS VDD VDD _1181_ sky130_fd_sc_hd__nor2_8
X_4364_ _1153_ _1175_ VSS VSS VDD VDD _1182_ sky130_fd_sc_hd__nor2_8
X_4365_ _1156_ VSS VSS VDD VDD _1183_ sky130_fd_sc_hd__buf_8
X_4366_ registers\[17\]\[0\] registers\[19\]\[0\] registers\[21\]\[0\]
+ registers\[23\]\[0\] _1183_ _1179_ VSS VSS VDD VDD _1184_
+ sky130_fd_sc_hd__mux4_1
X_4367_ _1180_ _1181_ _1182_ _1184_ VSS VSS VDD VDD _1185_
+ sky130_fd_sc_hd__a22oi_1
X_4368_ _1175_ _1148_ VSS VSS VDD VDD _1186_ sky130_fd_sc_hd__nor2_4
X_4369_ _1186_ VSS VSS VDD VDD _1187_ sky130_fd_sc_hd__buf_4
X_4370_ registers\[0\]\[0\] registers\[1\]\[0\] registers\[2\]\[0\]
+ registers\[3\]\[0\] _1165_ _1183_ VSS VSS VDD VDD _1188_ sky130_fd_sc_hd__mux4_1
X_4371_ _1150_ VSS VSS VDD VDD _1189_ sky130_fd_sc_hd__buf_6
X_4372_ registers\[4\]\[0\] registers\[5\]\[0\] registers\[6\]\[0\]
+ registers\[7\]\[0\] _1189_ _1178_ VSS VSS VDD VDD _1190_ sky130_fd_sc_hd__mux4_1
X_4373_ _1158_ VSS VSS VDD VDD _1191_ sky130_fd_sc_hd__buf_8
X_4374_ _1191_ VSS VSS VDD VDD _1192_ sky130_fd_sc_hd__buf_8
X_4375_ _1188_ _1190_ _1192_ VSS VSS VDD VDD _1193_ sky130_fd_sc_hd__mux2i_1
X_4376_ _1148_ net1 VSS VSS VDD VDD _1194_ sky130_fd_sc_hd__nor2b_1
X_4377_ _1194_ VSS VSS VDD VDD _1195_ sky130_fd_sc_hd__clkbuf_4
X_4378_ _1195_ VSS VSS VDD VDD _1196_ sky130_fd_sc_hd__clkbuf_16
X_4379_ registers\[9\]\[0\] registers\[11\]\[0\] registers\[13\]\[0\]
+ registers\[15\]\[0\] _1155_ _1159_ VSS VSS VDD VDD _1197_
+ sky130_fd_sc_hd__mux4_1
X_4380_ registers\[8\]\[0\] registers\[10\]\[0\] registers\[12\]\[0\]
+ registers\[14\]\[0\] _1155_ _1159_ VSS VSS VDD VDD _1198_
+ sky130_fd_sc_hd__mux4_1
X_4381_ _1197_ _1198_ _1152_ VSS VSS VDD VDD _1199_ sky130_fd_sc_hd__mux2i_1
X_4382_ net3 _1122_ VSS VSS VDD VDD _1200_ sky130_fd_sc_hd__nand2_4
X_4383_ _1200_ VSS VSS VDD VDD _1201_ sky130_fd_sc_hd__buf_4
X_4384_ _1187_ _1193_ _1196_ _1199_ _1201_ VSS VSS VDD VDD
+ _1202_ sky130_fd_sc_hd__a221o_2
X_4385_ _1149_ _1177_ _1185_ _1202_ VSS VSS VDD VDD _0034_
+ sky130_fd_sc_hd__a31oi_2
X_4386_ _1152_ VSS VSS VDD VDD _1203_ sky130_fd_sc_hd__clkbuf_4
X_4387_ _1166_ VSS VSS VDD VDD _1204_ sky130_fd_sc_hd__buf_4
X_4388_ _1162_ VSS VSS VDD VDD _1205_ sky130_fd_sc_hd__buf_6
X_4389_ registers\[17\]\[10\] registers\[19\]\[10\] registers\[21\]\[10\]
+ registers\[23\]\[10\] _1204_ _1205_ VSS VSS VDD VDD _1206_
+ sky130_fd_sc_hd__mux4_1
X_4390_ registers\[18\]\[10\] registers\[22\]\[10\] _1160_
+ VSS VSS VDD VDD _1207_ sky130_fd_sc_hd__mux2i_1
X_4391_ registers\[16\]\[10\] registers\[20\]\[10\] _1179_
+ VSS VSS VDD VDD _1208_ sky130_fd_sc_hd__mux2i_1
X_4392_ _1173_ _1207_ _1208_ _1169_ _1176_ VSS VSS VDD VDD
+ _1209_ sky130_fd_sc_hd__a221oi_1
X_4393_ _1203_ _1206_ _1209_ VSS VSS VDD VDD _1210_ sky130_fd_sc_hd__o21ai_1
X_4394_ registers\[24\]\[10\] registers\[26\]\[10\] registers\[28\]\[10\]
+ registers\[30\]\[10\] _1178_ _1179_ VSS VSS VDD VDD _1211_
+ sky130_fd_sc_hd__mux4_1
X_4395_ _1165_ _1175_ VSS VSS VDD VDD _1212_ sky130_fd_sc_hd__nor2b_4
X_4396_ _1165_ _1175_ VSS VSS VDD VDD _1213_ sky130_fd_sc_hd__and2_0
X_4397_ _1213_ VSS VSS VDD VDD _1214_ sky130_fd_sc_hd__clkbuf_4
X_4398_ _1214_ VSS VSS VDD VDD _1215_ sky130_fd_sc_hd__buf_6
X_4399_ registers\[25\]\[10\] registers\[27\]\[10\] registers\[29\]\[10\]
+ registers\[31\]\[10\] _1183_ _1179_ VSS VSS VDD VDD _1216_
+ sky130_fd_sc_hd__mux4_1
X_4400_ _1211_ _1212_ _1215_ _1216_ VSS VSS VDD VDD _1217_
+ sky130_fd_sc_hd__a22oi_2
X_4401_ registers\[0\]\[10\] registers\[1\]\[10\] registers\[2\]\[10\]
+ registers\[3\]\[10\] _1165_ _1183_ VSS VSS VDD VDD _1218_
+ sky130_fd_sc_hd__mux4_1
X_4402_ _1156_ VSS VSS VDD VDD _1219_ sky130_fd_sc_hd__buf_6
X_4403_ registers\[4\]\[10\] registers\[5\]\[10\] registers\[6\]\[10\]
+ registers\[7\]\[10\] _1189_ _1219_ VSS VSS VDD VDD _1220_
+ sky130_fd_sc_hd__mux4_1
X_4404_ _1218_ _1220_ _1192_ VSS VSS VDD VDD _1221_ sky130_fd_sc_hd__mux2i_1
X_4405_ _1159_ VSS VSS VDD VDD _1222_ sky130_fd_sc_hd__buf_8
X_4406_ registers\[9\]\[10\] registers\[11\]\[10\] registers\[13\]\[10\]
+ registers\[15\]\[10\] _1156_ _1222_ VSS VSS VDD VDD _1223_
+ sky130_fd_sc_hd__mux4_1
X_4407_ _1155_ VSS VSS VDD VDD _1224_ sky130_fd_sc_hd__buf_8
X_4408_ _1159_ VSS VSS VDD VDD _1225_ sky130_fd_sc_hd__buf_6
X_4409_ registers\[8\]\[10\] registers\[10\]\[10\] registers\[12\]\[10\]
+ registers\[14\]\[10\] _1224_ _1225_ VSS VSS VDD VDD _1226_
+ sky130_fd_sc_hd__mux4_1
X_4410_ _1223_ _1226_ _1153_ VSS VSS VDD VDD _1227_ sky130_fd_sc_hd__mux2i_1
X_4411_ _1195_ VSS VSS VDD VDD _1228_ sky130_fd_sc_hd__buf_4
X_4412_ _1187_ _1221_ _1227_ _1228_ _1201_ VSS VSS VDD VDD
+ _1229_ sky130_fd_sc_hd__a221o_2
X_4413_ _1149_ _1210_ _1217_ _1229_ VSS VSS VDD VDD _0035_
+ sky130_fd_sc_hd__a31oi_4
X_4414_ registers\[17\]\[11\] registers\[19\]\[11\] registers\[21\]\[11\]
+ registers\[23\]\[11\] _1204_ _1205_ VSS VSS VDD VDD _1230_
+ sky130_fd_sc_hd__mux4_1
X_4415_ _1172_ VSS VSS VDD VDD _1231_ sky130_fd_sc_hd__buf_4
X_4416_ _1159_ VSS VSS VDD VDD _1232_ sky130_fd_sc_hd__buf_6
X_4417_ registers\[18\]\[11\] registers\[22\]\[11\] _1232_
+ VSS VSS VDD VDD _1233_ sky130_fd_sc_hd__mux2i_1
X_4418_ registers\[16\]\[11\] registers\[20\]\[11\] _1179_
+ VSS VSS VDD VDD _1234_ sky130_fd_sc_hd__mux2i_1
X_4419_ _1168_ VSS VSS VDD VDD _1235_ sky130_fd_sc_hd__buf_4
X_4420_ _1175_ VSS VSS VDD VDD _1236_ sky130_fd_sc_hd__buf_4
X_4421_ _1231_ _1233_ _1234_ _1235_ _1236_ VSS VSS VDD VDD
+ _1237_ sky130_fd_sc_hd__a221oi_2
X_4422_ _1203_ _1230_ _1237_ VSS VSS VDD VDD _1238_ sky130_fd_sc_hd__o21ai_0
X_4423_ _1212_ VSS VSS VDD VDD _1239_ sky130_fd_sc_hd__buf_6
X_4424_ _1222_ VSS VSS VDD VDD _1240_ sky130_fd_sc_hd__buf_6
X_4425_ registers\[24\]\[11\] registers\[26\]\[11\] registers\[28\]\[11\]
+ registers\[30\]\[11\] _1167_ _1240_ VSS VSS VDD VDD _1241_
+ sky130_fd_sc_hd__mux4_1
X_4426_ _1166_ VSS VSS VDD VDD _1242_ sky130_fd_sc_hd__buf_6
X_4427_ _1162_ VSS VSS VDD VDD _1243_ sky130_fd_sc_hd__buf_8
X_4428_ registers\[25\]\[11\] registers\[27\]\[11\] registers\[29\]\[11\]
+ registers\[31\]\[11\] _1242_ _1243_ VSS VSS VDD VDD _1244_
+ sky130_fd_sc_hd__mux4_1
X_4429_ _1239_ _1241_ _1244_ _1215_ VSS VSS VDD VDD _1245_
+ sky130_fd_sc_hd__a22oi_2
X_4430_ registers\[0\]\[11\] registers\[1\]\[11\] registers\[2\]\[11\]
+ registers\[3\]\[11\] _1165_ _1183_ VSS VSS VDD VDD _1246_
+ sky130_fd_sc_hd__mux4_1
X_4431_ registers\[4\]\[11\] registers\[5\]\[11\] registers\[6\]\[11\]
+ registers\[7\]\[11\] _1189_ _1219_ VSS VSS VDD VDD _1247_
+ sky130_fd_sc_hd__mux4_1
X_4432_ _1222_ VSS VSS VDD VDD _1248_ sky130_fd_sc_hd__buf_8
X_4433_ _1246_ _1247_ _1248_ VSS VSS VDD VDD _1249_ sky130_fd_sc_hd__mux2i_1
X_4434_ registers\[9\]\[11\] registers\[11\]\[11\] registers\[13\]\[11\]
+ registers\[15\]\[11\] _1156_ _1222_ VSS VSS VDD VDD _1250_
+ sky130_fd_sc_hd__mux4_1
X_4435_ _1155_ VSS VSS VDD VDD _1251_ sky130_fd_sc_hd__buf_6
X_4436_ registers\[8\]\[11\] registers\[10\]\[11\] registers\[12\]\[11\]
+ registers\[14\]\[11\] _1251_ _1225_ VSS VSS VDD VDD _1252_
+ sky130_fd_sc_hd__mux4_1
X_4437_ _1250_ _1252_ _1153_ VSS VSS VDD VDD _1253_ sky130_fd_sc_hd__mux2i_1
X_4438_ _1187_ _1249_ _1253_ _1228_ _1201_ VSS VSS VDD VDD
+ _1254_ sky130_fd_sc_hd__a221o_1
X_4439_ _1149_ _1238_ _1245_ _1254_ VSS VSS VDD VDD _0036_
+ sky130_fd_sc_hd__a31oi_2
X_4440_ registers\[25\]\[12\] registers\[27\]\[12\] registers\[29\]\[12\]
+ registers\[31\]\[12\] _1157_ _1160_ VSS VSS VDD VDD _1255_
+ sky130_fd_sc_hd__mux4_1
X_4441_ registers\[24\]\[12\] registers\[28\]\[12\] _1243_
+ VSS VSS VDD VDD _1256_ sky130_fd_sc_hd__mux2i_1
X_4442_ _1169_ _1256_ VSS VSS VDD VDD _1257_ sky130_fd_sc_hd__nand2_1
X_4443_ registers\[26\]\[12\] registers\[30\]\[12\] _1163_
+ VSS VSS VDD VDD _1258_ sky130_fd_sc_hd__mux2i_1
X_4444_ _1173_ _1258_ VSS VSS VDD VDD _1259_ sky130_fd_sc_hd__nand2_1
X_4445_ _1154_ _1255_ _1257_ _1259_ _1176_ VSS VSS VDD VDD
+ _1260_ sky130_fd_sc_hd__o2111ai_4
X_4446_ registers\[16\]\[12\] registers\[18\]\[12\] registers\[20\]\[12\]
+ registers\[22\]\[12\] _1167_ _1240_ VSS VSS VDD VDD _1261_
+ sky130_fd_sc_hd__mux4_1
X_4447_ registers\[17\]\[12\] registers\[19\]\[12\] registers\[21\]\[12\]
+ registers\[23\]\[12\] _1242_ _1243_ VSS VSS VDD VDD _1262_
+ sky130_fd_sc_hd__mux4_1
X_4448_ _1181_ _1261_ _1262_ _1182_ VSS VSS VDD VDD _1263_
+ sky130_fd_sc_hd__a22oi_1
X_4449_ registers\[0\]\[12\] registers\[1\]\[12\] registers\[2\]\[12\]
+ registers\[3\]\[12\] _1165_ _1183_ VSS VSS VDD VDD _1264_
+ sky130_fd_sc_hd__mux4_1
X_4450_ _1150_ VSS VSS VDD VDD _1265_ sky130_fd_sc_hd__buf_8
X_4451_ registers\[4\]\[12\] registers\[5\]\[12\] registers\[6\]\[12\]
+ registers\[7\]\[12\] _1265_ _1219_ VSS VSS VDD VDD _1266_
+ sky130_fd_sc_hd__mux4_1
X_4452_ _1264_ _1266_ _1248_ VSS VSS VDD VDD _1267_ sky130_fd_sc_hd__mux2i_1
X_4453_ _1155_ VSS VSS VDD VDD _1268_ sky130_fd_sc_hd__buf_6
X_4454_ registers\[9\]\[12\] registers\[11\]\[12\] registers\[13\]\[12\]
+ registers\[15\]\[12\] _1268_ _1222_ VSS VSS VDD VDD _1269_
+ sky130_fd_sc_hd__mux4_1
X_4455_ _1158_ VSS VSS VDD VDD _1270_ sky130_fd_sc_hd__buf_4
X_4456_ registers\[8\]\[12\] registers\[10\]\[12\] registers\[12\]\[12\]
+ registers\[14\]\[12\] _1251_ _1270_ VSS VSS VDD VDD _1271_
+ sky130_fd_sc_hd__mux4_1
X_4457_ _1269_ _1271_ _1153_ VSS VSS VDD VDD _1272_ sky130_fd_sc_hd__mux2i_4
X_4458_ _1187_ _1267_ _1272_ _1228_ _1201_ VSS VSS VDD VDD
+ _1273_ sky130_fd_sc_hd__a221o_2
X_4459_ _1149_ _1260_ _1263_ _1273_ VSS VSS VDD VDD _0037_
+ sky130_fd_sc_hd__a31oi_2
X_4460_ _1162_ VSS VSS VDD VDD _1274_ sky130_fd_sc_hd__buf_4
X_4461_ registers\[17\]\[13\] registers\[19\]\[13\] registers\[21\]\[13\]
+ registers\[23\]\[13\] _1204_ _1274_ VSS VSS VDD VDD _1275_
+ sky130_fd_sc_hd__mux4_1
X_4462_ registers\[18\]\[13\] registers\[22\]\[13\] _1232_
+ VSS VSS VDD VDD _1276_ sky130_fd_sc_hd__mux2i_1
X_4463_ registers\[16\]\[13\] registers\[20\]\[13\] _1179_
+ VSS VSS VDD VDD _1277_ sky130_fd_sc_hd__mux2i_1
X_4464_ _1231_ _1276_ _1277_ _1235_ _1236_ VSS VSS VDD VDD
+ _1278_ sky130_fd_sc_hd__a221oi_1
X_4465_ _1203_ _1275_ _1278_ VSS VSS VDD VDD _1279_ sky130_fd_sc_hd__o21ai_0
X_4466_ _1222_ VSS VSS VDD VDD _1280_ sky130_fd_sc_hd__buf_6
X_4467_ registers\[24\]\[13\] registers\[26\]\[13\] registers\[28\]\[13\]
+ registers\[30\]\[13\] _1167_ _1280_ VSS VSS VDD VDD _1281_
+ sky130_fd_sc_hd__mux4_1
X_4468_ _1162_ VSS VSS VDD VDD _1282_ sky130_fd_sc_hd__buf_6
X_4469_ registers\[25\]\[13\] registers\[27\]\[13\] registers\[29\]\[13\]
+ registers\[31\]\[13\] _1242_ _1282_ VSS VSS VDD VDD _1283_
+ sky130_fd_sc_hd__mux4_1
X_4470_ _1239_ _1281_ _1283_ _1215_ VSS VSS VDD VDD _1284_
+ sky130_fd_sc_hd__a22oi_2
X_4471_ registers\[0\]\[13\] registers\[1\]\[13\] registers\[2\]\[13\]
+ registers\[3\]\[13\] _1165_ _1183_ VSS VSS VDD VDD _1285_
+ sky130_fd_sc_hd__mux4_1
X_4472_ registers\[4\]\[13\] registers\[5\]\[13\] registers\[6\]\[13\]
+ registers\[7\]\[13\] _1265_ _1219_ VSS VSS VDD VDD _1286_
+ sky130_fd_sc_hd__mux4_1
X_4473_ _1285_ _1286_ _1248_ VSS VSS VDD VDD _1287_ sky130_fd_sc_hd__mux2i_1
X_4474_ _1159_ VSS VSS VDD VDD _1288_ sky130_fd_sc_hd__buf_6
X_4475_ registers\[9\]\[13\] registers\[11\]\[13\] registers\[13\]\[13\]
+ registers\[15\]\[13\] _1268_ _1288_ VSS VSS VDD VDD _1289_
+ sky130_fd_sc_hd__mux4_1
X_4476_ registers\[8\]\[13\] registers\[10\]\[13\] registers\[12\]\[13\]
+ registers\[14\]\[13\] _1251_ _1270_ VSS VSS VDD VDD _1290_
+ sky130_fd_sc_hd__mux4_1
X_4477_ _1289_ _1290_ _1153_ VSS VSS VDD VDD _1291_ sky130_fd_sc_hd__mux2i_4
X_4478_ _1187_ _1287_ _1291_ _1228_ _1201_ VSS VSS VDD VDD
+ _1292_ sky130_fd_sc_hd__a221o_1
X_4479_ _1149_ _1279_ _1284_ _1292_ VSS VSS VDD VDD _0038_
+ sky130_fd_sc_hd__a31oi_1
X_4480_ registers\[17\]\[14\] registers\[19\]\[14\] registers\[21\]\[14\]
+ registers\[23\]\[14\] _1204_ _1274_ VSS VSS VDD VDD _1293_
+ sky130_fd_sc_hd__mux4_1
X_4481_ registers\[18\]\[14\] registers\[22\]\[14\] _1232_
+ VSS VSS VDD VDD _1294_ sky130_fd_sc_hd__mux2i_1
X_4482_ registers\[16\]\[14\] registers\[20\]\[14\] _1179_
+ VSS VSS VDD VDD _1295_ sky130_fd_sc_hd__mux2i_1
X_4483_ _1231_ _1294_ _1295_ _1235_ _1236_ VSS VSS VDD VDD
+ _1296_ sky130_fd_sc_hd__a221oi_2
X_4484_ _1203_ _1293_ _1296_ VSS VSS VDD VDD _1297_ sky130_fd_sc_hd__o21ai_0
X_4485_ registers\[24\]\[14\] registers\[26\]\[14\] registers\[28\]\[14\]
+ registers\[30\]\[14\] _1167_ _1280_ VSS VSS VDD VDD _1298_
+ sky130_fd_sc_hd__mux4_1
X_4486_ registers\[25\]\[14\] registers\[27\]\[14\] registers\[29\]\[14\]
+ registers\[31\]\[14\] _1242_ _1282_ VSS VSS VDD VDD _1299_
+ sky130_fd_sc_hd__mux4_1
X_4487_ _1239_ _1298_ _1299_ _1215_ VSS VSS VDD VDD _1300_
+ sky130_fd_sc_hd__a22oi_2
X_4488_ _1150_ VSS VSS VDD VDD _1301_ sky130_fd_sc_hd__buf_16
X_4489_ _1301_ VSS VSS VDD VDD _1302_ sky130_fd_sc_hd__buf_16
X_4490_ _1166_ VSS VSS VDD VDD _1303_ sky130_fd_sc_hd__buf_6
X_4491_ registers\[8\]\[14\] registers\[9\]\[14\] registers\[10\]\[14\]
+ registers\[11\]\[14\] _1302_ _1303_ VSS VSS VDD VDD _1304_
+ sky130_fd_sc_hd__mux4_1
X_4492_ registers\[12\]\[14\] registers\[13\]\[14\] registers\[14\]\[14\]
+ registers\[15\]\[14\] _1265_ _1219_ VSS VSS VDD VDD _1305_
+ sky130_fd_sc_hd__mux4_1
X_4493_ _1304_ _1305_ _1248_ VSS VSS VDD VDD _1306_ sky130_fd_sc_hd__mux2i_1
X_4494_ registers\[1\]\[14\] registers\[3\]\[14\] registers\[5\]\[14\]
+ registers\[7\]\[14\] _1268_ _1288_ VSS VSS VDD VDD _1307_
+ sky130_fd_sc_hd__mux4_1
X_4495_ registers\[0\]\[14\] registers\[2\]\[14\] registers\[4\]\[14\]
+ registers\[6\]\[14\] _1251_ _1270_ VSS VSS VDD VDD _1308_
+ sky130_fd_sc_hd__mux4_1
X_4496_ _1307_ _1308_ _1153_ VSS VSS VDD VDD _1309_ sky130_fd_sc_hd__mux2i_1
X_4497_ _1186_ VSS VSS VDD VDD _1310_ sky130_fd_sc_hd__buf_8
X_4498_ _1196_ _1306_ _1309_ _1310_ _1201_ VSS VSS VDD VDD
+ _1311_ sky130_fd_sc_hd__a221o_2
X_4499_ _1149_ _1297_ _1300_ _1311_ VSS VSS VDD VDD _0039_
+ sky130_fd_sc_hd__a31oi_1
X_4500_ registers\[17\]\[15\] registers\[19\]\[15\] registers\[21\]\[15\]
+ registers\[23\]\[15\] _1204_ _1274_ VSS VSS VDD VDD _1312_
+ sky130_fd_sc_hd__mux4_1
X_4501_ registers\[18\]\[15\] registers\[22\]\[15\] _1232_
+ VSS VSS VDD VDD _1313_ sky130_fd_sc_hd__mux2i_1
X_4502_ registers\[16\]\[15\] registers\[20\]\[15\] _1179_
+ VSS VSS VDD VDD _1314_ sky130_fd_sc_hd__mux2i_1
X_4503_ _1231_ _1313_ _1314_ _1235_ _1236_ VSS VSS VDD VDD
+ _1315_ sky130_fd_sc_hd__a221oi_2
X_4504_ _1203_ _1312_ _1315_ VSS VSS VDD VDD _1316_ sky130_fd_sc_hd__o21ai_0
X_4505_ registers\[24\]\[15\] registers\[26\]\[15\] registers\[28\]\[15\]
+ registers\[30\]\[15\] _1167_ _1280_ VSS VSS VDD VDD _1317_
+ sky130_fd_sc_hd__mux4_1
X_4506_ registers\[25\]\[15\] registers\[27\]\[15\] registers\[29\]\[15\]
+ registers\[31\]\[15\] _1242_ _1282_ VSS VSS VDD VDD _1318_
+ sky130_fd_sc_hd__mux4_1
X_4507_ _1239_ _1317_ _1318_ _1215_ VSS VSS VDD VDD _1319_
+ sky130_fd_sc_hd__a22oi_2
X_4508_ registers\[0\]\[15\] registers\[1\]\[15\] registers\[2\]\[15\]
+ registers\[3\]\[15\] _1302_ _1303_ VSS VSS VDD VDD _1320_
+ sky130_fd_sc_hd__mux4_1
X_4509_ registers\[4\]\[15\] registers\[5\]\[15\] registers\[6\]\[15\]
+ registers\[7\]\[15\] _1265_ _1219_ VSS VSS VDD VDD _1321_
+ sky130_fd_sc_hd__mux4_1
X_4510_ _1320_ _1321_ _1248_ VSS VSS VDD VDD _1322_ sky130_fd_sc_hd__mux2i_1
X_4511_ registers\[9\]\[15\] registers\[11\]\[15\] registers\[13\]\[15\]
+ registers\[15\]\[15\] _1268_ _1288_ VSS VSS VDD VDD _1323_
+ sky130_fd_sc_hd__mux4_1
X_4512_ registers\[8\]\[15\] registers\[10\]\[15\] registers\[12\]\[15\]
+ registers\[14\]\[15\] _1251_ _1270_ VSS VSS VDD VDD _1324_
+ sky130_fd_sc_hd__mux4_1
X_4513_ _1323_ _1324_ _1153_ VSS VSS VDD VDD _1325_ sky130_fd_sc_hd__mux2i_2
X_4514_ _1187_ _1322_ _1325_ _1228_ _1201_ VSS VSS VDD VDD
+ _1326_ sky130_fd_sc_hd__a221o_2
X_4515_ _1149_ _1316_ _1319_ _1326_ VSS VSS VDD VDD _0040_
+ sky130_fd_sc_hd__a31oi_1
X_4516_ registers\[17\]\[16\] registers\[19\]\[16\] registers\[21\]\[16\]
+ registers\[23\]\[16\] _1204_ _1274_ VSS VSS VDD VDD _1327_
+ sky130_fd_sc_hd__mux4_1
X_4517_ registers\[18\]\[16\] registers\[22\]\[16\] _1232_
+ VSS VSS VDD VDD _1328_ sky130_fd_sc_hd__mux2i_1
X_4518_ _1222_ VSS VSS VDD VDD _1329_ sky130_fd_sc_hd__buf_6
X_4519_ registers\[16\]\[16\] registers\[20\]\[16\] _1329_
+ VSS VSS VDD VDD _1330_ sky130_fd_sc_hd__mux2i_1
X_4520_ _1231_ _1328_ _1330_ _1235_ _1236_ VSS VSS VDD VDD
+ _1331_ sky130_fd_sc_hd__a221oi_1
X_4521_ _1203_ _1327_ _1331_ VSS VSS VDD VDD _1332_ sky130_fd_sc_hd__o21ai_0
X_4522_ registers\[24\]\[16\] registers\[26\]\[16\] registers\[28\]\[16\]
+ registers\[30\]\[16\] _1167_ _1280_ VSS VSS VDD VDD _1333_
+ sky130_fd_sc_hd__mux4_1
X_4523_ registers\[25\]\[16\] registers\[27\]\[16\] registers\[29\]\[16\]
+ registers\[31\]\[16\] _1242_ _1282_ VSS VSS VDD VDD _1334_
+ sky130_fd_sc_hd__mux4_1
X_4524_ _1239_ _1333_ _1334_ _1215_ VSS VSS VDD VDD _1335_
+ sky130_fd_sc_hd__a22oi_2
X_4525_ registers\[0\]\[16\] registers\[1\]\[16\] registers\[2\]\[16\]
+ registers\[3\]\[16\] _1302_ _1303_ VSS VSS VDD VDD _1336_
+ sky130_fd_sc_hd__mux4_1
X_4526_ registers\[4\]\[16\] registers\[5\]\[16\] registers\[6\]\[16\]
+ registers\[7\]\[16\] _1265_ _1219_ VSS VSS VDD VDD _1337_
+ sky130_fd_sc_hd__mux4_1
X_4527_ _1336_ _1337_ _1248_ VSS VSS VDD VDD _1338_ sky130_fd_sc_hd__mux2i_1
X_4528_ registers\[9\]\[16\] registers\[11\]\[16\] registers\[13\]\[16\]
+ registers\[15\]\[16\] _1268_ _1288_ VSS VSS VDD VDD _1339_
+ sky130_fd_sc_hd__mux4_1
X_4529_ registers\[8\]\[16\] registers\[10\]\[16\] registers\[12\]\[16\]
+ registers\[14\]\[16\] _1251_ _1270_ VSS VSS VDD VDD _1340_
+ sky130_fd_sc_hd__mux4_1
X_4530_ _1152_ VSS VSS VDD VDD _1341_ sky130_fd_sc_hd__buf_16
X_4531_ _1339_ _1340_ _1341_ VSS VSS VDD VDD _1342_ sky130_fd_sc_hd__mux2i_4
X_4532_ _1187_ _1338_ _1342_ _1228_ _1201_ VSS VSS VDD VDD
+ _1343_ sky130_fd_sc_hd__a221o_2
X_4533_ _1149_ _1332_ _1335_ _1343_ VSS VSS VDD VDD _0041_
+ sky130_fd_sc_hd__a31oi_1
X_4534_ registers\[25\]\[17\] registers\[27\]\[17\] registers\[29\]\[17\]
+ registers\[31\]\[17\] _1157_ _1160_ VSS VSS VDD VDD _1344_
+ sky130_fd_sc_hd__mux4_1
X_4535_ registers\[24\]\[17\] registers\[28\]\[17\] _1243_
+ VSS VSS VDD VDD _1345_ sky130_fd_sc_hd__mux2i_1
X_4536_ _1169_ _1345_ VSS VSS VDD VDD _1346_ sky130_fd_sc_hd__nand2_1
X_4537_ registers\[26\]\[17\] registers\[30\]\[17\] _1163_
+ VSS VSS VDD VDD _1347_ sky130_fd_sc_hd__mux2i_1
X_4538_ _1173_ _1347_ VSS VSS VDD VDD _1348_ sky130_fd_sc_hd__nand2_1
X_4539_ _1154_ _1344_ _1346_ _1348_ _1176_ VSS VSS VDD VDD
+ _1349_ sky130_fd_sc_hd__o2111ai_4
X_4540_ registers\[16\]\[17\] registers\[18\]\[17\] registers\[20\]\[17\]
+ registers\[22\]\[17\] _1167_ _1280_ VSS VSS VDD VDD _1350_
+ sky130_fd_sc_hd__mux4_1
X_4541_ registers\[17\]\[17\] registers\[19\]\[17\] registers\[21\]\[17\]
+ registers\[23\]\[17\] _1242_ _1282_ VSS VSS VDD VDD _1351_
+ sky130_fd_sc_hd__mux4_1
X_4542_ _1181_ _1350_ _1351_ _1182_ VSS VSS VDD VDD _1352_
+ sky130_fd_sc_hd__a22oi_1
X_4543_ registers\[8\]\[17\] registers\[9\]\[17\] registers\[10\]\[17\]
+ registers\[11\]\[17\] _1302_ _1303_ VSS VSS VDD VDD _1353_
+ sky130_fd_sc_hd__mux4_1
X_4544_ registers\[12\]\[17\] registers\[13\]\[17\] registers\[14\]\[17\]
+ registers\[15\]\[17\] _1265_ _1219_ VSS VSS VDD VDD _1354_
+ sky130_fd_sc_hd__mux4_1
X_4545_ _1353_ _1354_ _1248_ VSS VSS VDD VDD _1355_ sky130_fd_sc_hd__mux2i_2
X_4546_ registers\[1\]\[17\] registers\[3\]\[17\] registers\[5\]\[17\]
+ registers\[7\]\[17\] _1268_ _1288_ VSS VSS VDD VDD _1356_
+ sky130_fd_sc_hd__mux4_1
X_4547_ registers\[0\]\[17\] registers\[2\]\[17\] registers\[4\]\[17\]
+ registers\[6\]\[17\] _1251_ _1270_ VSS VSS VDD VDD _1357_
+ sky130_fd_sc_hd__mux4_1
X_4548_ _1356_ _1357_ _1341_ VSS VSS VDD VDD _1358_ sky130_fd_sc_hd__mux2i_1
X_4549_ _1196_ _1355_ _1358_ _1310_ _1201_ VSS VSS VDD VDD
+ _1359_ sky130_fd_sc_hd__a221o_2
X_4550_ _1149_ _1349_ _1352_ _1359_ VSS VSS VDD VDD _0042_
+ sky130_fd_sc_hd__a31oi_2
X_4551_ registers\[17\]\[18\] registers\[19\]\[18\] registers\[21\]\[18\]
+ registers\[23\]\[18\] _1204_ _1274_ VSS VSS VDD VDD _1360_
+ sky130_fd_sc_hd__mux4_1
X_4552_ registers\[18\]\[18\] registers\[22\]\[18\] _1232_
+ VSS VSS VDD VDD _1361_ sky130_fd_sc_hd__mux2i_1
X_4553_ registers\[16\]\[18\] registers\[20\]\[18\] _1329_
+ VSS VSS VDD VDD _1362_ sky130_fd_sc_hd__mux2i_1
X_4554_ _1231_ _1361_ _1362_ _1235_ _1236_ VSS VSS VDD VDD
+ _1363_ sky130_fd_sc_hd__a221oi_1
X_4555_ _1203_ _1360_ _1363_ VSS VSS VDD VDD _1364_ sky130_fd_sc_hd__o21ai_0
X_4556_ _1156_ VSS VSS VDD VDD _1365_ sky130_fd_sc_hd__buf_8
X_4557_ registers\[24\]\[18\] registers\[26\]\[18\] registers\[28\]\[18\]
+ registers\[30\]\[18\] _1365_ _1280_ VSS VSS VDD VDD _1366_
+ sky130_fd_sc_hd__mux4_1
X_4558_ registers\[25\]\[18\] registers\[27\]\[18\] registers\[29\]\[18\]
+ registers\[31\]\[18\] _1242_ _1282_ VSS VSS VDD VDD _1367_
+ sky130_fd_sc_hd__mux4_1
X_4559_ _1239_ _1366_ _1367_ _1215_ VSS VSS VDD VDD _1368_
+ sky130_fd_sc_hd__a22oi_2
X_4560_ registers\[0\]\[18\] registers\[1\]\[18\] registers\[2\]\[18\]
+ registers\[3\]\[18\] _1302_ _1303_ VSS VSS VDD VDD _1369_
+ sky130_fd_sc_hd__mux4_1
X_4561_ registers\[4\]\[18\] registers\[5\]\[18\] registers\[6\]\[18\]
+ registers\[7\]\[18\] _1265_ _1219_ VSS VSS VDD VDD _1370_
+ sky130_fd_sc_hd__mux4_1
X_4562_ _1369_ _1370_ _1248_ VSS VSS VDD VDD _1371_ sky130_fd_sc_hd__mux2i_1
X_4563_ registers\[9\]\[18\] registers\[11\]\[18\] registers\[13\]\[18\]
+ registers\[15\]\[18\] _1268_ _1288_ VSS VSS VDD VDD _1372_
+ sky130_fd_sc_hd__mux4_1
X_4564_ registers\[8\]\[18\] registers\[10\]\[18\] registers\[12\]\[18\]
+ registers\[14\]\[18\] _1251_ _1270_ VSS VSS VDD VDD _1373_
+ sky130_fd_sc_hd__mux4_1
X_4565_ _1372_ _1373_ _1341_ VSS VSS VDD VDD _1374_ sky130_fd_sc_hd__mux2i_4
X_4566_ _1187_ _1371_ _1374_ _1228_ _1201_ VSS VSS VDD VDD
+ _1375_ sky130_fd_sc_hd__a221o_1
X_4567_ _1149_ _1364_ _1368_ _1375_ VSS VSS VDD VDD _0043_
+ sky130_fd_sc_hd__a31oi_1
X_4568_ _1148_ VSS VSS VDD VDD _1376_ sky130_fd_sc_hd__buf_6
X_4569_ registers\[25\]\[19\] registers\[27\]\[19\] registers\[29\]\[19\]
+ registers\[31\]\[19\] _1157_ _1160_ VSS VSS VDD VDD _1377_
+ sky130_fd_sc_hd__mux4_1
X_4570_ registers\[24\]\[19\] registers\[28\]\[19\] _1243_
+ VSS VSS VDD VDD _1378_ sky130_fd_sc_hd__mux2i_1
X_4571_ _1169_ _1378_ VSS VSS VDD VDD _1379_ sky130_fd_sc_hd__nand2_1
X_4572_ registers\[26\]\[19\] registers\[30\]\[19\] _1163_
+ VSS VSS VDD VDD _1380_ sky130_fd_sc_hd__mux2i_1
X_4573_ _1173_ _1380_ VSS VSS VDD VDD _1381_ sky130_fd_sc_hd__nand2_1
X_4574_ _1154_ _1377_ _1379_ _1381_ _1176_ VSS VSS VDD VDD
+ _1382_ sky130_fd_sc_hd__o2111ai_4
X_4575_ registers\[16\]\[19\] registers\[18\]\[19\] registers\[20\]\[19\]
+ registers\[22\]\[19\] _1365_ _1280_ VSS VSS VDD VDD _1383_
+ sky130_fd_sc_hd__mux4_1
X_4576_ registers\[17\]\[19\] registers\[19\]\[19\] registers\[21\]\[19\]
+ registers\[23\]\[19\] _1242_ _1282_ VSS VSS VDD VDD _1384_
+ sky130_fd_sc_hd__mux4_1
X_4577_ _1181_ _1383_ _1384_ _1182_ VSS VSS VDD VDD _1385_
+ sky130_fd_sc_hd__a22oi_1
X_4578_ registers\[0\]\[19\] registers\[1\]\[19\] registers\[2\]\[19\]
+ registers\[3\]\[19\] _1302_ _1303_ VSS VSS VDD VDD _1386_
+ sky130_fd_sc_hd__mux4_1
X_4579_ registers\[4\]\[19\] registers\[5\]\[19\] registers\[6\]\[19\]
+ registers\[7\]\[19\] _1265_ _1219_ VSS VSS VDD VDD _1387_
+ sky130_fd_sc_hd__mux4_1
X_4580_ _1386_ _1387_ _1248_ VSS VSS VDD VDD _1388_ sky130_fd_sc_hd__mux2i_1
X_4581_ registers\[9\]\[19\] registers\[11\]\[19\] registers\[13\]\[19\]
+ registers\[15\]\[19\] _1268_ _1288_ VSS VSS VDD VDD _1389_
+ sky130_fd_sc_hd__mux4_1
X_4582_ registers\[8\]\[19\] registers\[10\]\[19\] registers\[12\]\[19\]
+ registers\[14\]\[19\] _1251_ _1270_ VSS VSS VDD VDD _1390_
+ sky130_fd_sc_hd__mux4_1
X_4583_ _1389_ _1390_ _1341_ VSS VSS VDD VDD _1391_ sky130_fd_sc_hd__mux2i_4
X_4584_ _1200_ VSS VSS VDD VDD _1392_ sky130_fd_sc_hd__buf_6
X_4585_ _1187_ _1388_ _1391_ _1228_ _1392_ VSS VSS VDD VDD
+ _1393_ sky130_fd_sc_hd__a221o_2
X_4586_ _1376_ _1382_ _1385_ _1393_ VSS VSS VDD VDD _0044_
+ sky130_fd_sc_hd__a31oi_2
X_4587_ registers\[25\]\[1\] registers\[27\]\[1\] registers\[29\]\[1\]
+ registers\[31\]\[1\] _1157_ _1160_ VSS VSS VDD VDD _1394_
+ sky130_fd_sc_hd__mux4_1
X_4588_ registers\[24\]\[1\] registers\[28\]\[1\] _1243_ VSS
+ VSS VDD VDD _1395_ sky130_fd_sc_hd__mux2i_1
X_4589_ _1169_ _1395_ VSS VSS VDD VDD _1396_ sky130_fd_sc_hd__nand2_1
X_4590_ registers\[26\]\[1\] registers\[30\]\[1\] _1163_ VSS
+ VSS VDD VDD _1397_ sky130_fd_sc_hd__mux2i_1
X_4591_ _1173_ _1397_ VSS VSS VDD VDD _1398_ sky130_fd_sc_hd__nand2_1
X_4592_ _1154_ _1394_ _1396_ _1398_ _1176_ VSS VSS VDD VDD
+ _1399_ sky130_fd_sc_hd__o2111ai_4
X_4593_ registers\[16\]\[1\] registers\[18\]\[1\] registers\[20\]\[1\]
+ registers\[22\]\[1\] _1365_ _1280_ VSS VSS VDD VDD _1400_
+ sky130_fd_sc_hd__mux4_1
X_4594_ registers\[17\]\[1\] registers\[19\]\[1\] registers\[21\]\[1\]
+ registers\[23\]\[1\] _1242_ _1282_ VSS VSS VDD VDD _1401_
+ sky130_fd_sc_hd__mux4_1
X_4595_ _1181_ _1400_ _1401_ _1182_ VSS VSS VDD VDD _1402_
+ sky130_fd_sc_hd__a22oi_2
X_4596_ registers\[0\]\[1\] registers\[1\]\[1\] registers\[2\]\[1\]
+ registers\[3\]\[1\] _1302_ _1303_ VSS VSS VDD VDD _1403_ sky130_fd_sc_hd__mux4_1
X_4597_ _1156_ VSS VSS VDD VDD _1404_ sky130_fd_sc_hd__buf_6
X_4598_ registers\[4\]\[1\] registers\[5\]\[1\] registers\[6\]\[1\]
+ registers\[7\]\[1\] _1265_ _1404_ VSS VSS VDD VDD _1405_ sky130_fd_sc_hd__mux4_1
X_4599_ _1403_ _1405_ _1248_ VSS VSS VDD VDD _1406_ sky130_fd_sc_hd__mux2i_1
X_4600_ registers\[9\]\[1\] registers\[11\]\[1\] registers\[13\]\[1\]
+ registers\[15\]\[1\] _1268_ _1288_ VSS VSS VDD VDD _1407_
+ sky130_fd_sc_hd__mux4_1
X_4601_ registers\[8\]\[1\] registers\[10\]\[1\] registers\[12\]\[1\]
+ registers\[14\]\[1\] _1251_ _1270_ VSS VSS VDD VDD _1408_
+ sky130_fd_sc_hd__mux4_1
X_4602_ _1407_ _1408_ _1341_ VSS VSS VDD VDD _1409_ sky130_fd_sc_hd__mux2i_4
X_4603_ _1187_ _1406_ _1409_ _1228_ _1392_ VSS VSS VDD VDD
+ _1410_ sky130_fd_sc_hd__a221o_4
X_4604_ _1376_ _1399_ _1402_ _1410_ VSS VSS VDD VDD _0045_
+ sky130_fd_sc_hd__a31oi_4
X_4605_ registers\[17\]\[20\] registers\[19\]\[20\] registers\[21\]\[20\]
+ registers\[23\]\[20\] _1204_ _1274_ VSS VSS VDD VDD _1411_
+ sky130_fd_sc_hd__mux4_1
X_4606_ registers\[18\]\[20\] registers\[22\]\[20\] _1232_
+ VSS VSS VDD VDD _1412_ sky130_fd_sc_hd__mux2i_1
X_4607_ registers\[16\]\[20\] registers\[20\]\[20\] _1329_
+ VSS VSS VDD VDD _1413_ sky130_fd_sc_hd__mux2i_1
X_4608_ _1231_ _1412_ _1413_ _1235_ _1236_ VSS VSS VDD VDD
+ _1414_ sky130_fd_sc_hd__a221oi_2
X_4609_ _1203_ _1411_ _1414_ VSS VSS VDD VDD _1415_ sky130_fd_sc_hd__o21ai_1
X_4610_ registers\[24\]\[20\] registers\[26\]\[20\] registers\[28\]\[20\]
+ registers\[30\]\[20\] _1365_ _1280_ VSS VSS VDD VDD _1416_
+ sky130_fd_sc_hd__mux4_1
X_4611_ _1166_ VSS VSS VDD VDD _1417_ sky130_fd_sc_hd__buf_8
X_4612_ registers\[25\]\[20\] registers\[27\]\[20\] registers\[29\]\[20\]
+ registers\[31\]\[20\] _1417_ _1282_ VSS VSS VDD VDD _1418_
+ sky130_fd_sc_hd__mux4_1
X_4613_ _1239_ _1416_ _1418_ _1215_ VSS VSS VDD VDD _1419_
+ sky130_fd_sc_hd__a22oi_2
X_4614_ _1186_ VSS VSS VDD VDD _1420_ sky130_fd_sc_hd__buf_6
X_4615_ registers\[0\]\[20\] registers\[1\]\[20\] registers\[2\]\[20\]
+ registers\[3\]\[20\] _1302_ _1303_ VSS VSS VDD VDD _1421_
+ sky130_fd_sc_hd__mux4_1
X_4616_ registers\[4\]\[20\] registers\[5\]\[20\] registers\[6\]\[20\]
+ registers\[7\]\[20\] _1265_ _1404_ VSS VSS VDD VDD _1422_
+ sky130_fd_sc_hd__mux4_1
X_4617_ _1222_ VSS VSS VDD VDD _1423_ sky130_fd_sc_hd__buf_8
X_4618_ _1421_ _1422_ _1423_ VSS VSS VDD VDD _1424_ sky130_fd_sc_hd__mux2i_1
X_4619_ registers\[9\]\[20\] registers\[11\]\[20\] registers\[13\]\[20\]
+ registers\[15\]\[20\] _1268_ _1288_ VSS VSS VDD VDD _1425_
+ sky130_fd_sc_hd__mux4_1
X_4620_ _1155_ VSS VSS VDD VDD _1426_ sky130_fd_sc_hd__buf_8
X_4621_ registers\[8\]\[20\] registers\[10\]\[20\] registers\[12\]\[20\]
+ registers\[14\]\[20\] _1426_ _1270_ VSS VSS VDD VDD _1427_
+ sky130_fd_sc_hd__mux4_1
X_4622_ _1425_ _1427_ _1341_ VSS VSS VDD VDD _1428_ sky130_fd_sc_hd__mux2i_4
X_4623_ _1195_ VSS VSS VDD VDD _1429_ sky130_fd_sc_hd__buf_6
X_4624_ _1420_ _1424_ _1428_ _1429_ _1392_ VSS VSS VDD VDD
+ _1430_ sky130_fd_sc_hd__a221o_2
X_4625_ _1376_ _1415_ _1419_ _1430_ VSS VSS VDD VDD _0046_
+ sky130_fd_sc_hd__a31oi_2
X_4626_ registers\[17\]\[21\] registers\[19\]\[21\] registers\[21\]\[21\]
+ registers\[23\]\[21\] _1204_ _1274_ VSS VSS VDD VDD _1431_
+ sky130_fd_sc_hd__mux4_1
X_4627_ registers\[18\]\[21\] registers\[22\]\[21\] _1232_
+ VSS VSS VDD VDD _1432_ sky130_fd_sc_hd__mux2i_1
X_4628_ registers\[16\]\[21\] registers\[20\]\[21\] _1329_
+ VSS VSS VDD VDD _1433_ sky130_fd_sc_hd__mux2i_1
X_4629_ _1231_ _1432_ _1433_ _1235_ _1236_ VSS VSS VDD VDD
+ _1434_ sky130_fd_sc_hd__a221oi_2
X_4630_ _1203_ _1431_ _1434_ VSS VSS VDD VDD _1435_ sky130_fd_sc_hd__o21ai_1
X_4631_ registers\[24\]\[21\] registers\[26\]\[21\] registers\[28\]\[21\]
+ registers\[30\]\[21\] _1365_ _1280_ VSS VSS VDD VDD _1436_
+ sky130_fd_sc_hd__mux4_1
X_4632_ registers\[25\]\[21\] registers\[27\]\[21\] registers\[29\]\[21\]
+ registers\[31\]\[21\] _1417_ _1282_ VSS VSS VDD VDD _1437_
+ sky130_fd_sc_hd__mux4_1
X_4633_ _1239_ _1436_ _1437_ _1215_ VSS VSS VDD VDD _1438_
+ sky130_fd_sc_hd__a22oi_2
X_4634_ registers\[8\]\[21\] registers\[9\]\[21\] registers\[10\]\[21\]
+ registers\[11\]\[21\] _1302_ _1303_ VSS VSS VDD VDD _1439_
+ sky130_fd_sc_hd__mux4_1
X_4635_ _1150_ VSS VSS VDD VDD _1440_ sky130_fd_sc_hd__buf_6
X_4636_ registers\[12\]\[21\] registers\[13\]\[21\] registers\[14\]\[21\]
+ registers\[15\]\[21\] _1440_ _1404_ VSS VSS VDD VDD _1441_
+ sky130_fd_sc_hd__mux4_1
X_4637_ _1439_ _1441_ _1423_ VSS VSS VDD VDD _1442_ sky130_fd_sc_hd__mux2i_2
X_4638_ _1155_ VSS VSS VDD VDD _1443_ sky130_fd_sc_hd__buf_6
X_4639_ registers\[1\]\[21\] registers\[3\]\[21\] registers\[5\]\[21\]
+ registers\[7\]\[21\] _1443_ _1288_ VSS VSS VDD VDD _1444_
+ sky130_fd_sc_hd__mux4_1
X_4640_ _1158_ VSS VSS VDD VDD _1445_ sky130_fd_sc_hd__buf_6
X_4641_ registers\[0\]\[21\] registers\[2\]\[21\] registers\[4\]\[21\]
+ registers\[6\]\[21\] _1426_ _1445_ VSS VSS VDD VDD _1446_
+ sky130_fd_sc_hd__mux4_1
X_4642_ _1444_ _1446_ _1341_ VSS VSS VDD VDD _1447_ sky130_fd_sc_hd__mux2i_1
X_4643_ _1196_ _1442_ _1447_ _1310_ _1392_ VSS VSS VDD VDD
+ _1448_ sky130_fd_sc_hd__a221o_4
X_4644_ _1376_ _1435_ _1438_ _1448_ VSS VSS VDD VDD _0047_
+ sky130_fd_sc_hd__a31oi_4
X_4645_ registers\[17\]\[22\] registers\[19\]\[22\] registers\[21\]\[22\]
+ registers\[23\]\[22\] _1204_ _1274_ VSS VSS VDD VDD _1449_
+ sky130_fd_sc_hd__mux4_1
X_4646_ registers\[18\]\[22\] registers\[22\]\[22\] _1232_
+ VSS VSS VDD VDD _1450_ sky130_fd_sc_hd__mux2i_1
X_4647_ registers\[16\]\[22\] registers\[20\]\[22\] _1329_
+ VSS VSS VDD VDD _1451_ sky130_fd_sc_hd__mux2i_1
X_4648_ _1231_ _1450_ _1451_ _1235_ _1236_ VSS VSS VDD VDD
+ _1452_ sky130_fd_sc_hd__a221oi_2
X_4649_ _1203_ _1449_ _1452_ VSS VSS VDD VDD _1453_ sky130_fd_sc_hd__o21ai_0
X_4650_ _1222_ VSS VSS VDD VDD _1454_ sky130_fd_sc_hd__buf_6
X_4651_ registers\[24\]\[22\] registers\[26\]\[22\] registers\[28\]\[22\]
+ registers\[30\]\[22\] _1365_ _1454_ VSS VSS VDD VDD _1455_
+ sky130_fd_sc_hd__mux4_1
X_4652_ _1162_ VSS VSS VDD VDD _1456_ sky130_fd_sc_hd__buf_6
X_4653_ registers\[25\]\[22\] registers\[27\]\[22\] registers\[29\]\[22\]
+ registers\[31\]\[22\] _1417_ _1456_ VSS VSS VDD VDD _1457_
+ sky130_fd_sc_hd__mux4_1
X_4654_ _1239_ _1455_ _1457_ _1215_ VSS VSS VDD VDD _1458_
+ sky130_fd_sc_hd__a22oi_2
X_4655_ registers\[0\]\[22\] registers\[1\]\[22\] registers\[2\]\[22\]
+ registers\[3\]\[22\] _1302_ _1303_ VSS VSS VDD VDD _1459_
+ sky130_fd_sc_hd__mux4_1
X_4656_ registers\[4\]\[22\] registers\[5\]\[22\] registers\[6\]\[22\]
+ registers\[7\]\[22\] _1440_ _1404_ VSS VSS VDD VDD _1460_
+ sky130_fd_sc_hd__mux4_1
X_4657_ _1459_ _1460_ _1423_ VSS VSS VDD VDD _1461_ sky130_fd_sc_hd__mux2i_1
X_4658_ _1159_ VSS VSS VDD VDD _1462_ sky130_fd_sc_hd__buf_6
X_4659_ registers\[9\]\[22\] registers\[11\]\[22\] registers\[13\]\[22\]
+ registers\[15\]\[22\] _1443_ _1462_ VSS VSS VDD VDD _1463_
+ sky130_fd_sc_hd__mux4_1
X_4660_ registers\[8\]\[22\] registers\[10\]\[22\] registers\[12\]\[22\]
+ registers\[14\]\[22\] _1426_ _1445_ VSS VSS VDD VDD _1464_
+ sky130_fd_sc_hd__mux4_1
X_4661_ _1463_ _1464_ _1341_ VSS VSS VDD VDD _1465_ sky130_fd_sc_hd__mux2i_2
X_4662_ _1420_ _1461_ _1465_ _1429_ _1392_ VSS VSS VDD VDD
+ _1466_ sky130_fd_sc_hd__a221o_2
X_4663_ _1376_ _1453_ _1458_ _1466_ VSS VSS VDD VDD _0048_
+ sky130_fd_sc_hd__a31oi_2
X_4664_ _1151_ VSS VSS VDD VDD _1467_ sky130_fd_sc_hd__clkbuf_4
X_4665_ _1166_ VSS VSS VDD VDD _1468_ sky130_fd_sc_hd__buf_4
X_4666_ registers\[17\]\[23\] registers\[19\]\[23\] registers\[21\]\[23\]
+ registers\[23\]\[23\] _1468_ _1274_ VSS VSS VDD VDD _1469_
+ sky130_fd_sc_hd__mux4_1
X_4667_ registers\[18\]\[23\] registers\[22\]\[23\] _1232_
+ VSS VSS VDD VDD _1470_ sky130_fd_sc_hd__mux2i_1
X_4668_ registers\[16\]\[23\] registers\[20\]\[23\] _1329_
+ VSS VSS VDD VDD _1471_ sky130_fd_sc_hd__mux2i_1
X_4669_ _1231_ _1470_ _1471_ _1235_ _1236_ VSS VSS VDD VDD
+ _1472_ sky130_fd_sc_hd__a221oi_2
X_4670_ _1467_ _1469_ _1472_ VSS VSS VDD VDD _1473_ sky130_fd_sc_hd__o21ai_1
X_4671_ registers\[24\]\[23\] registers\[26\]\[23\] registers\[28\]\[23\]
+ registers\[30\]\[23\] _1365_ _1454_ VSS VSS VDD VDD _1474_
+ sky130_fd_sc_hd__mux4_1
X_4672_ registers\[25\]\[23\] registers\[27\]\[23\] registers\[29\]\[23\]
+ registers\[31\]\[23\] _1417_ _1456_ VSS VSS VDD VDD _1475_
+ sky130_fd_sc_hd__mux4_1
X_4673_ _1214_ VSS VSS VDD VDD _1476_ sky130_fd_sc_hd__buf_8
X_4674_ _1239_ _1474_ _1475_ _1476_ VSS VSS VDD VDD _1477_
+ sky130_fd_sc_hd__a22oi_4
X_4675_ _1150_ VSS VSS VDD VDD _1478_ sky130_fd_sc_hd__buf_6
X_4676_ _1166_ VSS VSS VDD VDD _1479_ sky130_fd_sc_hd__buf_6
X_4677_ registers\[8\]\[23\] registers\[9\]\[23\] registers\[10\]\[23\]
+ registers\[11\]\[23\] _1478_ _1479_ VSS VSS VDD VDD _1480_
+ sky130_fd_sc_hd__mux4_1
X_4678_ registers\[12\]\[23\] registers\[13\]\[23\] registers\[14\]\[23\]
+ registers\[15\]\[23\] _1440_ _1404_ VSS VSS VDD VDD _1481_
+ sky130_fd_sc_hd__mux4_1
X_4679_ _1480_ _1481_ _1423_ VSS VSS VDD VDD _1482_ sky130_fd_sc_hd__mux2i_2
X_4680_ registers\[1\]\[23\] registers\[3\]\[23\] registers\[5\]\[23\]
+ registers\[7\]\[23\] _1443_ _1462_ VSS VSS VDD VDD _1483_
+ sky130_fd_sc_hd__mux4_1
X_4681_ registers\[0\]\[23\] registers\[2\]\[23\] registers\[4\]\[23\]
+ registers\[6\]\[23\] _1426_ _1445_ VSS VSS VDD VDD _1484_
+ sky130_fd_sc_hd__mux4_1
X_4682_ _1483_ _1484_ _1341_ VSS VSS VDD VDD _1485_ sky130_fd_sc_hd__mux2i_1
X_4683_ _1196_ _1482_ _1485_ _1310_ _1392_ VSS VSS VDD VDD
+ _1486_ sky130_fd_sc_hd__a221o_4
X_4684_ _1376_ _1473_ _1477_ _1486_ VSS VSS VDD VDD _0049_
+ sky130_fd_sc_hd__a31oi_4
X_4685_ registers\[17\]\[24\] registers\[19\]\[24\] registers\[21\]\[24\]
+ registers\[23\]\[24\] _1468_ _1274_ VSS VSS VDD VDD _1487_
+ sky130_fd_sc_hd__mux4_1
X_4686_ _1172_ VSS VSS VDD VDD _1488_ sky130_fd_sc_hd__buf_4
X_4687_ _1159_ VSS VSS VDD VDD _1489_ sky130_fd_sc_hd__buf_6
X_4688_ registers\[18\]\[24\] registers\[22\]\[24\] _1489_
+ VSS VSS VDD VDD _1490_ sky130_fd_sc_hd__mux2i_1
X_4689_ registers\[16\]\[24\] registers\[20\]\[24\] _1329_
+ VSS VSS VDD VDD _1491_ sky130_fd_sc_hd__mux2i_1
X_4690_ _1168_ VSS VSS VDD VDD _1492_ sky130_fd_sc_hd__buf_4
X_4691_ _1175_ VSS VSS VDD VDD _1493_ sky130_fd_sc_hd__buf_4
X_4692_ _1488_ _1490_ _1491_ _1492_ _1493_ VSS VSS VDD VDD
+ _1494_ sky130_fd_sc_hd__a221oi_2
X_4693_ _1467_ _1487_ _1494_ VSS VSS VDD VDD _1495_ sky130_fd_sc_hd__o21ai_1
X_4694_ _1212_ VSS VSS VDD VDD _1496_ sky130_fd_sc_hd__buf_8
X_4695_ registers\[24\]\[24\] registers\[26\]\[24\] registers\[28\]\[24\]
+ registers\[30\]\[24\] _1365_ _1454_ VSS VSS VDD VDD _1497_
+ sky130_fd_sc_hd__mux4_1
X_4696_ registers\[25\]\[24\] registers\[27\]\[24\] registers\[29\]\[24\]
+ registers\[31\]\[24\] _1417_ _1456_ VSS VSS VDD VDD _1498_
+ sky130_fd_sc_hd__mux4_1
X_4697_ _1496_ _1497_ _1498_ _1476_ VSS VSS VDD VDD _1499_
+ sky130_fd_sc_hd__a22oi_4
X_4698_ registers\[8\]\[24\] registers\[9\]\[24\] registers\[10\]\[24\]
+ registers\[11\]\[24\] _1478_ _1479_ VSS VSS VDD VDD _1500_
+ sky130_fd_sc_hd__mux4_1
X_4699_ registers\[12\]\[24\] registers\[13\]\[24\] registers\[14\]\[24\]
+ registers\[15\]\[24\] _1440_ _1404_ VSS VSS VDD VDD _1501_
+ sky130_fd_sc_hd__mux4_1
X_4700_ _1500_ _1501_ _1423_ VSS VSS VDD VDD _1502_ sky130_fd_sc_hd__mux2i_4
X_4701_ registers\[1\]\[24\] registers\[3\]\[24\] registers\[5\]\[24\]
+ registers\[7\]\[24\] _1443_ _1462_ VSS VSS VDD VDD _1503_
+ sky130_fd_sc_hd__mux4_1
X_4702_ registers\[0\]\[24\] registers\[2\]\[24\] registers\[4\]\[24\]
+ registers\[6\]\[24\] _1426_ _1445_ VSS VSS VDD VDD _1504_
+ sky130_fd_sc_hd__mux4_1
X_4703_ _1503_ _1504_ _1341_ VSS VSS VDD VDD _1505_ sky130_fd_sc_hd__mux2i_1
X_4704_ _1196_ _1502_ _1505_ _1310_ _1392_ VSS VSS VDD VDD
+ _1506_ sky130_fd_sc_hd__a221o_4
X_4705_ _1376_ _1495_ _1499_ _1506_ VSS VSS VDD VDD _0050_
+ sky130_fd_sc_hd__a31oi_4
X_4706_ registers\[25\]\[25\] registers\[27\]\[25\] registers\[29\]\[25\]
+ registers\[31\]\[25\] _1157_ _1160_ VSS VSS VDD VDD _1507_
+ sky130_fd_sc_hd__mux4_1
X_4707_ registers\[24\]\[25\] registers\[28\]\[25\] _1243_
+ VSS VSS VDD VDD _1508_ sky130_fd_sc_hd__mux2i_1
X_4708_ _1169_ _1508_ VSS VSS VDD VDD _1509_ sky130_fd_sc_hd__nand2_1
X_4709_ registers\[26\]\[25\] registers\[30\]\[25\] _1163_
+ VSS VSS VDD VDD _1510_ sky130_fd_sc_hd__mux2i_1
X_4710_ _1173_ _1510_ VSS VSS VDD VDD _1511_ sky130_fd_sc_hd__nand2_1
X_4711_ _1154_ _1507_ _1509_ _1511_ _1176_ VSS VSS VDD VDD
+ _1512_ sky130_fd_sc_hd__o2111ai_4
X_4712_ registers\[16\]\[25\] registers\[18\]\[25\] registers\[20\]\[25\]
+ registers\[22\]\[25\] _1365_ _1454_ VSS VSS VDD VDD _1513_
+ sky130_fd_sc_hd__mux4_1
X_4713_ registers\[17\]\[25\] registers\[19\]\[25\] registers\[21\]\[25\]
+ registers\[23\]\[25\] _1417_ _1456_ VSS VSS VDD VDD _1514_
+ sky130_fd_sc_hd__mux4_1
X_4714_ _1181_ _1513_ _1514_ _1182_ VSS VSS VDD VDD _1515_
+ sky130_fd_sc_hd__a22oi_1
X_4715_ registers\[0\]\[25\] registers\[1\]\[25\] registers\[2\]\[25\]
+ registers\[3\]\[25\] _1478_ _1479_ VSS VSS VDD VDD _1516_
+ sky130_fd_sc_hd__mux4_1
X_4716_ registers\[4\]\[25\] registers\[5\]\[25\] registers\[6\]\[25\]
+ registers\[7\]\[25\] _1440_ _1404_ VSS VSS VDD VDD _1517_
+ sky130_fd_sc_hd__mux4_1
X_4717_ _1516_ _1517_ _1423_ VSS VSS VDD VDD _1518_ sky130_fd_sc_hd__mux2i_1
X_4718_ registers\[9\]\[25\] registers\[11\]\[25\] registers\[13\]\[25\]
+ registers\[15\]\[25\] _1443_ _1462_ VSS VSS VDD VDD _1519_
+ sky130_fd_sc_hd__mux4_1
X_4719_ registers\[8\]\[25\] registers\[10\]\[25\] registers\[12\]\[25\]
+ registers\[14\]\[25\] _1426_ _1445_ VSS VSS VDD VDD _1520_
+ sky130_fd_sc_hd__mux4_1
X_4720_ _1152_ VSS VSS VDD VDD _1521_ sky130_fd_sc_hd__buf_8
X_4721_ _1519_ _1520_ _1521_ VSS VSS VDD VDD _1522_ sky130_fd_sc_hd__mux2i_2
X_4722_ _1420_ _1518_ _1522_ _1429_ _1392_ VSS VSS VDD VDD
+ _1523_ sky130_fd_sc_hd__a221o_4
X_4723_ _1376_ _1512_ _1515_ _1523_ VSS VSS VDD VDD _0051_
+ sky130_fd_sc_hd__a31oi_2
X_4724_ _1162_ VSS VSS VDD VDD _1524_ sky130_fd_sc_hd__buf_4
X_4725_ registers\[17\]\[26\] registers\[19\]\[26\] registers\[21\]\[26\]
+ registers\[23\]\[26\] _1468_ _1524_ VSS VSS VDD VDD _1525_
+ sky130_fd_sc_hd__mux4_1
X_4726_ registers\[18\]\[26\] registers\[22\]\[26\] _1489_
+ VSS VSS VDD VDD _1526_ sky130_fd_sc_hd__mux2i_1
X_4727_ registers\[16\]\[26\] registers\[20\]\[26\] _1329_
+ VSS VSS VDD VDD _1527_ sky130_fd_sc_hd__mux2i_1
X_4728_ _1488_ _1526_ _1527_ _1492_ _1493_ VSS VSS VDD VDD
+ _1528_ sky130_fd_sc_hd__a221oi_2
X_4729_ _1467_ _1525_ _1528_ VSS VSS VDD VDD _1529_ sky130_fd_sc_hd__o21ai_1
X_4730_ registers\[24\]\[26\] registers\[26\]\[26\] registers\[28\]\[26\]
+ registers\[30\]\[26\] _1365_ _1454_ VSS VSS VDD VDD _1530_
+ sky130_fd_sc_hd__mux4_1
X_4731_ registers\[25\]\[26\] registers\[27\]\[26\] registers\[29\]\[26\]
+ registers\[31\]\[26\] _1417_ _1456_ VSS VSS VDD VDD _1531_
+ sky130_fd_sc_hd__mux4_1
X_4732_ _1496_ _1530_ _1531_ _1476_ VSS VSS VDD VDD _1532_
+ sky130_fd_sc_hd__a22oi_4
X_4733_ registers\[0\]\[26\] registers\[1\]\[26\] registers\[2\]\[26\]
+ registers\[3\]\[26\] _1478_ _1479_ VSS VSS VDD VDD _1533_
+ sky130_fd_sc_hd__mux4_1
X_4734_ registers\[4\]\[26\] registers\[5\]\[26\] registers\[6\]\[26\]
+ registers\[7\]\[26\] _1440_ _1404_ VSS VSS VDD VDD _1534_
+ sky130_fd_sc_hd__mux4_1
X_4735_ _1533_ _1534_ _1423_ VSS VSS VDD VDD _1535_ sky130_fd_sc_hd__mux2i_1
X_4736_ registers\[9\]\[26\] registers\[11\]\[26\] registers\[13\]\[26\]
+ registers\[15\]\[26\] _1443_ _1462_ VSS VSS VDD VDD _1536_
+ sky130_fd_sc_hd__mux4_1
X_4737_ registers\[8\]\[26\] registers\[10\]\[26\] registers\[12\]\[26\]
+ registers\[14\]\[26\] _1426_ _1445_ VSS VSS VDD VDD _1537_
+ sky130_fd_sc_hd__mux4_1
X_4738_ _1536_ _1537_ _1521_ VSS VSS VDD VDD _1538_ sky130_fd_sc_hd__mux2i_4
X_4739_ _1420_ _1535_ _1538_ _1429_ _1392_ VSS VSS VDD VDD
+ _1539_ sky130_fd_sc_hd__a221o_4
X_4740_ _1376_ _1529_ _1532_ _1539_ VSS VSS VDD VDD _0052_
+ sky130_fd_sc_hd__a31oi_4
X_4741_ registers\[25\]\[27\] registers\[27\]\[27\] registers\[29\]\[27\]
+ registers\[31\]\[27\] _1157_ _1160_ VSS VSS VDD VDD _1540_
+ sky130_fd_sc_hd__mux4_1
X_4742_ registers\[24\]\[27\] registers\[28\]\[27\] _1243_
+ VSS VSS VDD VDD _1541_ sky130_fd_sc_hd__mux2i_1
X_4743_ _1169_ _1541_ VSS VSS VDD VDD _1542_ sky130_fd_sc_hd__nand2_1
X_4744_ registers\[26\]\[27\] registers\[30\]\[27\] _1163_
+ VSS VSS VDD VDD _1543_ sky130_fd_sc_hd__mux2i_1
X_4745_ _1173_ _1543_ VSS VSS VDD VDD _1544_ sky130_fd_sc_hd__nand2_1
X_4746_ _1154_ _1540_ _1542_ _1544_ _1176_ VSS VSS VDD VDD
+ _1545_ sky130_fd_sc_hd__o2111ai_4
X_4747_ _1156_ VSS VSS VDD VDD _1546_ sky130_fd_sc_hd__buf_6
X_4748_ registers\[16\]\[27\] registers\[18\]\[27\] registers\[20\]\[27\]
+ registers\[22\]\[27\] _1546_ _1454_ VSS VSS VDD VDD _1547_
+ sky130_fd_sc_hd__mux4_1
X_4749_ registers\[17\]\[27\] registers\[19\]\[27\] registers\[21\]\[27\]
+ registers\[23\]\[27\] _1417_ _1456_ VSS VSS VDD VDD _1548_
+ sky130_fd_sc_hd__mux4_1
X_4750_ _1181_ _1547_ _1548_ _1182_ VSS VSS VDD VDD _1549_
+ sky130_fd_sc_hd__a22oi_2
X_4751_ registers\[0\]\[27\] registers\[1\]\[27\] registers\[2\]\[27\]
+ registers\[3\]\[27\] _1478_ _1479_ VSS VSS VDD VDD _1550_
+ sky130_fd_sc_hd__mux4_1
X_4752_ registers\[4\]\[27\] registers\[5\]\[27\] registers\[6\]\[27\]
+ registers\[7\]\[27\] _1440_ _1404_ VSS VSS VDD VDD _1551_
+ sky130_fd_sc_hd__mux4_1
X_4753_ _1550_ _1551_ _1423_ VSS VSS VDD VDD _1552_ sky130_fd_sc_hd__mux2i_1
X_4754_ registers\[9\]\[27\] registers\[11\]\[27\] registers\[13\]\[27\]
+ registers\[15\]\[27\] _1443_ _1462_ VSS VSS VDD VDD _1553_
+ sky130_fd_sc_hd__mux4_1
X_4755_ registers\[8\]\[27\] registers\[10\]\[27\] registers\[12\]\[27\]
+ registers\[14\]\[27\] _1426_ _1445_ VSS VSS VDD VDD _1554_
+ sky130_fd_sc_hd__mux4_1
X_4756_ _1553_ _1554_ _1521_ VSS VSS VDD VDD _1555_ sky130_fd_sc_hd__mux2i_2
X_4757_ _1420_ _1552_ _1555_ _1429_ _1392_ VSS VSS VDD VDD
+ _1556_ sky130_fd_sc_hd__a221o_4
X_4758_ _1376_ _1545_ _1549_ _1556_ VSS VSS VDD VDD _0053_
+ sky130_fd_sc_hd__a31oi_4
X_4759_ _1148_ VSS VSS VDD VDD _1557_ sky130_fd_sc_hd__buf_4
X_4760_ registers\[17\]\[28\] registers\[19\]\[28\] registers\[21\]\[28\]
+ registers\[23\]\[28\] _1468_ _1524_ VSS VSS VDD VDD _1558_
+ sky130_fd_sc_hd__mux4_1
X_4761_ registers\[18\]\[28\] registers\[22\]\[28\] _1489_
+ VSS VSS VDD VDD _1559_ sky130_fd_sc_hd__mux2i_1
X_4762_ registers\[16\]\[28\] registers\[20\]\[28\] _1329_
+ VSS VSS VDD VDD _1560_ sky130_fd_sc_hd__mux2i_1
X_4763_ _1488_ _1559_ _1560_ _1492_ _1493_ VSS VSS VDD VDD
+ _1561_ sky130_fd_sc_hd__a221oi_1
X_4764_ _1467_ _1558_ _1561_ VSS VSS VDD VDD _1562_ sky130_fd_sc_hd__o21ai_0
X_4765_ registers\[24\]\[28\] registers\[26\]\[28\] registers\[28\]\[28\]
+ registers\[30\]\[28\] _1546_ _1454_ VSS VSS VDD VDD _1563_
+ sky130_fd_sc_hd__mux4_1
X_4766_ registers\[25\]\[28\] registers\[27\]\[28\] registers\[29\]\[28\]
+ registers\[31\]\[28\] _1417_ _1456_ VSS VSS VDD VDD _1564_
+ sky130_fd_sc_hd__mux4_1
X_4767_ _1496_ _1563_ _1564_ _1476_ VSS VSS VDD VDD _1565_
+ sky130_fd_sc_hd__a22oi_4
X_4768_ registers\[0\]\[28\] registers\[1\]\[28\] registers\[2\]\[28\]
+ registers\[3\]\[28\] _1478_ _1479_ VSS VSS VDD VDD _1566_
+ sky130_fd_sc_hd__mux4_1
X_4769_ registers\[4\]\[28\] registers\[5\]\[28\] registers\[6\]\[28\]
+ registers\[7\]\[28\] _1440_ _1404_ VSS VSS VDD VDD _1567_
+ sky130_fd_sc_hd__mux4_1
X_4770_ _1566_ _1567_ _1423_ VSS VSS VDD VDD _1568_ sky130_fd_sc_hd__mux2i_1
X_4771_ registers\[9\]\[28\] registers\[11\]\[28\] registers\[13\]\[28\]
+ registers\[15\]\[28\] _1443_ _1462_ VSS VSS VDD VDD _1569_
+ sky130_fd_sc_hd__mux4_1
X_4772_ registers\[8\]\[28\] registers\[10\]\[28\] registers\[12\]\[28\]
+ registers\[14\]\[28\] _1426_ _1445_ VSS VSS VDD VDD _1570_
+ sky130_fd_sc_hd__mux4_1
X_4773_ _1569_ _1570_ _1521_ VSS VSS VDD VDD _1571_ sky130_fd_sc_hd__mux2i_2
X_4774_ _1200_ VSS VSS VDD VDD _1572_ sky130_fd_sc_hd__buf_4
X_4775_ _1420_ _1568_ _1571_ _1429_ _1572_ VSS VSS VDD VDD
+ _1573_ sky130_fd_sc_hd__a221o_2
X_4776_ _1557_ _1562_ _1565_ _1573_ VSS VSS VDD VDD _0054_
+ sky130_fd_sc_hd__a31oi_1
X_4777_ registers\[17\]\[29\] registers\[19\]\[29\] registers\[21\]\[29\]
+ registers\[23\]\[29\] _1468_ _1524_ VSS VSS VDD VDD _1574_
+ sky130_fd_sc_hd__mux4_1
X_4778_ registers\[18\]\[29\] registers\[22\]\[29\] _1489_
+ VSS VSS VDD VDD _1575_ sky130_fd_sc_hd__mux2i_1
X_4779_ registers\[16\]\[29\] registers\[20\]\[29\] _1329_
+ VSS VSS VDD VDD _1576_ sky130_fd_sc_hd__mux2i_1
X_4780_ _1488_ _1575_ _1576_ _1492_ _1493_ VSS VSS VDD VDD
+ _1577_ sky130_fd_sc_hd__a221oi_2
X_4781_ _1467_ _1574_ _1577_ VSS VSS VDD VDD _1578_ sky130_fd_sc_hd__o21ai_0
X_4782_ registers\[24\]\[29\] registers\[26\]\[29\] registers\[28\]\[29\]
+ registers\[30\]\[29\] _1546_ _1454_ VSS VSS VDD VDD _1579_
+ sky130_fd_sc_hd__mux4_1
X_4783_ registers\[25\]\[29\] registers\[27\]\[29\] registers\[29\]\[29\]
+ registers\[31\]\[29\] _1417_ _1456_ VSS VSS VDD VDD _1580_
+ sky130_fd_sc_hd__mux4_1
X_4784_ _1496_ _1579_ _1580_ _1476_ VSS VSS VDD VDD _1581_
+ sky130_fd_sc_hd__a22oi_4
X_4785_ registers\[8\]\[29\] registers\[9\]\[29\] registers\[10\]\[29\]
+ registers\[11\]\[29\] _1478_ _1479_ VSS VSS VDD VDD _1582_
+ sky130_fd_sc_hd__mux4_1
X_4786_ _1156_ VSS VSS VDD VDD _1583_ sky130_fd_sc_hd__buf_6
X_4787_ registers\[12\]\[29\] registers\[13\]\[29\] registers\[14\]\[29\]
+ registers\[15\]\[29\] _1440_ _1583_ VSS VSS VDD VDD _1584_
+ sky130_fd_sc_hd__mux4_1
X_4788_ _1582_ _1584_ _1423_ VSS VSS VDD VDD _1585_ sky130_fd_sc_hd__mux2i_2
X_4789_ registers\[1\]\[29\] registers\[3\]\[29\] registers\[5\]\[29\]
+ registers\[7\]\[29\] _1443_ _1462_ VSS VSS VDD VDD _1586_
+ sky130_fd_sc_hd__mux4_1
X_4790_ registers\[0\]\[29\] registers\[2\]\[29\] registers\[4\]\[29\]
+ registers\[6\]\[29\] _1426_ _1445_ VSS VSS VDD VDD _1587_
+ sky130_fd_sc_hd__mux4_1
X_4791_ _1586_ _1587_ _1521_ VSS VSS VDD VDD _1588_ sky130_fd_sc_hd__mux2i_1
X_4792_ _1196_ _1585_ _1588_ _1310_ _1572_ VSS VSS VDD VDD
+ _1589_ sky130_fd_sc_hd__a221o_2
X_4793_ _1557_ _1578_ _1581_ _1589_ VSS VSS VDD VDD _0055_
+ sky130_fd_sc_hd__a31oi_2
X_4794_ registers\[17\]\[2\] registers\[19\]\[2\] registers\[21\]\[2\]
+ registers\[23\]\[2\] _1468_ _1524_ VSS VSS VDD VDD _1590_
+ sky130_fd_sc_hd__mux4_1
X_4795_ registers\[18\]\[2\] registers\[22\]\[2\] _1489_ VSS
+ VSS VDD VDD _1591_ sky130_fd_sc_hd__mux2i_1
X_4796_ registers\[16\]\[2\] registers\[20\]\[2\] _1240_ VSS
+ VSS VDD VDD _1592_ sky130_fd_sc_hd__mux2i_1
X_4797_ _1488_ _1591_ _1592_ _1492_ _1493_ VSS VSS VDD VDD
+ _1593_ sky130_fd_sc_hd__a221oi_1
X_4798_ _1467_ _1590_ _1593_ VSS VSS VDD VDD _1594_ sky130_fd_sc_hd__o21ai_0
X_4799_ registers\[24\]\[2\] registers\[26\]\[2\] registers\[28\]\[2\]
+ registers\[30\]\[2\] _1546_ _1454_ VSS VSS VDD VDD _1595_
+ sky130_fd_sc_hd__mux4_1
X_4800_ _1166_ VSS VSS VDD VDD _1596_ sky130_fd_sc_hd__buf_6
X_4801_ registers\[25\]\[2\] registers\[27\]\[2\] registers\[29\]\[2\]
+ registers\[31\]\[2\] _1596_ _1456_ VSS VSS VDD VDD _1597_
+ sky130_fd_sc_hd__mux4_1
X_4802_ _1496_ _1595_ _1597_ _1476_ VSS VSS VDD VDD _1598_
+ sky130_fd_sc_hd__a22oi_4
X_4803_ registers\[0\]\[2\] registers\[1\]\[2\] registers\[2\]\[2\]
+ registers\[3\]\[2\] _1478_ _1479_ VSS VSS VDD VDD _1599_ sky130_fd_sc_hd__mux4_1
X_4804_ registers\[4\]\[2\] registers\[5\]\[2\] registers\[6\]\[2\]
+ registers\[7\]\[2\] _1440_ _1583_ VSS VSS VDD VDD _1600_ sky130_fd_sc_hd__mux4_1
X_4805_ _1222_ VSS VSS VDD VDD _1601_ sky130_fd_sc_hd__clkbuf_16
X_4806_ _1599_ _1600_ _1601_ VSS VSS VDD VDD _1602_ sky130_fd_sc_hd__mux2i_1
X_4807_ registers\[9\]\[2\] registers\[11\]\[2\] registers\[13\]\[2\]
+ registers\[15\]\[2\] _1443_ _1462_ VSS VSS VDD VDD _1603_
+ sky130_fd_sc_hd__mux4_1
X_4808_ _1155_ VSS VSS VDD VDD _1604_ sky130_fd_sc_hd__buf_8
X_4809_ registers\[8\]\[2\] registers\[10\]\[2\] registers\[12\]\[2\]
+ registers\[14\]\[2\] _1604_ _1445_ VSS VSS VDD VDD _1605_
+ sky130_fd_sc_hd__mux4_1
X_4810_ _1603_ _1605_ _1521_ VSS VSS VDD VDD _1606_ sky130_fd_sc_hd__mux2i_2
X_4811_ _1420_ _1602_ _1606_ _1429_ _1572_ VSS VSS VDD VDD
+ _1607_ sky130_fd_sc_hd__a221o_2
X_4812_ _1557_ _1594_ _1598_ _1607_ VSS VSS VDD VDD _0056_
+ sky130_fd_sc_hd__a31oi_1
X_4813_ registers\[17\]\[30\] registers\[19\]\[30\] registers\[21\]\[30\]
+ registers\[23\]\[30\] _1468_ _1524_ VSS VSS VDD VDD _1608_
+ sky130_fd_sc_hd__mux4_1
X_4814_ registers\[18\]\[30\] registers\[22\]\[30\] _1489_
+ VSS VSS VDD VDD _1609_ sky130_fd_sc_hd__mux2i_2
X_4815_ registers\[16\]\[30\] registers\[20\]\[30\] _1240_
+ VSS VSS VDD VDD _1610_ sky130_fd_sc_hd__mux2i_1
X_4816_ _1488_ _1609_ _1610_ _1492_ _1493_ VSS VSS VDD VDD
+ _1611_ sky130_fd_sc_hd__a221oi_2
X_4817_ _1467_ _1608_ _1611_ VSS VSS VDD VDD _1612_ sky130_fd_sc_hd__o21ai_0
X_4818_ registers\[24\]\[30\] registers\[26\]\[30\] registers\[28\]\[30\]
+ registers\[30\]\[30\] _1546_ _1454_ VSS VSS VDD VDD _1613_
+ sky130_fd_sc_hd__mux4_1
X_4819_ registers\[25\]\[30\] registers\[27\]\[30\] registers\[29\]\[30\]
+ registers\[31\]\[30\] _1596_ _1456_ VSS VSS VDD VDD _1614_
+ sky130_fd_sc_hd__mux4_1
X_4820_ _1496_ _1613_ _1614_ _1476_ VSS VSS VDD VDD _1615_
+ sky130_fd_sc_hd__a22oi_2
X_4821_ registers\[8\]\[30\] registers\[9\]\[30\] registers\[10\]\[30\]
+ registers\[11\]\[30\] _1478_ _1479_ VSS VSS VDD VDD _1616_
+ sky130_fd_sc_hd__mux4_1
X_4822_ registers\[12\]\[30\] registers\[13\]\[30\] registers\[14\]\[30\]
+ registers\[15\]\[30\] _1301_ _1583_ VSS VSS VDD VDD _1617_
+ sky130_fd_sc_hd__mux4_1
X_4823_ _1616_ _1617_ _1601_ VSS VSS VDD VDD _1618_ sky130_fd_sc_hd__mux2i_2
X_4824_ registers\[1\]\[30\] registers\[3\]\[30\] registers\[5\]\[30\]
+ registers\[7\]\[30\] _1224_ _1462_ VSS VSS VDD VDD _1619_
+ sky130_fd_sc_hd__mux4_1
X_4825_ registers\[0\]\[30\] registers\[2\]\[30\] registers\[4\]\[30\]
+ registers\[6\]\[30\] _1604_ _1191_ VSS VSS VDD VDD _1620_
+ sky130_fd_sc_hd__mux4_1
X_4826_ _1619_ _1620_ _1521_ VSS VSS VDD VDD _1621_ sky130_fd_sc_hd__mux2i_1
X_4827_ _1196_ _1618_ _1621_ _1310_ _1572_ VSS VSS VDD VDD
+ _1622_ sky130_fd_sc_hd__a221o_2
X_4828_ _1557_ _1612_ _1615_ _1622_ VSS VSS VDD VDD _0057_
+ sky130_fd_sc_hd__a31oi_1
X_4829_ registers\[17\]\[31\] registers\[19\]\[31\] registers\[21\]\[31\]
+ registers\[23\]\[31\] _1468_ _1524_ VSS VSS VDD VDD _1623_
+ sky130_fd_sc_hd__mux4_1
X_4830_ registers\[18\]\[31\] registers\[22\]\[31\] _1489_
+ VSS VSS VDD VDD _1624_ sky130_fd_sc_hd__mux2i_2
X_4831_ registers\[16\]\[31\] registers\[20\]\[31\] _1240_
+ VSS VSS VDD VDD _1625_ sky130_fd_sc_hd__mux2i_1
X_4832_ _1488_ _1624_ _1625_ _1492_ _1493_ VSS VSS VDD VDD
+ _1626_ sky130_fd_sc_hd__a221oi_2
X_4833_ _1467_ _1623_ _1626_ VSS VSS VDD VDD _1627_ sky130_fd_sc_hd__o21ai_0
X_4834_ registers\[24\]\[31\] registers\[26\]\[31\] registers\[28\]\[31\]
+ registers\[30\]\[31\] _1546_ _1192_ VSS VSS VDD VDD _1628_
+ sky130_fd_sc_hd__mux4_1
X_4835_ registers\[25\]\[31\] registers\[27\]\[31\] registers\[29\]\[31\]
+ registers\[31\]\[31\] _1596_ _1205_ VSS VSS VDD VDD _1629_
+ sky130_fd_sc_hd__mux4_1
X_4836_ _1496_ _1628_ _1629_ _1476_ VSS VSS VDD VDD _1630_
+ sky130_fd_sc_hd__a22oi_2
X_4837_ registers\[8\]\[31\] registers\[9\]\[31\] registers\[10\]\[31\]
+ registers\[11\]\[31\] _1478_ _1479_ VSS VSS VDD VDD _1631_
+ sky130_fd_sc_hd__mux4_1
X_4838_ registers\[12\]\[31\] registers\[13\]\[31\] registers\[14\]\[31\]
+ registers\[15\]\[31\] _1301_ _1583_ VSS VSS VDD VDD _1632_
+ sky130_fd_sc_hd__mux4_1
X_4839_ _1631_ _1632_ _1601_ VSS VSS VDD VDD _1633_ sky130_fd_sc_hd__mux2i_2
X_4840_ registers\[1\]\[31\] registers\[3\]\[31\] registers\[5\]\[31\]
+ registers\[7\]\[31\] _1224_ _1225_ VSS VSS VDD VDD _1634_
+ sky130_fd_sc_hd__mux4_1
X_4841_ registers\[0\]\[31\] registers\[2\]\[31\] registers\[4\]\[31\]
+ registers\[6\]\[31\] _1604_ _1191_ VSS VSS VDD VDD _1635_
+ sky130_fd_sc_hd__mux4_1
X_4842_ _1634_ _1635_ _1521_ VSS VSS VDD VDD _1636_ sky130_fd_sc_hd__mux2i_1
X_4843_ _1196_ _1633_ _1636_ _1310_ _1572_ VSS VSS VDD VDD
+ _1637_ sky130_fd_sc_hd__a221o_2
X_4844_ _1557_ _1627_ _1630_ _1637_ VSS VSS VDD VDD _0058_
+ sky130_fd_sc_hd__a31oi_1
X_4845_ registers\[25\]\[3\] registers\[27\]\[3\] registers\[29\]\[3\]
+ registers\[31\]\[3\] _1166_ _1160_ VSS VSS VDD VDD _1638_
+ sky130_fd_sc_hd__mux4_1
X_4846_ registers\[24\]\[3\] registers\[28\]\[3\] _1243_ VSS
+ VSS VDD VDD _1639_ sky130_fd_sc_hd__mux2i_1
X_4847_ _1169_ _1639_ VSS VSS VDD VDD _1640_ sky130_fd_sc_hd__nand2_1
X_4848_ registers\[26\]\[3\] registers\[30\]\[3\] _1163_ VSS
+ VSS VDD VDD _1641_ sky130_fd_sc_hd__mux2i_1
X_4849_ _1173_ _1641_ VSS VSS VDD VDD _1642_ sky130_fd_sc_hd__nand2_1
X_4850_ _1153_ _1638_ _1640_ _1642_ _1176_ VSS VSS VDD VDD
+ _1643_ sky130_fd_sc_hd__o2111ai_4
X_4851_ registers\[16\]\[3\] registers\[18\]\[3\] registers\[20\]\[3\]
+ registers\[22\]\[3\] _1546_ _1192_ VSS VSS VDD VDD _1644_
+ sky130_fd_sc_hd__mux4_1
X_4852_ registers\[17\]\[3\] registers\[19\]\[3\] registers\[21\]\[3\]
+ registers\[23\]\[3\] _1596_ _1205_ VSS VSS VDD VDD _1645_
+ sky130_fd_sc_hd__mux4_1
X_4853_ _1181_ _1644_ _1645_ _1182_ VSS VSS VDD VDD _1646_
+ sky130_fd_sc_hd__a22oi_1
X_4854_ registers\[0\]\[3\] registers\[1\]\[3\] registers\[2\]\[3\]
+ registers\[3\]\[3\] _1189_ _1178_ VSS VSS VDD VDD _1647_ sky130_fd_sc_hd__mux4_1
X_4855_ registers\[4\]\[3\] registers\[5\]\[3\] registers\[6\]\[3\]
+ registers\[7\]\[3\] _1301_ _1583_ VSS VSS VDD VDD _1648_ sky130_fd_sc_hd__mux4_1
X_4856_ _1647_ _1648_ _1601_ VSS VSS VDD VDD _1649_ sky130_fd_sc_hd__mux2i_1
X_4857_ registers\[9\]\[3\] registers\[11\]\[3\] registers\[13\]\[3\]
+ registers\[15\]\[3\] _1224_ _1225_ VSS VSS VDD VDD _1650_
+ sky130_fd_sc_hd__mux4_1
X_4858_ registers\[8\]\[3\] registers\[10\]\[3\] registers\[12\]\[3\]
+ registers\[14\]\[3\] _1604_ _1191_ VSS VSS VDD VDD _1651_
+ sky130_fd_sc_hd__mux4_1
X_4859_ _1650_ _1651_ _1521_ VSS VSS VDD VDD _1652_ sky130_fd_sc_hd__mux2i_4
X_4860_ _1420_ _1649_ _1652_ _1429_ _1572_ VSS VSS VDD VDD
+ _1653_ sky130_fd_sc_hd__a221o_2
X_4861_ _1557_ _1643_ _1646_ _1653_ VSS VSS VDD VDD _0059_
+ sky130_fd_sc_hd__a31oi_2
X_4862_ registers\[17\]\[4\] registers\[19\]\[4\] registers\[21\]\[4\]
+ registers\[23\]\[4\] _1468_ _1524_ VSS VSS VDD VDD _1654_
+ sky130_fd_sc_hd__mux4_1
X_4863_ registers\[18\]\[4\] registers\[22\]\[4\] _1489_ VSS
+ VSS VDD VDD _1655_ sky130_fd_sc_hd__mux2i_1
X_4864_ registers\[16\]\[4\] registers\[20\]\[4\] _1240_ VSS
+ VSS VDD VDD _1656_ sky130_fd_sc_hd__mux2i_1
X_4865_ _1488_ _1655_ _1656_ _1492_ _1493_ VSS VSS VDD VDD
+ _1657_ sky130_fd_sc_hd__a221oi_1
X_4866_ _1467_ _1654_ _1657_ VSS VSS VDD VDD _1658_ sky130_fd_sc_hd__o21ai_0
X_4867_ registers\[24\]\[4\] registers\[26\]\[4\] registers\[28\]\[4\]
+ registers\[30\]\[4\] _1546_ _1192_ VSS VSS VDD VDD _1659_
+ sky130_fd_sc_hd__mux4_1
X_4868_ registers\[25\]\[4\] registers\[27\]\[4\] registers\[29\]\[4\]
+ registers\[31\]\[4\] _1596_ _1205_ VSS VSS VDD VDD _1660_
+ sky130_fd_sc_hd__mux4_1
X_4869_ _1496_ _1659_ _1660_ _1476_ VSS VSS VDD VDD _1661_
+ sky130_fd_sc_hd__a22oi_2
X_4870_ registers\[0\]\[4\] registers\[1\]\[4\] registers\[2\]\[4\]
+ registers\[3\]\[4\] _1189_ _1178_ VSS VSS VDD VDD _1662_ sky130_fd_sc_hd__mux4_1
X_4871_ registers\[4\]\[4\] registers\[5\]\[4\] registers\[6\]\[4\]
+ registers\[7\]\[4\] _1301_ _1583_ VSS VSS VDD VDD _1663_ sky130_fd_sc_hd__mux4_1
X_4872_ _1662_ _1663_ _1601_ VSS VSS VDD VDD _1664_ sky130_fd_sc_hd__mux2i_1
X_4873_ registers\[9\]\[4\] registers\[11\]\[4\] registers\[13\]\[4\]
+ registers\[15\]\[4\] _1224_ _1225_ VSS VSS VDD VDD _1665_
+ sky130_fd_sc_hd__mux4_1
X_4874_ registers\[8\]\[4\] registers\[10\]\[4\] registers\[12\]\[4\]
+ registers\[14\]\[4\] _1604_ _1191_ VSS VSS VDD VDD _1666_
+ sky130_fd_sc_hd__mux4_1
X_4875_ _1665_ _1666_ _1521_ VSS VSS VDD VDD _1667_ sky130_fd_sc_hd__mux2i_2
X_4876_ _1420_ _1664_ _1667_ _1429_ _1572_ VSS VSS VDD VDD
+ _1668_ sky130_fd_sc_hd__a221o_1
X_4877_ _1557_ _1658_ _1661_ _1668_ VSS VSS VDD VDD _0060_
+ sky130_fd_sc_hd__a31oi_1
X_4878_ registers\[25\]\[5\] registers\[27\]\[5\] registers\[29\]\[5\]
+ registers\[31\]\[5\] _1166_ _1160_ VSS VSS VDD VDD _1669_
+ sky130_fd_sc_hd__mux4_1
X_4879_ registers\[24\]\[5\] registers\[28\]\[5\] _1243_ VSS
+ VSS VDD VDD _1670_ sky130_fd_sc_hd__mux2i_1
X_4880_ _1169_ _1670_ VSS VSS VDD VDD _1671_ sky130_fd_sc_hd__nand2_1
X_4881_ registers\[26\]\[5\] registers\[30\]\[5\] _1163_ VSS
+ VSS VDD VDD _1672_ sky130_fd_sc_hd__mux2i_1
X_4882_ _1173_ _1672_ VSS VSS VDD VDD _1673_ sky130_fd_sc_hd__nand2_1
X_4883_ _1153_ _1669_ _1671_ _1673_ _1176_ VSS VSS VDD VDD
+ _1674_ sky130_fd_sc_hd__o2111ai_4
X_4884_ registers\[16\]\[5\] registers\[18\]\[5\] registers\[20\]\[5\]
+ registers\[22\]\[5\] _1546_ _1192_ VSS VSS VDD VDD _1675_
+ sky130_fd_sc_hd__mux4_1
X_4885_ registers\[17\]\[5\] registers\[19\]\[5\] registers\[21\]\[5\]
+ registers\[23\]\[5\] _1596_ _1205_ VSS VSS VDD VDD _1676_
+ sky130_fd_sc_hd__mux4_1
X_4886_ _1181_ _1675_ _1676_ _1182_ VSS VSS VDD VDD _1677_
+ sky130_fd_sc_hd__a22oi_1
X_4887_ registers\[0\]\[5\] registers\[1\]\[5\] registers\[2\]\[5\]
+ registers\[3\]\[5\] _1189_ _1178_ VSS VSS VDD VDD _1678_ sky130_fd_sc_hd__mux4_1
X_4888_ registers\[4\]\[5\] registers\[5\]\[5\] registers\[6\]\[5\]
+ registers\[7\]\[5\] _1301_ _1583_ VSS VSS VDD VDD _1679_ sky130_fd_sc_hd__mux4_1
X_4889_ _1678_ _1679_ _1601_ VSS VSS VDD VDD _1680_ sky130_fd_sc_hd__mux2i_1
X_4890_ registers\[9\]\[5\] registers\[11\]\[5\] registers\[13\]\[5\]
+ registers\[15\]\[5\] _1224_ _1225_ VSS VSS VDD VDD _1681_
+ sky130_fd_sc_hd__mux4_1
X_4891_ registers\[8\]\[5\] registers\[10\]\[5\] registers\[12\]\[5\]
+ registers\[14\]\[5\] _1604_ _1191_ VSS VSS VDD VDD _1682_
+ sky130_fd_sc_hd__mux4_1
X_4892_ _1681_ _1682_ _1152_ VSS VSS VDD VDD _1683_ sky130_fd_sc_hd__mux2i_2
X_4893_ _1420_ _1680_ _1683_ _1429_ _1572_ VSS VSS VDD VDD
+ _1684_ sky130_fd_sc_hd__a221o_2
X_4894_ _1557_ _1674_ _1677_ _1684_ VSS VSS VDD VDD _0061_
+ sky130_fd_sc_hd__a31oi_2
X_4895_ registers\[17\]\[6\] registers\[19\]\[6\] registers\[21\]\[6\]
+ registers\[23\]\[6\] _1468_ _1524_ VSS VSS VDD VDD _1685_
+ sky130_fd_sc_hd__mux4_1
X_4896_ registers\[18\]\[6\] registers\[22\]\[6\] _1489_ VSS
+ VSS VDD VDD _1686_ sky130_fd_sc_hd__mux2i_1
X_4897_ registers\[16\]\[6\] registers\[20\]\[6\] _1240_ VSS
+ VSS VDD VDD _1687_ sky130_fd_sc_hd__mux2i_1
X_4898_ _1488_ _1686_ _1687_ _1492_ _1493_ VSS VSS VDD VDD
+ _1688_ sky130_fd_sc_hd__a221oi_1
X_4899_ _1467_ _1685_ _1688_ VSS VSS VDD VDD _1689_ sky130_fd_sc_hd__o21ai_0
X_4900_ registers\[24\]\[6\] registers\[26\]\[6\] registers\[28\]\[6\]
+ registers\[30\]\[6\] _1546_ _1192_ VSS VSS VDD VDD _1690_
+ sky130_fd_sc_hd__mux4_1
X_4901_ registers\[25\]\[6\] registers\[27\]\[6\] registers\[29\]\[6\]
+ registers\[31\]\[6\] _1596_ _1205_ VSS VSS VDD VDD _1691_
+ sky130_fd_sc_hd__mux4_1
X_4902_ _1496_ _1690_ _1691_ _1476_ VSS VSS VDD VDD _1692_
+ sky130_fd_sc_hd__a22oi_2
X_4903_ registers\[0\]\[6\] registers\[1\]\[6\] registers\[2\]\[6\]
+ registers\[3\]\[6\] _1189_ _1178_ VSS VSS VDD VDD _1693_ sky130_fd_sc_hd__mux4_1
X_4904_ registers\[4\]\[6\] registers\[5\]\[6\] registers\[6\]\[6\]
+ registers\[7\]\[6\] _1301_ _1583_ VSS VSS VDD VDD _1694_ sky130_fd_sc_hd__mux4_1
X_4905_ _1693_ _1694_ _1601_ VSS VSS VDD VDD _1695_ sky130_fd_sc_hd__mux2i_1
X_4906_ registers\[9\]\[6\] registers\[11\]\[6\] registers\[13\]\[6\]
+ registers\[15\]\[6\] _1224_ _1225_ VSS VSS VDD VDD _1696_
+ sky130_fd_sc_hd__mux4_1
X_4907_ registers\[8\]\[6\] registers\[10\]\[6\] registers\[12\]\[6\]
+ registers\[14\]\[6\] _1604_ _1191_ VSS VSS VDD VDD _1697_
+ sky130_fd_sc_hd__mux4_1
X_4908_ _1696_ _1697_ _1152_ VSS VSS VDD VDD _1698_ sky130_fd_sc_hd__mux2i_1
X_4909_ _1310_ _1695_ _1698_ _1195_ _1572_ VSS VSS VDD VDD
+ _1699_ sky130_fd_sc_hd__a221o_1
X_4910_ _1557_ _1689_ _1692_ _1699_ VSS VSS VDD VDD _0062_
+ sky130_fd_sc_hd__a31oi_1
X_4911_ registers\[17\]\[7\] registers\[19\]\[7\] registers\[21\]\[7\]
+ registers\[23\]\[7\] _1183_ _1524_ VSS VSS VDD VDD _1700_
+ sky130_fd_sc_hd__mux4_1
X_4912_ registers\[18\]\[7\] registers\[22\]\[7\] _1489_ VSS
+ VSS VDD VDD _1701_ sky130_fd_sc_hd__mux2i_1
X_4913_ registers\[16\]\[7\] registers\[20\]\[7\] _1240_ VSS
+ VSS VDD VDD _1702_ sky130_fd_sc_hd__mux2i_1
X_4914_ _1488_ _1701_ _1702_ _1492_ _1493_ VSS VSS VDD VDD
+ _1703_ sky130_fd_sc_hd__a221oi_2
X_4915_ _1154_ _1700_ _1703_ VSS VSS VDD VDD _1704_ sky130_fd_sc_hd__o21ai_1
X_4916_ registers\[24\]\[7\] registers\[26\]\[7\] registers\[28\]\[7\]
+ registers\[30\]\[7\] _1157_ _1192_ VSS VSS VDD VDD _1705_
+ sky130_fd_sc_hd__mux4_1
X_4917_ registers\[25\]\[7\] registers\[27\]\[7\] registers\[29\]\[7\]
+ registers\[31\]\[7\] _1596_ _1205_ VSS VSS VDD VDD _1706_
+ sky130_fd_sc_hd__mux4_1
X_4918_ _1496_ _1705_ _1706_ _1214_ VSS VSS VDD VDD _1707_
+ sky130_fd_sc_hd__a22oi_4
X_4919_ registers\[8\]\[7\] registers\[9\]\[7\] registers\[10\]\[7\]
+ registers\[11\]\[7\] _1189_ _1178_ VSS VSS VDD VDD _1708_
+ sky130_fd_sc_hd__mux4_1
X_4920_ registers\[12\]\[7\] registers\[13\]\[7\] registers\[14\]\[7\]
+ registers\[15\]\[7\] _1301_ _1583_ VSS VSS VDD VDD _1709_
+ sky130_fd_sc_hd__mux4_1
X_4921_ _1708_ _1709_ _1601_ VSS VSS VDD VDD _1710_ sky130_fd_sc_hd__mux2i_1
X_4922_ registers\[1\]\[7\] registers\[3\]\[7\] registers\[5\]\[7\]
+ registers\[7\]\[7\] _1224_ _1225_ VSS VSS VDD VDD _1711_ sky130_fd_sc_hd__mux4_1
X_4923_ registers\[0\]\[7\] registers\[2\]\[7\] registers\[4\]\[7\]
+ registers\[6\]\[7\] _1604_ _1191_ VSS VSS VDD VDD _1712_ sky130_fd_sc_hd__mux4_1
X_4924_ _1711_ _1712_ _1152_ VSS VSS VDD VDD _1713_ sky130_fd_sc_hd__mux2i_1
X_4925_ _1196_ _1710_ _1713_ _1186_ _1572_ VSS VSS VDD VDD
+ _1714_ sky130_fd_sc_hd__a221o_2
X_4926_ _1557_ _1704_ _1707_ _1714_ VSS VSS VDD VDD _0063_
+ sky130_fd_sc_hd__a31oi_4
X_4927_ registers\[17\]\[8\] registers\[19\]\[8\] registers\[21\]\[8\]
+ registers\[23\]\[8\] _1183_ _1524_ VSS VSS VDD VDD _1715_
+ sky130_fd_sc_hd__mux4_1
X_4928_ registers\[18\]\[8\] registers\[22\]\[8\] _1162_ VSS
+ VSS VDD VDD _1716_ sky130_fd_sc_hd__mux2i_1
X_4929_ registers\[16\]\[8\] registers\[20\]\[8\] _1240_ VSS
+ VSS VDD VDD _1717_ sky130_fd_sc_hd__mux2i_1
X_4930_ _1172_ _1716_ _1717_ _1168_ _1175_ VSS VSS VDD VDD
+ _1718_ sky130_fd_sc_hd__a221oi_1
X_4931_ _1154_ _1715_ _1718_ VSS VSS VDD VDD _1719_ sky130_fd_sc_hd__o21ai_1
X_4932_ registers\[24\]\[8\] registers\[26\]\[8\] registers\[28\]\[8\]
+ registers\[30\]\[8\] _1157_ _1192_ VSS VSS VDD VDD _1720_
+ sky130_fd_sc_hd__mux4_1
X_4933_ registers\[25\]\[8\] registers\[27\]\[8\] registers\[29\]\[8\]
+ registers\[31\]\[8\] _1596_ _1205_ VSS VSS VDD VDD _1721_
+ sky130_fd_sc_hd__mux4_1
X_4934_ _1212_ _1720_ _1721_ _1214_ VSS VSS VDD VDD _1722_
+ sky130_fd_sc_hd__a22oi_4
X_4935_ registers\[0\]\[8\] registers\[1\]\[8\] registers\[2\]\[8\]
+ registers\[3\]\[8\] _1189_ _1178_ VSS VSS VDD VDD _1723_ sky130_fd_sc_hd__mux4_1
X_4936_ registers\[4\]\[8\] registers\[5\]\[8\] registers\[6\]\[8\]
+ registers\[7\]\[8\] _1301_ _1583_ VSS VSS VDD VDD _1724_ sky130_fd_sc_hd__mux4_1
X_4937_ _1723_ _1724_ _1601_ VSS VSS VDD VDD _1725_ sky130_fd_sc_hd__mux2i_1
X_4938_ registers\[9\]\[8\] registers\[11\]\[8\] registers\[13\]\[8\]
+ registers\[15\]\[8\] _1224_ _1225_ VSS VSS VDD VDD _1726_
+ sky130_fd_sc_hd__mux4_1
X_4939_ registers\[8\]\[8\] registers\[10\]\[8\] registers\[12\]\[8\]
+ registers\[14\]\[8\] _1604_ _1191_ VSS VSS VDD VDD _1727_
+ sky130_fd_sc_hd__mux4_1
X_4940_ _1726_ _1727_ _1152_ VSS VSS VDD VDD _1728_ sky130_fd_sc_hd__mux2i_1
X_4941_ _1310_ _1725_ _1728_ _1195_ _1200_ VSS VSS VDD VDD
+ _1729_ sky130_fd_sc_hd__a221o_2
X_4942_ _1148_ _1719_ _1722_ _1729_ VSS VSS VDD VDD _0064_
+ sky130_fd_sc_hd__a31oi_4
X_4943_ registers\[17\]\[9\] registers\[19\]\[9\] registers\[21\]\[9\]
+ registers\[23\]\[9\] _1183_ _1179_ VSS VSS VDD VDD _1730_
+ sky130_fd_sc_hd__mux4_1
X_4944_ registers\[18\]\[9\] registers\[22\]\[9\] _1162_ VSS
+ VSS VDD VDD _1731_ sky130_fd_sc_hd__mux2i_1
X_4945_ registers\[16\]\[9\] registers\[20\]\[9\] _1240_ VSS
+ VSS VDD VDD _1732_ sky130_fd_sc_hd__mux2i_1
X_4946_ _1172_ _1731_ _1732_ _1168_ _1175_ VSS VSS VDD VDD
+ _1733_ sky130_fd_sc_hd__a221oi_1
X_4947_ _1154_ _1730_ _1733_ VSS VSS VDD VDD _1734_ sky130_fd_sc_hd__o21ai_1
X_4948_ registers\[24\]\[9\] registers\[26\]\[9\] registers\[28\]\[9\]
+ registers\[30\]\[9\] _1157_ _1192_ VSS VSS VDD VDD _1735_
+ sky130_fd_sc_hd__mux4_1
X_4949_ registers\[25\]\[9\] registers\[27\]\[9\] registers\[29\]\[9\]
+ registers\[31\]\[9\] _1596_ _1205_ VSS VSS VDD VDD _1736_
+ sky130_fd_sc_hd__mux4_1
X_4950_ _1212_ _1735_ _1736_ _1214_ VSS VSS VDD VDD _1737_
+ sky130_fd_sc_hd__a22oi_2
X_4951_ registers\[8\]\[9\] registers\[9\]\[9\] registers\[10\]\[9\]
+ registers\[11\]\[9\] _1189_ _1178_ VSS VSS VDD VDD _1738_
+ sky130_fd_sc_hd__mux4_1
X_4952_ registers\[12\]\[9\] registers\[13\]\[9\] registers\[14\]\[9\]
+ registers\[15\]\[9\] _1301_ _1167_ VSS VSS VDD VDD _1739_
+ sky130_fd_sc_hd__mux4_1
X_4953_ _1738_ _1739_ _1601_ VSS VSS VDD VDD _1740_ sky130_fd_sc_hd__mux2i_1
X_4954_ registers\[1\]\[9\] registers\[3\]\[9\] registers\[5\]\[9\]
+ registers\[7\]\[9\] _1224_ _1225_ VSS VSS VDD VDD _1741_ sky130_fd_sc_hd__mux4_1
X_4955_ registers\[0\]\[9\] registers\[2\]\[9\] registers\[4\]\[9\]
+ registers\[6\]\[9\] _1604_ _1191_ VSS VSS VDD VDD _1742_ sky130_fd_sc_hd__mux4_1
X_4956_ _1741_ _1742_ _1152_ VSS VSS VDD VDD _1743_ sky130_fd_sc_hd__mux2i_1
X_4957_ _1228_ _1740_ _1743_ _1186_ _1200_ VSS VSS VDD VDD
+ _1744_ sky130_fd_sc_hd__a221o_2
X_4958_ _1148_ _1734_ _1737_ _1744_ VSS VSS VDD VDD _0065_
+ sky130_fd_sc_hd__a31oi_4
X_4959_ net167 VSS VSS VDD VDD _1745_ sky130_fd_sc_hd__buf_8
X_4960_ _1745_ VSS VSS VDD VDD _1746_ sky130_fd_sc_hd__buf_4
X_4961_ read_addr2[0] VSS VSS VDD VDD _1747_ sky130_fd_sc_hd__buf_6
X_4962_ _1747_ VSS VSS VDD VDD _1748_ sky130_fd_sc_hd__clkinvlp_4
X_4963_ _1748_ VSS VSS VDD VDD _1749_ sky130_fd_sc_hd__buf_16
X_4964_ _1749_ VSS VSS VDD VDD _1750_ sky130_fd_sc_hd__buf_12
X_4965_ _1750_ VSS VSS VDD VDD _1751_ sky130_fd_sc_hd__buf_16
X_4966_ read_addr2[1] VSS VSS VDD VDD _1752_ sky130_fd_sc_hd__buf_8
X_4967_ _1752_ VSS VSS VDD VDD _1753_ sky130_fd_sc_hd__buf_16
X_4968_ _1753_ VSS VSS VDD VDD _1754_ sky130_fd_sc_hd__buf_8
X_4969_ read_addr2[2] VSS VSS VDD VDD _1755_ sky130_fd_sc_hd__clkbuf_2
X_4970_ _1755_ VSS VSS VDD VDD _1756_ sky130_fd_sc_hd__buf_6
X_4971_ _1756_ VSS VSS VDD VDD _1757_ sky130_fd_sc_hd__buf_8
X_4972_ registers\[25\]\[0\] registers\[27\]\[0\] registers\[29\]\[0\]
+ registers\[31\]\[0\] _1754_ _1757_ VSS VSS VDD VDD _1758_
+ sky130_fd_sc_hd__mux4_1
X_4973_ _1756_ VSS VSS VDD VDD _1759_ sky130_fd_sc_hd__buf_6
X_4974_ _1759_ VSS VSS VDD VDD _1760_ sky130_fd_sc_hd__buf_6
X_4975_ registers\[24\]\[0\] registers\[28\]\[0\] _1760_ VSS
+ VSS VDD VDD _1761_ sky130_fd_sc_hd__mux2i_1
X_4976_ _1747_ VSS VSS VDD VDD _1762_ sky130_fd_sc_hd__buf_6
X_4977_ _1752_ VSS VSS VDD VDD _1763_ sky130_fd_sc_hd__buf_8
X_4978_ _1763_ VSS VSS VDD VDD _1764_ sky130_fd_sc_hd__buf_6
X_4979_ _1762_ _1764_ VSS VSS VDD VDD _1765_ sky130_fd_sc_hd__nor2_2
X_4980_ _1765_ VSS VSS VDD VDD _1766_ sky130_fd_sc_hd__buf_6
X_4981_ _1761_ _1766_ VSS VSS VDD VDD _1767_ sky130_fd_sc_hd__nand2_1
X_4982_ registers\[26\]\[0\] registers\[30\]\[0\] _1760_ VSS
+ VSS VDD VDD _1768_ sky130_fd_sc_hd__mux2i_1
X_4983_ _1762_ _1764_ VSS VSS VDD VDD _1769_ sky130_fd_sc_hd__nor2b_2
X_4984_ _1769_ VSS VSS VDD VDD _1770_ sky130_fd_sc_hd__buf_6
X_4985_ _1768_ _1770_ VSS VSS VDD VDD _1771_ sky130_fd_sc_hd__nand2_1
X_4986_ net2 VSS VSS VDD VDD _1772_ sky130_fd_sc_hd__buf_8
X_4987_ _1772_ VSS VSS VDD VDD _1773_ sky130_fd_sc_hd__buf_16
X_4988_ _1751_ _1758_ _1767_ _1771_ _1773_ VSS VSS VDD VDD
+ _1774_ sky130_fd_sc_hd__o2111ai_4
X_4989_ _1753_ VSS VSS VDD VDD _1775_ sky130_fd_sc_hd__buf_6
X_4990_ _1759_ VSS VSS VDD VDD _1776_ sky130_fd_sc_hd__buf_6
X_4991_ registers\[16\]\[0\] registers\[18\]\[0\] registers\[20\]\[0\]
+ registers\[22\]\[0\] _1775_ _1776_ VSS VSS VDD VDD _1777_
+ sky130_fd_sc_hd__mux4_1
X_4992_ _1762_ _1772_ VSS VSS VDD VDD _1778_ sky130_fd_sc_hd__nor2_8
X_4993_ _1750_ _1772_ VSS VSS VDD VDD _1779_ sky130_fd_sc_hd__nor2_8
X_4994_ _1753_ VSS VSS VDD VDD _1780_ sky130_fd_sc_hd__buf_8
X_4995_ registers\[17\]\[0\] registers\[19\]\[0\] registers\[21\]\[0\]
+ registers\[23\]\[0\] _1780_ _1776_ VSS VSS VDD VDD _1781_
+ sky130_fd_sc_hd__mux4_1
X_4996_ _1777_ _1778_ _1779_ _1781_ VSS VSS VDD VDD _1782_
+ sky130_fd_sc_hd__a22oi_1
X_4997_ _1745_ net2 VSS VSS VDD VDD _1783_ sky130_fd_sc_hd__nor2b_1
X_4998_ _1783_ VSS VSS VDD VDD _1784_ sky130_fd_sc_hd__buf_2
X_4999_ _1784_ VSS VSS VDD VDD _1785_ sky130_fd_sc_hd__buf_8
X_5000_ registers\[8\]\[0\] registers\[9\]\[0\] registers\[10\]\[0\]
+ registers\[11\]\[0\] _1762_ _1780_ VSS VSS VDD VDD _1786_
+ sky130_fd_sc_hd__mux4_1
X_5001_ _1747_ VSS VSS VDD VDD _1787_ sky130_fd_sc_hd__buf_6
X_5002_ registers\[12\]\[0\] registers\[13\]\[0\] registers\[14\]\[0\]
+ registers\[15\]\[0\] _1787_ _1775_ VSS VSS VDD VDD _1788_
+ sky130_fd_sc_hd__mux4_1
X_5003_ _1755_ VSS VSS VDD VDD _1789_ sky130_fd_sc_hd__buf_8
X_5004_ _1789_ VSS VSS VDD VDD _1790_ sky130_fd_sc_hd__buf_8
X_5005_ _1786_ _1788_ _1790_ VSS VSS VDD VDD _1791_ sky130_fd_sc_hd__mux2i_1
X_5006_ _1772_ _1745_ VSS VSS VDD VDD _1792_ sky130_fd_sc_hd__nor2_4
X_5007_ _1792_ VSS VSS VDD VDD _1793_ sky130_fd_sc_hd__buf_4
X_5008_ registers\[1\]\[0\] registers\[3\]\[0\] registers\[5\]\[0\]
+ registers\[7\]\[0\] _1752_ _1756_ VSS VSS VDD VDD _1794_ sky130_fd_sc_hd__mux4_1
X_5009_ registers\[0\]\[0\] registers\[2\]\[0\] registers\[4\]\[0\]
+ registers\[6\]\[0\] _1752_ _1756_ VSS VSS VDD VDD _1795_ sky130_fd_sc_hd__mux4_1
X_5010_ _1794_ _1795_ _1749_ VSS VSS VDD VDD _1796_ sky130_fd_sc_hd__mux2i_1
X_5011_ _1122_ net4 VSS VSS VDD VDD _1797_ sky130_fd_sc_hd__nand2_4
X_5012_ _1797_ VSS VSS VDD VDD _1798_ sky130_fd_sc_hd__buf_4
X_5013_ _1785_ _1791_ _1793_ _1796_ _1798_ VSS VSS VDD VDD
+ _1799_ sky130_fd_sc_hd__a221o_2
X_5014_ _1746_ _1774_ _1782_ _1799_ VSS VSS VDD VDD _0066_
+ sky130_fd_sc_hd__a31oi_2
X_5015_ _1749_ VSS VSS VDD VDD _1800_ sky130_fd_sc_hd__clkbuf_4
X_5016_ _1763_ VSS VSS VDD VDD _1801_ sky130_fd_sc_hd__buf_4
X_5017_ _1759_ VSS VSS VDD VDD _1802_ sky130_fd_sc_hd__buf_6
X_5018_ registers\[17\]\[10\] registers\[19\]\[10\] registers\[21\]\[10\]
+ registers\[23\]\[10\] _1801_ _1802_ VSS VSS VDD VDD _1803_
+ sky130_fd_sc_hd__mux4_1
X_5019_ registers\[18\]\[10\] registers\[22\]\[10\] _1757_
+ VSS VSS VDD VDD _1804_ sky130_fd_sc_hd__mux2i_1
X_5020_ registers\[16\]\[10\] registers\[20\]\[10\] _1776_
+ VSS VSS VDD VDD _1805_ sky130_fd_sc_hd__mux2i_1
X_5021_ _1770_ _1804_ _1805_ _1766_ _1773_ VSS VSS VDD VDD
+ _1806_ sky130_fd_sc_hd__a221oi_1
X_5022_ _1800_ _1803_ _1806_ VSS VSS VDD VDD _1807_ sky130_fd_sc_hd__o21ai_1
X_5023_ registers\[24\]\[10\] registers\[26\]\[10\] registers\[28\]\[10\]
+ registers\[30\]\[10\] _1775_ _1776_ VSS VSS VDD VDD _1808_
+ sky130_fd_sc_hd__mux4_1
X_5024_ _1762_ _1772_ VSS VSS VDD VDD _1809_ sky130_fd_sc_hd__nor2b_4
X_5025_ _1762_ _1772_ VSS VSS VDD VDD _1810_ sky130_fd_sc_hd__and2_0
X_5026_ _1810_ VSS VSS VDD VDD _1811_ sky130_fd_sc_hd__buf_4
X_5027_ _1811_ VSS VSS VDD VDD _1812_ sky130_fd_sc_hd__buf_8
X_5028_ registers\[25\]\[10\] registers\[27\]\[10\] registers\[29\]\[10\]
+ registers\[31\]\[10\] _1780_ _1776_ VSS VSS VDD VDD _1813_
+ sky130_fd_sc_hd__mux4_1
X_5029_ _1808_ _1809_ _1812_ _1813_ VSS VSS VDD VDD _1814_
+ sky130_fd_sc_hd__a22oi_2
X_5030_ registers\[0\]\[10\] registers\[1\]\[10\] registers\[2\]\[10\]
+ registers\[3\]\[10\] _1762_ _1780_ VSS VSS VDD VDD _1815_
+ sky130_fd_sc_hd__mux4_1
X_5031_ _1753_ VSS VSS VDD VDD _1816_ sky130_fd_sc_hd__buf_6
X_5032_ registers\[4\]\[10\] registers\[5\]\[10\] registers\[6\]\[10\]
+ registers\[7\]\[10\] _1787_ _1816_ VSS VSS VDD VDD _1817_
+ sky130_fd_sc_hd__mux4_1
X_5033_ _1815_ _1817_ _1790_ VSS VSS VDD VDD _1818_ sky130_fd_sc_hd__mux2i_1
X_5034_ _1756_ VSS VSS VDD VDD _1819_ sky130_fd_sc_hd__buf_8
X_5035_ registers\[9\]\[10\] registers\[11\]\[10\] registers\[13\]\[10\]
+ registers\[15\]\[10\] _1753_ _1819_ VSS VSS VDD VDD _1820_
+ sky130_fd_sc_hd__mux4_1
X_5036_ _1752_ VSS VSS VDD VDD _1821_ sky130_fd_sc_hd__buf_8
X_5037_ _1756_ VSS VSS VDD VDD _1822_ sky130_fd_sc_hd__buf_8
X_5038_ registers\[8\]\[10\] registers\[10\]\[10\] registers\[12\]\[10\]
+ registers\[14\]\[10\] _1821_ _1822_ VSS VSS VDD VDD _1823_
+ sky130_fd_sc_hd__mux4_1
X_5039_ _1820_ _1823_ _1750_ VSS VSS VDD VDD _1824_ sky130_fd_sc_hd__mux2i_1
X_5040_ _1784_ VSS VSS VDD VDD _1825_ sky130_fd_sc_hd__clkbuf_8
X_5041_ _1793_ _1818_ _1824_ _1825_ _1798_ VSS VSS VDD VDD
+ _1826_ sky130_fd_sc_hd__a221o_2
X_5042_ _1746_ _1807_ _1814_ _1826_ VSS VSS VDD VDD _0067_
+ sky130_fd_sc_hd__a31oi_4
X_5043_ registers\[17\]\[11\] registers\[19\]\[11\] registers\[21\]\[11\]
+ registers\[23\]\[11\] _1801_ _1802_ VSS VSS VDD VDD _1827_
+ sky130_fd_sc_hd__mux4_1
X_5044_ _1769_ VSS VSS VDD VDD _1828_ sky130_fd_sc_hd__buf_4
X_5045_ _1756_ VSS VSS VDD VDD _1829_ sky130_fd_sc_hd__buf_6
X_5046_ registers\[18\]\[11\] registers\[22\]\[11\] _1829_
+ VSS VSS VDD VDD _1830_ sky130_fd_sc_hd__mux2i_1
X_5047_ registers\[16\]\[11\] registers\[20\]\[11\] _1776_
+ VSS VSS VDD VDD _1831_ sky130_fd_sc_hd__mux2i_1
X_5048_ _1765_ VSS VSS VDD VDD _1832_ sky130_fd_sc_hd__buf_6
X_5049_ _1772_ VSS VSS VDD VDD _1833_ sky130_fd_sc_hd__buf_4
X_5050_ _1828_ _1830_ _1831_ _1832_ _1833_ VSS VSS VDD VDD
+ _1834_ sky130_fd_sc_hd__a221oi_2
X_5051_ _1800_ _1827_ _1834_ VSS VSS VDD VDD _1835_ sky130_fd_sc_hd__o21ai_0
X_5052_ _1809_ VSS VSS VDD VDD _1836_ sky130_fd_sc_hd__buf_8
X_5053_ _1819_ VSS VSS VDD VDD _1837_ sky130_fd_sc_hd__buf_6
X_5054_ registers\[24\]\[11\] registers\[26\]\[11\] registers\[28\]\[11\]
+ registers\[30\]\[11\] _1764_ _1837_ VSS VSS VDD VDD _1838_
+ sky130_fd_sc_hd__mux4_1
X_5055_ _1763_ VSS VSS VDD VDD _1839_ sky130_fd_sc_hd__buf_6
X_5056_ _1759_ VSS VSS VDD VDD _1840_ sky130_fd_sc_hd__buf_8
X_5057_ registers\[25\]\[11\] registers\[27\]\[11\] registers\[29\]\[11\]
+ registers\[31\]\[11\] _1839_ _1840_ VSS VSS VDD VDD _1841_
+ sky130_fd_sc_hd__mux4_1
X_5058_ _1836_ _1838_ _1841_ _1812_ VSS VSS VDD VDD _1842_
+ sky130_fd_sc_hd__a22oi_2
X_5059_ registers\[0\]\[11\] registers\[1\]\[11\] registers\[2\]\[11\]
+ registers\[3\]\[11\] _1762_ _1780_ VSS VSS VDD VDD _1843_
+ sky130_fd_sc_hd__mux4_1
X_5060_ registers\[4\]\[11\] registers\[5\]\[11\] registers\[6\]\[11\]
+ registers\[7\]\[11\] _1787_ _1816_ VSS VSS VDD VDD _1844_
+ sky130_fd_sc_hd__mux4_1
X_5061_ _1819_ VSS VSS VDD VDD _1845_ sky130_fd_sc_hd__buf_8
X_5062_ _1843_ _1844_ _1845_ VSS VSS VDD VDD _1846_ sky130_fd_sc_hd__mux2i_1
X_5063_ registers\[9\]\[11\] registers\[11\]\[11\] registers\[13\]\[11\]
+ registers\[15\]\[11\] _1753_ _1819_ VSS VSS VDD VDD _1847_
+ sky130_fd_sc_hd__mux4_1
X_5064_ _1752_ VSS VSS VDD VDD _1848_ sky130_fd_sc_hd__buf_6
X_5065_ registers\[8\]\[11\] registers\[10\]\[11\] registers\[12\]\[11\]
+ registers\[14\]\[11\] _1848_ _1822_ VSS VSS VDD VDD _1849_
+ sky130_fd_sc_hd__mux4_1
X_5066_ _1847_ _1849_ _1750_ VSS VSS VDD VDD _1850_ sky130_fd_sc_hd__mux2i_1
X_5067_ _1793_ _1846_ _1850_ _1825_ _1798_ VSS VSS VDD VDD
+ _1851_ sky130_fd_sc_hd__a221o_1
X_5068_ _1746_ _1835_ _1842_ _1851_ VSS VSS VDD VDD _0068_
+ sky130_fd_sc_hd__a31oi_2
X_5069_ registers\[25\]\[12\] registers\[27\]\[12\] registers\[29\]\[12\]
+ registers\[31\]\[12\] _1754_ _1757_ VSS VSS VDD VDD _1852_
+ sky130_fd_sc_hd__mux4_1
X_5070_ registers\[24\]\[12\] registers\[28\]\[12\] _1840_
+ VSS VSS VDD VDD _1853_ sky130_fd_sc_hd__mux2i_1
X_5071_ _1766_ _1853_ VSS VSS VDD VDD _1854_ sky130_fd_sc_hd__nand2_1
X_5072_ registers\[26\]\[12\] registers\[30\]\[12\] _1760_
+ VSS VSS VDD VDD _1855_ sky130_fd_sc_hd__mux2i_1
X_5073_ _1770_ _1855_ VSS VSS VDD VDD _1856_ sky130_fd_sc_hd__nand2_1
X_5074_ _1751_ _1852_ _1854_ _1856_ _1773_ VSS VSS VDD VDD
+ _1857_ sky130_fd_sc_hd__o2111ai_4
X_5075_ registers\[16\]\[12\] registers\[18\]\[12\] registers\[20\]\[12\]
+ registers\[22\]\[12\] _1764_ _1837_ VSS VSS VDD VDD _1858_
+ sky130_fd_sc_hd__mux4_1
X_5076_ registers\[17\]\[12\] registers\[19\]\[12\] registers\[21\]\[12\]
+ registers\[23\]\[12\] _1839_ _1840_ VSS VSS VDD VDD _1859_
+ sky130_fd_sc_hd__mux4_1
X_5077_ _1778_ _1858_ _1859_ _1779_ VSS VSS VDD VDD _1860_
+ sky130_fd_sc_hd__a22oi_1
X_5078_ registers\[0\]\[12\] registers\[1\]\[12\] registers\[2\]\[12\]
+ registers\[3\]\[12\] _1762_ _1780_ VSS VSS VDD VDD _1861_
+ sky130_fd_sc_hd__mux4_1
X_5079_ _1747_ VSS VSS VDD VDD _1862_ sky130_fd_sc_hd__buf_6
X_5080_ registers\[4\]\[12\] registers\[5\]\[12\] registers\[6\]\[12\]
+ registers\[7\]\[12\] _1862_ _1816_ VSS VSS VDD VDD _1863_
+ sky130_fd_sc_hd__mux4_1
X_5081_ _1861_ _1863_ _1845_ VSS VSS VDD VDD _1864_ sky130_fd_sc_hd__mux2i_1
X_5082_ _1752_ VSS VSS VDD VDD _1865_ sky130_fd_sc_hd__buf_6
X_5083_ registers\[9\]\[12\] registers\[11\]\[12\] registers\[13\]\[12\]
+ registers\[15\]\[12\] _1865_ _1819_ VSS VSS VDD VDD _1866_
+ sky130_fd_sc_hd__mux4_1
X_5084_ _1755_ VSS VSS VDD VDD _1867_ sky130_fd_sc_hd__buf_6
X_5085_ registers\[8\]\[12\] registers\[10\]\[12\] registers\[12\]\[12\]
+ registers\[14\]\[12\] _1848_ _1867_ VSS VSS VDD VDD _1868_
+ sky130_fd_sc_hd__mux4_1
X_5086_ _1866_ _1868_ _1750_ VSS VSS VDD VDD _1869_ sky130_fd_sc_hd__mux2i_4
X_5087_ _1793_ _1864_ _1869_ _1825_ _1798_ VSS VSS VDD VDD
+ _1870_ sky130_fd_sc_hd__a221o_2
X_5088_ _1746_ _1857_ _1860_ _1870_ VSS VSS VDD VDD _0069_
+ sky130_fd_sc_hd__a31oi_2
X_5089_ _1759_ VSS VSS VDD VDD _1871_ sky130_fd_sc_hd__buf_4
X_5090_ registers\[17\]\[13\] registers\[19\]\[13\] registers\[21\]\[13\]
+ registers\[23\]\[13\] _1801_ _1871_ VSS VSS VDD VDD _1872_
+ sky130_fd_sc_hd__mux4_1
X_5091_ registers\[18\]\[13\] registers\[22\]\[13\] _1829_
+ VSS VSS VDD VDD _1873_ sky130_fd_sc_hd__mux2i_1
X_5092_ registers\[16\]\[13\] registers\[20\]\[13\] _1776_
+ VSS VSS VDD VDD _1874_ sky130_fd_sc_hd__mux2i_1
X_5093_ _1828_ _1873_ _1874_ _1832_ _1833_ VSS VSS VDD VDD
+ _1875_ sky130_fd_sc_hd__a221oi_1
X_5094_ _1800_ _1872_ _1875_ VSS VSS VDD VDD _1876_ sky130_fd_sc_hd__o21ai_0
X_5095_ _1819_ VSS VSS VDD VDD _1877_ sky130_fd_sc_hd__buf_6
X_5096_ registers\[24\]\[13\] registers\[26\]\[13\] registers\[28\]\[13\]
+ registers\[30\]\[13\] _1764_ _1877_ VSS VSS VDD VDD _1878_
+ sky130_fd_sc_hd__mux4_1
X_5097_ _1759_ VSS VSS VDD VDD _1879_ sky130_fd_sc_hd__buf_6
X_5098_ registers\[25\]\[13\] registers\[27\]\[13\] registers\[29\]\[13\]
+ registers\[31\]\[13\] _1839_ _1879_ VSS VSS VDD VDD _1880_
+ sky130_fd_sc_hd__mux4_1
X_5099_ _1836_ _1878_ _1880_ _1812_ VSS VSS VDD VDD _1881_
+ sky130_fd_sc_hd__a22oi_2
X_5100_ registers\[0\]\[13\] registers\[1\]\[13\] registers\[2\]\[13\]
+ registers\[3\]\[13\] _1762_ _1780_ VSS VSS VDD VDD _1882_
+ sky130_fd_sc_hd__mux4_1
X_5101_ registers\[4\]\[13\] registers\[5\]\[13\] registers\[6\]\[13\]
+ registers\[7\]\[13\] _1862_ _1816_ VSS VSS VDD VDD _1883_
+ sky130_fd_sc_hd__mux4_1
X_5102_ _1882_ _1883_ _1845_ VSS VSS VDD VDD _1884_ sky130_fd_sc_hd__mux2i_1
X_5103_ _1756_ VSS VSS VDD VDD _1885_ sky130_fd_sc_hd__buf_4
X_5104_ registers\[9\]\[13\] registers\[11\]\[13\] registers\[13\]\[13\]
+ registers\[15\]\[13\] _1865_ _1885_ VSS VSS VDD VDD _1886_
+ sky130_fd_sc_hd__mux4_1
X_5105_ registers\[8\]\[13\] registers\[10\]\[13\] registers\[12\]\[13\]
+ registers\[14\]\[13\] _1848_ _1867_ VSS VSS VDD VDD _1887_
+ sky130_fd_sc_hd__mux4_1
X_5106_ _1886_ _1887_ _1750_ VSS VSS VDD VDD _1888_ sky130_fd_sc_hd__mux2i_4
X_5107_ _1793_ _1884_ _1888_ _1825_ _1798_ VSS VSS VDD VDD
+ _1889_ sky130_fd_sc_hd__a221o_1
X_5108_ _1746_ _1876_ _1881_ _1889_ VSS VSS VDD VDD _0070_
+ sky130_fd_sc_hd__a31oi_1
X_5109_ registers\[25\]\[14\] registers\[27\]\[14\] registers\[29\]\[14\]
+ registers\[31\]\[14\] _1754_ _1757_ VSS VSS VDD VDD _1890_
+ sky130_fd_sc_hd__mux4_1
X_5110_ registers\[24\]\[14\] registers\[28\]\[14\] _1840_
+ VSS VSS VDD VDD _1891_ sky130_fd_sc_hd__mux2i_1
X_5111_ _1766_ _1891_ VSS VSS VDD VDD _1892_ sky130_fd_sc_hd__nand2_1
X_5112_ registers\[26\]\[14\] registers\[30\]\[14\] _1760_
+ VSS VSS VDD VDD _1893_ sky130_fd_sc_hd__mux2i_1
X_5113_ _1770_ _1893_ VSS VSS VDD VDD _1894_ sky130_fd_sc_hd__nand2_1
X_5114_ _1751_ _1890_ _1892_ _1894_ _1773_ VSS VSS VDD VDD
+ _1895_ sky130_fd_sc_hd__o2111ai_4
X_5115_ registers\[16\]\[14\] registers\[18\]\[14\] registers\[20\]\[14\]
+ registers\[22\]\[14\] _1764_ _1877_ VSS VSS VDD VDD _1896_
+ sky130_fd_sc_hd__mux4_1
X_5116_ registers\[17\]\[14\] registers\[19\]\[14\] registers\[21\]\[14\]
+ registers\[23\]\[14\] _1839_ _1879_ VSS VSS VDD VDD _1897_
+ sky130_fd_sc_hd__mux4_1
X_5117_ _1778_ _1896_ _1897_ _1779_ VSS VSS VDD VDD _1898_
+ sky130_fd_sc_hd__a22oi_1
X_5118_ _1747_ VSS VSS VDD VDD _1899_ sky130_fd_sc_hd__buf_16
X_5119_ _1899_ VSS VSS VDD VDD _1900_ sky130_fd_sc_hd__buf_16
X_5120_ _1763_ VSS VSS VDD VDD _1901_ sky130_fd_sc_hd__buf_6
X_5121_ registers\[0\]\[14\] registers\[1\]\[14\] registers\[2\]\[14\]
+ registers\[3\]\[14\] _1900_ _1901_ VSS VSS VDD VDD _1902_
+ sky130_fd_sc_hd__mux4_1
X_5122_ registers\[4\]\[14\] registers\[5\]\[14\] registers\[6\]\[14\]
+ registers\[7\]\[14\] _1862_ _1816_ VSS VSS VDD VDD _1903_
+ sky130_fd_sc_hd__mux4_1
X_5123_ _1902_ _1903_ _1845_ VSS VSS VDD VDD _1904_ sky130_fd_sc_hd__mux2i_1
X_5124_ registers\[9\]\[14\] registers\[11\]\[14\] registers\[13\]\[14\]
+ registers\[15\]\[14\] _1865_ _1885_ VSS VSS VDD VDD _1905_
+ sky130_fd_sc_hd__mux4_1
X_5125_ registers\[8\]\[14\] registers\[10\]\[14\] registers\[12\]\[14\]
+ registers\[14\]\[14\] _1848_ _1867_ VSS VSS VDD VDD _1906_
+ sky130_fd_sc_hd__mux4_1
X_5126_ _1905_ _1906_ _1750_ VSS VSS VDD VDD _1907_ sky130_fd_sc_hd__mux2i_1
X_5127_ _1793_ _1904_ _1907_ _1825_ _1798_ VSS VSS VDD VDD
+ _1908_ sky130_fd_sc_hd__a221o_2
X_5128_ _1746_ _1895_ _1898_ _1908_ VSS VSS VDD VDD _0071_
+ sky130_fd_sc_hd__a31oi_2
X_5129_ registers\[17\]\[15\] registers\[19\]\[15\] registers\[21\]\[15\]
+ registers\[23\]\[15\] _1801_ _1871_ VSS VSS VDD VDD _1909_
+ sky130_fd_sc_hd__mux4_1
X_5130_ registers\[18\]\[15\] registers\[22\]\[15\] _1829_
+ VSS VSS VDD VDD _1910_ sky130_fd_sc_hd__mux2i_1
X_5131_ registers\[16\]\[15\] registers\[20\]\[15\] _1776_
+ VSS VSS VDD VDD _1911_ sky130_fd_sc_hd__mux2i_1
Xread_data1\[0\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0034_ _0032_
+ VSS VSS VDD VDD net44 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[10\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0035_
+ _0032_ VSS VSS VDD VDD net45 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[11\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0036_
+ _0032_ VSS VSS VDD VDD net46 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[12\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0037_
+ _0032_ VSS VSS VDD VDD net47 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[13\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0038_
+ _0032_ VSS VSS VDD VDD net48 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[14\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0039_
+ _0032_ VSS VSS VDD VDD net49 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[15\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0040_
+ _0032_ VSS VSS VDD VDD net50 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[16\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0041_
+ _0032_ VSS VSS VDD VDD net51 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[17\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0042_
+ _0032_ VSS VSS VDD VDD net52 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[18\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0043_
+ _0032_ VSS VSS VDD VDD net53 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[19\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0044_
+ _0032_ VSS VSS VDD VDD net54 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[1\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0045_ _0032_
+ VSS VSS VDD VDD net55 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[20\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0046_
+ _0032_ VSS VSS VDD VDD net56 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[21\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0047_
+ _0032_ VSS VSS VDD VDD net57 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[22\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0048_
+ _0032_ VSS VSS VDD VDD net58 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[23\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0049_
+ _0032_ VSS VSS VDD VDD net59 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0050_
+ _0032_ VSS VSS VDD VDD net60 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[25\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0051_
+ _0032_ VSS VSS VDD VDD net61 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[26\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0052_
+ _0032_ VSS VSS VDD VDD net62 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[27\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0053_
+ _0032_ VSS VSS VDD VDD net63 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[28\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0054_
+ _0032_ VSS VSS VDD VDD net64 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[29\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0055_
+ _0032_ VSS VSS VDD VDD net65 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[2\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0056_ _0032_
+ VSS VSS VDD VDD net66 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[30\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0057_
+ _0032_ VSS VSS VDD VDD net67 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[31\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0058_
+ _0032_ VSS VSS VDD VDD net68 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[3\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0059_ _0032_
+ VSS VSS VDD VDD net69 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[4\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0060_ _0032_
+ VSS VSS VDD VDD net70 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[5\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0061_ _0032_
+ VSS VSS VDD VDD net71 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[6\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0062_ _0032_
+ VSS VSS VDD VDD net72 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[7\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0063_ _0032_
+ VSS VSS VDD VDD net73 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[8\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0064_ _0032_
+ VSS VSS VDD VDD net74 sky130_fd_sc_hd__edfxtp_1
Xread_data1\[9\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0065_ _0032_
+ VSS VSS VDD VDD net75 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[0\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0066_ _0033_
+ VSS VSS VDD VDD net76 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[10\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0067_
+ _0033_ VSS VSS VDD VDD net77 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[11\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0068_
+ _0033_ VSS VSS VDD VDD net78 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[12\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0069_
+ _0033_ VSS VSS VDD VDD net79 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[13\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0070_
+ _0033_ VSS VSS VDD VDD net80 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[14\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0071_
+ _0033_ VSS VSS VDD VDD net81 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[15\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0072_
+ _0033_ VSS VSS VDD VDD net82 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[16\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0073_
+ _0033_ VSS VSS VDD VDD net83 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[17\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0074_
+ _0033_ VSS VSS VDD VDD net84 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[18\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0075_
+ _0033_ VSS VSS VDD VDD net85 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[19\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0076_
+ _0033_ VSS VSS VDD VDD net86 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[1\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0077_ _0033_
+ VSS VSS VDD VDD net87 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[20\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0078_
+ _0033_ VSS VSS VDD VDD net88 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[21\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0079_
+ _0033_ VSS VSS VDD VDD net89 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[22\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0080_
+ _0033_ VSS VSS VDD VDD net90 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[23\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0081_
+ _0033_ VSS VSS VDD VDD net91 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0082_
+ _0033_ VSS VSS VDD VDD net92 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0083_
+ _0033_ VSS VSS VDD VDD net93 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[26\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0084_
+ _0033_ VSS VSS VDD VDD net94 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[27\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0085_
+ _0033_ VSS VSS VDD VDD net95 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[28\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0086_
+ _0033_ VSS VSS VDD VDD net96 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[29\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0087_
+ _0033_ VSS VSS VDD VDD net97 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[2\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0088_ _0033_
+ VSS VSS VDD VDD net98 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[30\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0089_
+ _0033_ VSS VSS VDD VDD net99 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[31\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0090_
+ _0033_ VSS VSS VDD VDD net100 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[3\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0091_ _0033_
+ VSS VSS VDD VDD net101 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[4\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0092_ _0033_
+ VSS VSS VDD VDD net102 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[5\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0093_ _0033_
+ VSS VSS VDD VDD net103 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[6\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0094_ _0033_
+ VSS VSS VDD VDD net104 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[7\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0095_ _0033_
+ VSS VSS VDD VDD net105 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[8\]$_SDFFCE_PN0P_ clknet_leaf_44_clk _0096_ _0033_
+ VSS VSS VDD VDD net106 sky130_fd_sc_hd__edfxtp_1
Xread_data2\[9\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0097_ _0033_
+ VSS VSS VDD VDD net107 sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0098_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0099_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0100_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0101_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0102_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0103_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0104_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0105_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0106_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0107_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0108_
+ net113 VSS VSS VDD VDD registers\[0\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0109_
+ net113 VSS VSS VDD VDD registers\[0\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0110_
+ net113 VSS VSS VDD VDD registers\[0\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0111_
+ net113 VSS VSS VDD VDD registers\[0\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0112_
+ net113 VSS VSS VDD VDD registers\[0\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0113_
+ net113 VSS VSS VDD VDD registers\[0\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0114_
+ net113 VSS VSS VDD VDD registers\[0\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0115_
+ net113 VSS VSS VDD VDD registers\[0\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0116_
+ net113 VSS VSS VDD VDD registers\[0\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0117_
+ net113 VSS VSS VDD VDD registers\[0\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0118_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0119_
+ net113 VSS VSS VDD VDD registers\[0\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0120_
+ net113 VSS VSS VDD VDD registers\[0\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0121_
+ net113 VSS VSS VDD VDD registers\[0\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0122_
+ net113 VSS VSS VDD VDD registers\[0\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0123_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0124_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0125_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0126_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0127_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0128_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[0\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0129_
+ _0031_ VSS VSS VDD VDD registers\[0\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0130_
+ net134 VSS VSS VDD VDD registers\[10\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0131_
+ net134 VSS VSS VDD VDD registers\[10\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0132_
+ net134 VSS VSS VDD VDD registers\[10\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0133_
+ net134 VSS VSS VDD VDD registers\[10\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0134_
+ net134 VSS VSS VDD VDD registers\[10\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0135_
+ net134 VSS VSS VDD VDD registers\[10\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0136_
+ net134 VSS VSS VDD VDD registers\[10\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0137_
+ net134 VSS VSS VDD VDD registers\[10\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0138_
+ net134 VSS VSS VDD VDD registers\[10\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0139_
+ net134 VSS VSS VDD VDD registers\[10\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0140_
+ net134 VSS VSS VDD VDD registers\[10\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0141_
+ net134 VSS VSS VDD VDD registers\[10\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0142_
+ net134 VSS VSS VDD VDD registers\[10\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0143_
+ net134 VSS VSS VDD VDD registers\[10\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0144_
+ net134 VSS VSS VDD VDD registers\[10\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0145_
+ net134 VSS VSS VDD VDD registers\[10\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0146_
+ net134 VSS VSS VDD VDD registers\[10\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0147_
+ net134 VSS VSS VDD VDD registers\[10\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0148_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0149_
+ net134 VSS VSS VDD VDD registers\[10\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0150_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _0151_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0152_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0153_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0154_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0155_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0156_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0157_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0158_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0159_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0160_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[10\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0161_
+ _0030_ VSS VSS VDD VDD registers\[10\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0162_
+ net121 VSS VSS VDD VDD registers\[11\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0163_
+ net121 VSS VSS VDD VDD registers\[11\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0164_
+ net121 VSS VSS VDD VDD registers\[11\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0165_
+ net121 VSS VSS VDD VDD registers\[11\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _0166_
+ net121 VSS VSS VDD VDD registers\[11\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0167_
+ net121 VSS VSS VDD VDD registers\[11\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0168_
+ net121 VSS VSS VDD VDD registers\[11\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0169_
+ net121 VSS VSS VDD VDD registers\[11\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0170_
+ net121 VSS VSS VDD VDD registers\[11\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0171_
+ net121 VSS VSS VDD VDD registers\[11\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0172_
+ net121 VSS VSS VDD VDD registers\[11\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0173_
+ net121 VSS VSS VDD VDD registers\[11\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0174_
+ net121 VSS VSS VDD VDD registers\[11\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0175_
+ net121 VSS VSS VDD VDD registers\[11\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0176_
+ net121 VSS VSS VDD VDD registers\[11\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0177_
+ net121 VSS VSS VDD VDD registers\[11\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0178_
+ net121 VSS VSS VDD VDD registers\[11\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0179_
+ net121 VSS VSS VDD VDD registers\[11\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _0180_
+ net121 VSS VSS VDD VDD registers\[11\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0181_
+ net121 VSS VSS VDD VDD registers\[11\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0182_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _0183_
+ net121 VSS VSS VDD VDD registers\[11\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0184_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0185_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0186_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0187_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0188_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0189_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0190_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0191_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0192_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[11\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0193_
+ _0029_ VSS VSS VDD VDD registers\[11\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0194_
+ net112 VSS VSS VDD VDD registers\[12\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0195_
+ net112 VSS VSS VDD VDD registers\[12\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0196_
+ net112 VSS VSS VDD VDD registers\[12\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0197_
+ net112 VSS VSS VDD VDD registers\[12\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0198_
+ net112 VSS VSS VDD VDD registers\[12\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0199_
+ net112 VSS VSS VDD VDD registers\[12\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0200_
+ net112 VSS VSS VDD VDD registers\[12\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0201_
+ net112 VSS VSS VDD VDD registers\[12\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0202_
+ net112 VSS VSS VDD VDD registers\[12\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0203_
+ net112 VSS VSS VDD VDD registers\[12\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0204_
+ net112 VSS VSS VDD VDD registers\[12\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0205_
+ net112 VSS VSS VDD VDD registers\[12\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0206_
+ net112 VSS VSS VDD VDD registers\[12\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0207_
+ net112 VSS VSS VDD VDD registers\[12\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0208_
+ net112 VSS VSS VDD VDD registers\[12\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0209_
+ net112 VSS VSS VDD VDD registers\[12\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0210_
+ net112 VSS VSS VDD VDD registers\[12\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0211_
+ net112 VSS VSS VDD VDD registers\[12\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0212_
+ net112 VSS VSS VDD VDD registers\[12\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0213_
+ net112 VSS VSS VDD VDD registers\[12\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0214_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0215_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0216_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0217_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0218_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0219_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0220_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0221_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0222_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0223_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0224_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[12\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0225_
+ _0028_ VSS VSS VDD VDD registers\[12\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0226_
+ net133 VSS VSS VDD VDD registers\[13\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0227_
+ net133 VSS VSS VDD VDD registers\[13\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0228_
+ net133 VSS VSS VDD VDD registers\[13\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0229_
+ net133 VSS VSS VDD VDD registers\[13\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _0230_
+ net133 VSS VSS VDD VDD registers\[13\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0231_
+ net133 VSS VSS VDD VDD registers\[13\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0232_
+ net133 VSS VSS VDD VDD registers\[13\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0233_
+ net133 VSS VSS VDD VDD registers\[13\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0234_
+ net133 VSS VSS VDD VDD registers\[13\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0235_
+ net133 VSS VSS VDD VDD registers\[13\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0236_
+ net133 VSS VSS VDD VDD registers\[13\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0237_
+ net133 VSS VSS VDD VDD registers\[13\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0238_
+ net133 VSS VSS VDD VDD registers\[13\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0239_
+ net133 VSS VSS VDD VDD registers\[13\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0240_
+ net133 VSS VSS VDD VDD registers\[13\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0241_
+ net133 VSS VSS VDD VDD registers\[13\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0242_
+ net133 VSS VSS VDD VDD registers\[13\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0243_
+ net133 VSS VSS VDD VDD registers\[13\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0244_
+ net133 VSS VSS VDD VDD registers\[13\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0245_
+ net133 VSS VSS VDD VDD registers\[13\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0246_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0247_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0248_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0249_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _0250_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0251_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0252_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0253_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _0254_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0255_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0256_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[13\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0257_
+ _0027_ VSS VSS VDD VDD registers\[13\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0258_
+ net132 VSS VSS VDD VDD registers\[14\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0259_
+ net132 VSS VSS VDD VDD registers\[14\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0260_
+ net132 VSS VSS VDD VDD registers\[14\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0261_
+ net132 VSS VSS VDD VDD registers\[14\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0262_
+ net132 VSS VSS VDD VDD registers\[14\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0263_
+ net132 VSS VSS VDD VDD registers\[14\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0264_
+ net132 VSS VSS VDD VDD registers\[14\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0265_
+ net132 VSS VSS VDD VDD registers\[14\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0266_
+ net132 VSS VSS VDD VDD registers\[14\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0267_
+ net132 VSS VSS VDD VDD registers\[14\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0268_
+ net132 VSS VSS VDD VDD registers\[14\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0269_
+ net132 VSS VSS VDD VDD registers\[14\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0270_
+ net132 VSS VSS VDD VDD registers\[14\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0271_
+ net132 VSS VSS VDD VDD registers\[14\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0272_
+ net132 VSS VSS VDD VDD registers\[14\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0273_
+ net132 VSS VSS VDD VDD registers\[14\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0274_
+ net132 VSS VSS VDD VDD registers\[14\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _0275_
+ net132 VSS VSS VDD VDD registers\[14\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0276_
+ net132 VSS VSS VDD VDD registers\[14\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0277_
+ net132 VSS VSS VDD VDD registers\[14\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0278_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0279_
+ net132 VSS VSS VDD VDD registers\[14\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0280_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0281_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0282_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0283_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0284_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0285_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0286_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0287_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0288_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[14\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0289_
+ _0026_ VSS VSS VDD VDD registers\[14\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0290_
+ net120 VSS VSS VDD VDD registers\[15\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0291_
+ net120 VSS VSS VDD VDD registers\[15\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0292_
+ net120 VSS VSS VDD VDD registers\[15\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0293_
+ net120 VSS VSS VDD VDD registers\[15\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0294_
+ net120 VSS VSS VDD VDD registers\[15\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0295_
+ net120 VSS VSS VDD VDD registers\[15\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_104_clk _0296_
+ net120 VSS VSS VDD VDD registers\[15\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0297_
+ net120 VSS VSS VDD VDD registers\[15\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _0298_
+ net120 VSS VSS VDD VDD registers\[15\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _0299_
+ net120 VSS VSS VDD VDD registers\[15\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0300_
+ net120 VSS VSS VDD VDD registers\[15\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0301_
+ net120 VSS VSS VDD VDD registers\[15\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_2_clk _0302_
+ net120 VSS VSS VDD VDD registers\[15\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _0303_
+ net120 VSS VSS VDD VDD registers\[15\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _0304_
+ net120 VSS VSS VDD VDD registers\[15\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0305_
+ net120 VSS VSS VDD VDD registers\[15\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0306_
+ net120 VSS VSS VDD VDD registers\[15\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _0307_
+ net120 VSS VSS VDD VDD registers\[15\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0308_
+ net120 VSS VSS VDD VDD registers\[15\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0309_
+ net120 VSS VSS VDD VDD registers\[15\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _0310_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_17_clk _0311_
+ net120 VSS VSS VDD VDD registers\[15\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0312_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_21_clk _0313_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _0314_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _0315_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0316_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0317_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _0318_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0319_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0320_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[15\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0321_
+ _0025_ VSS VSS VDD VDD registers\[15\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0322_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0323_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0324_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0325_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0326_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0327_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0328_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0329_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0330_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0331_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0332_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0333_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0334_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0335_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0336_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0337_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0338_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0339_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0340_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0341_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0342_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0343_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0344_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0345_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0346_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0347_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0348_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0349_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0350_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0351_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0352_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[16\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0353_
+ _0024_ VSS VSS VDD VDD registers\[16\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0354_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0355_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0356_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0357_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0358_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0359_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0360_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0361_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0362_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0363_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0364_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0365_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0366_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0367_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0368_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0369_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0370_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0371_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0372_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0373_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0374_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0375_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0376_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0377_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0378_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0379_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0380_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0381_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0382_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0383_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0384_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[17\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0385_
+ _0023_ VSS VSS VDD VDD registers\[17\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0386_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0387_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0388_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0389_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0390_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0391_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0392_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0393_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0394_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0395_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0396_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0397_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0398_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0399_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0400_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0401_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0402_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0403_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0404_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0405_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0406_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0407_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0408_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0409_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0410_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0411_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0412_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0413_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0414_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0415_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0416_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[18\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0417_
+ _0022_ VSS VSS VDD VDD registers\[18\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0418_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0419_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0420_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0421_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0422_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0423_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0424_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0425_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0426_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0427_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0428_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0429_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0430_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0431_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0432_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0433_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0434_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0435_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0436_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0437_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0438_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0439_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0440_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0441_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0442_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0443_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0444_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0445_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0446_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0447_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0448_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[19\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0449_
+ _0021_ VSS VSS VDD VDD registers\[19\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0450_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0451_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0452_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0453_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0454_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0455_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0456_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0457_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0458_
+ net131 VSS VSS VDD VDD registers\[1\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0459_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0460_
+ net131 VSS VSS VDD VDD registers\[1\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0461_
+ net131 VSS VSS VDD VDD registers\[1\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0462_
+ net131 VSS VSS VDD VDD registers\[1\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0463_
+ net131 VSS VSS VDD VDD registers\[1\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0464_
+ net131 VSS VSS VDD VDD registers\[1\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _0465_
+ net131 VSS VSS VDD VDD registers\[1\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _0466_
+ net131 VSS VSS VDD VDD registers\[1\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0467_
+ net131 VSS VSS VDD VDD registers\[1\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0468_
+ net131 VSS VSS VDD VDD registers\[1\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0469_
+ net131 VSS VSS VDD VDD registers\[1\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0470_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0471_
+ net131 VSS VSS VDD VDD registers\[1\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0472_
+ net131 VSS VSS VDD VDD registers\[1\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0473_
+ net131 VSS VSS VDD VDD registers\[1\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0474_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0475_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0476_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0477_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0478_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0479_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0480_
+ _0020_ VSS VSS VDD VDD registers\[1\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[1\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0481_
+ net131 VSS VSS VDD VDD registers\[1\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0482_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0483_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0484_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0485_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0486_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0487_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0488_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0489_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0490_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0491_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0492_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0493_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0494_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0495_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0496_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0497_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0498_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0499_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0500_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0501_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0502_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0503_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0504_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0505_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0506_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0507_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0508_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0509_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0510_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0511_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0512_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[20\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0513_
+ _0019_ VSS VSS VDD VDD registers\[20\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0514_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0515_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0516_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0517_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0518_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0519_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0520_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0521_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0522_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_82_clk _0523_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0524_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0525_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0526_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0527_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0528_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0529_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0530_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0531_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0532_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0533_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0534_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0535_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0536_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0537_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0538_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0539_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0540_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0541_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0542_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0543_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0544_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[21\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0545_
+ _0018_ VSS VSS VDD VDD registers\[21\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0546_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0547_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0548_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_85_clk _0549_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0550_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0551_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0552_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0553_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_84_clk _0554_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_83_clk _0555_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_88_clk _0556_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0557_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0558_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_89_clk _0559_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0560_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0561_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0562_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_35_clk _0563_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0564_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0565_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_41_clk _0566_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0567_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0568_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0569_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0570_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0571_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0572_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_40_clk _0573_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_42_clk _0574_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_37_clk _0575_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_36_clk _0576_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[22\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_63_clk _0577_
+ _0017_ VSS VSS VDD VDD registers\[22\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0578_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_87_clk _0579_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_86_clk _0580_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0581_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0582_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0583_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0584_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0585_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0586_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_81_clk _0587_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0588_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0589_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0590_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_65_clk _0591_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0592_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0593_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_62_clk _0594_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0595_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0596_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0597_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0598_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0599_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0600_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0601_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_45_clk _0602_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0603_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0604_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_39_clk _0605_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_43_clk _0606_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_38_clk _0607_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_61_clk _0608_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[23\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_64_clk _0609_
+ _0016_ VSS VSS VDD VDD registers\[23\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0610_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0611_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0612_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0613_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0614_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0615_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0616_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0617_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0618_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0619_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0620_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0621_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0622_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0623_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0624_
+ _0015_ VSS VSS VDD VDD registers\[24\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0625_
+ net111 VSS VSS VDD VDD registers\[24\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0626_
+ net111 VSS VSS VDD VDD registers\[24\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0627_
+ net111 VSS VSS VDD VDD registers\[24\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0628_
+ net111 VSS VSS VDD VDD registers\[24\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0629_
+ net111 VSS VSS VDD VDD registers\[24\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0630_
+ net111 VSS VSS VDD VDD registers\[24\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0631_
+ net111 VSS VSS VDD VDD registers\[24\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0632_
+ net111 VSS VSS VDD VDD registers\[24\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0633_
+ net111 VSS VSS VDD VDD registers\[24\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0634_
+ net111 VSS VSS VDD VDD registers\[24\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0635_
+ net111 VSS VSS VDD VDD registers\[24\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0636_
+ net111 VSS VSS VDD VDD registers\[24\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0637_
+ net111 VSS VSS VDD VDD registers\[24\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0638_
+ net111 VSS VSS VDD VDD registers\[24\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0639_
+ net111 VSS VSS VDD VDD registers\[24\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0640_
+ net111 VSS VSS VDD VDD registers\[24\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[24\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0641_
+ net111 VSS VSS VDD VDD registers\[24\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0642_
+ net130 VSS VSS VDD VDD registers\[25\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0643_
+ net130 VSS VSS VDD VDD registers\[25\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0644_
+ net130 VSS VSS VDD VDD registers\[25\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0645_
+ net130 VSS VSS VDD VDD registers\[25\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0646_
+ net130 VSS VSS VDD VDD registers\[25\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0647_
+ net130 VSS VSS VDD VDD registers\[25\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0648_
+ net130 VSS VSS VDD VDD registers\[25\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0649_
+ net130 VSS VSS VDD VDD registers\[25\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0650_
+ net130 VSS VSS VDD VDD registers\[25\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0651_
+ net130 VSS VSS VDD VDD registers\[25\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0652_
+ net130 VSS VSS VDD VDD registers\[25\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0653_
+ net130 VSS VSS VDD VDD registers\[25\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0654_
+ net130 VSS VSS VDD VDD registers\[25\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0655_
+ net130 VSS VSS VDD VDD registers\[25\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0656_
+ net130 VSS VSS VDD VDD registers\[25\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0657_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0658_
+ net130 VSS VSS VDD VDD registers\[25\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0659_
+ net130 VSS VSS VDD VDD registers\[25\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0660_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0661_
+ net130 VSS VSS VDD VDD registers\[25\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0662_
+ net130 VSS VSS VDD VDD registers\[25\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0663_
+ net130 VSS VSS VDD VDD registers\[25\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0664_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0665_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0666_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0667_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0668_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0669_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_48_clk _0670_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0671_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0672_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[25\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0673_
+ _0014_ VSS VSS VDD VDD registers\[25\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0674_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0675_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0676_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0677_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0678_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0679_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0680_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0681_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0682_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0683_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0684_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0685_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0686_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0687_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0688_
+ _0013_ VSS VSS VDD VDD registers\[26\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0689_
+ net129 VSS VSS VDD VDD registers\[26\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0690_
+ net129 VSS VSS VDD VDD registers\[26\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0691_
+ net129 VSS VSS VDD VDD registers\[26\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0692_
+ net129 VSS VSS VDD VDD registers\[26\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0693_
+ net129 VSS VSS VDD VDD registers\[26\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0694_
+ net129 VSS VSS VDD VDD registers\[26\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0695_
+ net129 VSS VSS VDD VDD registers\[26\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0696_
+ net129 VSS VSS VDD VDD registers\[26\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0697_
+ net129 VSS VSS VDD VDD registers\[26\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0698_
+ net129 VSS VSS VDD VDD registers\[26\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0699_
+ net129 VSS VSS VDD VDD registers\[26\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0700_
+ net129 VSS VSS VDD VDD registers\[26\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0701_
+ net129 VSS VSS VDD VDD registers\[26\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0702_
+ net129 VSS VSS VDD VDD registers\[26\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0703_
+ net129 VSS VSS VDD VDD registers\[26\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0704_
+ net129 VSS VSS VDD VDD registers\[26\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[26\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0705_
+ net129 VSS VSS VDD VDD registers\[26\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0706_
+ net118 VSS VSS VDD VDD registers\[27\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0707_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0708_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0709_
+ net118 VSS VSS VDD VDD registers\[27\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0710_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0711_
+ net118 VSS VSS VDD VDD registers\[27\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0712_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0713_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0714_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0715_
+ _0012_ VSS VSS VDD VDD registers\[27\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0716_
+ net118 VSS VSS VDD VDD registers\[27\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0717_
+ net118 VSS VSS VDD VDD registers\[27\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0718_
+ net118 VSS VSS VDD VDD registers\[27\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0719_
+ net118 VSS VSS VDD VDD registers\[27\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0720_
+ net118 VSS VSS VDD VDD registers\[27\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0721_
+ net119 VSS VSS VDD VDD registers\[27\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0722_
+ net118 VSS VSS VDD VDD registers\[27\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0723_
+ net118 VSS VSS VDD VDD registers\[27\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0724_
+ net119 VSS VSS VDD VDD registers\[27\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0725_
+ net118 VSS VSS VDD VDD registers\[27\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0726_
+ net118 VSS VSS VDD VDD registers\[27\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0727_
+ net118 VSS VSS VDD VDD registers\[27\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0728_
+ net119 VSS VSS VDD VDD registers\[27\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0729_
+ net119 VSS VSS VDD VDD registers\[27\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0730_
+ net119 VSS VSS VDD VDD registers\[27\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0731_
+ net119 VSS VSS VDD VDD registers\[27\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0732_
+ net119 VSS VSS VDD VDD registers\[27\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0733_
+ net119 VSS VSS VDD VDD registers\[27\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0734_
+ net119 VSS VSS VDD VDD registers\[27\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0735_
+ net119 VSS VSS VDD VDD registers\[27\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0736_
+ net119 VSS VSS VDD VDD registers\[27\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[27\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0737_
+ net119 VSS VSS VDD VDD registers\[27\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0738_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0739_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0740_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0741_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0742_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0743_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0744_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0745_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0746_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0747_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0748_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0749_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0750_
+ net169 VSS VSS VDD VDD registers\[28\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0751_
+ _0011_ VSS VSS VDD VDD registers\[28\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0752_
+ net169 VSS VSS VDD VDD registers\[28\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0753_
+ net169 VSS VSS VDD VDD registers\[28\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0754_
+ net169 VSS VSS VDD VDD registers\[28\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0755_
+ net169 VSS VSS VDD VDD registers\[28\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0756_
+ net169 VSS VSS VDD VDD registers\[28\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0757_
+ net169 VSS VSS VDD VDD registers\[28\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0758_
+ net169 VSS VSS VDD VDD registers\[28\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0759_
+ net169 VSS VSS VDD VDD registers\[28\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0760_
+ net169 VSS VSS VDD VDD registers\[28\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0761_
+ net169 VSS VSS VDD VDD registers\[28\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0762_
+ net169 VSS VSS VDD VDD registers\[28\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0763_
+ net169 VSS VSS VDD VDD registers\[28\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0764_
+ net169 VSS VSS VDD VDD registers\[28\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0765_
+ net169 VSS VSS VDD VDD registers\[28\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0766_
+ net169 VSS VSS VDD VDD registers\[28\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0767_
+ net169 VSS VSS VDD VDD registers\[28\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0768_
+ net169 VSS VSS VDD VDD registers\[28\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[28\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0769_
+ net169 VSS VSS VDD VDD registers\[28\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0770_
+ net128 VSS VSS VDD VDD registers\[29\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0771_
+ net128 VSS VSS VDD VDD registers\[29\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0772_
+ net128 VSS VSS VDD VDD registers\[29\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0773_
+ net128 VSS VSS VDD VDD registers\[29\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_78_clk _0774_
+ net128 VSS VSS VDD VDD registers\[29\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0775_
+ net128 VSS VSS VDD VDD registers\[29\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0776_
+ net128 VSS VSS VDD VDD registers\[29\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0777_
+ net128 VSS VSS VDD VDD registers\[29\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0778_
+ net128 VSS VSS VDD VDD registers\[29\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0779_
+ net128 VSS VSS VDD VDD registers\[29\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0780_
+ net128 VSS VSS VDD VDD registers\[29\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0781_
+ net128 VSS VSS VDD VDD registers\[29\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0782_
+ net128 VSS VSS VDD VDD registers\[29\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0783_
+ net128 VSS VSS VDD VDD registers\[29\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_69_clk _0784_
+ net128 VSS VSS VDD VDD registers\[29\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0785_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0786_
+ net128 VSS VSS VDD VDD registers\[29\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0787_
+ net128 VSS VSS VDD VDD registers\[29\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0788_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0789_
+ net128 VSS VSS VDD VDD registers\[29\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0790_
+ net128 VSS VSS VDD VDD registers\[29\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0791_
+ net128 VSS VSS VDD VDD registers\[29\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0792_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0793_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0794_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0795_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0796_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0797_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0798_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0799_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0800_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[29\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0801_
+ _0010_ VSS VSS VDD VDD registers\[29\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0802_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0803_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0804_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0805_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0806_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0807_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0808_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0809_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _0810_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0811_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0812_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0813_
+ _0009_ VSS VSS VDD VDD registers\[2\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0814_
+ net127 VSS VSS VDD VDD registers\[2\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _0815_
+ net127 VSS VSS VDD VDD registers\[2\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0816_
+ net127 VSS VSS VDD VDD registers\[2\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _0817_
+ net127 VSS VSS VDD VDD registers\[2\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0818_
+ net127 VSS VSS VDD VDD registers\[2\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0819_
+ net127 VSS VSS VDD VDD registers\[2\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0820_
+ net127 VSS VSS VDD VDD registers\[2\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0821_
+ net127 VSS VSS VDD VDD registers\[2\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0822_
+ net127 VSS VSS VDD VDD registers\[2\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0823_
+ net127 VSS VSS VDD VDD registers\[2\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0824_
+ net127 VSS VSS VDD VDD registers\[2\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _0825_
+ net127 VSS VSS VDD VDD registers\[2\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0826_
+ net127 VSS VSS VDD VDD registers\[2\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0827_
+ net127 VSS VSS VDD VDD registers\[2\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0828_
+ net127 VSS VSS VDD VDD registers\[2\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0829_
+ net127 VSS VSS VDD VDD registers\[2\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0830_
+ net127 VSS VSS VDD VDD registers\[2\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0831_
+ net127 VSS VSS VDD VDD registers\[2\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _0832_
+ net127 VSS VSS VDD VDD registers\[2\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[2\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0833_
+ net127 VSS VSS VDD VDD registers\[2\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0834_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0835_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_80_clk _0836_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0837_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0838_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_74_clk _0839_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0840_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0841_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0842_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0843_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0844_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_72_clk _0845_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0846_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0847_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0848_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0849_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0850_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0851_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0852_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0853_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_51_clk _0854_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0855_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0856_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0857_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0858_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0859_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0860_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0861_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_46_clk _0862_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0863_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0864_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[30\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0865_
+ _0008_ VSS VSS VDD VDD registers\[30\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_71_clk _0866_
+ net117 VSS VSS VDD VDD registers\[31\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0867_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_79_clk _0868_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0869_
+ net117 VSS VSS VDD VDD registers\[31\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0870_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_75_clk _0871_
+ net117 VSS VSS VDD VDD registers\[31\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_76_clk _0872_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0873_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_73_clk _0874_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_77_clk _0875_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0876_
+ net117 VSS VSS VDD VDD registers\[31\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_66_clk _0877_
+ _0007_ VSS VSS VDD VDD registers\[31\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_70_clk _0878_
+ net117 VSS VSS VDD VDD registers\[31\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0879_
+ net117 VSS VSS VDD VDD registers\[31\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_68_clk _0880_
+ net117 VSS VSS VDD VDD registers\[31\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_58_clk _0881_
+ net116 VSS VSS VDD VDD registers\[31\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_57_clk _0882_
+ net117 VSS VSS VDD VDD registers\[31\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_56_clk _0883_
+ net117 VSS VSS VDD VDD registers\[31\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_54_clk _0884_
+ net116 VSS VSS VDD VDD registers\[31\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0885_
+ net117 VSS VSS VDD VDD registers\[31\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_50_clk _0886_
+ net117 VSS VSS VDD VDD registers\[31\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_55_clk _0887_
+ net117 VSS VSS VDD VDD registers\[31\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0888_
+ net116 VSS VSS VDD VDD registers\[31\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0889_
+ net116 VSS VSS VDD VDD registers\[31\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_49_clk _0890_
+ net116 VSS VSS VDD VDD registers\[31\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_52_clk _0891_
+ net116 VSS VSS VDD VDD registers\[31\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0892_
+ net116 VSS VSS VDD VDD registers\[31\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_53_clk _0893_
+ net116 VSS VSS VDD VDD registers\[31\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_47_clk _0894_
+ net116 VSS VSS VDD VDD registers\[31\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_60_clk _0895_
+ net116 VSS VSS VDD VDD registers\[31\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_59_clk _0896_
+ net116 VSS VSS VDD VDD registers\[31\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[31\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_67_clk _0897_
+ net116 VSS VSS VDD VDD registers\[31\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0898_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0899_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0900_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_95_clk _0901_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0902_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0903_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0904_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0905_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0906_
+ net115 VSS VSS VDD VDD registers\[3\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0907_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0908_
+ net115 VSS VSS VDD VDD registers\[3\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_7_clk _0909_
+ net115 VSS VSS VDD VDD registers\[3\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0910_
+ net115 VSS VSS VDD VDD registers\[3\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0911_
+ net115 VSS VSS VDD VDD registers\[3\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0912_
+ net115 VSS VSS VDD VDD registers\[3\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _0913_
+ net115 VSS VSS VDD VDD registers\[3\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0914_
+ net115 VSS VSS VDD VDD registers\[3\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0915_
+ net115 VSS VSS VDD VDD registers\[3\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0916_
+ net115 VSS VSS VDD VDD registers\[3\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0917_
+ net115 VSS VSS VDD VDD registers\[3\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _0918_
+ net115 VSS VSS VDD VDD registers\[3\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0919_
+ net115 VSS VSS VDD VDD registers\[3\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0920_
+ net115 VSS VSS VDD VDD registers\[3\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _0921_
+ net115 VSS VSS VDD VDD registers\[3\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0922_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0923_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0924_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0925_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0926_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0927_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _0928_
+ _0006_ VSS VSS VDD VDD registers\[3\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[3\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0929_
+ net115 VSS VSS VDD VDD registers\[3\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_90_clk _0930_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0931_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0932_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0933_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0934_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0935_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0936_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0937_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _0938_
+ net109 VSS VSS VDD VDD registers\[4\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0939_
+ _0005_ VSS VSS VDD VDD registers\[4\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _0940_
+ net109 VSS VSS VDD VDD registers\[4\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _0941_
+ net109 VSS VSS VDD VDD registers\[4\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0942_
+ net109 VSS VSS VDD VDD registers\[4\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _0943_
+ net109 VSS VSS VDD VDD registers\[4\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0944_
+ net109 VSS VSS VDD VDD registers\[4\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _0945_
+ net109 VSS VSS VDD VDD registers\[4\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _0946_
+ net109 VSS VSS VDD VDD registers\[4\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0947_
+ net109 VSS VSS VDD VDD registers\[4\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0948_
+ net110 VSS VSS VDD VDD registers\[4\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0949_
+ net109 VSS VSS VDD VDD registers\[4\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0950_
+ net110 VSS VSS VDD VDD registers\[4\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0951_
+ net109 VSS VSS VDD VDD registers\[4\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0952_
+ net109 VSS VSS VDD VDD registers\[4\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _0953_
+ net109 VSS VSS VDD VDD registers\[4\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0954_
+ net110 VSS VSS VDD VDD registers\[4\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0955_
+ net110 VSS VSS VDD VDD registers\[4\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _0956_
+ net110 VSS VSS VDD VDD registers\[4\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _0957_
+ net110 VSS VSS VDD VDD registers\[4\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0958_
+ net110 VSS VSS VDD VDD registers\[4\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0959_
+ net110 VSS VSS VDD VDD registers\[4\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _0960_
+ net110 VSS VSS VDD VDD registers\[4\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[4\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0961_
+ net110 VSS VSS VDD VDD registers\[4\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0962_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0963_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0964_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0965_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0966_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0967_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _0968_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0969_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _0970_
+ net125 VSS VSS VDD VDD registers\[5\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _0971_
+ _0004_ VSS VSS VDD VDD registers\[5\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _0972_
+ net125 VSS VSS VDD VDD registers\[5\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _0973_
+ net125 VSS VSS VDD VDD registers\[5\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0974_
+ net125 VSS VSS VDD VDD registers\[5\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _0975_
+ net125 VSS VSS VDD VDD registers\[5\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _0976_
+ net125 VSS VSS VDD VDD registers\[5\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _0977_
+ net125 VSS VSS VDD VDD registers\[5\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _0978_
+ net125 VSS VSS VDD VDD registers\[5\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0979_
+ net125 VSS VSS VDD VDD registers\[5\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0980_
+ net126 VSS VSS VDD VDD registers\[5\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _0981_
+ net125 VSS VSS VDD VDD registers\[5\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _0982_
+ net126 VSS VSS VDD VDD registers\[5\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0983_
+ net125 VSS VSS VDD VDD registers\[5\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _0984_
+ net125 VSS VSS VDD VDD registers\[5\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _0985_
+ net125 VSS VSS VDD VDD registers\[5\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _0986_
+ net126 VSS VSS VDD VDD registers\[5\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0987_
+ net126 VSS VSS VDD VDD registers\[5\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _0988_
+ net126 VSS VSS VDD VDD registers\[5\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0989_
+ net126 VSS VSS VDD VDD registers\[5\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _0990_
+ net126 VSS VSS VDD VDD registers\[5\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _0991_
+ net126 VSS VSS VDD VDD registers\[5\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _0992_
+ net126 VSS VSS VDD VDD registers\[5\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[5\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _0993_
+ net126 VSS VSS VDD VDD registers\[5\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _0994_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _0995_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _0996_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0997_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _0998_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _0999_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _1000_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _1001_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _1002_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _1003_
+ _0003_ VSS VSS VDD VDD registers\[6\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _1004_
+ net123 VSS VSS VDD VDD registers\[6\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _1005_
+ net123 VSS VSS VDD VDD registers\[6\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _1006_
+ net123 VSS VSS VDD VDD registers\[6\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _1007_
+ net123 VSS VSS VDD VDD registers\[6\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _1008_
+ net123 VSS VSS VDD VDD registers\[6\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1009_
+ net123 VSS VSS VDD VDD registers\[6\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _1010_
+ net123 VSS VSS VDD VDD registers\[6\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1011_
+ net123 VSS VSS VDD VDD registers\[6\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _1012_
+ net123 VSS VSS VDD VDD registers\[6\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1013_
+ net123 VSS VSS VDD VDD registers\[6\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _1014_
+ net123 VSS VSS VDD VDD registers\[6\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1015_
+ net123 VSS VSS VDD VDD registers\[6\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _1016_
+ net123 VSS VSS VDD VDD registers\[6\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _1017_
+ net123 VSS VSS VDD VDD registers\[6\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _1018_
+ net124 VSS VSS VDD VDD registers\[6\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _1019_
+ net124 VSS VSS VDD VDD registers\[6\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _1020_
+ net124 VSS VSS VDD VDD registers\[6\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _1021_
+ net124 VSS VSS VDD VDD registers\[6\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _1022_
+ net124 VSS VSS VDD VDD registers\[6\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _1023_
+ net124 VSS VSS VDD VDD registers\[6\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _1024_
+ net124 VSS VSS VDD VDD registers\[6\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[6\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _1025_
+ net124 VSS VSS VDD VDD registers\[6\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_91_clk _1026_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _1027_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _1028_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _1029_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_96_clk _1030_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _1031_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_98_clk _1032_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _1033_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_93_clk _1034_
+ net114 VSS VSS VDD VDD registers\[7\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_97_clk _1035_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _1036_
+ net114 VSS VSS VDD VDD registers\[7\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _1037_
+ net114 VSS VSS VDD VDD registers\[7\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_8_clk _1038_
+ net114 VSS VSS VDD VDD registers\[7\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_6_clk _1039_
+ net114 VSS VSS VDD VDD registers\[7\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _1040_
+ net114 VSS VSS VDD VDD registers\[7\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1041_
+ net114 VSS VSS VDD VDD registers\[7\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_11_clk _1042_
+ net114 VSS VSS VDD VDD registers\[7\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_15_clk _1043_
+ net114 VSS VSS VDD VDD registers\[7\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_12_clk _1044_
+ net114 VSS VSS VDD VDD registers\[7\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1045_
+ net114 VSS VSS VDD VDD registers\[7\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _1046_
+ net114 VSS VSS VDD VDD registers\[7\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1047_
+ net114 VSS VSS VDD VDD registers\[7\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _1048_
+ net114 VSS VSS VDD VDD registers\[7\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _1049_
+ net114 VSS VSS VDD VDD registers\[7\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_25_clk _1050_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_31_clk _1051_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_26_clk _1052_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_30_clk _1053_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_29_clk _1054_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _1055_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _1056_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[7\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_9_clk _1057_
+ _0002_ VSS VSS VDD VDD registers\[7\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _1058_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _1059_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_99_clk _1060_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _1061_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _1062_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_100_clk _1063_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _1064_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _1065_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_105_clk _1066_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_101_clk _1067_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _1068_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _1069_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _1070_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_5_clk _1071_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _1072_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _1073_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1074_
+ _0001_ VSS VSS VDD VDD registers\[8\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _1075_
+ net108 VSS VSS VDD VDD registers\[8\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1076_
+ net108 VSS VSS VDD VDD registers\[8\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1077_
+ net108 VSS VSS VDD VDD registers\[8\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _1078_
+ net108 VSS VSS VDD VDD registers\[8\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1079_
+ net108 VSS VSS VDD VDD registers\[8\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _1080_
+ net108 VSS VSS VDD VDD registers\[8\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _1081_
+ net108 VSS VSS VDD VDD registers\[8\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _1082_
+ net108 VSS VSS VDD VDD registers\[8\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _1083_
+ net108 VSS VSS VDD VDD registers\[8\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _1084_
+ net108 VSS VSS VDD VDD registers\[8\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _1085_
+ net108 VSS VSS VDD VDD registers\[8\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _1086_
+ net108 VSS VSS VDD VDD registers\[8\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_33_clk _1087_
+ net108 VSS VSS VDD VDD registers\[8\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _1088_
+ net108 VSS VSS VDD VDD registers\[8\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[8\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _1089_
+ net108 VSS VSS VDD VDD registers\[8\]\[9\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[0\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _1090_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[0\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[10\]$_SDFFCE_PN0P_ clknet_leaf_92_clk _1091_
+ net122 VSS VSS VDD VDD registers\[9\]\[10\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[11\]$_SDFFCE_PN0P_ clknet_leaf_94_clk _1092_
+ net122 VSS VSS VDD VDD registers\[9\]\[11\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[12\]$_SDFFCE_PN0P_ clknet_leaf_0_clk _1093_
+ net122 VSS VSS VDD VDD registers\[9\]\[12\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[13\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _1094_
+ net122 VSS VSS VDD VDD registers\[9\]\[13\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[14\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _1095_
+ net122 VSS VSS VDD VDD registers\[9\]\[14\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[15\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _1096_
+ net122 VSS VSS VDD VDD registers\[9\]\[15\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[16\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _1097_
+ net122 VSS VSS VDD VDD registers\[9\]\[16\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[17\]$_SDFFCE_PN0P_ clknet_leaf_102_clk _1098_
+ net122 VSS VSS VDD VDD registers\[9\]\[17\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[18\]$_SDFFCE_PN0P_ clknet_leaf_103_clk _1099_
+ net122 VSS VSS VDD VDD registers\[9\]\[18\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[19\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _1100_
+ net122 VSS VSS VDD VDD registers\[9\]\[19\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[1\]$_SDFFCE_PN0P_ clknet_leaf_1_clk _1101_
+ net122 VSS VSS VDD VDD registers\[9\]\[1\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[20\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _1102_
+ net122 VSS VSS VDD VDD registers\[9\]\[20\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[21\]$_SDFFCE_PN0P_ clknet_leaf_3_clk _1103_
+ net122 VSS VSS VDD VDD registers\[9\]\[21\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[22\]$_SDFFCE_PN0P_ clknet_leaf_4_clk _1104_
+ net122 VSS VSS VDD VDD registers\[9\]\[22\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[23\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1105_
+ net122 VSS VSS VDD VDD registers\[9\]\[23\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[24\]$_SDFFCE_PN0P_ clknet_leaf_14_clk _1106_
+ net122 VSS VSS VDD VDD registers\[9\]\[24\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[25\]$_SDFFCE_PN0P_ clknet_leaf_16_clk _1107_
+ net122 VSS VSS VDD VDD registers\[9\]\[25\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[26\]$_SDFFCE_PN0P_ clknet_leaf_18_clk _1108_
+ net122 VSS VSS VDD VDD registers\[9\]\[26\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[27\]$_SDFFCE_PN0P_ clknet_leaf_13_clk _1109_
+ net122 VSS VSS VDD VDD registers\[9\]\[27\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[28\]$_SDFFCE_PN0P_ clknet_leaf_19_clk _1110_
+ net122 VSS VSS VDD VDD registers\[9\]\[28\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[29\]$_SDFFCE_PN0P_ clknet_leaf_20_clk _1111_
+ net122 VSS VSS VDD VDD registers\[9\]\[29\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[2\]$_SDFFCE_PN0P_ clknet_leaf_24_clk _1112_
+ net122 VSS VSS VDD VDD registers\[9\]\[2\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[30\]$_SDFFCE_PN0P_ clknet_leaf_22_clk _1113_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[30\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[31\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _1114_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[31\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[3\]$_SDFFCE_PN0P_ clknet_leaf_23_clk _1115_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[3\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[4\]$_SDFFCE_PN0P_ clknet_leaf_27_clk _1116_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[4\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[5\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _1117_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[5\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[6\]$_SDFFCE_PN0P_ clknet_leaf_28_clk _1118_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[6\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[7\]$_SDFFCE_PN0P_ clknet_leaf_32_clk _1119_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[7\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[8\]$_SDFFCE_PN0P_ clknet_leaf_34_clk _1120_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[8\] sky130_fd_sc_hd__edfxtp_1
Xregisters\[9\]\[9\]$_SDFFCE_PN0P_ clknet_leaf_10_clk _1121_
+ _0000_ VSS VSS VDD VDD registers\[9\]\[9\] sky130_fd_sc_hd__edfxtp_1
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_96 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_97 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_98 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_99 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_368 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_369 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_370 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_371 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_372 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_373 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_374 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_375 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_376 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_377 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_378 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_379 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_380 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_381 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_382 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_383 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_384 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_385 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_386 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_387 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_388 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_389 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_390 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_391 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_392 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_393 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_394 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_395 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_396 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_397 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_398 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_399 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_400 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_33_401 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_402 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_403 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_404 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_405 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_406 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_407 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_408 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_409 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_410 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_411 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_412 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_413 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_414 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_415 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_416 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_417 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_418 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_419 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_420 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_421 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_422 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_423 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_424 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_425 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_426 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_427 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_428 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_429 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_430 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_431 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_432 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_433 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_434 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_435 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_436 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_437 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_438 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_439 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_440 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_441 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_442 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_443 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_444 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_445 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_446 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_447 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_448 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_449 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_450 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_451 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_452 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_453 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_454 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_455 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_456 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_457 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_458 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_459 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_460 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_461 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_462 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_463 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_464 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_465 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_466 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_467 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_468 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_469 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_470 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_471 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_472 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_473 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_474 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_475 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_476 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_477 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_478 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_479 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_480 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_481 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_482 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_483 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_484 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_485 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_486 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_487 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_488 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_489 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_490 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_491 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_492 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_493 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_494 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_495 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_496 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_497 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_498 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_499 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_500 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_501 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_502 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_503 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_504 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_505 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_506 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_507 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_508 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_509 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_510 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_511 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_512 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_513 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_514 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_515 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_516 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_517 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_518 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_519 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_520 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_521 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_522 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_523 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_524 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_525 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_526 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_527 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_528 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_529 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_530 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_531 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_532 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_533 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_534 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_535 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_536 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_537 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_538 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_539 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_540 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_541 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_542 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_543 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_544 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_545 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_546 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_547 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_548 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_549 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_550 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_551 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_552 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_553 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_554 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_555 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_556 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_557 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_558 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_559 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_560 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_561 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_562 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_563 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_564 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_565 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_566 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_567 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_568 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_569 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_570 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_571 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_572 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_573 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_574 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_575 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_576 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_577 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_578 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_579 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_580 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_581 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_582 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_583 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_584 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_49_585 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_586 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_587 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_588 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_589 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_590 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_591 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_592 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_593 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_594 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_595 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_596 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_597 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_598 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_599 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_600 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_601 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_602 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_603 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_604 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_605 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_606 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_607 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_608 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_609 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_610 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_611 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_612 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_613 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_614 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_615 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_616 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_617 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_618 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_619 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_620 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_621 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_622 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_623 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_624 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_625 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_626 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_627 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_628 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_629 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_630 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_53_631 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_632 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_633 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_634 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_635 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_636 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_637 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_638 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_639 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_640 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_641 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_642 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_643 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_644 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_645 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_646 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_647 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_648 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_649 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_650 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_651 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_652 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_653 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_654 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_655 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_656 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_657 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_658 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_659 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_660 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_661 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_662 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_663 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_664 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_665 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_666 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_667 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_668 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_669 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_670 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_671 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_672 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_673 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_674 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_675 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_676 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_677 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_678 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_679 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_680 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_681 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_682 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_683 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_684 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_685 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_686 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_687 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_688 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_689 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_690 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_691 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_692 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_693 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_694 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_695 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_696 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_697 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_698 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_699 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_59_700 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_701 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_702 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_703 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_704 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_705 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_706 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_707 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_708 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_709 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_710 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_711 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_712 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_713 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_714 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_715 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_716 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_717 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_718 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_719 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_720 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_721 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_722 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_723 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_724 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_725 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_726 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_727 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_728 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_729 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_730 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_731 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_732 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_733 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_734 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_735 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_736 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_737 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_738 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_739 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_740 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_741 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_742 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_743 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_744 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_745 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_63_746 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_747 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_748 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_749 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_750 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_751 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_752 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_753 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_754 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_755 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_756 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_757 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_758 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_759 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_760 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_761 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_762 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_763 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_764 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_765 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_766 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_767 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_768 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_65_769 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_770 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_771 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_772 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_773 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_774 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_775 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_776 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_777 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_778 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_779 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_780 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_781 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_782 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_783 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_784 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_785 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_786 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_787 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_788 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_789 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_790 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_791 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_67_792 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_793 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_794 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_795 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_796 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_797 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_798 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_799 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_800 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_801 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_802 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_803 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_804 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_805 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_806 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_807 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_808 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_809 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_810 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_811 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_812 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_813 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_814 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_69_815 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_816 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_817 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_818 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_819 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_820 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_821 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_822 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_823 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_824 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_825 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_826 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_827 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_828 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_829 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_830 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_831 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_832 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_833 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_834 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_835 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_836 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_837 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_838 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_839 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_840 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_841 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_842 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_843 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_844 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_845 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_846 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_847 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_848 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_849 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_850 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_851 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_852 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_853 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_854 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_855 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_856 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_857 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_858 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_859 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_860 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_73_861 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_862 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_863 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_864 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_865 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_866 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_867 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_868 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_869 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_870 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_871 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_872 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_873 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_874 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_875 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_876 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_877 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_878 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_879 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_880 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_881 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_882 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_883 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_884 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_885 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_886 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_887 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_888 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_889 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_890 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_891 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_892 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_893 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_894 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_895 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_896 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_897 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_898 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_899 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_900 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_901 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_902 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_903 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_904 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_905 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_906 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_907 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_908 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_909 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_910 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_911 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_912 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_913 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_914 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_915 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_916 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_917 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_918 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_919 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_920 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_921 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_922 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_923 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_924 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_925 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_926 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_927 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_928 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_929 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_930 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_931 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_932 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_933 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_934 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_935 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_936 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_937 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_938 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_939 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_940 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_941 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_942 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_943 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_944 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_945 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_946 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_947 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_948 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_949 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_950 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_951 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_952 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_953 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_954 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_955 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_956 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_957 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_958 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_959 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_960 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_961 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_962 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_963 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_964 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_965 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_966 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_967 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_968 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_969 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_970 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_971 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_972 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_973 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_974 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_975 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_976 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_977 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_978 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_979 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_980 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_981 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_982 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_983 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_984 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_985 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_986 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_987 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_988 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_989 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_990 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_991 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_992 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_993 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_994 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_995 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_996 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_997 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_998 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_85_999 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1000 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1001 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1002 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1003 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1004 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1005 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1006 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1007 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1008 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1009 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1010 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1011 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1012 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1013 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1014 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1015 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1016 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1017 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1018 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1019 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1020 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1021 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1022 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1023 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1024 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1025 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1026 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1027 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1028 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1029 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1030 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1031 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1032 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1033 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1034 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1035 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1036 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1037 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1038 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1039 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1040 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1041 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1042 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1043 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1044 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_89_1045 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1046 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1047 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1048 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1049 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1050 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1051 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1052 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1053 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1054 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1055 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1056 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1057 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1058 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1059 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1060 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1061 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1062 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1063 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1064 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1065 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1066 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1067 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1068 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1069 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1070 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1071 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1072 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1073 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1074 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1075 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1076 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1077 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1078 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1079 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1080 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1081 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1082 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1083 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1084 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1085 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1086 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1087 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1088 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1089 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1090 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_93_1091 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1092 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1093 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1094 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1095 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1096 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1097 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1098 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1099 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1100 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1101 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1102 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1103 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1104 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1105 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1106 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1107 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1108 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1109 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1110 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1111 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1112 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1113 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1114 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1115 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1116 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1117 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1118 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1119 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1120 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1121 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1122 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1123 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1124 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1125 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1126 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1127 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1128 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1129 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1130 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1131 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1132 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1133 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1134 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1135 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1136 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_97_1137 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1138 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1139 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1140 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1141 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1142 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1143 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1144 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1145 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1146 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1147 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1148 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1149 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1150 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1151 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1152 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1153 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1154 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1155 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1156 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1157 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1158 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1159 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_99_1160 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1161 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1162 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1163 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1164 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1165 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1166 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1167 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1168 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1169 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1170 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1171 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1172 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1173 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1174 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1175 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1176 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1177 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1178 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1179 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1180 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1181 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1182 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_101_1183 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1184 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1185 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1186 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1187 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1188 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1189 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1190 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1191 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1192 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1193 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1194 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1195 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1196 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1197 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1198 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1199 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1200 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1201 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1202 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1203 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1204 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1205 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1206 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1207 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1208 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1209 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1210 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1211 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1212 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1213 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1214 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1215 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1216 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1217 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1218 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1219 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1220 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1221 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1222 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1223 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1224 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1225 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1226 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1227 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1228 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1229 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1230 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1231 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1232 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1233 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1234 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1235 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1236 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1237 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1238 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1239 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1240 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1241 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1242 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1243 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1244 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1245 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1246 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1247 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1248 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1249 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1250 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1251 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1252 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1253 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1254 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1255 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1256 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1257 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1258 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1259 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1260 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1261 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1262 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1263 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1264 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1265 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1266 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1267 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1268 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1269 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1270 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1271 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1272 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1273 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1274 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1275 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1276 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1277 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1278 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1279 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1280 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1281 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1282 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1283 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1284 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1285 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1286 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_110_1287 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1288 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1289 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1290 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1291 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1292 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1293 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1294 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1295 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1296 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1297 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1298 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1299 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1300 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1301 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1302 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1303 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1304 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1305 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1306 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1307 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1308 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1309 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1310 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1311 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1312 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1313 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1314 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1315 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1316 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1317 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1318 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1319 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1320 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_113_1321 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1322 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1323 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1324 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1325 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1326 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1327 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1328 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1329 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1330 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1331 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1332 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1333 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1334 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1335 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1336 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1337 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1338 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1339 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1340 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1341 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1342 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1343 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_115_1344 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1345 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1346 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1347 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1348 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1349 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1350 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1351 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1352 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1353 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1354 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1355 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1356 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1357 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1358 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1359 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1360 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1361 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1362 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1363 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1364 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1365 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1366 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1367 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 read_addr1[3] VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_2
Xinput2 read_addr2[3] VSS VSS VDD VDD net2 sky130_fd_sc_hd__buf_2
Xinput3 read_en1 VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_4
Xinput4 read_en2 VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_4
Xinput5 rst_n VSS VSS VDD VDD net5 sky130_fd_sc_hd__buf_2
Xinput6 write_addr[0] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_2
Xinput7 write_addr[1] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_2
Xinput8 write_addr[2] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_8
Xinput9 write_addr[3] VSS VSS VDD VDD net9 sky130_fd_sc_hd__buf_6
Xinput10 write_addr[4] VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_6
Xinput11 net153 VSS VSS VDD VDD net11 sky130_fd_sc_hd__buf_2
Xinput12 net152 VSS VSS VDD VDD net12 sky130_fd_sc_hd__clkbuf_2
Xinput13 net154 VSS VSS VDD VDD net13 sky130_fd_sc_hd__clkbuf_2
Xinput14 net165 VSS VSS VDD VDD net14 sky130_fd_sc_hd__clkbuf_4
Xinput15 net155 VSS VSS VDD VDD net15 sky130_fd_sc_hd__clkbuf_2
Xinput16 net147 VSS VSS VDD VDD net16 sky130_fd_sc_hd__clkbuf_2
Xinput17 net145 VSS VSS VDD VDD net17 sky130_fd_sc_hd__clkbuf_2
Xinput18 net158 VSS VSS VDD VDD net18 sky130_fd_sc_hd__clkbuf_2
Xinput19 net156 VSS VSS VDD VDD net19 sky130_fd_sc_hd__buf_2
Xinput20 net164 VSS VSS VDD VDD net20 sky130_fd_sc_hd__clkbuf_2
Xinput21 net151 VSS VSS VDD VDD net21 sky130_fd_sc_hd__buf_2
Xinput22 net140 VSS VSS VDD VDD net22 sky130_fd_sc_hd__clkbuf_2
Xinput23 net148 VSS VSS VDD VDD net23 sky130_fd_sc_hd__clkbuf_2
Xinput24 net137 VSS VSS VDD VDD net24 sky130_fd_sc_hd__clkbuf_2
Xinput25 net138 VSS VSS VDD VDD net25 sky130_fd_sc_hd__clkbuf_2
Xinput26 net135 VSS VSS VDD VDD net26 sky130_fd_sc_hd__clkbuf_2
Xinput27 net149 VSS VSS VDD VDD net27 sky130_fd_sc_hd__clkbuf_2
Xinput28 net139 VSS VSS VDD VDD net28 sky130_fd_sc_hd__clkbuf_2
Xinput29 net150 VSS VSS VDD VDD net29 sky130_fd_sc_hd__clkbuf_2
Xinput30 net142 VSS VSS VDD VDD net30 sky130_fd_sc_hd__clkbuf_2
Xinput31 net161 VSS VSS VDD VDD net31 sky130_fd_sc_hd__buf_2
Xinput32 net136 VSS VSS VDD VDD net32 sky130_fd_sc_hd__clkbuf_2
Xinput33 net160 VSS VSS VDD VDD net33 sky130_fd_sc_hd__clkbuf_2
Xinput34 net143 VSS VSS VDD VDD net34 sky130_fd_sc_hd__clkbuf_2
Xinput35 net141 VSS VSS VDD VDD net35 sky130_fd_sc_hd__clkbuf_2
Xinput36 net163 VSS VSS VDD VDD net36 sky130_fd_sc_hd__clkbuf_2
Xinput37 net146 VSS VSS VDD VDD net37 sky130_fd_sc_hd__clkbuf_2
Xinput38 net144 VSS VSS VDD VDD net38 sky130_fd_sc_hd__clkbuf_2
Xinput39 net166 VSS VSS VDD VDD net39 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput40 net162 VSS VSS VDD VDD net40 sky130_fd_sc_hd__buf_2
Xinput41 net157 VSS VSS VDD VDD net41 sky130_fd_sc_hd__buf_2
Xinput42 net159 VSS VSS VDD VDD net42 sky130_fd_sc_hd__buf_2
Xinput43 write_en VSS VSS VDD VDD net43 sky130_fd_sc_hd__buf_2
Xoutput44 net44 VSS VSS VDD VDD read_data1[0] sky130_fd_sc_hd__clkbuf_1
Xoutput45 net45 VSS VSS VDD VDD read_data1[10] sky130_fd_sc_hd__clkbuf_1
Xoutput46 net46 VSS VSS VDD VDD read_data1[11] sky130_fd_sc_hd__clkbuf_1
Xoutput47 net47 VSS VSS VDD VDD read_data1[12] sky130_fd_sc_hd__clkbuf_1
Xoutput48 net48 VSS VSS VDD VDD read_data1[13] sky130_fd_sc_hd__clkbuf_1
Xoutput49 net49 VSS VSS VDD VDD read_data1[14] sky130_fd_sc_hd__clkbuf_1
Xoutput50 net50 VSS VSS VDD VDD read_data1[15] sky130_fd_sc_hd__clkbuf_1
Xoutput51 net51 VSS VSS VDD VDD read_data1[16] sky130_fd_sc_hd__clkbuf_1
Xoutput52 net52 VSS VSS VDD VDD read_data1[17] sky130_fd_sc_hd__clkbuf_1
Xoutput53 net53 VSS VSS VDD VDD read_data1[18] sky130_fd_sc_hd__clkbuf_1
Xoutput54 net54 VSS VSS VDD VDD read_data1[19] sky130_fd_sc_hd__clkbuf_1
Xoutput55 net55 VSS VSS VDD VDD read_data1[1] sky130_fd_sc_hd__clkbuf_1
Xoutput56 net56 VSS VSS VDD VDD read_data1[20] sky130_fd_sc_hd__clkbuf_1
Xoutput57 net57 VSS VSS VDD VDD read_data1[21] sky130_fd_sc_hd__clkbuf_1
Xoutput58 net58 VSS VSS VDD VDD read_data1[22] sky130_fd_sc_hd__clkbuf_1
Xoutput59 net59 VSS VSS VDD VDD read_data1[23] sky130_fd_sc_hd__clkbuf_1
Xoutput60 net60 VSS VSS VDD VDD read_data1[24] sky130_fd_sc_hd__clkbuf_1
Xoutput61 net61 VSS VSS VDD VDD read_data1[25] sky130_fd_sc_hd__clkbuf_1
Xoutput62 net62 VSS VSS VDD VDD read_data1[26] sky130_fd_sc_hd__clkbuf_1
Xoutput63 net63 VSS VSS VDD VDD read_data1[27] sky130_fd_sc_hd__clkbuf_1
Xoutput64 net64 VSS VSS VDD VDD read_data1[28] sky130_fd_sc_hd__clkbuf_1
Xoutput65 net65 VSS VSS VDD VDD read_data1[29] sky130_fd_sc_hd__clkbuf_1
Xoutput66 net66 VSS VSS VDD VDD read_data1[2] sky130_fd_sc_hd__clkbuf_1
Xoutput67 net67 VSS VSS VDD VDD read_data1[30] sky130_fd_sc_hd__clkbuf_1
Xoutput68 net68 VSS VSS VDD VDD read_data1[31] sky130_fd_sc_hd__clkbuf_1
Xoutput69 net69 VSS VSS VDD VDD read_data1[3] sky130_fd_sc_hd__clkbuf_1
Xoutput70 net70 VSS VSS VDD VDD read_data1[4] sky130_fd_sc_hd__clkbuf_1
Xoutput71 net71 VSS VSS VDD VDD read_data1[5] sky130_fd_sc_hd__clkbuf_1
Xoutput72 net72 VSS VSS VDD VDD read_data1[6] sky130_fd_sc_hd__clkbuf_1
Xoutput73 net73 VSS VSS VDD VDD read_data1[7] sky130_fd_sc_hd__clkbuf_1
Xoutput74 net74 VSS VSS VDD VDD read_data1[8] sky130_fd_sc_hd__clkbuf_1
Xoutput75 net75 VSS VSS VDD VDD read_data1[9] sky130_fd_sc_hd__clkbuf_1
Xoutput76 net76 VSS VSS VDD VDD read_data2[0] sky130_fd_sc_hd__clkbuf_1
Xoutput77 net77 VSS VSS VDD VDD read_data2[10] sky130_fd_sc_hd__clkbuf_1
Xoutput78 net78 VSS VSS VDD VDD read_data2[11] sky130_fd_sc_hd__clkbuf_1
Xoutput79 net79 VSS VSS VDD VDD read_data2[12] sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VSS VSS VDD VDD read_data2[13] sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VSS VSS VDD VDD read_data2[14] sky130_fd_sc_hd__clkbuf_1
Xoutput82 net82 VSS VSS VDD VDD read_data2[15] sky130_fd_sc_hd__clkbuf_1
Xoutput83 net83 VSS VSS VDD VDD read_data2[16] sky130_fd_sc_hd__clkbuf_1
Xoutput84 net84 VSS VSS VDD VDD read_data2[17] sky130_fd_sc_hd__clkbuf_1
Xoutput85 net85 VSS VSS VDD VDD read_data2[18] sky130_fd_sc_hd__clkbuf_1
Xoutput86 net86 VSS VSS VDD VDD read_data2[19] sky130_fd_sc_hd__clkbuf_1
Xoutput87 net87 VSS VSS VDD VDD read_data2[1] sky130_fd_sc_hd__clkbuf_1
Xoutput88 net88 VSS VSS VDD VDD read_data2[20] sky130_fd_sc_hd__clkbuf_1
Xoutput89 net89 VSS VSS VDD VDD read_data2[21] sky130_fd_sc_hd__clkbuf_1
Xoutput90 net90 VSS VSS VDD VDD read_data2[22] sky130_fd_sc_hd__clkbuf_1
Xoutput91 net91 VSS VSS VDD VDD read_data2[23] sky130_fd_sc_hd__clkbuf_1
Xoutput92 net92 VSS VSS VDD VDD read_data2[24] sky130_fd_sc_hd__clkbuf_1
Xoutput93 net93 VSS VSS VDD VDD read_data2[25] sky130_fd_sc_hd__clkbuf_1
Xoutput94 net94 VSS VSS VDD VDD read_data2[26] sky130_fd_sc_hd__clkbuf_1
Xoutput95 net95 VSS VSS VDD VDD read_data2[27] sky130_fd_sc_hd__clkbuf_1
Xoutput96 net96 VSS VSS VDD VDD read_data2[28] sky130_fd_sc_hd__clkbuf_1
Xoutput97 net97 VSS VSS VDD VDD read_data2[29] sky130_fd_sc_hd__clkbuf_1
Xoutput98 net98 VSS VSS VDD VDD read_data2[2] sky130_fd_sc_hd__clkbuf_1
Xoutput99 net99 VSS VSS VDD VDD read_data2[30] sky130_fd_sc_hd__clkbuf_1
Xoutput100 net100 VSS VSS VDD VDD read_data2[31] sky130_fd_sc_hd__clkbuf_1
Xoutput101 net101 VSS VSS VDD VDD read_data2[3] sky130_fd_sc_hd__clkbuf_1
Xoutput102 net102 VSS VSS VDD VDD read_data2[4] sky130_fd_sc_hd__clkbuf_1
Xoutput103 net103 VSS VSS VDD VDD read_data2[5] sky130_fd_sc_hd__clkbuf_1
Xoutput104 net104 VSS VSS VDD VDD read_data2[6] sky130_fd_sc_hd__clkbuf_1
Xoutput105 net105 VSS VSS VDD VDD read_data2[7] sky130_fd_sc_hd__clkbuf_1
Xoutput106 net106 VSS VSS VDD VDD read_data2[8] sky130_fd_sc_hd__clkbuf_1
Xoutput107 net107 VSS VSS VDD VDD read_data2[9] sky130_fd_sc_hd__clkbuf_1
Xmax_cap108 _0001_ VSS VSS VDD VDD net108 sky130_fd_sc_hd__buf_16
Xload_slew109 net110 VSS VSS VDD VDD net109 sky130_fd_sc_hd__buf_16
Xload_slew110 _0005_ VSS VSS VDD VDD net110 sky130_fd_sc_hd__buf_16
Xload_slew111 _0015_ VSS VSS VDD VDD net111 sky130_fd_sc_hd__buf_16
Xmax_cap112 _0028_ VSS VSS VDD VDD net112 sky130_fd_sc_hd__buf_16
Xload_slew113 _0031_ VSS VSS VDD VDD net113 sky130_fd_sc_hd__buf_16
Xload_slew114 _0002_ VSS VSS VDD VDD net114 sky130_fd_sc_hd__buf_16
Xload_slew115 _0006_ VSS VSS VDD VDD net115 sky130_fd_sc_hd__buf_16
Xload_slew116 net117 VSS VSS VDD VDD net116 sky130_fd_sc_hd__buf_16
Xload_slew117 _0007_ VSS VSS VDD VDD net117 sky130_fd_sc_hd__buf_16
Xload_slew118 net119 VSS VSS VDD VDD net118 sky130_fd_sc_hd__buf_16
Xload_slew119 _0012_ VSS VSS VDD VDD net119 sky130_fd_sc_hd__buf_16
Xmax_cap120 _0025_ VSS VSS VDD VDD net120 sky130_fd_sc_hd__buf_12
Xmax_cap121 _0029_ VSS VSS VDD VDD net121 sky130_fd_sc_hd__buf_12
Xload_slew122 _0000_ VSS VSS VDD VDD net122 sky130_fd_sc_hd__buf_12
Xload_slew123 net124 VSS VSS VDD VDD net123 sky130_fd_sc_hd__buf_16
Xload_slew124 _0003_ VSS VSS VDD VDD net124 sky130_fd_sc_hd__buf_16
Xload_slew125 net126 VSS VSS VDD VDD net125 sky130_fd_sc_hd__buf_16
Xload_slew126 _0004_ VSS VSS VDD VDD net126 sky130_fd_sc_hd__buf_16
Xmax_cap127 _0009_ VSS VSS VDD VDD net127 sky130_fd_sc_hd__buf_12
Xmax_cap128 _0010_ VSS VSS VDD VDD net128 sky130_fd_sc_hd__buf_12
Xmax_cap129 _0013_ VSS VSS VDD VDD net129 sky130_fd_sc_hd__buf_16
Xmax_cap130 _0014_ VSS VSS VDD VDD net130 sky130_fd_sc_hd__buf_12
Xload_slew131 _0020_ VSS VSS VDD VDD net131 sky130_fd_sc_hd__buf_16
Xmax_cap132 _0026_ VSS VSS VDD VDD net132 sky130_fd_sc_hd__buf_12
Xmax_cap133 _0027_ VSS VSS VDD VDD net133 sky130_fd_sc_hd__buf_12
Xmax_cap134 _0030_ VSS VSS VDD VDD net134 sky130_fd_sc_hd__buf_16
Xclkbuf_leaf_0_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_0_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_1_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_1_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_2_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_2_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_3_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_3_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_4_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_4_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_5_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_6_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_6_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_7_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_7_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_8_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_8_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_9_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_9_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_10_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_10_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_11_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_11_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_12_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_12_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_13_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_13_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_14_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_14_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_15_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_15_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_16_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_16_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_17_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_17_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_18_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_18_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_19_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_19_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_20_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_20_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_21_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_21_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_22_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_22_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_23_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_23_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_24_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_24_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_25_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_25_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_26_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_26_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_27_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_27_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_28_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_28_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_29_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_29_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_30_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_30_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_31_clk clknet_3_5__leaf_clk VSS VSS VDD VDD clknet_leaf_31_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_32_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_32_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_33_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_33_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_34_clk clknet_3_4__leaf_clk VSS VSS VDD VDD clknet_leaf_34_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_35_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_35_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_36_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_36_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_37_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_37_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_38_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_38_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_39_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_39_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_40_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_40_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_41_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_41_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_42_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_42_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_43_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_43_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_44_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_44_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_45_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_45_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_46_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_46_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_47_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_47_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_48_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_48_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_49_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_49_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_50_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_50_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_51_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_51_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_52_clk clknet_3_7__leaf_clk VSS VSS VDD VDD clknet_leaf_52_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_53_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_53_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_54_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_54_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_55_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_55_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_56_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_56_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_57_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_57_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_58_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_58_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_59_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_59_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_60_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_60_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_61_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_61_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_62_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_62_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_63_clk clknet_3_6__leaf_clk VSS VSS VDD VDD clknet_leaf_63_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_64_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_64_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_65_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_65_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_66_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_66_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_67_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_67_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_68_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_68_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_69_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_69_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_70_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_70_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_71_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_71_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_72_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_72_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_73_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_73_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_74_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_74_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_75_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_75_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_76_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_76_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_77_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_77_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_78_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_78_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_79_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_79_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_80_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_80_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_81_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_81_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_82_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_82_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_83_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_83_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_84_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_84_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_85_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_85_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_86_clk clknet_3_2__leaf_clk VSS VSS VDD VDD clknet_leaf_86_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_87_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_87_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_88_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_88_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_89_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_89_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_90_clk clknet_3_3__leaf_clk VSS VSS VDD VDD clknet_leaf_90_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_91_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_91_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_92_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_92_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_93_clk clknet_3_1__leaf_clk VSS VSS VDD VDD clknet_leaf_93_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_94_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_94_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_95_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_95_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_96_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_96_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_97_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_97_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_98_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_98_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_99_clk clknet_3_0__leaf_clk VSS VSS VDD VDD clknet_leaf_99_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_100_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_100_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_101_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_101_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_102_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_102_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_103_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_103_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_104_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_104_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_leaf_105_clk clknet_3_0__leaf_clk VSS VSS VDD VDD
+ clknet_leaf_105_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_4__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_4__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_5__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_5__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_6__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_6__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkbuf_3_7__f_clk clknet_0_clk VSS VSS VDD VDD clknet_3_7__leaf_clk
+ sky130_fd_sc_hd__clkbuf_16
Xclkload0 clknet_3_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkinv_8
Xclkload1 clknet_3_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__inv_6
Xclkload2 clknet_3_2__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_16
Xclkload3 clknet_3_3__leaf_clk VSS VSS VDD VDD _unconnected_3
+ sky130_fd_sc_hd__inv_6
Xclkload4 clknet_3_4__leaf_clk VSS VSS VDD VDD _unconnected_4
+ sky130_fd_sc_hd__clkinv_8
Xclkload5 clknet_3_5__leaf_clk VSS VSS VDD VDD _unconnected_5
+ sky130_fd_sc_hd__inv_6
Xclkload6 clknet_3_7__leaf_clk VSS VSS VDD VDD _unconnected_6
+ sky130_fd_sc_hd__clkbuf_16
Xclkload7 clknet_leaf_94_clk VSS VSS VDD VDD _unconnected_7
+ sky130_fd_sc_hd__clkbuf_1
Xclkload8 clknet_leaf_95_clk VSS VSS VDD VDD _unconnected_8
+ sky130_fd_sc_hd__clkinv_1
Xclkload9 clknet_leaf_98_clk VSS VSS VDD VDD _unconnected_9
+ sky130_fd_sc_hd__clkinv_1
Xclkload10 clknet_leaf_99_clk VSS VSS VDD VDD _unconnected_10
+ sky130_fd_sc_hd__clkinv_1
Xclkload11 clknet_leaf_100_clk VSS VSS VDD VDD _unconnected_11
+ sky130_fd_sc_hd__clkinv_1
Xclkload12 clknet_leaf_101_clk VSS VSS VDD VDD _unconnected_12
+ sky130_fd_sc_hd__clkbuf_1
Xclkload13 clknet_leaf_102_clk VSS VSS VDD VDD _unconnected_13
+ sky130_fd_sc_hd__bufinv_16
Xclkload14 clknet_leaf_103_clk VSS VSS VDD VDD _unconnected_14
+ sky130_fd_sc_hd__clkinv_1
Xclkload15 clknet_leaf_104_clk VSS VSS VDD VDD _unconnected_15
+ sky130_fd_sc_hd__clkbuf_1
Xclkload16 clknet_leaf_105_clk VSS VSS VDD VDD _unconnected_16
+ sky130_fd_sc_hd__clkbuf_1
Xclkload17 clknet_leaf_0_clk VSS VSS VDD VDD _unconnected_17
+ sky130_fd_sc_hd__clkinv_1
Xclkload18 clknet_leaf_1_clk VSS VSS VDD VDD _unconnected_18
+ sky130_fd_sc_hd__clkinv_1
Xclkload19 clknet_leaf_3_clk VSS VSS VDD VDD _unconnected_19
+ sky130_fd_sc_hd__clkinv_1
Xclkload20 clknet_leaf_4_clk VSS VSS VDD VDD _unconnected_20
+ sky130_fd_sc_hd__clkinv_1
Xclkload21 clknet_leaf_5_clk VSS VSS VDD VDD _unconnected_21
+ sky130_fd_sc_hd__clkinv_2
Xclkload22 clknet_leaf_6_clk VSS VSS VDD VDD _unconnected_22
+ sky130_fd_sc_hd__clkinv_2
Xclkload23 clknet_leaf_7_clk VSS VSS VDD VDD _unconnected_23
+ sky130_fd_sc_hd__bufinv_16
Xclkload24 clknet_leaf_8_clk VSS VSS VDD VDD _unconnected_24
+ sky130_fd_sc_hd__bufinv_16
Xclkload25 clknet_leaf_9_clk VSS VSS VDD VDD _unconnected_25
+ sky130_fd_sc_hd__clkinv_2
Xclkload26 clknet_leaf_91_clk VSS VSS VDD VDD _unconnected_26
+ sky130_fd_sc_hd__clkinv_1
Xclkload27 clknet_leaf_92_clk VSS VSS VDD VDD _unconnected_27
+ sky130_fd_sc_hd__clkinv_1
Xclkload28 clknet_leaf_93_clk VSS VSS VDD VDD _unconnected_28
+ sky130_fd_sc_hd__clkinv_1
Xclkload29 clknet_leaf_73_clk VSS VSS VDD VDD _unconnected_29
+ sky130_fd_sc_hd__clkbuf_1
Xclkload30 clknet_leaf_74_clk VSS VSS VDD VDD _unconnected_30
+ sky130_fd_sc_hd__clkinv_2
Xclkload31 clknet_leaf_75_clk VSS VSS VDD VDD _unconnected_31
+ sky130_fd_sc_hd__clkinv_2
Xclkload32 clknet_leaf_76_clk VSS VSS VDD VDD _unconnected_32
+ sky130_fd_sc_hd__bufinv_16
Xclkload33 clknet_leaf_77_clk VSS VSS VDD VDD _unconnected_33
+ sky130_fd_sc_hd__clkinv_1
Xclkload34 clknet_leaf_79_clk VSS VSS VDD VDD _unconnected_34
+ sky130_fd_sc_hd__clkbuf_1
Xclkload35 clknet_leaf_80_clk VSS VSS VDD VDD _unconnected_35
+ sky130_fd_sc_hd__clkinv_2
Xclkload36 clknet_leaf_81_clk VSS VSS VDD VDD _unconnected_36
+ sky130_fd_sc_hd__clkinv_2
Xclkload37 clknet_leaf_82_clk VSS VSS VDD VDD _unconnected_37
+ sky130_fd_sc_hd__clkinv_1
Xclkload38 clknet_leaf_83_clk VSS VSS VDD VDD _unconnected_38
+ sky130_fd_sc_hd__clkinv_1
Xclkload39 clknet_leaf_85_clk VSS VSS VDD VDD _unconnected_39
+ sky130_fd_sc_hd__clkinv_2
Xclkload40 clknet_leaf_86_clk VSS VSS VDD VDD _unconnected_40
+ sky130_fd_sc_hd__bufinv_16
Xclkload41 clknet_leaf_64_clk VSS VSS VDD VDD _unconnected_41
+ sky130_fd_sc_hd__bufinv_16
Xclkload42 clknet_leaf_65_clk VSS VSS VDD VDD _unconnected_42
+ sky130_fd_sc_hd__clkbuf_1
Xclkload43 clknet_leaf_66_clk VSS VSS VDD VDD _unconnected_43
+ sky130_fd_sc_hd__clkinv_1
Xclkload44 clknet_leaf_68_clk VSS VSS VDD VDD _unconnected_44
+ sky130_fd_sc_hd__clkbuf_1
Xclkload45 clknet_leaf_69_clk VSS VSS VDD VDD _unconnected_45
+ sky130_fd_sc_hd__clkbuf_1
Xclkload46 clknet_leaf_70_clk VSS VSS VDD VDD _unconnected_46
+ sky130_fd_sc_hd__clkbuf_1
Xclkload47 clknet_leaf_71_clk VSS VSS VDD VDD _unconnected_47
+ sky130_fd_sc_hd__clkbuf_1
Xclkload48 clknet_leaf_72_clk VSS VSS VDD VDD _unconnected_48
+ sky130_fd_sc_hd__clkbuf_1
Xclkload49 clknet_leaf_87_clk VSS VSS VDD VDD _unconnected_49
+ sky130_fd_sc_hd__clkinv_1
Xclkload50 clknet_leaf_88_clk VSS VSS VDD VDD _unconnected_50
+ sky130_fd_sc_hd__clkbuf_1
Xclkload51 clknet_leaf_89_clk VSS VSS VDD VDD _unconnected_51
+ sky130_fd_sc_hd__clkbuf_1
Xclkload52 clknet_leaf_90_clk VSS VSS VDD VDD _unconnected_52
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload53 clknet_leaf_11_clk VSS VSS VDD VDD _unconnected_53
+ sky130_fd_sc_hd__clkinv_1
Xclkload54 clknet_leaf_12_clk VSS VSS VDD VDD _unconnected_54
+ sky130_fd_sc_hd__clkinv_2
Xclkload55 clknet_leaf_13_clk VSS VSS VDD VDD _unconnected_55
+ sky130_fd_sc_hd__clkinv_2
Xclkload56 clknet_leaf_14_clk VSS VSS VDD VDD _unconnected_56
+ sky130_fd_sc_hd__clkinv_2
Xclkload57 clknet_leaf_15_clk VSS VSS VDD VDD _unconnected_57
+ sky130_fd_sc_hd__clkinv_2
Xclkload58 clknet_leaf_16_clk VSS VSS VDD VDD _unconnected_58
+ sky130_fd_sc_hd__bufinv_16
Xclkload59 clknet_leaf_17_clk VSS VSS VDD VDD _unconnected_59
+ sky130_fd_sc_hd__clkinv_2
Xclkload60 clknet_leaf_18_clk VSS VSS VDD VDD _unconnected_60
+ sky130_fd_sc_hd__clkinv_2
Xclkload61 clknet_leaf_32_clk VSS VSS VDD VDD _unconnected_61
+ sky130_fd_sc_hd__bufinv_16
Xclkload62 clknet_leaf_33_clk VSS VSS VDD VDD _unconnected_62
+ sky130_fd_sc_hd__clkinv_2
Xclkload63 clknet_leaf_34_clk VSS VSS VDD VDD _unconnected_63
+ sky130_fd_sc_hd__inv_6
Xclkload64 clknet_leaf_20_clk VSS VSS VDD VDD _unconnected_64
+ sky130_fd_sc_hd__clkinv_1
Xclkload65 clknet_leaf_21_clk VSS VSS VDD VDD _unconnected_65
+ sky130_fd_sc_hd__clkinv_2
Xclkload66 clknet_leaf_23_clk VSS VSS VDD VDD _unconnected_66
+ sky130_fd_sc_hd__clkbuf_1
Xclkload67 clknet_leaf_24_clk VSS VSS VDD VDD _unconnected_67
+ sky130_fd_sc_hd__clkinv_1
Xclkload68 clknet_leaf_25_clk VSS VSS VDD VDD _unconnected_68
+ sky130_fd_sc_hd__clkbuf_1
Xclkload69 clknet_leaf_26_clk VSS VSS VDD VDD _unconnected_69
+ sky130_fd_sc_hd__clkbuf_1
Xclkload70 clknet_leaf_27_clk VSS VSS VDD VDD _unconnected_70
+ sky130_fd_sc_hd__clkbuf_1
Xclkload71 clknet_leaf_28_clk VSS VSS VDD VDD _unconnected_71
+ sky130_fd_sc_hd__clkbuf_1
Xclkload72 clknet_leaf_29_clk VSS VSS VDD VDD _unconnected_72
+ sky130_fd_sc_hd__clkbuf_1
Xclkload73 clknet_leaf_30_clk VSS VSS VDD VDD _unconnected_73
+ sky130_fd_sc_hd__clkinv_2
Xclkload74 clknet_leaf_31_clk VSS VSS VDD VDD _unconnected_74
+ sky130_fd_sc_hd__clkinv_1
Xclkload75 clknet_leaf_35_clk VSS VSS VDD VDD _unconnected_75
+ sky130_fd_sc_hd__clkbuf_1
Xclkload76 clknet_leaf_36_clk VSS VSS VDD VDD _unconnected_76
+ sky130_fd_sc_hd__clkinv_1
Xclkload77 clknet_leaf_37_clk VSS VSS VDD VDD _unconnected_77
+ sky130_fd_sc_hd__bufinv_16
Xclkload78 clknet_leaf_38_clk VSS VSS VDD VDD _unconnected_78
+ sky130_fd_sc_hd__bufinv_16
Xclkload79 clknet_leaf_53_clk VSS VSS VDD VDD _unconnected_79
+ sky130_fd_sc_hd__bufinv_16
Xclkload80 clknet_leaf_54_clk VSS VSS VDD VDD _unconnected_80
+ sky130_fd_sc_hd__clkinv_2
Xclkload81 clknet_leaf_55_clk VSS VSS VDD VDD _unconnected_81
+ sky130_fd_sc_hd__clkbuf_1
Xclkload82 clknet_leaf_56_clk VSS VSS VDD VDD _unconnected_82
+ sky130_fd_sc_hd__clkbuf_1
Xclkload83 clknet_leaf_57_clk VSS VSS VDD VDD _unconnected_83
+ sky130_fd_sc_hd__clkinv_1
Xclkload84 clknet_leaf_59_clk VSS VSS VDD VDD _unconnected_84
+ sky130_fd_sc_hd__clkinv_2
Xclkload85 clknet_leaf_60_clk VSS VSS VDD VDD _unconnected_85
+ sky130_fd_sc_hd__clkinv_1
Xclkload86 clknet_leaf_61_clk VSS VSS VDD VDD _unconnected_86
+ sky130_fd_sc_hd__clkbuf_1
Xclkload87 clknet_leaf_62_clk VSS VSS VDD VDD _unconnected_87
+ sky130_fd_sc_hd__clkinv_1
Xclkload88 clknet_leaf_63_clk VSS VSS VDD VDD _unconnected_88
+ sky130_fd_sc_hd__clkinv_1
Xclkload89 clknet_leaf_39_clk VSS VSS VDD VDD _unconnected_89
+ sky130_fd_sc_hd__bufinv_16
Xclkload90 clknet_leaf_40_clk VSS VSS VDD VDD _unconnected_90
+ sky130_fd_sc_hd__bufinv_16
Xclkload91 clknet_leaf_41_clk VSS VSS VDD VDD _unconnected_91
+ sky130_fd_sc_hd__bufinv_16
Xclkload92 clknet_leaf_42_clk VSS VSS VDD VDD _unconnected_92
+ sky130_fd_sc_hd__clkinv_2
Xclkload93 clknet_leaf_44_clk VSS VSS VDD VDD _unconnected_93
+ sky130_fd_sc_hd__clkinv_2
Xclkload94 clknet_leaf_45_clk VSS VSS VDD VDD _unconnected_94
+ sky130_fd_sc_hd__clkinv_2
Xclkload95 clknet_leaf_46_clk VSS VSS VDD VDD _unconnected_95
+ sky130_fd_sc_hd__bufinv_16
Xclkload96 clknet_leaf_47_clk VSS VSS VDD VDD _unconnected_96
+ sky130_fd_sc_hd__clkinv_2
Xclkload97 clknet_leaf_48_clk VSS VSS VDD VDD _unconnected_97
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload98 clknet_leaf_49_clk VSS VSS VDD VDD _unconnected_98
+ sky130_fd_sc_hd__clkinv_2
Xclkload99 clknet_leaf_50_clk VSS VSS VDD VDD _unconnected_99
+ sky130_fd_sc_hd__bufinv_16
Xclkload100 clknet_leaf_51_clk VSS VSS VDD VDD _unconnected_100
+ sky130_fd_sc_hd__clkinvlp_4
Xclkload101 clknet_leaf_52_clk VSS VSS VDD VDD _unconnected_101
+ sky130_fd_sc_hd__bufinv_16
Xhold1 write_data[23] VSS VSS VDD VDD net135 sky130_fd_sc_hd__dlygate4sd3_1
Xhold2 write_data[29] VSS VSS VDD VDD net136 sky130_fd_sc_hd__dlygate4sd3_1
Xhold3 write_data[21] VSS VSS VDD VDD net137 sky130_fd_sc_hd__dlygate4sd3_1
Xhold4 write_data[22] VSS VSS VDD VDD net138 sky130_fd_sc_hd__dlygate4sd3_1
Xhold5 write_data[25] VSS VSS VDD VDD net139 sky130_fd_sc_hd__dlygate4sd3_1
Xhold6 write_data[1] VSS VSS VDD VDD net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold7 write_data[31] VSS VSS VDD VDD net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold8 write_data[27] VSS VSS VDD VDD net142 sky130_fd_sc_hd__dlygate4sd3_1
Xhold9 write_data[30] VSS VSS VDD VDD net143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 write_data[5] VSS VSS VDD VDD net144 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 write_data[15] VSS VSS VDD VDD net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 write_data[4] VSS VSS VDD VDD net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 write_data[14] VSS VSS VDD VDD net147 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 write_data[20] VSS VSS VDD VDD net148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 write_data[24] VSS VSS VDD VDD net149 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 write_data[26] VSS VSS VDD VDD net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 write_data[19] VSS VSS VDD VDD net151 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 write_data[10] VSS VSS VDD VDD net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold19 write_data[0] VSS VSS VDD VDD net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 write_data[11] VSS VSS VDD VDD net154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 write_data[13] VSS VSS VDD VDD net155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 write_data[17] VSS VSS VDD VDD net156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 write_data[8] VSS VSS VDD VDD net157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 write_data[16] VSS VSS VDD VDD net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 write_data[9] VSS VSS VDD VDD net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 write_data[2] VSS VSS VDD VDD net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 write_data[28] VSS VSS VDD VDD net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 write_data[7] VSS VSS VDD VDD net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 write_data[3] VSS VSS VDD VDD net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 write_data[18] VSS VSS VDD VDD net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 write_data[12] VSS VSS VDD VDD net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 write_data[6] VSS VSS VDD VDD net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 read_addr2[4] VSS VSS VDD VDD net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 read_addr1[4] VSS VSS VDD VDD net168 sky130_fd_sc_hd__dlygate4sd3_1
Xmax_cap1 _0011_ VSS VSS VDD VDD net169 sky130_fd_sc_hd__buf_16
XANTENNA_1 _0076_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_2 _2357_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_3 _2363_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_4 _2363_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_5 _2369_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_6 _2401_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_7 _2441_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_8 _2514_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_9 _2514_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_10 net108 VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_11 _2348_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_12 _2349_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
XANTENNA_13 _2430_ VSS VSS VDD VDD sky130_fd_sc_hd__diode_2
.ENDS register_file
