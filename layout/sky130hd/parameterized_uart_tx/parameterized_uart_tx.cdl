* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_uart_tx clk data_in[0] data_in[1] data_in[2]
+ data_in[3] data_in[4] data_in[5] data_in[6] data_in[7] rst_n
+ tx tx_busy tx_start
X_094_ clk_counter\[1\] VSS VSS VDD VDD _089_ sky130_fd_sc_hd__inv_1
X_095_ bit_index\[0\] VSS VSS VDD VDD _052_ sky130_fd_sc_hd__clkbuf_2
X_096_ state\[2\] state\[0\] VSS VSS VDD VDD _053_ sky130_fd_sc_hd__or2_1
X_097_ clk_counter\[5\] clk_counter\[4\] VSS VSS VDD VDD _054_
+ sky130_fd_sc_hd__nand2_1
X_098_ clk_counter\[3\] clk_counter\[2\] clk_counter\[1\]
+ _090_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__nor4_1
X_099_ _054_ _055_ VSS VSS VDD VDD _056_ sky130_fd_sc_hd__or2_0
X_100_ _087_ _052_ _053_ _056_ VSS VSS VDD VDD _057_ sky130_fd_sc_hd__nor4_1
X_101_ state\[1\] VSS VSS VDD VDD _058_ sky130_fd_sc_hd__clkbuf_2
X_102_ _058_ _052_ _056_ VSS VSS VDD VDD _059_ sky130_fd_sc_hd__and3_1
X_103_ _052_ _053_ _057_ _058_ _059_ VSS VSS VDD VDD _000_
+ sky130_fd_sc_hd__a221o_1
X_104_ bit_index\[1\] VSS VSS VDD VDD _060_ sky130_fd_sc_hd__inv_1
X_105_ state\[2\] VSS VSS VDD VDD _061_ sky130_fd_sc_hd__buf_2
X_106_ _061_ state\[0\] VSS VSS VDD VDD _062_ sky130_fd_sc_hd__nor2_1
X_107_ _054_ _055_ VSS VSS VDD VDD _063_ sky130_fd_sc_hd__nor2_2
X_108_ _058_ _086_ _062_ _063_ VSS VSS VDD VDD _064_ sky130_fd_sc_hd__nand4_1
X_109_ _056_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__buf_2
X_110_ _058_ bit_index\[1\] _065_ VSS VSS VDD VDD _066_ sky130_fd_sc_hd__nand3_1
X_111_ _060_ _062_ _064_ _066_ VSS VSS VDD VDD _001_ sky130_fd_sc_hd__o211ai_1
X_112_ _058_ _088_ _062_ _063_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__nand4_1
X_113_ bit_index\[2\] _053_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nand2_1
X_114_ _058_ bit_index\[2\] _065_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nand3_1
X_115_ _067_ _068_ _069_ VSS VSS VDD VDD _002_ sky130_fd_sc_hd__nand3_1
X_116_ state\[1\] state\[0\] VSS VSS VDD VDD _070_ sky130_fd_sc_hd__or2_0
X_117_ _070_ VSS VSS VDD VDD _071_ sky130_fd_sc_hd__buf_6
X_118_ _071_ VSS VSS VDD VDD _072_ sky130_fd_sc_hd__buf_2
X_119_ _061_ clk_counter\[0\] VSS VSS VDD VDD _073_ sky130_fd_sc_hd__nor2_1
X_120_ _058_ state\[0\] VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nor2_2
X_121_ _054_ _055_ _074_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__o21ai_0
X_122_ clk_counter\[0\] _072_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__nand2_1
X_123_ clk_counter\[0\] _075_ _076_ VSS VSS VDD VDD _077_
+ sky130_fd_sc_hd__o21ai_0
X_124_ _061_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__buf_2
X_125_ _065_ _072_ _073_ _077_ _078_ VSS VSS VDD VDD _003_
+ sky130_fd_sc_hd__a32o_1
X_126_ _091_ _063_ _074_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__nor3_1
X_127_ clk_counter\[1\] _072_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__nand2_1
X_128_ _091_ _063_ _071_ _080_ _061_ VSS VSS VDD VDD _081_
+ sky130_fd_sc_hd__o311ai_0
X_129_ _078_ _079_ _081_ VSS VSS VDD VDD _004_ sky130_fd_sc_hd__o21a_1
X_130_ clk_counter\[2\] _074_ state\[2\] VSS VSS VDD VDD _082_
+ sky130_fd_sc_hd__nor3b_1
X_131_ _061_ _072_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__nor2_1
X_132_ clk_counter\[2\] _092_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__xnor2_1
X_133_ _078_ clk_counter\[2\] _072_ VSS VSS VDD VDD _022_
+ sky130_fd_sc_hd__nand3_1
X_134_ _063_ _082_ _083_ _084_ _022_ VSS VSS VDD VDD _005_
+ sky130_fd_sc_hd__o41ai_1
X_135_ _061_ _071_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__nand2_1
X_136_ clk_counter\[2\] clk_counter\[1\] clk_counter\[0\]
+ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__nand3_1
X_137_ clk_counter\[3\] _024_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__nor2_1
X_138_ clk_counter\[3\] _024_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__and2_0
X_139_ _023_ _025_ _026_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__a21oi_1
X_140_ _061_ _072_ _065_ VSS VSS VDD VDD _028_ sky130_fd_sc_hd__o21ai_0
X_141_ _078_ clk_counter\[3\] _072_ VSS VSS VDD VDD _029_
+ sky130_fd_sc_hd__nand3_1
X_142_ _027_ _028_ _029_ VSS VSS VDD VDD _006_ sky130_fd_sc_hd__o21ai_0
X_143_ clk_counter\[3\] clk_counter\[2\] _092_ VSS VSS VDD
+ VDD _030_ sky130_fd_sc_hd__nand3_1
X_144_ clk_counter\[4\] _030_ VSS VSS VDD VDD _031_ sky130_fd_sc_hd__nor2_1
X_145_ clk_counter\[4\] _030_ VSS VSS VDD VDD _032_ sky130_fd_sc_hd__and2_0
X_146_ _023_ _031_ _032_ VSS VSS VDD VDD _033_ sky130_fd_sc_hd__a21oi_1
X_147_ _078_ clk_counter\[4\] _072_ VSS VSS VDD VDD _034_
+ sky130_fd_sc_hd__nand3_1
X_148_ _028_ _033_ _034_ VSS VSS VDD VDD _007_ sky130_fd_sc_hd__o21ai_0
X_149_ state\[2\] _071_ _024_ VSS VSS VDD VDD _035_ sky130_fd_sc_hd__a21oi_1
X_150_ clk_counter\[4\] clk_counter\[3\] _035_ clk_counter\[5\]
+ VSS VSS VDD VDD _036_ sky130_fd_sc_hd__a31oi_1
X_151_ _065_ _072_ _061_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__a21oi_1
X_152_ _063_ _074_ _036_ _037_ VSS VSS VDD VDD _008_ sky130_fd_sc_hd__a211oi_1
X_153_ _071_ state\[2\] net11 VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nor3b_4
X_154_ data_reg\[0\] net2 _038_ VSS VSS VDD VDD _009_ sky130_fd_sc_hd__mux2_1
X_155_ data_reg\[1\] net3 _038_ VSS VSS VDD VDD _010_ sky130_fd_sc_hd__mux2_1
X_156_ data_reg\[2\] net4 _038_ VSS VSS VDD VDD _011_ sky130_fd_sc_hd__mux2_1
X_157_ data_reg\[3\] net5 _038_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__mux2_1
X_158_ data_reg\[4\] net6 _038_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__mux2_1
X_159_ data_reg\[5\] net7 _038_ VSS VSS VDD VDD _014_ sky130_fd_sc_hd__mux2_1
X_160_ data_reg\[6\] net8 _038_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__mux2_1
X_161_ data_reg\[7\] net9 _038_ VSS VSS VDD VDD _016_ sky130_fd_sc_hd__mux2_1
X_162_ state\[0\] _065_ _074_ net11 VSS VSS VDD VDD _039_
+ sky130_fd_sc_hd__a22oi_1
X_163_ _078_ _039_ VSS VSS VDD VDD _017_ sky130_fd_sc_hd__nor2_1
X_164_ state\[0\] _087_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nor2_1
X_165_ _065_ _040_ _058_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__o21ai_0
X_166_ _058_ state\[0\] _063_ VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nand3b_1
X_167_ _041_ _042_ _078_ VSS VSS VDD VDD _018_ sky130_fd_sc_hd__a21oi_1
X_168_ _061_ _040_ _065_ _058_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nor4b_1
X_169_ _078_ _065_ _074_ _043_ VSS VSS VDD VDD _019_ sky130_fd_sc_hd__a31o_1
X_170_ data_reg\[2\] data_reg\[3\] data_reg\[6\] data_reg\[7\]
+ _052_ bit_index\[2\] VSS VSS VDD VDD _044_ sky130_fd_sc_hd__mux4_1
X_171_ _044_ bit_index\[1\] VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand2b_1
X_172_ data_reg\[4\] data_reg\[5\] _052_ VSS VSS VDD VDD _046_
+ sky130_fd_sc_hd__mux2i_1
X_173_ _052_ data_reg\[0\] VSS VSS VDD VDD _047_ sky130_fd_sc_hd__nor2b_1
X_174_ _052_ data_reg\[1\] bit_index\[1\] bit_index\[2\] _047_
+ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__a2111oi_0
X_175_ _060_ bit_index\[2\] _046_ _048_ _053_ VSS VSS VDD
+ VDD _049_ sky130_fd_sc_hd__a311oi_1
X_176_ _061_ net12 _045_ _049_ _074_ VSS VSS VDD VDD _020_
+ sky130_fd_sc_hd__a221o_1
X_177_ net11 net13 _072_ VSS VSS VDD VDD _050_ sky130_fd_sc_hd__mux2i_1
X_178_ _078_ net13 _065_ _074_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nand4_1
X_179_ _078_ _050_ _051_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__o21ai_0
X_180_ bit_index\[0\] bit_index\[1\] VSS VSS VDD VDD _085_
+ _086_ sky130_fd_sc_hd__ha_1
X_181_ bit_index\[2\] _085_ VSS VSS VDD VDD _087_ _088_ sky130_fd_sc_hd__ha_1
X_182_ clk_counter\[0\] _089_ VSS VSS VDD VDD _090_ _091_
+ sky130_fd_sc_hd__ha_1
X_183_ clk_counter\[0\] clk_counter\[1\] VSS VSS VDD VDD _092_
+ _093_ sky130_fd_sc_hd__ha_1
Xbit_index\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _000_ net1
+ VSS VSS VDD VDD bit_index\[0\] sky130_fd_sc_hd__dfrtp_1
Xbit_index\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _001_ net1
+ VSS VSS VDD VDD bit_index\[1\] sky130_fd_sc_hd__dfrtp_1
Xbit_index\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _002_ net1
+ VSS VSS VDD VDD bit_index\[2\] sky130_fd_sc_hd__dfrtp_2
Xclk_counter\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _003_ net1
+ VSS VSS VDD VDD clk_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xclk_counter\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _004_ net1
+ VSS VSS VDD VDD clk_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xclk_counter\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _005_ net1
+ VSS VSS VDD VDD clk_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xclk_counter\[3\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _006_ net1
+ VSS VSS VDD VDD clk_counter\[3\] sky130_fd_sc_hd__dfrtp_1
Xclk_counter\[4\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _007_ net1
+ VSS VSS VDD VDD clk_counter\[4\] sky130_fd_sc_hd__dfrtp_1
Xclk_counter\[5\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _008_ net1
+ VSS VSS VDD VDD clk_counter\[5\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _009_ net1
+ VSS VSS VDD VDD data_reg\[0\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[1\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _010_ net1
+ VSS VSS VDD VDD data_reg\[1\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _011_ net1
+ VSS VSS VDD VDD data_reg\[2\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _012_ net1
+ VSS VSS VDD VDD data_reg\[3\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _013_ net1
+ VSS VSS VDD VDD data_reg\[4\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _014_ net1
+ VSS VSS VDD VDD data_reg\[5\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[6\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _015_ net1
+ VSS VSS VDD VDD data_reg\[6\] sky130_fd_sc_hd__dfrtp_1
Xdata_reg\[7\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _016_ net1
+ VSS VSS VDD VDD data_reg\[7\] sky130_fd_sc_hd__dfrtp_1
Xstate\[0\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _017_ net1 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfrtp_2
Xstate\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _018_ net1 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_1
Xstate\[2\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _019_ net1 VSS
+ VSS VDD VDD state\[2\] sky130_fd_sc_hd__dfrtp_2
Xtx$_DFFE_PN1P_ clknet_1_1__leaf_clk _020_ net10 VSS VSS VDD
+ VDD net12 sky130_fd_sc_hd__dfstp_1
Xtx_busy$_DFFE_PN0P_ clknet_1_0__leaf_clk _021_ net1 VSS VSS
+ VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xhold1 net10 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_8
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 data_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 data_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 data_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 data_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 data_in[4] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 data_in[5] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 data_in[6] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 data_in[7] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 net14 VSS VSS VDD VDD net10 sky130_fd_sc_hd__clkbuf_1
Xinput10 tx_start VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD tx sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD tx_busy sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__bufinv_16
Xhold2 rst_n VSS VSS VDD VDD net14 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS parameterized_uart_tx
