* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT power_domain_controller clk domain_clock_on[0] domain_clock_on[1]
+ domain_clock_on[2] domain_clock_on[3] domain_enable[0] domain_enable[1]
+ domain_enable[2] domain_enable[3] domain_isolate[0] domain_isolate[1]
+ domain_isolate[2] domain_isolate[3] domain_isolation_on[0]
+ domain_isolation_on[1] domain_isolation_on[2] domain_isolation_on[3]
+ domain_power_on[0] domain_power_on[1] domain_power_on[2] domain_power_on[3]
+ domain_reset_n[0] domain_reset_n[1] domain_reset_n[2] domain_reset_n[3]
+ domain_status[0] domain_status[1] domain_status[2] domain_status[3]
+ domain_transition[0] domain_transition[1] domain_transition[2]
+ domain_transition[3] rst_n start_transition transition_done
X_152_ delay_counter\[0\] VSS VSS VDD VDD _146_ sky130_fd_sc_hd__inv_1
X_153_ delay_counter\[1\] VSS VSS VDD VDD _147_ sky130_fd_sc_hd__inv_1
X_154_ state\[0\] VSS VSS VDD VDD _139_ sky130_fd_sc_hd__clkbuf_4
X_155_ _139_ VSS VSS VDD VDD _140_ sky130_fd_sc_hd__clkinvlp_4
X_156_ state\[2\] state\[1\] _140_ VSS VSS VDD VDD _141_ sky130_fd_sc_hd__and3_1
X_157_ net35 _141_ VSS VSS VDD VDD _142_ sky130_fd_sc_hd__nand2_1
X_158_ target_status\[3\] net31 _142_ VSS VSS VDD VDD _000_
+ sky130_fd_sc_hd__mux2_1
X_159_ net34 _141_ VSS VSS VDD VDD _143_ sky130_fd_sc_hd__nand2_1
X_160_ target_status\[2\] net30 _143_ VSS VSS VDD VDD _001_
+ sky130_fd_sc_hd__mux2_1
X_161_ net33 _141_ VSS VSS VDD VDD _144_ sky130_fd_sc_hd__nand2_1
X_162_ target_status\[1\] net29 _144_ VSS VSS VDD VDD _002_
+ sky130_fd_sc_hd__mux2_1
X_163_ net32 _141_ VSS VSS VDD VDD _145_ sky130_fd_sc_hd__nand2_1
X_164_ target_status\[0\] net28 _145_ VSS VSS VDD VDD _003_
+ sky130_fd_sc_hd__mux2_1
X_165_ state\[1\] state\[0\] VSS VSS VDD VDD _036_ sky130_fd_sc_hd__nor2_2
X_166_ state\[2\] _036_ VSS VSS VDD VDD _037_ sky130_fd_sc_hd__and2_1
X_167_ net35 _037_ VSS VSS VDD VDD _038_ sky130_fd_sc_hd__nand2_1
X_168_ target_status\[3\] net15 _038_ VSS VSS VDD VDD _004_
+ sky130_fd_sc_hd__mux2_1
X_169_ net34 _037_ VSS VSS VDD VDD _039_ sky130_fd_sc_hd__nand2_1
X_170_ target_status\[2\] net14 _039_ VSS VSS VDD VDD _005_
+ sky130_fd_sc_hd__mux2_1
X_171_ net33 _037_ VSS VSS VDD VDD _040_ sky130_fd_sc_hd__nand2_1
X_172_ target_status\[1\] net13 _040_ VSS VSS VDD VDD _006_
+ sky130_fd_sc_hd__mux2_1
X_173_ net32 _037_ VSS VSS VDD VDD _041_ sky130_fd_sc_hd__nand2_1
X_174_ target_status\[0\] net12 _041_ VSS VSS VDD VDD _007_
+ sky130_fd_sc_hd__mux2_1
X_175_ state\[2\] _139_ state\[1\] VSS VSS VDD VDD _042_ sky130_fd_sc_hd__nor3b_4
X_176_ net35 _042_ VSS VSS VDD VDD _043_ sky130_fd_sc_hd__nand2_1
X_177_ target_status\[3\] net23 _043_ VSS VSS VDD VDD _008_
+ sky130_fd_sc_hd__mux2_1
X_178_ net34 _042_ VSS VSS VDD VDD _044_ sky130_fd_sc_hd__nand2_1
X_179_ target_status\[2\] net22 _044_ VSS VSS VDD VDD _009_
+ sky130_fd_sc_hd__mux2_1
X_180_ net33 _042_ VSS VSS VDD VDD _045_ sky130_fd_sc_hd__nand2_1
X_181_ target_status\[1\] net21 _045_ VSS VSS VDD VDD _010_
+ sky130_fd_sc_hd__mux2_1
X_182_ net32 _042_ VSS VSS VDD VDD _046_ sky130_fd_sc_hd__nand2_1
X_183_ target_status\[0\] net20 _046_ VSS VSS VDD VDD _011_
+ sky130_fd_sc_hd__mux2_1
X_184_ state\[2\] VSS VSS VDD VDD _047_ sky130_fd_sc_hd__buf_2
X_185_ _047_ VSS VSS VDD VDD _048_ sky130_fd_sc_hd__buf_2
X_186_ delay_counter\[2\] VSS VSS VDD VDD _049_ sky130_fd_sc_hd__buf_6
X_187_ _049_ delay_counter\[3\] _150_ VSS VSS VDD VDD _050_
+ sky130_fd_sc_hd__nor3b_2
X_188_ delay_counter\[0\] _050_ VSS VSS VDD VDD _051_ sky130_fd_sc_hd__nor2_1
X_189_ net11 _146_ VSS VSS VDD VDD _052_ sky130_fd_sc_hd__nor2_1
X_190_ delay_counter\[2\] delay_counter\[3\] _150_ VSS VSS
+ VDD VDD _053_ sky130_fd_sc_hd__or3b_2
X_191_ state\[1\] VSS VSS VDD VDD _054_ sky130_fd_sc_hd__buf_2
X_192_ _054_ VSS VSS VDD VDD _055_ sky130_fd_sc_hd__inv_1
X_193_ delay_counter\[0\] _053_ _055_ VSS VSS VDD VDD _056_
+ sky130_fd_sc_hd__a21oi_1
X_194_ _139_ _051_ _052_ _036_ _056_ VSS VSS VDD VDD _057_
+ sky130_fd_sc_hd__a221oi_1
X_195_ _140_ _053_ _055_ VSS VSS VDD VDD _058_ sky130_fd_sc_hd__o21ai_0
X_196_ _054_ state\[2\] VSS VSS VDD VDD _059_ sky130_fd_sc_hd__nor2b_1
X_197_ _048_ delay_counter\[0\] _058_ _059_ _051_ VSS VSS
+ VDD VDD _060_ sky130_fd_sc_hd__a32oi_1
X_198_ net5 net31 VSS VSS VDD VDD _061_ sky130_fd_sc_hd__xnor2_2
X_199_ net2 net28 VSS VSS VDD VDD _062_ sky130_fd_sc_hd__xnor2_2
X_200_ net4 net30 VSS VSS VDD VDD _063_ sky130_fd_sc_hd__xnor2_2
X_201_ net3 net29 VSS VSS VDD VDD _064_ sky130_fd_sc_hd__xnor2_2
X_202_ _061_ _062_ _063_ _064_ VSS VSS VDD VDD _065_ sky130_fd_sc_hd__nand4_1
X_203_ state\[2\] state\[1\] state\[0\] VSS VSS VDD VDD _066_
+ sky130_fd_sc_hd__or3_1
X_204_ _146_ _065_ _066_ VSS VSS VDD VDD _067_ sky130_fd_sc_hd__or3_1
X_205_ _048_ _057_ _060_ _067_ VSS VSS VDD VDD _012_ sky130_fd_sc_hd__o211ai_1
X_206_ _149_ _053_ VSS VSS VDD VDD _068_ sky130_fd_sc_hd__nand2_1
X_207_ _047_ _147_ _050_ VSS VSS VDD VDD _069_ sky130_fd_sc_hd__nand3_1
X_208_ _047_ _068_ _069_ VSS VSS VDD VDD _070_ sky130_fd_sc_hd__o21ai_0
X_209_ net11 VSS VSS VDD VDD _071_ sky130_fd_sc_hd__inv_1
X_210_ _061_ _062_ _063_ _064_ _071_ VSS VSS VDD VDD _072_
+ sky130_fd_sc_hd__a41oi_4
X_211_ delay_counter\[1\] _066_ _072_ VSS VSS VDD VDD _073_
+ sky130_fd_sc_hd__nor3_1
X_212_ _047_ _054_ VSS VSS VDD VDD _074_ sky130_fd_sc_hd__nand2_1
X_213_ _149_ _053_ _059_ VSS VSS VDD VDD _075_ sky130_fd_sc_hd__nand3_1
X_214_ _149_ _050_ _042_ VSS VSS VDD VDD _076_ sky130_fd_sc_hd__o21ai_0
X_215_ delay_counter\[1\] _074_ _075_ _076_ VSS VSS VDD VDD
+ _077_ sky130_fd_sc_hd__o211ai_1
X_216_ _139_ _070_ _073_ _077_ VSS VSS VDD VDD _013_ sky130_fd_sc_hd__a211oi_1
X_217_ _148_ _036_ VSS VSS VDD VDD _078_ sky130_fd_sc_hd__nor2_1
X_218_ _054_ _148_ VSS VSS VDD VDD _079_ sky130_fd_sc_hd__nand2b_1
X_219_ _047_ _078_ _079_ VSS VSS VDD VDD _080_ sky130_fd_sc_hd__o21ai_0
X_220_ delay_counter\[3\] _150_ VSS VSS VDD VDD _081_ sky130_fd_sc_hd__nor2b_1
X_221_ _139_ _148_ VSS VSS VDD VDD _082_ sky130_fd_sc_hd__nand2_1
X_222_ _049_ _081_ _082_ VSS VSS VDD VDD _083_ sky130_fd_sc_hd__or3_1
X_223_ _139_ _049_ _054_ VSS VSS VDD VDD _084_ sky130_fd_sc_hd__nor3b_1
X_224_ _148_ _081_ _084_ VSS VSS VDD VDD _085_ sky130_fd_sc_hd__o21ai_0
X_225_ _055_ _140_ _049_ VSS VSS VDD VDD _086_ sky130_fd_sc_hd__nand3_1
X_226_ _083_ _085_ _086_ _047_ VSS VSS VDD VDD _087_ sky130_fd_sc_hd__a31o_1
X_227_ _049_ _081_ _079_ VSS VSS VDD VDD _088_ sky130_fd_sc_hd__nor3_1
X_228_ _148_ _074_ _049_ VSS VSS VDD VDD _089_ sky130_fd_sc_hd__a21boi_0
X_229_ _048_ _088_ _089_ VSS VSS VDD VDD _090_ sky130_fd_sc_hd__a21oi_1
X_230_ _049_ _072_ _080_ _087_ _090_ VSS VSS VDD VDD _014_
+ sky130_fd_sc_hd__a32oi_1
X_231_ _150_ delay_counter\[0\] delay_counter\[1\] VSS VSS
+ VDD VDD _091_ sky130_fd_sc_hd__nor3_1
X_232_ _055_ _150_ _091_ VSS VSS VDD VDD _092_ sky130_fd_sc_hd__a21oi_1
X_233_ _049_ delay_counter\[0\] delay_counter\[1\] delay_counter\[3\]
+ VSS VSS VDD VDD _093_ sky130_fd_sc_hd__o31ai_1
X_234_ _049_ delay_counter\[3\] _092_ _093_ VSS VSS VDD VDD
+ _094_ sky130_fd_sc_hd__o31a_1
X_235_ _047_ delay_counter\[3\] _036_ VSS VSS VDD VDD _095_
+ sky130_fd_sc_hd__nand3b_1
X_236_ delay_counter\[3\] _150_ VSS VSS VDD VDD _096_ sky130_fd_sc_hd__nor2_1
X_237_ state\[1\] _049_ delay_counter\[0\] delay_counter\[1\]
+ VSS VSS VDD VDD _097_ sky130_fd_sc_hd__nor4_1
X_238_ delay_counter\[3\] _096_ _097_ VSS VSS VDD VDD _098_
+ sky130_fd_sc_hd__mux2_1
X_239_ _072_ _095_ _098_ _048_ VSS VSS VDD VDD _099_ sky130_fd_sc_hd__a2bb2oi_1
X_240_ _048_ _036_ _094_ _099_ VSS VSS VDD VDD _015_ sky130_fd_sc_hd__o31ai_1
X_241_ _054_ _140_ VSS VSS VDD VDD _100_ sky130_fd_sc_hd__nor2_1
X_242_ state\[1\] _139_ VSS VSS VDD VDD _101_ sky130_fd_sc_hd__nand2b_1
X_243_ net32 target_status\[0\] VSS VSS VDD VDD _102_ sky130_fd_sc_hd__nand2_1
X_244_ _101_ _102_ net16 VSS VSS VDD VDD _103_ sky130_fd_sc_hd__o21ai_0
X_245_ target_status\[0\] net32 VSS VSS VDD VDD _104_ sky130_fd_sc_hd__nor2b_1
X_246_ net16 _104_ VSS VSS VDD VDD _105_ sky130_fd_sc_hd__nor2_1
X_247_ _048_ _103_ _105_ VSS VSS VDD VDD _106_ sky130_fd_sc_hd__a21oi_1
X_248_ net16 _100_ _106_ net6 VSS VSS VDD VDD _016_ sky130_fd_sc_hd__o22a_1
X_249_ net33 target_status\[1\] VSS VSS VDD VDD _107_ sky130_fd_sc_hd__nand2_1
X_250_ _101_ _107_ net17 VSS VSS VDD VDD _108_ sky130_fd_sc_hd__o21ai_0
X_251_ target_status\[1\] net33 VSS VSS VDD VDD _109_ sky130_fd_sc_hd__nor2b_1
X_252_ net17 _109_ VSS VSS VDD VDD _110_ sky130_fd_sc_hd__nor2_1
X_253_ _048_ _108_ _110_ VSS VSS VDD VDD _111_ sky130_fd_sc_hd__a21oi_1
X_254_ net17 _100_ _111_ net7 VSS VSS VDD VDD _017_ sky130_fd_sc_hd__o22a_1
X_255_ net34 target_status\[2\] VSS VSS VDD VDD _112_ sky130_fd_sc_hd__nand2_1
X_256_ _101_ _112_ net18 VSS VSS VDD VDD _113_ sky130_fd_sc_hd__o21ai_0
X_257_ target_status\[2\] net34 VSS VSS VDD VDD _114_ sky130_fd_sc_hd__nor2b_1
X_258_ net18 _114_ VSS VSS VDD VDD _115_ sky130_fd_sc_hd__nor2_1
X_259_ _048_ _113_ _115_ VSS VSS VDD VDD _116_ sky130_fd_sc_hd__a21oi_1
X_260_ net18 _100_ _116_ net8 VSS VSS VDD VDD _018_ sky130_fd_sc_hd__o22a_1
X_261_ net35 target_status\[3\] VSS VSS VDD VDD _117_ sky130_fd_sc_hd__nand2_1
X_262_ _101_ _117_ net19 VSS VSS VDD VDD _118_ sky130_fd_sc_hd__o21ai_0
X_263_ target_status\[3\] net35 VSS VSS VDD VDD _119_ sky130_fd_sc_hd__nor2b_1
X_264_ net19 _119_ VSS VSS VDD VDD _120_ sky130_fd_sc_hd__nor2_1
X_265_ _048_ _118_ _120_ VSS VSS VDD VDD _121_ sky130_fd_sc_hd__a21oi_1
X_266_ net19 _100_ _121_ net9 VSS VSS VDD VDD _019_ sky130_fd_sc_hd__o22a_1
X_267_ state\[2\] state\[1\] _139_ VSS VSS VDD VDD _122_ sky130_fd_sc_hd__and3b_1
X_268_ _050_ _122_ VSS VSS VDD VDD _123_ sky130_fd_sc_hd__and2_1
X_269_ net32 _123_ net24 VSS VSS VDD VDD _124_ sky130_fd_sc_hd__a21oi_1
X_270_ _104_ _122_ _124_ VSS VSS VDD VDD _020_ sky130_fd_sc_hd__a21oi_1
X_271_ net33 _123_ net25 VSS VSS VDD VDD _125_ sky130_fd_sc_hd__a21oi_1
X_272_ _109_ _122_ _125_ VSS VSS VDD VDD _021_ sky130_fd_sc_hd__a21oi_1
X_273_ net34 _123_ net26 VSS VSS VDD VDD _126_ sky130_fd_sc_hd__a21oi_1
X_274_ _114_ _122_ _126_ VSS VSS VDD VDD _022_ sky130_fd_sc_hd__a21oi_1
X_275_ net35 _123_ net27 VSS VSS VDD VDD _127_ sky130_fd_sc_hd__a21oi_1
X_276_ _119_ _122_ _127_ VSS VSS VDD VDD _023_ sky130_fd_sc_hd__a21oi_1
X_277_ _047_ _054_ _140_ VSS VSS VDD VDD _128_ sky130_fd_sc_hd__nand3_2
X_278_ net32 _128_ VSS VSS VDD VDD _129_ sky130_fd_sc_hd__nand2_1
X_279_ _066_ _072_ VSS VSS VDD VDD _130_ sky130_fd_sc_hd__nand2b_1
X_280_ _130_ VSS VSS VDD VDD _131_ sky130_fd_sc_hd__buf_6
X_281_ _062_ _129_ _131_ VSS VSS VDD VDD _024_ sky130_fd_sc_hd__mux2i_1
X_282_ net33 _128_ VSS VSS VDD VDD _132_ sky130_fd_sc_hd__nand2_1
X_283_ _064_ _132_ _131_ VSS VSS VDD VDD _025_ sky130_fd_sc_hd__mux2i_1
X_284_ net34 _128_ VSS VSS VDD VDD _133_ sky130_fd_sc_hd__nand2_1
X_285_ _063_ _133_ _131_ VSS VSS VDD VDD _026_ sky130_fd_sc_hd__mux2i_1
X_286_ net35 _128_ VSS VSS VDD VDD _134_ sky130_fd_sc_hd__nand2_1
X_287_ _061_ _134_ _131_ VSS VSS VDD VDD _027_ sky130_fd_sc_hd__mux2i_1
X_288_ _047_ _054_ _140_ _053_ VSS VSS VDD VDD _135_ sky130_fd_sc_hd__o211ai_1
X_289_ _139_ _050_ VSS VSS VDD VDD _136_ sky130_fd_sc_hd__nand2_1
X_290_ _066_ _072_ _135_ _074_ _136_ VSS VSS VDD VDD _028_
+ sky130_fd_sc_hd__o2111a_1
X_291_ _048_ _054_ _136_ VSS VSS VDD VDD _137_ sky130_fd_sc_hd__nand3b_1
X_292_ _054_ _136_ _137_ VSS VSS VDD VDD _029_ sky130_fd_sc_hd__o21ai_0
X_293_ _059_ _123_ VSS VSS VDD VDD _030_ sky130_fd_sc_hd__or2_0
X_294_ net2 target_status\[0\] _131_ VSS VSS VDD VDD _031_
+ sky130_fd_sc_hd__mux2_1
X_295_ net3 target_status\[1\] _131_ VSS VSS VDD VDD _032_
+ sky130_fd_sc_hd__mux2_1
X_296_ net4 target_status\[2\] _131_ VSS VSS VDD VDD _033_
+ sky130_fd_sc_hd__mux2_1
X_297_ net5 target_status\[3\] _131_ VSS VSS VDD VDD _034_
+ sky130_fd_sc_hd__mux2_1
X_298_ _139_ _059_ net36 VSS VSS VDD VDD _138_ sky130_fd_sc_hd__o21bai_1
X_299_ _047_ _055_ net36 _131_ _138_ VSS VSS VDD VDD _035_
+ sky130_fd_sc_hd__o311a_1
X_300_ _146_ _147_ VSS VSS VDD VDD _148_ _149_ sky130_fd_sc_hd__ha_1
X_301_ _146_ _147_ VSS VSS VDD VDD _150_ _151_ sky130_fd_sc_hd__ha_1
X_302_ clknet_2_2__leaf_clk _000_ net1 VSS VSS VDD VDD net31
+ sky130_fd_sc_hd__dfrtp_1
X_303_ clknet_2_0__leaf_clk _001_ net1 VSS VSS VDD VDD net30
+ sky130_fd_sc_hd__dfrtp_1
X_304_ clknet_2_2__leaf_clk _002_ net1 VSS VSS VDD VDD net29
+ sky130_fd_sc_hd__dfrtp_1
X_305_ clknet_2_0__leaf_clk _003_ net1 VSS VSS VDD VDD net28
+ sky130_fd_sc_hd__dfrtp_1
X_306_ clknet_2_2__leaf_clk _004_ net1 VSS VSS VDD VDD net15
+ sky130_fd_sc_hd__dfrtp_1
X_307_ clknet_2_0__leaf_clk _005_ net1 VSS VSS VDD VDD net14
+ sky130_fd_sc_hd__dfrtp_1
X_308_ clknet_2_2__leaf_clk _006_ net1 VSS VSS VDD VDD net13
+ sky130_fd_sc_hd__dfrtp_1
X_309_ clknet_2_2__leaf_clk _007_ net1 VSS VSS VDD VDD net12
+ sky130_fd_sc_hd__dfrtp_1
X_310_ clknet_2_3__leaf_clk _008_ net1 VSS VSS VDD VDD net23
+ sky130_fd_sc_hd__dfrtp_1
X_311_ clknet_2_0__leaf_clk _009_ net1 VSS VSS VDD VDD net22
+ sky130_fd_sc_hd__dfrtp_1
X_312_ clknet_2_2__leaf_clk _010_ net1 VSS VSS VDD VDD net21
+ sky130_fd_sc_hd__dfrtp_1
X_313_ clknet_2_2__leaf_clk _011_ net1 VSS VSS VDD VDD net20
+ sky130_fd_sc_hd__dfrtp_1
Xdelay_counter\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _012_
+ net1 VSS VSS VDD VDD delay_counter\[0\] sky130_fd_sc_hd__dfrtp_1
Xdelay_counter\[1\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _013_
+ net1 VSS VSS VDD VDD delay_counter\[1\] sky130_fd_sc_hd__dfrtp_1
Xdelay_counter\[2\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _014_
+ net1 VSS VSS VDD VDD delay_counter\[2\] sky130_fd_sc_hd__dfrtp_1
Xdelay_counter\[3\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _015_
+ net1 VSS VSS VDD VDD delay_counter\[3\] sky130_fd_sc_hd__dfrtp_2
Xdomain_isolation_on\[0\]$_DFFE_PN1P_ clknet_2_3__leaf_clk
+ _016_ net10 VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfstp_1
Xdomain_isolation_on\[1\]$_DFFE_PN1P_ clknet_2_3__leaf_clk
+ _017_ net10 VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfstp_1
Xdomain_isolation_on\[2\]$_DFFE_PN1P_ clknet_2_1__leaf_clk
+ _018_ net10 VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfstp_1
Xdomain_isolation_on\[3\]$_DFFE_PN1P_ clknet_2_3__leaf_clk
+ _019_ net10 VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfstp_1
Xdomain_reset_n\[0\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _020_
+ net1 VSS VSS VDD VDD net24 sky130_fd_sc_hd__dfrtp_1
Xdomain_reset_n\[1\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _021_
+ net1 VSS VSS VDD VDD net25 sky130_fd_sc_hd__dfrtp_1
Xdomain_reset_n\[2\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _022_
+ net1 VSS VSS VDD VDD net26 sky130_fd_sc_hd__dfrtp_1
Xdomain_reset_n\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _023_
+ net1 VSS VSS VDD VDD net27 sky130_fd_sc_hd__dfrtp_1
Xdomain_transition\[0\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _024_
+ net1 VSS VSS VDD VDD net32 sky130_fd_sc_hd__dfrtp_2
Xdomain_transition\[1\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _025_
+ net1 VSS VSS VDD VDD net33 sky130_fd_sc_hd__dfrtp_2
Xdomain_transition\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _026_
+ net1 VSS VSS VDD VDD net34 sky130_fd_sc_hd__dfrtp_4
Xdomain_transition\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _027_
+ net1 VSS VSS VDD VDD net35 sky130_fd_sc_hd__dfrtp_2
Xstate\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _028_ net1 VSS
+ VSS VDD VDD state\[0\] sky130_fd_sc_hd__dfrtp_1
Xstate\[1\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _029_ net1 VSS
+ VSS VDD VDD state\[1\] sky130_fd_sc_hd__dfrtp_2
Xstate\[2\]$_DFFE_PN0P_ clknet_2_1__leaf_clk _030_ net1 VSS
+ VSS VDD VDD state\[2\] sky130_fd_sc_hd__dfrtp_2
Xtarget_status\[0\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _031_
+ net1 VSS VSS VDD VDD target_status\[0\] sky130_fd_sc_hd__dfrtp_1
Xtarget_status\[1\]$_DFFE_PN0P_ clknet_2_2__leaf_clk _032_
+ net1 VSS VSS VDD VDD target_status\[1\] sky130_fd_sc_hd__dfrtp_1
Xtarget_status\[2\]$_DFFE_PN0P_ clknet_2_0__leaf_clk _033_
+ net1 VSS VSS VDD VDD target_status\[2\] sky130_fd_sc_hd__dfrtp_2
Xtarget_status\[3\]$_DFFE_PN0P_ clknet_2_3__leaf_clk _034_
+ net1 VSS VSS VDD VDD target_status\[3\] sky130_fd_sc_hd__dfrtp_1
Xtransition_done$_DFFE_PN1P_ clknet_2_1__leaf_clk _035_ net10
+ VSS VSS VDD VDD net36 sky130_fd_sc_hd__dfstp_1
Xhold1 net10 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_12
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 domain_enable[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_1
Xinput2 domain_enable[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_1
Xinput3 domain_enable[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_1
Xinput4 domain_enable[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_1
Xinput5 domain_isolate[0] VSS VSS VDD VDD net6 sky130_fd_sc_hd__clkbuf_1
Xinput6 domain_isolate[1] VSS VSS VDD VDD net7 sky130_fd_sc_hd__clkbuf_1
Xinput7 domain_isolate[2] VSS VSS VDD VDD net8 sky130_fd_sc_hd__clkbuf_1
Xinput8 domain_isolate[3] VSS VSS VDD VDD net9 sky130_fd_sc_hd__clkbuf_1
Xinput9 net37 VSS VSS VDD VDD net10 sky130_fd_sc_hd__buf_2
Xinput10 start_transition VSS VSS VDD VDD net11 sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD domain_clock_on[0] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD domain_clock_on[1] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD domain_clock_on[2] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD domain_clock_on[3] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD domain_isolation_on[0] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD domain_isolation_on[1] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD domain_isolation_on[2] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD domain_isolation_on[3] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD domain_power_on[0] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD domain_power_on[1] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD domain_power_on[2] sky130_fd_sc_hd__clkbuf_1
Xoutput22 net23 VSS VSS VDD VDD domain_power_on[3] sky130_fd_sc_hd__clkbuf_1
Xoutput23 net24 VSS VSS VDD VDD domain_reset_n[0] sky130_fd_sc_hd__clkbuf_1
Xoutput24 net25 VSS VSS VDD VDD domain_reset_n[1] sky130_fd_sc_hd__clkbuf_1
Xoutput25 net26 VSS VSS VDD VDD domain_reset_n[2] sky130_fd_sc_hd__clkbuf_1
Xoutput26 net27 VSS VSS VDD VDD domain_reset_n[3] sky130_fd_sc_hd__clkbuf_1
Xoutput27 net28 VSS VSS VDD VDD domain_status[0] sky130_fd_sc_hd__clkbuf_1
Xoutput28 net29 VSS VSS VDD VDD domain_status[1] sky130_fd_sc_hd__clkbuf_1
Xoutput29 net30 VSS VSS VDD VDD domain_status[2] sky130_fd_sc_hd__clkbuf_1
Xoutput30 net31 VSS VSS VDD VDD domain_status[3] sky130_fd_sc_hd__clkbuf_1
Xoutput31 net32 VSS VSS VDD VDD domain_transition[0] sky130_fd_sc_hd__clkbuf_1
Xoutput32 net33 VSS VSS VDD VDD domain_transition[1] sky130_fd_sc_hd__clkbuf_1
Xoutput33 net34 VSS VSS VDD VDD domain_transition[2] sky130_fd_sc_hd__clkbuf_1
Xoutput34 net35 VSS VSS VDD VDD domain_transition[3] sky130_fd_sc_hd__clkbuf_1
Xoutput35 net36 VSS VSS VDD VDD transition_done sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_2__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_2__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkbuf_2_3__f_clk clknet_0_clk VSS VSS VDD VDD clknet_2_3__leaf_clk
+ sky130_fd_sc_hd__clkbuf_4
Xclkload0 clknet_2_0__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_1
Xclkload1 clknet_2_1__leaf_clk VSS VSS VDD VDD _unconnected_1
+ sky130_fd_sc_hd__clkinv_2
Xclkload2 clknet_2_3__leaf_clk VSS VSS VDD VDD _unconnected_2
+ sky130_fd_sc_hd__clkbuf_1
Xhold2 rst_n VSS VSS VDD VDD net37 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS power_domain_controller
