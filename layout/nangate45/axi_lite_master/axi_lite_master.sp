* cell axi_lite_master
* pin awaddr[7]
* pin awaddr[8]
* pin read_data[0]
* pin rdata[0]
* pin wdata[16]
* pin wdata[17]
* pin wdata[18]
* pin write_data[16]
* pin write_data[18]
* pin write_data[1]
* pin wdata[1]
* pin wdata[19]
* pin wdata[24]
* pin write_data[19]
* pin wdata[20]
* pin write_data[17]
* pin write_data[24]
* pin write_data[20]
* pin write_data[21]
* pin wdata[21]
* pin awaddr[9]
* pin wdata[13]
* pin wdata[12]
* pin wdata[15]
* pin write_addr[9]
* pin write_data[15]
* pin write_addr[8]
* pin write_data[12]
* pin write_data[13]
* pin write_data[14]
* pin wdata[14]
* pin rdata[10]
* pin write_addr[7]
* pin read_data[10]
* pin rst_n
* pin write_data[11]
* pin write_data[10]
* pin write_data[0]
* pin wdata[10]
* pin wdata[0]
* pin wdata[11]
* pin rdata[6]
* pin read_done
* pin rdata[7]
* pin read_data[6]
* pin read_data[7]
* pin rdata[15]
* pin rdata[16]
* pin read_data[14]
* pin read_data[15]
* pin rdata[3]
* pin rdata[9]
* pin rdata[8]
* pin rdata[4]
* pin read_data[4]
* pin read_data[8]
* pin read_data[3]
* pin read_data[5]
* pin rdata[27]
* pin rdata[28]
* pin read_data[24]
* pin rdata[31]
* pin read_data[27]
* pin read_data[28]
* pin read_data[9]
* pin read_data[31]
* pin rdata[25]
* pin rdata[2]
* pin rdata[30]
* pin rdata[29]
* pin read_data[16]
* pin read_data[29]
* pin read_data[26]
* pin rdata[26]
* pin read_data[25]
* pin read_data[2]
* pin rdata[5]
* pin rdata[24]
* pin rdata[14]
* pin PWELL
* pin NWELL
* pin read_data[30]
* pin wdata[28]
* pin rdata[11]
* pin rdata[22]
* pin read_data[18]
* pin wdata[22]
* pin rdata[18]
* pin read_data[11]
* pin wdata[2]
* pin write_data[22]
* pin read_data[20]
* pin write_data[28]
* pin wdata[23]
* pin write_data[23]
* pin read_data[23]
* pin rdata[23]
* pin write_data[2]
* pin rdata[20]
* pin wdata[26]
* pin wdata[25]
* pin read_data[22]
* pin wdata[27]
* pin write_data[25]
* pin read_data[17]
* pin read_data[21]
* pin rdata[21]
* pin rdata[1]
* pin wdata[29]
* pin write_data[27]
* pin wdata[4]
* pin write_data[26]
* pin rdata[19]
* pin read_data[19]
* pin read_data[1]
* pin rdata[17]
* pin write_data[29]
* pin write_data[4]
* pin read_addr[11]
* pin write_data[31]
* pin araddr[11]
* pin write_data[3]
* pin write_data[30]
* pin wdata[30]
* pin araddr[12]
* pin read_addr[12]
* pin rready
* pin wdata[31]
* pin araddr[15]
* pin read_data[13]
* pin rvalid
* pin wdata[3]
* pin rdata[13]
* pin read_addr[15]
* pin read_addr[10]
* pin write_strb[0]
* pin araddr[10]
* pin rdata[12]
* pin wstrb[0]
* pin arvalid
* pin read_data[12]
* pin arready
* pin wdata[8]
* pin read_addr[13]
* pin araddr[0]
* pin araddr[16]
* pin write_data[8]
* pin write_data[9]
* pin wdata[9]
* pin read_addr[0]
* pin read_addr[16]
* pin clk
* pin write_addr[5]
* pin araddr[13]
* pin write_addr[6]
* pin read_addr[17]
* pin write_data[6]
* pin araddr[17]
* pin wdata[7]
* pin write_data[7]
* pin read_addr[14]
* pin wvalid
* pin write_addr[30]
* pin araddr[14]
* pin read_req
* pin write_strb[2]
* pin wstrb[2]
* pin wready
* pin bready
* pin write_addr[2]
* pin awaddr[2]
* pin read_addr[4]
* pin bvalid
* pin write_addr[27]
* pin awaddr[4]
* pin write_addr[4]
* pin araddr[6]
* pin araddr[3]
* pin araddr[4]
* pin write_req
* pin awaddr[3]
* pin read_addr[3]
* pin write_addr[3]
* pin araddr[29]
* pin write_addr[29]
* pin awaddr[29]
* pin awaddr[26]
* pin read_addr[29]
* pin read_addr[27]
* pin read_addr[6]
* pin write_addr[26]
* pin write_addr[25]
* pin read_addr[30]
* pin araddr[27]
* pin awaddr[28]
* pin write_addr[28]
* pin awaddr[27]
* pin read_addr[31]
* pin araddr[31]
* pin read_addr[28]
* pin wdata[5]
* pin awaddr[30]
* pin write_data[5]
* pin read_addr[5]
* pin araddr[30]
* pin read_addr[2]
* pin wdata[6]
* pin awaddr[6]
* pin araddr[2]
* pin araddr[5]
* pin awaddr[5]
* pin awaddr[25]
* pin awaddr[19]
* pin araddr[28]
* pin write_addr[31]
* pin write_addr[18]
* pin awaddr[18]
* pin awaddr[12]
* pin awaddr[20]
* pin write_addr[20]
* pin read_addr[9]
* pin awaddr[1]
* pin write_addr[1]
* pin write_addr[19]
* pin write_addr[21]
* pin write_addr[13]
* pin awvalid
* pin write_strb[3]
* pin awready
* pin write_addr[14]
* pin awaddr[16]
* pin write_addr[17]
* pin wstrb[3]
* pin awaddr[22]
* pin awaddr[23]
* pin write_addr[22]
* pin write_addr[23]
* pin write_addr[24]
* pin awaddr[21]
* pin awaddr[24]
* pin awaddr[31]
* pin write_addr[16]
* pin awaddr[17]
* pin awaddr[15]
* pin write_addr[12]
* pin write_addr[0]
* pin write_strb[1]
* pin wstrb[1]
* pin write_addr[15]
* pin awaddr[13]
* pin awaddr[0]
* pin awaddr[14]
* pin write_done
* pin write_addr[11]
* pin write_addr[10]
* pin read_addr[7]
* pin read_addr[8]
* pin awaddr[10]
* pin araddr[9]
* pin araddr[8]
* pin awaddr[11]
* pin araddr[7]
* pin read_addr[26]
* pin read_addr[23]
* pin araddr[26]
* pin araddr[23]
* pin araddr[21]
* pin read_addr[21]
* pin araddr[24]
* pin read_addr[24]
* pin read_addr[20]
* pin read_addr[25]
* pin read_addr[22]
* pin araddr[25]
* pin araddr[22]
* pin read_addr[1]
* pin read_addr[19]
* pin read_addr[18]
* pin araddr[19]
* pin araddr[1]
* pin araddr[20]
* pin araddr[18]
.SUBCKT axi_lite_master 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21
+ 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47
+ 48 49 50 51 52 53 54 55 56 57 58 59 60 61 62 63 64 65 66 67 68 69 70 71 72 73
+ 74 75 76 77 78 79 116 144 194 200 201 217 218 222 223 230 242 243 262 263 273
+ 274 288 289 290 291 292 302 309 312 313 321 322 323 324 332 338 339 340 347
+ 348 349 362 364 365 366 372 375 378 379 380 389 390 391 392 395 397 402 413
+ 414 426 427 428 429 435 438 439 440 453 463 472 473 475 481 495 496 503 504
+ 509 516 520 523 527 529 534 540 541 548 549 558 565 570 571 572 582 583 585
+ 586 595 596 606 607 608 618 619 620 624 628 640 648 655 659 660 661 672 673
+ 674 686 687 692 693 699 700 701 714 715 716 727 728 729 746 747 748 765 766
+ 773 774 783 784 785 794 808 821 823 834 836 837 839 841 842 843 844 849 851
+ 866 868 869 890 891 892 893 894 895 896 897 898 899 900 901 902 903 904 905
+ 906 907 908 910 911 912 913 914 915 916 917 918 919 920 922 923 924 925 926
+ 927 928 929 930 931 932 933 934 935 936 937 938 939 940 941 942 943
* net 1 awaddr[7]
* net 2 awaddr[8]
* net 3 read_data[0]
* net 4 rdata[0]
* net 5 wdata[16]
* net 6 wdata[17]
* net 7 wdata[18]
* net 8 write_data[16]
* net 9 write_data[18]
* net 10 write_data[1]
* net 11 wdata[1]
* net 12 wdata[19]
* net 13 wdata[24]
* net 14 write_data[19]
* net 15 wdata[20]
* net 16 write_data[17]
* net 17 write_data[24]
* net 18 write_data[20]
* net 19 write_data[21]
* net 20 wdata[21]
* net 21 awaddr[9]
* net 22 wdata[13]
* net 23 wdata[12]
* net 24 wdata[15]
* net 25 write_addr[9]
* net 26 write_data[15]
* net 27 write_addr[8]
* net 28 write_data[12]
* net 29 write_data[13]
* net 30 write_data[14]
* net 31 wdata[14]
* net 32 rdata[10]
* net 33 write_addr[7]
* net 34 read_data[10]
* net 35 rst_n
* net 36 write_data[11]
* net 37 write_data[10]
* net 38 write_data[0]
* net 39 wdata[10]
* net 40 wdata[0]
* net 41 wdata[11]
* net 42 rdata[6]
* net 43 read_done
* net 44 rdata[7]
* net 45 read_data[6]
* net 46 read_data[7]
* net 47 rdata[15]
* net 48 rdata[16]
* net 49 read_data[14]
* net 50 read_data[15]
* net 51 rdata[3]
* net 52 rdata[9]
* net 53 rdata[8]
* net 54 rdata[4]
* net 55 read_data[4]
* net 56 read_data[8]
* net 57 read_data[3]
* net 58 read_data[5]
* net 59 rdata[27]
* net 60 rdata[28]
* net 61 read_data[24]
* net 62 rdata[31]
* net 63 read_data[27]
* net 64 read_data[28]
* net 65 read_data[9]
* net 66 read_data[31]
* net 67 rdata[25]
* net 68 rdata[2]
* net 69 rdata[30]
* net 70 rdata[29]
* net 71 read_data[16]
* net 72 read_data[29]
* net 73 read_data[26]
* net 74 rdata[26]
* net 75 read_data[25]
* net 76 read_data[2]
* net 77 rdata[5]
* net 78 rdata[24]
* net 79 rdata[14]
* net 116 PWELL
* net 144 NWELL
* net 194 read_data[30]
* net 200 wdata[28]
* net 201 rdata[11]
* net 217 rdata[22]
* net 218 read_data[18]
* net 222 wdata[22]
* net 223 rdata[18]
* net 230 read_data[11]
* net 242 wdata[2]
* net 243 write_data[22]
* net 262 read_data[20]
* net 263 write_data[28]
* net 273 wdata[23]
* net 274 write_data[23]
* net 288 read_data[23]
* net 289 rdata[23]
* net 290 write_data[2]
* net 291 rdata[20]
* net 292 wdata[26]
* net 302 wdata[25]
* net 309 read_data[22]
* net 312 wdata[27]
* net 313 write_data[25]
* net 321 read_data[17]
* net 322 read_data[21]
* net 323 rdata[21]
* net 324 rdata[1]
* net 332 wdata[29]
* net 338 write_data[27]
* net 339 wdata[4]
* net 340 write_data[26]
* net 347 rdata[19]
* net 348 read_data[19]
* net 349 read_data[1]
* net 362 rdata[17]
* net 364 write_data[29]
* net 365 write_data[4]
* net 366 read_addr[11]
* net 372 write_data[31]
* net 375 araddr[11]
* net 378 write_data[3]
* net 379 write_data[30]
* net 380 wdata[30]
* net 389 araddr[12]
* net 390 read_addr[12]
* net 391 rready
* net 392 wdata[31]
* net 395 araddr[15]
* net 397 read_data[13]
* net 402 rvalid
* net 413 wdata[3]
* net 414 rdata[13]
* net 426 read_addr[15]
* net 427 read_addr[10]
* net 428 write_strb[0]
* net 429 araddr[10]
* net 435 rdata[12]
* net 438 wstrb[0]
* net 439 arvalid
* net 440 read_data[12]
* net 453 arready
* net 463 wdata[8]
* net 472 read_addr[13]
* net 473 araddr[0]
* net 475 araddr[16]
* net 481 write_data[8]
* net 495 write_data[9]
* net 496 wdata[9]
* net 503 read_addr[0]
* net 504 read_addr[16]
* net 509 clk
* net 516 write_addr[5]
* net 520 araddr[13]
* net 523 write_addr[6]
* net 527 read_addr[17]
* net 529 write_data[6]
* net 534 araddr[17]
* net 540 wdata[7]
* net 541 write_data[7]
* net 548 read_addr[14]
* net 549 wvalid
* net 558 write_addr[30]
* net 565 araddr[14]
* net 570 read_req
* net 571 write_strb[2]
* net 572 wstrb[2]
* net 582 wready
* net 583 bready
* net 585 write_addr[2]
* net 586 awaddr[2]
* net 595 read_addr[4]
* net 596 bvalid
* net 606 write_addr[27]
* net 607 awaddr[4]
* net 608 write_addr[4]
* net 618 araddr[6]
* net 619 araddr[3]
* net 620 araddr[4]
* net 624 write_req
* net 628 awaddr[3]
* net 640 read_addr[3]
* net 648 write_addr[3]
* net 655 araddr[29]
* net 659 write_addr[29]
* net 660 awaddr[29]
* net 661 awaddr[26]
* net 672 read_addr[29]
* net 673 read_addr[27]
* net 674 read_addr[6]
* net 686 write_addr[26]
* net 687 write_addr[25]
* net 692 read_addr[30]
* net 693 araddr[27]
* net 699 awaddr[28]
* net 700 write_addr[28]
* net 701 awaddr[27]
* net 714 read_addr[31]
* net 715 araddr[31]
* net 716 read_addr[28]
* net 727 wdata[5]
* net 728 awaddr[30]
* net 729 write_data[5]
* net 746 read_addr[5]
* net 747 araddr[30]
* net 748 read_addr[2]
* net 765 wdata[6]
* net 766 awaddr[6]
* net 773 araddr[2]
* net 774 araddr[5]
* net 783 awaddr[5]
* net 784 awaddr[25]
* net 785 awaddr[19]
* net 794 araddr[28]
* net 808 write_addr[31]
* net 821 write_addr[18]
* net 823 awaddr[18]
* net 834 awaddr[12]
* net 836 awaddr[20]
* net 837 write_addr[20]
* net 839 read_addr[9]
* net 841 awaddr[1]
* net 842 write_addr[1]
* net 843 write_addr[19]
* net 844 write_addr[21]
* net 849 write_addr[13]
* net 851 awvalid
* net 866 write_strb[3]
* net 868 awready
* net 869 write_addr[14]
* net 890 awaddr[16]
* net 891 write_addr[17]
* net 892 wstrb[3]
* net 893 awaddr[22]
* net 894 awaddr[23]
* net 895 write_addr[22]
* net 896 write_addr[23]
* net 897 write_addr[24]
* net 898 awaddr[21]
* net 899 awaddr[24]
* net 900 awaddr[31]
* net 901 write_addr[16]
* net 902 awaddr[17]
* net 903 awaddr[15]
* net 904 write_addr[12]
* net 905 write_addr[0]
* net 906 write_strb[1]
* net 907 wstrb[1]
* net 908 write_addr[15]
* net 910 awaddr[13]
* net 911 awaddr[0]
* net 912 awaddr[14]
* net 913 write_done
* net 914 write_addr[11]
* net 915 write_addr[10]
* net 916 read_addr[7]
* net 917 read_addr[8]
* net 918 awaddr[10]
* net 919 araddr[9]
* net 920 araddr[8]
* net 922 awaddr[11]
* net 923 araddr[7]
* net 924 read_addr[26]
* net 925 read_addr[23]
* net 926 araddr[26]
* net 927 araddr[23]
* net 928 araddr[21]
* net 929 read_addr[21]
* net 930 araddr[24]
* net 931 read_addr[24]
* net 932 read_addr[20]
* net 933 read_addr[25]
* net 934 read_addr[22]
* net 935 araddr[25]
* net 936 araddr[22]
* net 937 read_addr[1]
* net 938 read_addr[19]
* net 939 read_addr[18]
* net 940 araddr[19]
* net 941 araddr[1]
* net 942 araddr[20]
* net 943 araddr[18]
* cell instance $4 m0 *1 6.08,7
X$4 206 116 144 1 BUF_X1
* cell instance $8 r0 *1 2.66,4.2
X$8 162 116 144 2 BUF_X1
* cell instance $14 m0 *1 5.32,7
X$14 221 116 144 3 BUF_X1
* cell instance $21 r0 *1 3.8,4.2
X$21 4 116 144 220 BUF_X1
* cell instance $26 r0 *1 3.23,4.2
X$26 151 116 144 5 BUF_X1
* cell instance $32 m0 *1 7.98,7
X$32 124 116 144 6 BUF_X1
* cell instance $38 r0 *1 6.27,1.4
X$38 83 116 144 7 BUF_X1
* cell instance $45 r0 *1 6.27,4.2
X$45 8 116 144 164 BUF_X1
* cell instance $50 r0 *1 5.7,4.2
X$50 9 116 144 82 BUF_X1
* cell instance $57 r0 *1 6.84,4.2
X$57 10 116 144 165 BUF_X1
* cell instance $62 m0 *1 7.41,7
X$62 84 116 144 11 BUF_X1
* cell instance $68 m0 *1 8.55,7
X$68 196 116 144 12 BUF_X1
* cell instance $74 r0 *1 9.69,7
X$74 234 116 144 13 BUF_X1
* cell instance $80 m0 *1 9.12,7
X$80 14 116 144 123 BUF_X1
* cell instance $86 m0 *1 10.26,7
X$86 125 116 144 15 BUF_X1
* cell instance $93 m0 *1 9.69,7
X$93 16 116 144 153 BUF_X1
* cell instance $98 m0 *1 11.59,7
X$98 17 116 144 187 BUF_X1
* cell instance $105 m0 *1 12.16,7
X$105 18 116 144 167 BUF_X1
* cell instance $110 m0 *1 12.73,7
X$110 19 116 144 204 BUF_X1
* cell instance $116 m0 *1 13.3,7
X$116 205 116 144 20 BUF_X1
* cell instance $122 m0 *1 13.87,7
X$122 251 116 144 21 BUF_X1
* cell instance $128 r0 *1 15.77,4.2
X$128 89 116 144 22 BUF_X1
* cell instance $134 m0 *1 18.24,7
X$134 189 116 144 23 BUF_X1
* cell instance $140 r0 *1 15.2,4.2
X$140 155 116 144 24 BUF_X1
* cell instance $147 r0 *1 12.92,1.4
X$147 25 116 144 199 BUF_X1
* cell instance $153 r0 *1 13.68,1.4
X$153 26 116 144 170 BUF_X1
* cell instance $158 m0 *1 17.67,7
X$158 27 116 144 188 BUF_X1
* cell instance $165 r0 *1 18.24,4.2
X$165 28 116 144 128 BUF_X1
* cell instance $171 r0 *1 15.01,1.4
X$171 29 116 144 87 BUF_X1
* cell instance $176 r0 *1 16.91,1.4
X$176 30 116 144 90 BUF_X1
* cell instance $181 r0 *1 19.76,1.4
X$181 92 116 144 31 BUF_X1
* cell instance $189 m0 *1 20.33,7
X$189 32 116 144 191 BUF_X1
* cell instance $194 m0 *1 19.76,7
X$194 33 116 144 241 BUF_X1
* cell instance $200 r0 *1 20.71,1.4
X$200 93 116 144 34 BUF_X1
* cell instance $207 r0 *1 21.28,1.4
X$207 35 116 144 190 BUF_X2
* cell instance $212 r0 *1 22.04,1.4
X$212 36 116 144 94 BUF_X1
* cell instance $218 r0 *1 22.8,1.4
X$218 37 116 144 177 BUF_X1
* cell instance $224 r0 *1 23.37,1.4
X$224 38 116 144 130 BUF_X1
* cell instance $230 r0 *1 23.94,1.4
X$230 95 116 144 39 BUF_X1
* cell instance $236 r0 *1 24.51,1.4
X$236 96 116 144 40 BUF_X1
* cell instance $242 r0 *1 25.08,1.4
X$242 97 116 144 41 BUF_X1
* cell instance $248 r0 *1 25.65,1.4
X$248 42 116 144 98 BUF_X1
* cell instance $254 r0 *1 26.22,1.4
X$254 119 116 144 43 BUF_X1
* cell instance $261 r0 *1 28.69,1.4
X$261 44 116 144 134 BUF_X1
* cell instance $266 r0 *1 28.12,1.4
X$266 99 116 144 45 BUF_X1
* cell instance $272 r0 *1 29.26,1.4
X$272 121 116 144 46 BUF_X1
* cell instance $278 m0 *1 28.5,4.2
X$278 47 116 144 255 BUF_X1
* cell instance $285 r0 *1 30.4,1.4
X$285 48 116 144 150 BUF_X1
* cell instance $290 r0 *1 31.16,1.4
X$290 100 116 144 49 BUF_X1
* cell instance $296 r0 *1 29.83,1.4
X$296 256 116 144 50 BUF_X1
* cell instance $302 r0 *1 33.25,7
X$302 51 116 144 270 BUF_X1
* cell instance $308 m0 *1 31.54,7
X$308 52 116 144 101 BUF_X1
* cell instance $315 r0 *1 32.11,4.2
X$315 53 116 144 182 BUF_X1
* cell instance $321 m0 *1 32.11,7
X$321 54 116 144 207 BUF_X1
* cell instance $328 m0 *1 32.68,7
X$328 208 116 144 55 BUF_X1
* cell instance $332 r0 *1 33.25,1.4
X$332 135 116 144 56 BUF_X1
* cell instance $338 r0 *1 34.58,1.4
X$338 102 116 144 57 BUF_X1
* cell instance $344 r0 *1 35.15,1.4
X$344 103 116 144 58 BUF_X1
* cell instance $350 r0 *1 37.62,1.4
X$350 59 116 144 140 BUF_X1
* cell instance $356 r0 *1 35.72,1.4
X$356 60 116 144 104 BUF_X1
* cell instance $362 r0 *1 38.57,7
X$362 268 116 144 61 BUF_X1
* cell instance $369 r0 *1 38.19,4.2
X$369 62 116 144 141 BUF_X1
* cell instance $374 m0 *1 37.62,7
X$374 210 116 144 63 BUF_X1
* cell instance $380 r0 *1 37.62,4.2
X$380 107 116 144 64 BUF_X1
* cell instance $386 r0 *1 36.86,4.2
X$386 122 116 144 65 BUF_X1
* cell instance $392 r0 *1 38.76,4.2
X$392 108 116 144 66 BUF_X1
* cell instance $398 m0 *1 39.52,7
X$398 67 116 144 211 BUF_X1
* cell instance $404 r0 *1 41.23,1.4
X$404 68 116 144 143 BUF_X1
* cell instance $414 r0 *1 42.37,1.4
X$414 69 116 144 109 BUF_X1
* cell instance $417 r0 *1 42.94,1.4
X$417 70 116 144 110 BUF_X1
* cell instance $422 r0 *1 41.8,1.4
X$422 305 116 144 71 BUF_X1
* cell instance $428 r0 *1 44.84,1.4
X$428 111 116 144 72 BUF_X1
* cell instance $434 m0 *1 46.74,7
X$434 163 116 144 73 BUF_X1
* cell instance $441 r0 *1 45.79,1.4
X$441 74 116 144 112 BUF_X1
* cell instance $446 r0 *1 43.7,7
X$446 212 116 144 75 BUF_X1
* cell instance $452 r0 *1 43.7,4.2
X$452 158 116 144 76 BUF_X1
* cell instance $459 r0 *1 44.46,4.2
X$459 77 116 144 117 BUF_X1
* cell instance $465 r0 *1 45.22,7
X$465 78 116 144 237 BUF_X1
* cell instance $471 m0 *1 46.17,7
X$471 79 116 144 195 BUF_X1
* cell instance $476 r0 *1 9.31,15.4
X$476 318 116 144 80 CLKBUF_X3
* cell instance $486 r0 *1 1.71,7
X$486 116 1030 202 240 80 144 DFF_X1
* cell instance $488 m0 *1 8.17,9.8
X$488 116 963 247 269 80 144 DFF_X1
* cell instance $491 m0 *1 4.75,9.8
X$491 116 964 221 267 80 144 DFF_X1
* cell instance $494 m0 *1 2.47,12.6
X$494 116 972 231 278 80 144 DFF_X1
* cell instance $496 r0 *1 10.64,4.2
X$496 116 1078 124 198 80 144 DFF_X1
* cell instance $499 m0 *1 12.54,18.2
X$499 80 116 144 CLKBUF_X1
* cell instance $501 r0 *1 1.71,1.4
X$501 116 1033 83 115 80 144 DFF_X1
* cell instance $503 m0 *1 1.33,4.2
X$503 116 968 151 161 80 144 DFF_X1
* cell instance $505 r0 *1 1.33,15.4
X$505 116 1068 275 350 80 144 DFF_X1
* cell instance $507 r0 *1 7.79,12.6
X$507 116 1077 246 333 80 144 DFF_X1
* cell instance $510 r0 *1 4.37,12.6
X$510 116 1074 232 330 80 144 DFF_X1
* cell instance $513 m0 *1 6.27,4.2
X$513 116 965 84 148 80 144 DFF_X1
* cell instance $516 r0 *1 7.41,4.2
X$516 116 1035 196 166 80 144 DFF_X1
* cell instance $519 r0 *1 6.08,9.8
X$519 264 81 247 116 144 295 MUX2_X1
* cell instance $521 m0 *1 6.08,12.6
X$521 293 81 246 116 144 280 MUX2_X1
* cell instance $523 m0 *1 11.4,9.8
X$523 187 81 234 116 144 249 MUX2_X1
* cell instance $525 m0 *1 10.26,4.2
X$525 153 81 124 116 144 154 MUX2_X1
* cell instance $528 r0 *1 4.37,4.2
X$528 164 81 151 116 144 152 MUX2_X1
* cell instance $540 m0 *1 11.97,15.4
X$540 317 116 144 81 CLKBUF_X3
* cell instance $542 r0 *1 4.94,1.4
X$542 82 81 83 116 144 147 MUX2_X1
* cell instance $544 r0 *1 12.35,7
X$544 204 81 205 116 144 250 MUX2_X1
* cell instance $547 r0 *1 10.45,1.4
X$547 167 81 125 116 144 86 MUX2_X1
* cell instance $549 r0 *1 7.03,1.4
X$549 165 81 84 116 144 118 MUX2_X1
* cell instance $551 r0 *1 9.12,1.4
X$551 123 81 196 116 144 149 MUX2_X1
* cell instance $575 m0 *1 9.5,4.2
X$575 85 149 144 116 166 AND2_X1
* cell instance $578 m0 *1 10.83,7
X$578 85 154 144 116 198 AND2_X1
* cell instance $580 m0 *1 4.56,4.2
X$580 85 147 144 116 115 AND2_X1
* cell instance $583 m0 *1 5.51,4.2
X$583 85 152 144 116 161 AND2_X1
* cell instance $586 r0 *1 14.25,1.4
X$586 85 169 144 116 126 AND2_X1
* cell instance $589 r0 *1 16.72,4.2
X$589 85 172 144 116 224 AND2_X1
* cell instance $591 r0 *1 17.48,4.2
X$591 85 127 144 116 174 AND2_X1
* cell instance $593 r0 *1 19,1.4
X$593 85 91 144 116 129 AND2_X1
* cell instance $595 r0 *1 11.78,1.4
X$595 85 86 144 116 168 AND2_X1
* cell instance $598 r0 *1 8.36,1.4
X$598 85 118 144 116 148 AND2_X1
* cell instance $601 m0 *1 18.81,7
X$601 190 116 144 85 CLKBUF_X2
* cell instance $606 r0 *1 15.58,1.4
X$606 87 88 89 116 144 127 MUX2_X1
* cell instance $608 m0 *1 16.34,12.6
X$608 188 88 162 116 144 311 MUX2_X1
* cell instance $610 r0 *1 13.87,4.2
X$610 170 88 155 116 144 169 MUX2_X1
* cell instance $612 r0 *1 17.67,1.4
X$612 90 88 92 116 144 91 MUX2_X1
* cell instance $619 m0 *1 18.24,15.4
X$619 317 116 144 88 CLKBUF_X3
* cell instance $621 m0 *1 23.56,7
X$621 130 88 96 116 144 197 MUX2_X1
* cell instance $623 m0 *1 18.05,4.2
X$623 128 88 189 116 144 172 MUX2_X1
* cell instance $626 m0 *1 22.99,4.2
X$626 177 88 95 116 144 131 MUX2_X1
* cell instance $629 m0 *1 14.06,9.8
X$629 199 88 251 116 144 252 MUX2_X1
* cell instance $631 r0 *1 17.29,9.8
X$631 241 88 206 116 144 282 MUX2_X1
* cell instance $635 r0 *1 22.99,9.8
X$635 94 88 97 116 144 283 MUX2_X1
* cell instance $639 r0 *1 18.81,4.2
X$639 116 1041 89 174 175 144 DFF_X1
* cell instance $652 m0 *1 19.38,4.2
X$652 116 977 92 129 175 144 DFF_X1
* cell instance $658 r0 *1 20.71,7
X$658 191 203 93 116 144 226 MUX2_X1
* cell instance $661 r0 *1 18.62,9.8
X$661 116 1043 93 254 171 144 DFF_X1
* cell instance $670 r0 *1 22.23,4.2
X$670 116 1091 95 176 175 144 DFF_X1
* cell instance $676 m0 *1 22.99,9.8
X$676 116 1004 96 227 175 144 DFF_X1
* cell instance $684 m0 *1 22.8,12.6
X$684 116 1005 97 299 175 144 DFF_X1
* cell instance $689 r0 *1 26.79,1.4
X$689 98 133 99 116 144 179 MUX2_X1
* cell instance $693 m0 *1 25.27,4.2
X$693 116 991 99 132 156 144 DFF_X1
* cell instance $695 m0 *1 30.21,12.6
X$695 195 203 100 116 144 335 MUX2_X1
* cell instance $697 r0 *1 27.17,12.6
X$697 116 1031 100 336 304 144 DFF_X1
* cell instance $703 r0 *1 31.92,1.4
X$703 101 133 122 116 144 137 MUX2_X1
* cell instance $707 m0 *1 33.44,9.8
X$707 270 106 102 116 144 271 MUX2_X1
* cell instance $709 m0 *1 31.73,12.6
X$709 116 986 102 301 156 144 DFF_X1
* cell instance $712 m0 *1 32.3,4.2
X$712 116 997 103 183 156 144 DFF_X1
* cell instance $716 r0 *1 39.9,1.4
X$716 117 106 103 116 144 120 MUX2_X1
* cell instance $720 r0 *1 36.29,1.4
X$720 104 106 107 116 144 105 MUX2_X1
* cell instance $722 r0 *1 36.1,4.2
X$722 113 105 144 116 229 AND2_X1
* cell instance $725 r0 *1 34.77,7
X$725 133 116 144 106 CLKBUF_X3
* cell instance $728 m0 *1 40.85,4.2
X$728 143 106 158 116 144 173 MUX2_X1
* cell instance $730 m0 *1 44.08,7
X$730 109 106 219 116 144 213 MUX2_X1
* cell instance $741 r0 *1 38.57,1.4
X$741 141 106 108 116 144 142 MUX2_X1
* cell instance $746 r0 *1 31.92,7
X$746 207 106 208 116 144 209 MUX2_X1
* cell instance $748 r0 *1 37.24,7
X$748 140 106 210 116 144 228 MUX2_X1
* cell instance $750 r0 *1 46.36,1.4
X$750 112 106 163 116 144 114 MUX2_X1
* cell instance $753 r0 *1 43.51,1.4
X$753 110 106 111 116 144 146 MUX2_X1
* cell instance $758 m0 *1 34.39,7
X$758 116 979 107 229 156 144 DFF_X1
* cell instance $762 m0 *1 35.72,4.2
X$762 116 984 108 178 139 144 DFF_X1
* cell instance $774 m0 *1 42.18,4.2
X$774 116 1007 111 159 139 144 DFF_X1
* cell instance $787 r0 *1 47.69,1.4
X$787 113 114 144 116 145 AND2_X1
* cell instance $789 r0 *1 39.14,7
X$789 113 225 144 116 236 AND2_X1
* cell instance $791 r0 *1 38.57,9.8
X$791 113 259 144 116 284 AND2_X1
* cell instance $793 r0 *1 40.66,9.8
X$793 113 266 144 116 298 AND2_X1
* cell instance $795 r0 *1 42.56,4.2
X$795 113 146 144 116 159 AND2_X1
* cell instance $797 m0 *1 40.09,4.2
X$797 113 173 144 116 157 AND2_X1
* cell instance $800 m0 *1 39.14,4.2
X$800 113 142 144 116 178 AND2_X1
* cell instance $805 m0 *1 34.77,9.8
X$805 190 116 144 113 CLKBUF_X2
* cell instance $807 m0 *1 35.53,9.8
X$807 113 228 144 116 258 AND2_X1
* cell instance $809 m0 *1 45.41,7
X$809 113 213 144 116 160 AND2_X1
* cell instance $819 m0 *1 5.13,46.2
X$819 116 953 873 811 644 144 DFF_X1
* cell instance $820 m0 *1 8.36,46.2
X$820 812 116 144 836 BUF_X1
* cell instance $821 m0 *1 8.93,46.2
X$821 813 116 144 834 BUF_X1
* cell instance $822 m0 *1 9.5,46.2
X$822 116 960 815 840 644 144 DFF_X1
* cell instance $823 m0 *1 12.73,46.2
X$823 815 116 144 841 BUF_X1
* cell instance $826 r0 *1 1.33,46.2
X$826 116 1085 854 853 644 144 DFF_X1
* cell instance $830 r0 *1 4.56,46.2
X$830 871 705 873 116 144 835 MUX2_X1
* cell instance $831 r0 *1 5.89,46.2
X$831 116 1087 812 872 644 144 DFF_X1
* cell instance $832 r0 *1 9.12,46.2
X$832 116 1086 799 874 644 144 DFF_X1
* cell instance $833 r0 *1 12.35,46.2
X$833 814 705 815 116 144 883 MUX2_X1
* cell instance $834 m0 *1 14.25,46.2
X$834 844 116 144 824 BUF_X1
* cell instance $835 m0 *1 13.68,46.2
X$835 843 116 144 825 BUF_X1
* cell instance $837 m0 *1 15.01,46.2
X$837 753 846 144 116 845 AND2_X1
* cell instance $838 m0 *1 15.77,46.2
X$838 116 956 847 845 680 144 DFF_X1
* cell instance $839 m0 *1 19,46.2
X$839 116 955 813 848 680 144 DFF_X1
* cell instance $841 m0 *1 22.42,46.2
X$841 116 1002 870 850 630 144 DFF_X1
* cell instance $842 m0 *1 25.65,46.2
X$842 689 818 144 116 817 AND2_X1
* cell instance $845 r0 *1 13.68,46.2
X$845 865 666 801 116 144 816 MUX2_X1
* cell instance $846 r0 *1 15.01,46.2
X$846 875 666 847 116 144 846 MUX2_X1
* cell instance $847 r0 *1 16.34,46.2
X$847 866 116 144 707 BUF_X1
* cell instance $849 r0 *1 17.1,46.2
X$849 887 666 813 116 144 948 MUX2_X1
* cell instance $851 r0 *1 18.62,46.2
X$851 116 1079 886 888 680 144 DFF_X1
* cell instance $852 r0 *1 21.85,46.2
X$852 869 116 144 826 BUF_X1
* cell instance $854 r0 *1 22.61,46.2
X$854 826 666 870 116 144 876 MUX2_X1
* cell instance $857 r0 *1 24.51,46.2
X$857 116 1064 885 817 711 144 DFF_X1
* cell instance $858 r0 *1 27.74,46.2
X$858 116 1054 855 852 711 144 DFF_X1
* cell instance $859 m0 *1 28.5,46.2
X$859 689 827 144 116 852 AND2_X1
* cell instance $862 m0 *1 30.02,46.2
X$862 634 116 144 851 BUF_X1
* cell instance $863 m0 *1 30.59,46.2
X$863 116 1026 829 828 711 144 DFF_X1
* cell instance $864 m0 *1 33.82,46.2
X$864 116 1023 863 822 711 144 DFF_X1
* cell instance $865 m0 *1 37.05,46.2
X$865 116 994 831 830 652 144 DFF_X1
* cell instance $866 m0 *1 40.28,46.2
X$866 691 832 144 116 804 AND2_X1
* cell instance $867 m0 *1 41.04,46.2
X$867 839 116 144 795 BUF_X1
* cell instance $871 m0 *1 46.36,46.2
X$871 748 116 144 745 BUF_X1
* cell instance $873 r0 *1 30.97,46.2
X$873 868 116 144 668 BUF_X1
* cell instance $874 r0 *1 31.54,46.2
X$874 691 867 144 116 828 AND2_X1
* cell instance $875 r0 *1 32.3,46.2
X$875 856 770 829 116 144 867 MUX2_X1
* cell instance $876 r0 *1 33.63,46.2
X$876 882 770 802 116 144 803 MUX2_X1
* cell instance $877 r0 *1 34.96,46.2
X$877 864 770 863 116 144 806 MUX2_X1
* cell instance $878 r0 *1 36.29,46.2
X$878 881 770 831 116 144 857 MUX2_X1
* cell instance $879 r0 *1 37.62,46.2
X$879 691 857 144 116 830 AND2_X1
* cell instance $881 r0 *1 38.76,46.2
X$881 880 770 862 116 144 832 MUX2_X1
* cell instance $882 r0 *1 40.09,46.2
X$882 858 770 859 116 144 833 MUX2_X1
* cell instance $883 r0 *1 41.42,46.2
X$883 691 833 144 116 861 AND2_X1
* cell instance $885 r0 *1 42.37,46.2
X$885 116 1057 859 861 652 144 DFF_X1
* cell instance $886 r0 *1 45.6,46.2
X$886 116 1056 878 860 652 144 DFF_X1
* cell instance $887 m0 *1 47.88,46.2
X$887 713 116 144 773 BUF_X1
* cell instance $888 m0 *1 47.31,46.2
X$888 719 116 144 747 BUF_X1
* cell instance $889 m0 *1 48.45,46.2
X$889 749 116 144 794 BUF_X1
* cell instance $894 m0 *1 46.74,49
X$894 878 116 144 943 BUF_X1
* cell instance $898 m0 *1 27.93,29.4
X$898 493 116 144 458 INV_X1
* cell instance $900 r0 *1 27.93,29.4
X$900 493 466 116 144 566 NAND2_X2
* cell instance $902 r0 *1 29.64,29.4
X$902 514 513 467 400 144 576 116 NOR4_X2
* cell instance $903 m0 *1 30.4,29.4
X$903 522 144 400 116 BUF_X4
* cell instance $907 m0 *1 32.11,29.4
X$907 501 116 144 525 INV_X1
* cell instance $908 m0 *1 32.49,29.4
X$908 400 513 467 493 116 144 557 NOR4_X1
* cell instance $909 m0 *1 33.44,29.4
X$909 501 493 539 514 116 144 488 OR4_X1
* cell instance $910 m0 *1 34.58,29.4
X$910 562 538 478 525 556 116 144 536 AOI221_X1
* cell instance $911 m0 *1 35.72,29.4
X$911 531 116 144 538 INV_X1
* cell instance $915 r0 *1 32.3,29.4
X$915 501 561 514 563 116 144 569 AOI22_X1
* cell instance $916 r0 *1 33.25,29.4
X$916 577 584 557 561 525 144 116 562 OAI221_X1
* cell instance $917 r0 *1 34.39,29.4
X$917 526 514 563 116 556 144 AOI21_X1
* cell instance $920 r0 *1 35.72,29.4
X$920 531 564 144 116 584 AND2_X1
* cell instance $921 r0 *1 36.48,29.4
X$921 564 531 116 144 563 NAND2_X1
* cell instance $924 m0 *1 37.24,29.4
X$924 116 995 531 536 489 144 DFF_X1
* cell instance $926 m0 *1 43.7,29.4
X$926 424 535 144 116 546 AND2_X1
* cell instance $927 m0 *1 44.46,29.4
X$927 116 1015 532 528 489 144 DFF_X1
* cell instance $928 m0 *1 47.69,29.4
X$928 547 407 533 116 144 535 MUX2_X1
* cell instance $932 r0 *1 38.38,29.4
X$932 566 116 144 407 CLKBUF_X3
* cell instance $934 r0 *1 42.37,29.4
X$934 531 116 144 549 BUF_X1
* cell instance $936 r0 *1 43.32,29.4
X$936 116 1050 533 546 489 144 DFF_X1
* cell instance $937 r0 *1 46.55,29.4
X$937 581 407 532 116 144 555 MUX2_X1
* cell instance $938 r0 *1 47.88,29.4
X$938 527 116 144 547 BUF_X1
* cell instance $939 r0 *1 48.45,29.4
X$939 502 116 144 520 BUF_X1
* cell instance $942 m0 *1 2.85,18.2
X$942 364 116 144 370 BUF_X1
* cell instance $944 m0 *1 5.13,18.2
X$944 369 368 144 116 394 AND2_X1
* cell instance $945 m0 *1 5.89,18.2
X$945 338 116 144 353 BUF_X1
* cell instance $946 m0 *1 6.46,18.2
X$946 358 116 144 INV_X2
* cell instance $947 m0 *1 7.03,18.2
X$947 370 277 316 116 144 354 MUX2_X1
* cell instance $948 m0 *1 8.36,18.2
X$948 116 966 316 334 358 144 DFF_X1
* cell instance $949 m0 *1 11.59,18.2
X$949 317 116 144 277 CLKBUF_X3
* cell instance $955 m0 *1 1.33,18.2
X$955 372 116 144 376 BUF_X1
* cell instance $957 m0 *1 1.9,18.2
X$957 365 116 144 377 BUF_X1
* cell instance $960 r0 *1 1.33,18.2
X$960 378 116 144 393 BUF_X1
* cell instance $961 r0 *1 1.9,18.2
X$961 373 116 144 392 BUF_X1
* cell instance $963 r0 *1 2.66,18.2
X$963 383 116 144 380 BUF_X1
* cell instance $968 r0 *1 3.61,18.2
X$968 377 277 315 116 144 368 MUX2_X1
* cell instance $969 r0 *1 4.94,18.2
X$969 116 1071 315 394 358 144 DFF_X1
* cell instance $971 r0 *1 8.36,18.2
X$971 376 277 373 116 144 396 MUX2_X1
* cell instance $972 r0 *1 9.69,18.2
X$972 318 116 144 358 CLKBUF_X3
* cell instance $973 r0 *1 10.64,18.2
X$973 369 396 144 116 384 AND2_X1
* cell instance $978 m0 *1 28.12,18.2
X$978 133 144 203 116 BUF_X4
* cell instance $982 m0 *1 39.33,18.2
X$982 318 116 144 139 CLKBUF_X3
* cell instance $983 m0 *1 40.28,18.2
X$983 116 1018 344 371 359 144 DFF_X1
* cell instance $984 m0 *1 43.51,18.2
X$984 116 954 352 360 359 144 DFF_X1
* cell instance $985 m0 *1 46.74,18.2
X$985 285 367 144 116 363 AND2_X1
* cell instance $987 m0 *1 47.69,18.2
X$987 346 235 361 116 144 367 MUX2_X1
* cell instance $995 r0 *1 41.61,18.2
X$995 359 116 144 INV_X2
* cell instance $997 r0 *1 42.56,18.2
X$997 366 116 144 410 BUF_X1
* cell instance $998 r0 *1 43.13,18.2
X$998 116 1038 374 386 359 144 DFF_X1
* cell instance $999 r0 *1 46.36,18.2
X$999 408 116 144 395 BUF_X1
* cell instance $1001 r0 *1 47.12,18.2
X$1001 374 116 144 375 BUF_X1
* cell instance $1003 r0 *1 47.88,18.2
X$1003 390 116 144 387 BUF_X1
* cell instance $1004 r0 *1 48.45,18.2
X$1004 388 116 144 389 BUF_X1
* cell instance $1008 m0 *1 2.09,35
X$1008 641 543 612 116 144 609 MUX2_X1
* cell instance $1009 m0 *1 3.42,35
X$1009 585 116 144 642 BUF_X1
* cell instance $1010 m0 *1 3.99,35
X$1010 610 643 144 116 621 AND2_X1
* cell instance $1011 m0 *1 4.75,35
X$1011 642 543 613 116 144 623 MUX2_X1
* cell instance $1012 m0 *1 6.08,35
X$1012 116 975 613 622 644 144 DFF_X1
* cell instance $1013 m0 *1 9.31,35
X$1013 318 116 144 518 CLKBUF_X3
* cell instance $1014 m0 *1 10.26,35
X$1014 318 116 144 644 CLKBUF_X3
* cell instance $1015 m0 *1 11.21,35
X$1015 614 116 144 628 BUF_X1
* cell instance $1016 m0 *1 11.78,35
X$1016 518 116 144 INV_X2
* cell instance $1019 r0 *1 1.33,35
X$1019 606 116 144 675 BUF_X1
* cell instance $1021 r0 *1 2.09,35
X$1021 608 116 144 649 BUF_X1
* cell instance $1022 r0 *1 2.66,35
X$1022 610 663 144 116 664 AND2_X1
* cell instance $1027 r0 *1 3.61,35
X$1027 649 543 611 116 144 643 MUX2_X1
* cell instance $1028 r0 *1 4.94,35
X$1028 613 116 144 586 BUF_X1
* cell instance $1031 r0 *1 6.46,35
X$1031 648 116 144 650 BUF_X1
* cell instance $1032 r0 *1 7.03,35
X$1032 650 543 614 116 144 676 MUX2_X1
* cell instance $1034 r0 *1 8.74,35
X$1034 610 676 144 116 629 AND2_X1
* cell instance $1035 r0 *1 9.5,35
X$1035 116 1046 658 679 644 144 DFF_X1
* cell instance $1036 r0 *1 12.73,35
X$1036 610 651 144 116 678 AND2_X1
* cell instance $1037 m0 *1 12.92,35
X$1037 499 116 144 610 CLKBUF_X2
* cell instance $1045 r0 *1 21.28,35
X$1045 318 116 144 630 CLKBUF_X3
* cell instance $1046 r0 *1 22.23,35
X$1046 630 116 144 INV_X4
* cell instance $1048 m0 *1 23.37,35
X$1048 116 1001 631 603 630 144 DFF_X1
* cell instance $1051 m0 *1 28.12,35
X$1051 632 116 144 501 BUF_X2
* cell instance $1052 m0 *1 28.88,35
X$1052 318 116 144 519 CLKBUF_X3
* cell instance $1053 m0 *1 29.83,35
X$1053 605 458 445 633 590 116 144 647 AOI221_X1
* cell instance $1054 m0 *1 30.97,35
X$1054 634 116 144 633 INV_X1
* cell instance $1056 r0 *1 24.7,35
X$1056 116 1063 632 667 519 144 DFF_X1
* cell instance $1058 r0 *1 28.31,35
X$1058 116 1053 634 647 519 144 DFF_X1
* cell instance $1060 m0 *1 31.92,35
X$1060 116 615 539 626 519 144 DFF_X1
* cell instance $1062 m0 *1 35.15,35
X$1062 116 635 519 580 144 DFF_X2
* cell instance $1064 m0 *1 39.52,35
X$1064 116 1016 645 646 652 144 DFF_X1
* cell instance $1065 m0 *1 42.75,35
X$1065 318 116 144 489 CLKBUF_X3
* cell instance $1066 m0 *1 43.7,35
X$1066 594 657 144 116 646 AND2_X1
* cell instance $1072 r0 *1 37.43,35
X$1072 499 116 144 594 CLKBUF_X2
* cell instance $1075 r0 *1 40.09,35
X$1075 596 116 144 592 BUF_X1
* cell instance $1076 r0 *1 40.66,35
X$1076 318 116 144 652 CLKBUF_X3
* cell instance $1077 r0 *1 41.61,35
X$1077 594 684 144 116 682 AND2_X1
* cell instance $1079 r0 *1 42.75,35
X$1079 683 653 645 116 144 657 MUX2_X1
* cell instance $1080 r0 *1 44.08,35
X$1080 645 116 144 655 BUF_X1
* cell instance $1082 m0 *1 48.07,35
X$1082 638 116 144 619 BUF_X1
* cell instance $1083 m0 *1 44.84,35
X$1083 116 1017 638 636 489 144 DFF_X1
* cell instance $1085 r0 *1 44.84,35
X$1085 670 653 638 116 144 671 MUX2_X1
* cell instance $1086 r0 *1 46.17,35
X$1086 594 671 144 116 636 AND2_X1
* cell instance $1088 r0 *1 47.12,35
X$1088 595 116 144 656 BUF_X1
* cell instance $1089 r0 *1 47.69,35
X$1089 654 653 617 116 144 639 MUX2_X1
* cell instance $1092 m0 *1 3.04,26.6
X$1092 369 483 144 116 505 AND2_X1
* cell instance $1094 m0 *1 3.8,26.6
X$1094 506 441 482 116 144 498 MUX2_X1
* cell instance $1095 m0 *1 5.13,26.6
X$1095 369 498 144 116 507 AND2_X1
* cell instance $1096 m0 *1 5.89,26.6
X$1096 116 998 482 507 518 144 DFF_X1
* cell instance $1100 m0 *1 1.33,26.6
X$1100 495 116 144 497 BUF_X1
* cell instance $1102 m0 *1 1.9,26.6
X$1102 481 116 144 506 BUF_X1
* cell instance $1105 r0 *1 1.33,26.6
X$1105 517 116 144 496 BUF_X1
* cell instance $1106 r0 *1 1.9,26.6
X$1106 497 441 517 116 144 483 MUX2_X1
* cell instance $1110 r0 *1 3.23,26.6
X$1110 116 1082 517 505 518 144 DFF_X1
* cell instance $1113 r0 *1 7.41,26.6
X$1113 116 1092 560 524 518 144 DFF_X1
* cell instance $1116 r0 *1 11.59,26.6
X$1116 317 116 144 543 CLKBUF_X3
* cell instance $1120 r0 *1 13.87,26.6
X$1120 499 116 144 233 BUF_X2
* cell instance $1123 m0 *1 17.1,26.6
X$1123 190 116 144 499 CLKBUF_X3
* cell instance $1128 r0 *1 22.23,26.6
X$1128 116 1065 500 510 630 144 DFF_X1
* cell instance $1130 m0 *1 23.75,26.6
X$1130 493 484 116 144 317 NAND2_X2
* cell instance $1131 m0 *1 26.03,26.6
X$1131 500 116 144 493 CLKBUF_X3
* cell instance $1132 m0 *1 25.08,26.6
X$1132 509 116 144 318 CLKBUF_X3
* cell instance $1133 m0 *1 26.98,26.6
X$1133 485 203 512 116 144 510 NAND3_X1
* cell instance $1136 r0 *1 25.84,26.6
X$1136 445 521 493 116 485 144 AOI21_X1
* cell instance $1137 r0 *1 26.6,26.6
X$1137 484 466 116 144 521 NOR2_X1
* cell instance $1139 m0 *1 29.26,26.6
X$1139 514 513 501 400 144 486 116 NOR4_X2
* cell instance $1140 m0 *1 28.12,26.6
X$1140 501 513 514 400 116 144 465 OR4_X1
* cell instance $1141 m0 *1 30.97,26.6
X$1141 487 445 116 144 515 NOR2_X1
* cell instance $1144 r0 *1 28.88,26.6
X$1144 116 1052 522 515 519 144 DFF_X1
* cell instance $1146 m0 *1 31.92,26.6
X$1146 484 407 449 448 144 116 494 OAI22_X1
* cell instance $1147 m0 *1 34.39,26.6
X$1147 190 116 144 478 INV_X1
* cell instance $1148 m0 *1 34.77,26.6
X$1148 478 116 144 445 CLKBUF_X3
* cell instance $1149 m0 *1 35.72,26.6
X$1149 424 494 144 116 469 AND2_X1
* cell instance $1152 m0 *1 38.76,26.6
X$1152 116 1000 470 477 489 144 DFF_X1
* cell instance $1155 r0 *1 32.3,26.6
X$1155 513 493 501 514 144 462 116 NOR4_X2
* cell instance $1156 r0 *1 34.01,26.6
X$1156 493 467 513 400 116 144 526 OR4_X1
* cell instance $1159 r0 *1 36.1,26.6
X$1159 499 116 144 424 CLKBUF_X2
* cell instance $1162 r0 *1 40.66,26.6
X$1162 116 1049 452 511 489 144 DFF_X1
* cell instance $1163 m0 *1 42.56,26.6
X$1163 424 491 144 116 511 AND2_X1
* cell instance $1166 m0 *1 43.89,26.6
X$1166 503 116 144 492 BUF_X1
* cell instance $1168 m0 *1 44.46,26.6
X$1168 424 471 144 116 508 AND2_X1
* cell instance $1169 m0 *1 45.22,26.6
X$1169 116 1010 502 508 489 144 DFF_X1
* cell instance $1170 m0 *1 48.45,26.6
X$1170 504 116 144 490 BUF_X1
* cell instance $1175 r0 *1 45.22,26.6
X$1175 424 555 144 116 528 AND2_X1
* cell instance $1178 m0 *1 1.33,49
X$1178 753 879 144 116 853 AND2_X1
* cell instance $1180 m0 *1 2.09,49
X$1180 945 705 854 116 144 879 MUX2_X1
* cell instance $1181 m0 *1 3.42,49
X$1181 895 116 144 945 BUF_X1
* cell instance $1182 m0 *1 3.99,49
X$1182 854 116 144 893 BUF_X1
* cell instance $1184 m0 *1 4.75,49
X$1184 896 116 144 871 BUF_X1
* cell instance $1185 m0 *1 5.32,49
X$1185 847 116 144 890 BUF_X1
* cell instance $1186 m0 *1 5.89,49
X$1186 891 116 144 865 BUF_X1
* cell instance $1187 m0 *1 6.46,49
X$1187 753 946 144 116 872 AND2_X1
* cell instance $1188 m0 *1 7.22,49
X$1188 873 116 144 894 BUF_X1
* cell instance $1189 m0 *1 7.79,49
X$1189 838 705 812 116 144 946 MUX2_X1
* cell instance $1190 m0 *1 9.12,49
X$1190 709 116 144 892 BUF_X1
* cell instance $1191 m0 *1 9.69,49
X$1191 753 947 144 116 874 AND2_X1
* cell instance $1192 m0 *1 10.45,49
X$1192 753 883 144 116 840 AND2_X1
* cell instance $1194 m0 *1 11.4,49
X$1194 825 705 799 116 144 947 MUX2_X1
* cell instance $1196 m0 *1 12.92,49
X$1196 897 116 144 884 BUF_X1
* cell instance $1197 m0 *1 13.49,49
X$1197 781 116 144 898 BUF_X1
* cell instance $1198 m0 *1 14.06,49
X$1198 725 116 144 900 BUF_X1
* cell instance $1199 m0 *1 14.63,49
X$1199 786 116 144 899 BUF_X1
* cell instance $1200 m0 *1 15.2,49
X$1200 901 116 144 875 BUF_X1
* cell instance $1201 m0 *1 15.77,49
X$1201 801 116 144 902 BUF_X1
* cell instance $1202 m0 *1 16.34,49
X$1202 886 116 144 903 BUF_X1
* cell instance $1203 m0 *1 16.91,49
X$1203 904 116 144 887 BUF_X1
* cell instance $1204 m0 *1 17.48,49
X$1204 906 116 144 800 BUF_X1
* cell instance $1205 m0 *1 18.05,49
X$1205 689 948 144 116 848 AND2_X1
* cell instance $1206 m0 *1 18.81,49
X$1206 689 949 144 116 888 AND2_X1
* cell instance $1207 m0 *1 19.57,49
X$1207 905 116 144 889 BUF_X1
* cell instance $1208 m0 *1 20.14,49
X$1208 739 116 144 907 BUF_X1
* cell instance $1209 m0 *1 20.71,49
X$1209 908 116 144 909 BUF_X1
* cell instance $1210 m0 *1 21.28,49
X$1210 909 666 886 116 144 949 MUX2_X1
* cell instance $1211 m0 *1 22.61,49
X$1211 740 116 144 910 BUF_X1
* cell instance $1212 m0 *1 23.18,49
X$1212 780 116 144 911 BUF_X1
* cell instance $1213 m0 *1 23.75,49
X$1213 689 876 144 116 850 AND2_X1
* cell instance $1214 m0 *1 24.51,49
X$1214 870 116 144 912 BUF_X1
* cell instance $1215 m0 *1 25.08,49
X$1215 950 666 885 116 144 818 MUX2_X1
* cell instance $1216 m0 *1 26.41,49
X$1216 631 116 144 913 BUF_X1
* cell instance $1217 m0 *1 26.98,49
X$1217 915 116 144 950 BUF_X1
* cell instance $1218 m0 *1 27.55,49
X$1218 885 116 144 918 BUF_X1
* cell instance $1219 m0 *1 28.12,49
X$1219 917 116 144 819 BUF_X1
* cell instance $1220 m0 *1 28.69,49
X$1220 916 116 144 759 BUF_X1
* cell instance $1221 m0 *1 29.26,49
X$1221 741 116 144 920 BUF_X1
* cell instance $1222 m0 *1 29.83,49
X$1222 914 116 144 921 BUF_X1
* cell instance $1223 m0 *1 30.4,49
X$1223 921 666 855 116 144 827 MUX2_X1
* cell instance $1224 m0 *1 31.73,49
X$1224 855 116 144 922 BUF_X1
* cell instance $1225 m0 *1 32.3,49
X$1225 763 116 144 923 BUF_X1
* cell instance $1226 m0 *1 32.87,49
X$1226 924 116 144 856 BUF_X1
* cell instance $1227 m0 *1 33.44,49
X$1227 925 116 144 882 BUF_X1
* cell instance $1228 m0 *1 34.01,49
X$1228 829 116 144 926 BUF_X1
* cell instance $1229 m0 *1 34.58,49
X$1229 802 116 144 927 BUF_X1
* cell instance $1230 m0 *1 35.15,49
X$1230 790 116 144 919 BUF_X1
* cell instance $1231 m0 *1 35.72,49
X$1231 929 116 144 864 BUF_X1
* cell instance $1232 m0 *1 36.29,49
X$1232 791 116 144 930 BUF_X1
* cell instance $1233 m0 *1 36.86,49
X$1233 863 116 144 928 BUF_X1
* cell instance $1234 m0 *1 37.43,49
X$1234 932 116 144 881 BUF_X1
* cell instance $1235 m0 *1 38,49
X$1235 933 116 144 820 BUF_X1
* cell instance $1236 m0 *1 38.57,49
X$1236 931 116 144 797 BUF_X1
* cell instance $1237 m0 *1 39.14,49
X$1237 742 116 144 935 BUF_X1
* cell instance $1238 m0 *1 39.71,49
X$1238 934 116 144 805 BUF_X1
* cell instance $1239 m0 *1 40.28,49
X$1239 937 116 144 880 BUF_X1
* cell instance $1240 m0 *1 40.85,49
X$1240 938 116 144 858 BUF_X1
* cell instance $1241 m0 *1 41.42,49
X$1241 796 116 144 936 BUF_X1
* cell instance $1242 m0 *1 41.99,49
X$1242 831 116 144 942 BUF_X1
* cell instance $1243 m0 *1 42.56,49
X$1243 862 116 144 941 BUF_X1
* cell instance $1244 m0 *1 43.13,49
X$1244 859 116 144 940 BUF_X1
* cell instance $1245 m0 *1 43.7,49
X$1245 939 116 144 944 BUF_X1
* cell instance $1246 m0 *1 44.27,49
X$1246 944 770 878 116 144 877 MUX2_X1
* cell instance $1247 m0 *1 45.6,49
X$1247 691 877 144 116 860 AND2_X1
* cell instance $1252 m0 *1 3.61,21
X$1252 369 382 144 116 404 AND2_X1
* cell instance $1253 m0 *1 2.28,21
X$1253 393 277 381 116 144 382 MUX2_X1
* cell instance $1254 m0 *1 4.37,21
X$1254 403 277 383 116 144 398 MUX2_X1
* cell instance $1255 m0 *1 5.7,21
X$1255 369 398 144 116 406 AND2_X1
* cell instance $1257 m0 *1 6.65,21
X$1257 116 969 383 406 358 144 DFF_X1
* cell instance $1258 m0 *1 9.88,21
X$1258 116 973 373 384 358 144 DFF_X1
* cell instance $1265 m0 *1 33.82,21
X$1265 116 1028 385 412 304 144 DFF_X1
* cell instance $1268 m0 *1 41.61,21
X$1268 385 116 144 391 BUF_X1
* cell instance $1270 m0 *1 1.33,21
X$1270 379 116 144 403 BUF_X1
* cell instance $1275 r0 *1 1.52,21
X$1275 428 116 144 415 BUF_X1
* cell instance $1277 r0 *1 2.28,21
X$1277 381 116 144 413 BUF_X1
* cell instance $1278 r0 *1 2.85,21
X$1278 116 1069 381 404 358 144 DFF_X1
* cell instance $1282 r0 *1 6.08,21
X$1282 116 1070 418 416 358 144 DFF_X1
* cell instance $1283 r0 *1 9.31,21
X$1283 431 116 144 397 BUF_X1
* cell instance $1285 r0 *1 10.26,21
X$1285 116 1073 431 419 358 144 DFF_X1
* cell instance $1290 r0 *1 24.51,21
X$1290 116 1066 119 420 304 144 DFF_X1
* cell instance $1291 r0 *1 27.74,21
X$1291 116 1042 421 433 304 144 DFF_X1
* cell instance $1294 r0 *1 32.87,21
X$1294 399 116 144 480 INV_X1
* cell instance $1295 r0 *1 33.25,21
X$1295 399 401 144 116 422 AND2_X1
* cell instance $1296 r0 *1 34.01,21
X$1296 399 400 401 116 133 144 NAND3_X4
* cell instance $1297 r0 *1 36.48,21
X$1297 385 116 144 399 CLKBUF_X2
* cell instance $1300 r0 *1 40.47,21
X$1300 424 411 144 116 423 AND2_X1
* cell instance $1301 r0 *1 41.23,21
X$1301 434 407 408 116 144 411 MUX2_X1
* cell instance $1302 m0 *1 42.75,21
X$1302 410 407 374 116 144 432 MUX2_X1
* cell instance $1307 r0 *1 43.13,21
X$1307 426 116 144 434 BUF_X1
* cell instance $1308 r0 *1 43.7,21
X$1308 424 432 144 116 386 AND2_X1
* cell instance $1309 m0 *1 47.69,21
X$1309 387 407 388 116 144 405 MUX2_X1
* cell instance $1310 m0 *1 44.46,21
X$1310 116 958 388 409 359 144 DFF_X1
* cell instance $1313 r0 *1 44.65,21
X$1313 424 430 144 116 457 AND2_X1
* cell instance $1315 r0 *1 45.6,21
X$1315 424 405 144 116 409 AND2_X1
* cell instance $1317 r0 *1 46.55,21
X$1317 402 116 144 401 CLKBUF_X2
* cell instance $1319 r0 *1 47.69,21
X$1319 427 116 144 425 BUF_X1
* cell instance $1321 r0 *1 48.45,21
X$1321 437 116 144 429 BUF_X1
* cell instance $1325 m0 *1 1.52,37.8
X$1325 675 543 662 116 144 663 MUX2_X1
* cell instance $1326 m0 *1 2.85,37.8
X$1326 116 1019 662 664 644 144 DFF_X1
* cell instance $1330 r0 *1 1.52,37.8
X$1330 659 116 144 696 BUF_X1
* cell instance $1331 r0 *1 2.09,37.8
X$1331 116 1084 688 717 644 144 DFF_X1
* cell instance $1335 r0 *1 5.32,37.8
X$1335 688 116 144 699 BUF_X1
* cell instance $1337 m0 *1 6.65,37.8
X$1337 665 116 144 661 BUF_X1
* cell instance $1339 m0 *1 7.22,37.8
X$1339 696 543 658 116 144 677 MUX2_X1
* cell instance $1340 m0 *1 8.55,37.8
X$1340 610 723 144 116 698 AND2_X1
* cell instance $1343 m0 *1 10.26,37.8
X$1343 610 677 144 116 679 AND2_X1
* cell instance $1345 r0 *1 6.65,37.8
X$1345 686 116 144 706 BUF_X1
* cell instance $1346 r0 *1 7.22,37.8
X$1346 658 116 144 660 BUF_X1
* cell instance $1347 r0 *1 7.79,37.8
X$1347 116 1055 665 698 644 144 DFF_X1
* cell instance $1350 m0 *1 11.4,37.8
X$1350 116 983 725 678 680 144 DFF_X1
* cell instance $1353 r0 *1 12.35,37.8
X$1353 736 543 725 116 144 651 MUX2_X1
* cell instance $1357 m0 *1 15.2,37.8
X$1357 441 144 666 116 BUF_X4
* cell instance $1360 r0 *1 15.01,37.8
X$1360 116 1089 709 726 680 144 DFF_X1
* cell instance $1361 m0 *1 17.86,37.8
X$1361 680 116 144 INV_X2
* cell instance $1362 m0 *1 16.91,37.8
X$1362 318 116 144 680 CLKBUF_X3
* cell instance $1365 m0 *1 26.03,37.8
X$1365 445 697 666 116 667 144 AOI21_X1
* cell instance $1369 r0 *1 18.62,37.8
X$1369 116 1045 739 724 630 144 DFF_X1
* cell instance $1371 r0 *1 22.23,37.8
X$1371 499 116 144 689 CLKBUF_X2
* cell instance $1372 r0 *1 22.99,37.8
X$1372 689 710 144 116 756 AND2_X1
* cell instance $1375 m0 *1 27.93,37.8
X$1375 681 501 116 144 697 NAND2_X1
* cell instance $1377 m0 *1 28.88,37.8
X$1377 519 116 144 INV_X4
* cell instance $1379 m0 *1 30.78,37.8
X$1379 668 634 116 144 681 NAND2_X1
* cell instance $1380 m0 *1 31.35,37.8
X$1380 634 668 144 116 561 AND2_X1
* cell instance $1382 m0 *1 38.19,37.8
X$1382 116 992 669 682 652 144 DFF_X1
* cell instance $1383 m0 *1 41.42,37.8
X$1383 685 653 669 116 144 684 MUX2_X1
* cell instance $1386 m0 *1 43.7,37.8
X$1386 672 116 144 683 BUF_X1
* cell instance $1387 m0 *1 44.27,37.8
X$1387 640 116 144 670 BUF_X1
* cell instance $1388 m0 *1 44.84,37.8
X$1388 673 116 144 685 BUF_X1
* cell instance $1389 m0 *1 45.41,37.8
X$1389 594 694 144 116 721 AND2_X1
* cell instance $1390 m0 *1 46.17,37.8
X$1390 669 116 144 693 BUF_X1
* cell instance $1391 m0 *1 46.74,37.8
X$1391 594 639 144 116 637 AND2_X1
* cell instance $1392 m0 *1 47.5,37.8
X$1392 616 116 144 620 BUF_X1
* cell instance $1393 m0 *1 48.07,37.8
X$1393 674 116 144 654 BUF_X1
* cell instance $1396 r0 *1 30.21,37.8
X$1396 689 761 144 116 690 AND2_X1
* cell instance $1399 r0 *1 31.54,37.8
X$1399 318 116 144 711 CLKBUF_X3
* cell instance $1400 r0 *1 32.49,37.8
X$1400 711 116 144 INV_X2
* cell instance $1404 r0 *1 34.39,37.8
X$1404 691 764 144 116 722 AND2_X1
* cell instance $1406 r0 *1 35.34,37.8
X$1406 499 116 144 691 CLKBUF_X2
* cell instance $1408 r0 *1 37.62,37.8
X$1408 691 779 144 116 762 AND2_X1
* cell instance $1412 r0 *1 43.13,37.8
X$1412 116 1059 719 721 652 144 DFF_X1
* cell instance $1413 r0 *1 46.36,37.8
X$1413 695 653 719 116 144 694 MUX2_X1
* cell instance $1415 r0 *1 47.88,37.8
X$1415 692 116 144 695 BUF_X1
* cell instance $1416 r0 *1 48.45,37.8
X$1416 617 116 144 618 BUF_X1
* cell instance $1421 m0 *1 1.52,43.4
X$1421 662 116 144 701 BUF_X1
* cell instance $1423 m0 *1 2.28,43.4
X$1423 116 985 776 767 644 144 DFF_X1
* cell instance $1424 m0 *1 5.51,43.4
X$1424 545 116 144 783 BUF_X1
* cell instance $1427 m0 *1 9.31,43.4
X$1427 821 116 144 734 BUF_X1
* cell instance $1428 m0 *1 9.88,43.4
X$1428 116 1013 768 778 644 144 DFF_X1
* cell instance $1429 m0 *1 13.11,43.4
X$1429 884 705 786 116 144 777 MUX2_X1
* cell instance $1430 m0 *1 14.44,43.4
X$1430 824 705 781 116 144 787 MUX2_X1
* cell instance $1431 m0 *1 15.77,43.4
X$1431 753 787 144 116 782 AND2_X1
* cell instance $1435 r0 *1 1.33,43.4
X$1435 729 116 144 730 BUF_X1
* cell instance $1436 r0 *1 1.9,43.4
X$1436 776 116 144 727 BUF_X1
* cell instance $1437 r0 *1 2.47,43.4
X$1437 612 116 144 728 BUF_X1
* cell instance $1441 r0 *1 3.04,43.4
X$1441 752 116 144 784 BUF_X1
* cell instance $1442 r0 *1 3.61,43.4
X$1442 588 116 144 765 BUF_X1
* cell instance $1443 r0 *1 4.18,43.4
X$1443 700 116 144 703 BUF_X1
* cell instance $1445 r0 *1 5.51,43.4
X$1445 753 835 144 116 811 AND2_X1
* cell instance $1450 r0 *1 9.12,43.4
X$1450 837 116 144 838 BUF_X1
* cell instance $1453 r0 *1 10.64,43.4
X$1453 768 116 144 823 BUF_X1
* cell instance $1455 r0 *1 11.4,43.4
X$1455 799 116 144 785 BUF_X1
* cell instance $1456 r0 *1 11.97,43.4
X$1456 842 116 144 814 BUF_X1
* cell instance $1459 r0 *1 13.11,43.4
X$1459 808 116 144 736 BUF_X1
* cell instance $1462 r0 *1 14.25,43.4
X$1462 753 816 144 116 807 AND2_X1
* cell instance $1463 r0 *1 15.01,43.4
X$1463 116 1044 801 807 680 144 DFF_X1
* cell instance $1465 r0 *1 19.76,43.4
X$1465 889 666 780 116 144 788 MUX2_X1
* cell instance $1466 m0 *1 20.14,43.4
X$1466 689 788 144 116 798 AND2_X1
* cell instance $1468 m0 *1 20.9,43.4
X$1468 116 951 780 798 630 144 DFF_X1
* cell instance $1474 r0 *1 21.66,43.4
X$1474 849 116 144 769 BUF_X1
* cell instance $1477 m0 *1 29.64,43.4
X$1477 116 1027 790 789 711 144 DFF_X1
* cell instance $1478 m0 *1 28.31,43.4
X$1478 819 566 741 116 144 760 MUX2_X1
* cell instance $1479 m0 *1 32.87,43.4
X$1479 795 566 790 116 144 810 MUX2_X1
* cell instance $1482 m0 *1 35.15,43.4
X$1482 797 770 791 116 144 764 MUX2_X1
* cell instance $1487 r0 *1 30.4,43.4
X$1487 689 810 144 116 789 AND2_X1
* cell instance $1488 r0 *1 31.16,43.4
X$1488 116 1067 802 809 711 144 DFF_X1
* cell instance $1489 r0 *1 34.39,43.4
X$1489 691 803 144 116 809 AND2_X1
* cell instance $1490 r0 *1 35.15,43.4
X$1490 691 806 144 116 822 AND2_X1
* cell instance $1493 m0 *1 37.81,43.4
X$1493 820 770 742 116 144 779 MUX2_X1
* cell instance $1495 m0 *1 39.14,43.4
X$1495 116 1022 796 771 652 144 DFF_X1
* cell instance $1497 m0 *1 43.89,43.4
X$1497 743 116 144 715 BUF_X1
* cell instance $1498 m0 *1 44.46,43.4
X$1498 116 1024 749 775 652 144 DFF_X1
* cell instance $1499 m0 *1 47.69,43.4
X$1499 746 116 144 772 BUF_X1
* cell instance $1500 m0 *1 48.26,43.4
X$1500 716 116 144 750 BUF_X1
* cell instance $1504 r0 *1 38.38,43.4
X$1504 805 770 796 116 144 792 MUX2_X1
* cell instance $1506 r0 *1 39.9,43.4
X$1506 116 1060 862 804 652 144 DFF_X1
* cell instance $1509 r0 *1 45.03,43.4
X$1509 116 1061 793 712 652 144 DFF_X1
* cell instance $1511 r0 *1 48.45,43.4
X$1511 793 116 144 774 BUF_X1
* cell instance $1514 m0 *1 1.71,12.6
X$1514 275 116 144 302 BUF_X1
* cell instance $1519 r0 *1 1.33,12.6
X$1519 325 116 144 312 BUF_X1
* cell instance $1521 r0 *1 2.09,12.6
X$1521 276 277 232 116 144 326 MUX2_X1
* cell instance $1526 r0 *1 3.61,12.6
X$1526 248 326 144 116 330 AND2_X1
* cell instance $1529 m0 *1 7.98,12.6
X$1529 248 280 144 116 333 AND2_X1
* cell instance $1532 m0 *1 9.31,12.6
X$1532 116 978 234 297 171 144 DFF_X1
* cell instance $1537 r0 *1 11.97,12.6
X$1537 190 116 144 248 CLKBUF_X2
* cell instance $1540 m0 *1 12.92,12.6
X$1540 116 971 205 281 171 144 DFF_X1
* cell instance $1543 m0 *1 18.62,12.6
X$1543 233 282 144 116 303 AND2_X1
* cell instance $1546 r0 *1 13.49,12.6
X$1546 171 116 144 INV_X2
* cell instance $1547 r0 *1 14.06,12.6
X$1547 318 116 144 171 CLKBUF_X3
* cell instance $1548 r0 *1 15.01,12.6
X$1548 116 1076 162 337 171 144 DFF_X1
* cell instance $1549 r0 *1 18.24,12.6
X$1549 116 1075 206 303 175 144 DFF_X1
* cell instance $1553 m0 *1 26.98,12.6
X$1553 116 987 256 300 304 144 DFF_X1
* cell instance $1556 m0 *1 38,12.6
X$1556 116 952 268 284 139 144 DFF_X1
* cell instance $1557 m0 *1 41.23,12.6
X$1557 116 962 261 298 139 144 DFF_X1
* cell instance $1558 m0 *1 44.46,12.6
X$1558 285 216 144 116 286 AND2_X1
* cell instance $1559 m0 *1 45.22,12.6
X$1559 285 296 144 116 307 AND2_X1
* cell instance $1564 r0 *1 30.4,12.6
X$1564 150 203 305 116 144 357 MUX2_X1
* cell instance $1565 r0 *1 31.73,12.6
X$1565 116 1040 305 319 304 144 DFF_X1
* cell instance $1566 r0 *1 34.96,12.6
X$1566 156 116 144 INV_X2
* cell instance $1569 r0 *1 36.1,12.6
X$1569 133 116 144 235 CLKBUF_X3
* cell instance $1573 r0 *1 39.14,12.6
X$1573 285 310 144 116 320 AND2_X1
* cell instance $1577 r0 *1 41.99,12.6
X$1577 331 235 306 116 144 310 MUX2_X1
* cell instance $1578 r0 *1 43.32,12.6
X$1578 323 116 144 331 BUF_X1
* cell instance $1579 r0 *1 43.89,12.6
X$1579 306 116 144 322 BUF_X1
* cell instance $1580 r0 *1 44.46,12.6
X$1580 116 1034 308 307 139 144 DFF_X1
* cell instance $1581 m0 *1 47.69,12.6
X$1581 287 235 238 116 144 294 MUX2_X1
* cell instance $1582 m0 *1 46.36,12.6
X$1582 239 235 308 116 144 296 MUX2_X1
* cell instance $1585 r0 *1 48.45,12.6
X$1585 308 116 144 309 BUF_X1
* cell instance $1590 m0 *1 1.33,23.8
X$1590 454 116 144 438 BUF_X1
* cell instance $1592 m0 *1 1.9,23.8
X$1592 415 441 454 116 144 442 MUX2_X1
* cell instance $1593 m0 *1 3.23,23.8
X$1593 369 442 144 116 464 AND2_X1
* cell instance $1594 m0 *1 3.99,23.8
X$1594 418 116 144 440 BUF_X1
* cell instance $1595 m0 *1 4.56,23.8
X$1595 435 116 144 443 BUF_X1
* cell instance $1598 r0 *1 1.33,23.8
X$1598 482 116 144 463 BUF_X1
* cell instance $1600 r0 *1 2.09,23.8
X$1600 116 1062 454 464 358 144 DFF_X1
* cell instance $1606 m0 *1 5.51,23.8
X$1606 443 203 418 116 144 417 MUX2_X1
* cell instance $1607 m0 *1 7.03,23.8
X$1607 233 417 144 116 416 AND2_X1
* cell instance $1610 m0 *1 8.17,23.8
X$1610 414 116 144 444 BUF_X1
* cell instance $1613 m0 *1 9.12,23.8
X$1613 444 203 431 116 144 455 MUX2_X1
* cell instance $1616 m0 *1 11.02,23.8
X$1616 233 455 144 116 419 AND2_X1
* cell instance $1622 m0 *1 26.22,23.8
X$1622 445 456 203 116 420 144 AOI21_X1
* cell instance $1624 r0 *1 11.02,23.8
X$1624 190 116 144 369 BUF_X2
* cell instance $1630 m0 *1 27.36,23.8
X$1630 458 400 119 144 456 116 OAI21_X1
* cell instance $1632 m0 *1 28.69,23.8
X$1632 459 458 445 460 436 116 144 433 AOI221_X1
* cell instance $1634 m0 *1 30.02,23.8
X$1634 421 116 144 460 INV_X1
* cell instance $1636 m0 *1 30.59,23.8
X$1636 447 421 116 144 446 NAND2_X1
* cell instance $1637 m0 *1 31.16,23.8
X$1637 421 447 144 116 448 AND2_X1
* cell instance $1640 r0 *1 28.69,23.8
X$1640 465 467 446 116 459 144 AOI21_X1
* cell instance $1641 r0 *1 29.45,23.8
X$1641 466 486 449 448 436 116 144 OAI211_X2
* cell instance $1642 r0 *1 31.16,23.8
X$1642 400 468 467 448 116 144 487 AOI22_X1
* cell instance $1643 r0 *1 32.11,23.8
X$1643 467 116 144 449 INV_X1
* cell instance $1645 m0 *1 32.49,23.8
X$1645 448 462 451 422 450 116 144 OAI211_X2
* cell instance $1646 m0 *1 34.2,23.8
X$1646 400 116 144 451 INV_X1
* cell instance $1647 m0 *1 34.58,23.8
X$1647 401 399 116 144 468 NAND2_X1
* cell instance $1649 m0 *1 35.34,23.8
X$1649 116 981 461 469 359 144 DFF_X1
* cell instance $1650 m0 *1 38.57,23.8
X$1650 453 116 144 447 BUF_X1
* cell instance $1653 m0 *1 40.09,23.8
X$1653 116 959 408 423 359 144 DFF_X1
* cell instance $1654 m0 *1 43.32,23.8
X$1654 421 116 144 439 BUF_X1
* cell instance $1656 r0 *1 32.49,23.8
X$1656 479 449 478 480 450 116 144 412 AOI221_X1
* cell instance $1658 r0 *1 33.82,23.8
X$1658 488 400 468 116 479 144 AOI21_X1
* cell instance $1661 r0 *1 35.72,23.8
X$1661 461 144 467 116 BUF_X4
* cell instance $1665 r0 *1 41.8,23.8
X$1665 424 476 144 116 477 AND2_X1
* cell instance $1666 r0 *1 42.56,23.8
X$1666 492 407 470 116 144 476 MUX2_X1
* cell instance $1668 m0 *1 1.33,9.8
X$1668 263 116 144 244 BUF_X1
* cell instance $1670 m0 *1 1.9,9.8
X$1670 243 116 144 264 BUF_X1
* cell instance $1672 m0 *1 2.66,9.8
X$1672 232 116 144 242 BUF_X1
* cell instance $1673 m0 *1 3.23,9.8
X$1673 233 185 144 116 240 AND2_X1
* cell instance $1674 m0 *1 3.99,9.8
X$1674 233 186 144 116 267 AND2_X1
* cell instance $1679 r0 *1 1.33,9.8
X$1679 290 116 144 276 BUF_X1
* cell instance $1680 r0 *1 1.9,9.8
X$1680 244 277 231 116 144 245 MUX2_X1
* cell instance $1684 r0 *1 3.23,9.8
X$1684 248 245 144 116 278 AND2_X1
* cell instance $1685 r0 *1 3.99,9.8
X$1685 246 116 144 273 BUF_X1
* cell instance $1686 r0 *1 4.56,9.8
X$1686 279 116 144 292 BUF_X1
* cell instance $1688 r0 *1 5.32,9.8
X$1688 274 116 144 293 BUF_X1
* cell instance $1692 r0 *1 8.36,9.8
X$1692 248 295 144 116 269 AND2_X1
* cell instance $1694 r0 *1 12.16,9.8
X$1694 248 249 144 116 297 AND2_X1
* cell instance $1695 r0 *1 12.92,9.8
X$1695 248 250 144 116 281 AND2_X1
* cell instance $1698 m0 *1 15.39,9.8
X$1698 116 988 251 253 171 144 DFF_X1
* cell instance $1701 r0 *1 14.82,9.8
X$1701 233 252 144 116 253 AND2_X1
* cell instance $1704 m0 *1 19.19,9.8
X$1704 233 226 144 116 254 AND2_X1
* cell instance $1707 m0 *1 26.22,9.8
X$1707 190 116 144 138 CLKBUF_X2
* cell instance $1710 m0 *1 29.26,9.8
X$1710 116 990 208 272 156 144 DFF_X1
* cell instance $1712 m0 *1 32.68,9.8
X$1712 138 209 144 116 272 AND2_X1
* cell instance $1714 m0 *1 37.81,9.8
X$1714 237 235 268 116 144 259 MUX2_X1
* cell instance $1715 m0 *1 39.14,9.8
X$1715 116 1009 212 236 139 144 DFF_X1
* cell instance $1718 m0 *1 44.08,9.8
X$1718 116 1008 215 286 139 144 DFF_X1
* cell instance $1719 m0 *1 47.31,9.8
X$1719 285 294 144 116 265 AND2_X1
* cell instance $1723 r0 *1 24.32,9.8
X$1723 138 283 144 116 299 AND2_X1
* cell instance $1726 r0 *1 28.31,9.8
X$1726 255 203 256 116 144 257 MUX2_X1
* cell instance $1727 r0 *1 29.64,9.8
X$1727 285 257 144 116 300 AND2_X1
* cell instance $1731 r0 *1 33.06,9.8
X$1731 138 271 144 116 301 AND2_X1
* cell instance $1734 r0 *1 34.96,9.8
X$1734 116 1039 210 258 139 144 DFF_X1
* cell instance $1742 r0 *1 42.75,9.8
X$1742 289 116 144 260 BUF_X1
* cell instance $1743 r0 *1 43.32,9.8
X$1743 260 235 261 116 144 266 MUX2_X1
* cell instance $1744 r0 *1 44.65,9.8
X$1744 261 116 144 288 BUF_X1
* cell instance $1745 r0 *1 45.22,9.8
X$1745 116 1029 238 265 139 144 DFF_X1
* cell instance $1747 m0 *1 48.45,9.8
X$1747 238 116 144 262 BUF_X1
* cell instance $1748 r0 *1 48.45,9.8
X$1748 291 116 144 287 BUF_X1
* cell instance $1750 m0 *1 1.33,15.4
X$1750 340 116 144 328 BUF_X1
* cell instance $1752 m0 *1 1.9,15.4
X$1752 313 116 144 314 BUF_X1
* cell instance $1753 m0 *1 2.47,15.4
X$1753 314 277 275 116 144 341 MUX2_X1
* cell instance $1754 m0 *1 3.8,15.4
X$1754 248 341 144 116 350 AND2_X1
* cell instance $1756 m0 *1 4.75,15.4
X$1756 315 116 144 339 BUF_X1
* cell instance $1762 r0 *1 4.56,15.4
X$1762 328 277 279 116 144 342 MUX2_X1
* cell instance $1764 m0 *1 5.7,15.4
X$1764 248 342 144 116 343 AND2_X1
* cell instance $1765 m0 *1 6.65,15.4
X$1765 316 116 144 332 BUF_X1
* cell instance $1767 m0 *1 7.41,15.4
X$1767 116 967 325 351 171 144 DFF_X1
* cell instance $1768 m0 *1 10.64,15.4
X$1768 248 354 144 116 334 AND2_X1
* cell instance $1770 r0 *1 5.89,15.4
X$1770 116 1072 279 343 358 144 DFF_X1
* cell instance $1772 r0 *1 10.26,15.4
X$1772 248 355 144 116 351 AND2_X1
* cell instance $1773 r0 *1 11.02,15.4
X$1773 353 277 325 116 144 355 MUX2_X1
* cell instance $1776 m0 *1 15.96,15.4
X$1776 233 311 144 116 337 AND2_X1
* cell instance $1780 m0 *1 20.14,15.4
X$1780 318 116 144 175 CLKBUF_X3
* cell instance $1781 m0 *1 21.09,15.4
X$1781 175 116 144 INV_X4
* cell instance $1789 r0 *1 29.07,15.4
X$1789 318 116 144 304 CLKBUF_X3
* cell instance $1790 r0 *1 30.02,15.4
X$1790 304 116 144 INV_X4
* cell instance $1792 m0 *1 30.02,15.4
X$1792 285 335 144 116 336 AND2_X1
* cell instance $1794 m0 *1 31.35,15.4
X$1794 285 357 144 116 319 AND2_X1
* cell instance $1796 m0 *1 32.11,15.4
X$1796 318 116 144 156 CLKBUF_X3
* cell instance $1797 m0 *1 33.06,15.4
X$1797 190 116 144 285 CLKBUF_X2
* cell instance $1802 m0 *1 41.99,15.4
X$1802 356 235 344 116 144 345 MUX2_X1
* cell instance $1803 m0 *1 38.76,15.4
X$1803 116 1011 306 320 139 144 DFF_X1
* cell instance $1806 r0 *1 41.61,15.4
X$1806 318 116 144 359 CLKBUF_X3
* cell instance $1807 r0 *1 42.56,15.4
X$1807 285 345 144 116 371 AND2_X1
* cell instance $1809 m0 *1 43.89,15.4
X$1809 344 116 144 348 BUF_X1
* cell instance $1811 m0 *1 44.46,15.4
X$1811 347 116 144 356 BUF_X1
* cell instance $1814 r0 *1 44.27,15.4
X$1814 285 329 144 116 360 AND2_X1
* cell instance $1815 r0 *1 45.03,15.4
X$1815 116 1037 361 363 359 144 DFF_X1
* cell instance $1816 m0 *1 46.74,15.4
X$1816 362 116 144 327 BUF_X1
* cell instance $1817 m0 *1 45.41,15.4
X$1817 327 235 352 116 144 329 MUX2_X1
* cell instance $1819 m0 *1 47.88,15.4
X$1819 352 116 144 321 BUF_X1
* cell instance $1821 m0 *1 48.45,15.4
X$1821 324 116 144 346 BUF_X1
* cell instance $1824 r0 *1 48.45,15.4
X$1824 361 116 144 349 BUF_X1
* cell instance $1826 m0 *1 1.33,7
X$1826 202 116 144 230 BUF_X1
* cell instance $1828 m0 *1 1.9,7
X$1828 231 116 144 200 BUF_X1
* cell instance $1829 m0 *1 2.47,7
X$1829 184 203 202 116 144 185 MUX2_X1
* cell instance $1831 m0 *1 3.99,7
X$1831 220 203 221 116 144 186 MUX2_X1
* cell instance $1834 m0 *1 14.44,7
X$1834 116 970 189 224 171 144 DFF_X1
* cell instance $1845 r0 *1 6.46,7
X$1845 247 116 144 222 BUF_X1
* cell instance $1859 r0 *1 23.94,7
X$1859 138 197 144 116 227 AND2_X1
* cell instance $1861 m0 *1 26.98,7
X$1861 116 989 121 192 156 144 DFF_X1
* cell instance $1867 m0 *1 33.25,7
X$1867 138 137 144 116 193 AND2_X1
* cell instance $1881 r0 *1 39.9,7
X$1881 211 235 212 116 144 225 MUX2_X1
* cell instance $1887 r0 *1 45.79,7
X$1887 223 116 144 214 BUF_X1
* cell instance $1888 r0 *1 46.36,7
X$1888 214 235 215 116 144 216 MUX2_X1
* cell instance $1889 r0 *1 47.69,7
X$1889 215 116 144 218 BUF_X1
* cell instance $1892 m0 *1 48.45,7
X$1892 219 116 144 194 BUF_X1
* cell instance $1893 r0 *1 48.45,7
X$1893 217 116 144 239 BUF_X1
* cell instance $1895 m0 *1 1.33,29.4
X$1895 530 116 144 540 BUF_X1
* cell instance $1897 m0 *1 1.9,29.4
X$1897 529 116 144 550 BUF_X1
* cell instance $1898 m0 *1 2.47,29.4
X$1898 523 116 144 552 BUF_X1
* cell instance $1899 m0 *1 3.04,29.4
X$1899 116 980 530 551 518 144 DFF_X1
* cell instance $1900 m0 *1 6.27,29.4
X$1900 516 116 144 553 BUF_X1
* cell instance $1903 r0 *1 1.33,29.4
X$1903 541 116 144 542 BUF_X1
* cell instance $1904 r0 *1 1.9,29.4
X$1904 542 441 530 116 144 559 MUX2_X1
* cell instance $1908 r0 *1 3.23,29.4
X$1908 369 559 144 116 551 AND2_X1
* cell instance $1909 r0 *1 3.99,29.4
X$1909 550 441 588 116 144 567 MUX2_X1
* cell instance $1911 r0 *1 5.7,29.4
X$1911 552 543 560 116 144 544 MUX2_X1
* cell instance $1912 r0 *1 7.03,29.4
X$1912 369 567 144 116 599 AND2_X1
* cell instance $1914 m0 *1 7.22,29.4
X$1914 233 544 144 116 524 AND2_X1
* cell instance $1917 r0 *1 8.17,29.4
X$1917 553 543 545 116 144 554 MUX2_X1
* cell instance $1919 m0 *1 9.12,29.4
X$1919 233 554 144 116 537 AND2_X1
* cell instance $1920 m0 *1 10.07,29.4
X$1920 116 961 545 537 518 144 DFF_X1
* cell instance $1922 m0 *1 13.49,29.4
X$1922 317 116 144 705 CLKBUF_X3
* cell instance $1927 r0 *1 10.64,29.4
X$1927 116 1047 573 568 518 144 DFF_X1
* cell instance $1928 r0 *1 13.87,29.4
X$1928 499 574 144 116 568 AND2_X1
* cell instance $1931 m0 *1 16.34,29.4
X$1931 317 144 441 116 BUF_X4
* cell instance $1938 r0 *1 25.46,29.4
X$1938 570 116 144 466 BUF_X1
* cell instance $1940 r0 *1 26.22,29.4
X$1940 569 445 116 144 575 NOR2_X1
* cell instance $1943 m0 *1 8.55,32.2
X$1943 573 116 144 572 BUF_X1
* cell instance $1946 m0 *1 9.31,32.2
X$1946 116 1014 588 599 518 144 DFF_X1
* cell instance $1947 m0 *1 12.54,32.2
X$1947 600 441 573 116 144 574 MUX2_X1
* cell instance $1951 m0 *1 24.51,32.2
X$1951 116 1006 604 575 519 144 DFF_X1
* cell instance $1953 m0 *1 27.93,32.2
X$1953 604 116 144 514 CLKBUF_X3
* cell instance $1954 m0 *1 28.88,32.2
X$1954 467 513 514 522 116 144 589 OR4_X1
* cell instance $1955 m0 *1 30.02,32.2
X$1955 484 576 525 561 590 116 144 OAI211_X2
* cell instance $1956 m0 *1 31.73,32.2
X$1956 501 493 467 522 116 144 578 OR4_X1
* cell instance $1957 m0 *1 32.87,32.2
X$1957 514 116 144 577 INV_X1
* cell instance $1958 m0 *1 33.25,32.2
X$1958 539 116 144 513 CLKBUF_X3
* cell instance $1959 m0 *1 34.2,32.2
X$1959 591 578 116 144 579 NOR2_X1
* cell instance $1961 m0 *1 34.96,32.2
X$1961 563 578 591 116 144 602 OR3_X1
* cell instance $1962 m0 *1 35.91,32.2
X$1962 580 116 144 593 INV_X1
* cell instance $1967 m0 *1 41.8,32.2
X$1967 489 116 144 INV_X2
* cell instance $1972 m0 *1 2.09,32.2
X$1972 116 982 612 587 518 144 DFF_X1
* cell instance $1975 r0 *1 1.33,32.2
X$1975 611 116 144 607 BUF_X1
* cell instance $1976 r0 *1 1.9,32.2
X$1976 558 116 144 641 BUF_X1
* cell instance $1978 r0 *1 2.85,32.2
X$1978 610 609 144 116 587 AND2_X1
* cell instance $1983 r0 *1 3.8,32.2
X$1983 116 1081 611 621 518 144 DFF_X1
* cell instance $1985 m0 *1 5.7,32.2
X$1985 610 623 144 116 622 AND2_X1
* cell instance $1987 r0 *1 7.03,32.2
X$1987 571 116 144 600 BUF_X1
* cell instance $1989 r0 *1 7.98,32.2
X$1989 116 1080 614 629 518 144 DFF_X1
* cell instance $1994 r0 *1 24.32,32.2
X$1994 624 116 144 484 CLKBUF_X2
* cell instance $1997 r0 *1 25.65,32.2
X$1997 445 625 512 116 603 144 AOI21_X1
* cell instance $1999 r0 *1 26.6,32.2
X$1999 458 513 631 144 625 116 OAI21_X1
* cell instance $2002 r0 *1 29.07,32.2
X$2002 589 501 681 116 605 144 AOI21_X1
* cell instance $2005 r0 *1 32.11,32.2
X$2005 627 445 116 144 626 NOR2_X1
* cell instance $2006 r0 *1 32.68,32.2
X$2006 514 584 513 601 116 144 627 AOI22_X1
* cell instance $2007 r0 *1 33.63,32.2
X$2007 592 580 513 116 144 512 NAND3_X1
* cell instance $2008 r0 *1 34.39,32.2
X$2008 615 592 580 116 591 144 AOI21_X1
* cell instance $2009 r0 *1 35.15,32.2
X$2009 579 577 445 593 602 116 144 635 AOI221_X1
* cell instance $2011 r0 *1 36.67,32.2
X$2011 592 580 116 144 601 NAND2_X1
* cell instance $2015 r0 *1 40.85,32.2
X$2015 566 116 144 653 CLKBUF_X3
* cell instance $2017 r0 *1 41.99,32.2
X$2017 582 116 144 564 BUF_X1
* cell instance $2018 r0 *1 42.56,32.2
X$2018 116 1051 616 597 489 144 DFF_X1
* cell instance $2019 m0 *1 44.08,32.2
X$2019 594 598 144 116 597 AND2_X1
* cell instance $2020 m0 *1 43.51,32.2
X$2020 580 116 144 583 BUF_X1
* cell instance $2021 m0 *1 44.84,32.2
X$2021 656 653 616 116 144 598 MUX2_X1
* cell instance $2023 r0 *1 45.79,32.2
X$2023 116 1048 617 637 489 144 DFF_X1
* cell instance $2024 m0 *1 46.74,32.2
X$2024 548 116 144 581 BUF_X1
* cell instance $2027 m0 *1 47.5,32.2
X$2027 532 116 144 565 BUF_X1
* cell instance $2030 m0 *1 48.45,32.2
X$2030 533 116 144 534 BUF_X1
* cell instance $2032 m0 *1 1.33,40.6
X$2032 687 116 144 731 BUF_X1
* cell instance $2034 m0 *1 1.9,40.6
X$2034 731 705 752 116 144 702 MUX2_X1
* cell instance $2035 m0 *1 3.23,40.6
X$2035 610 702 144 116 733 AND2_X1
* cell instance $2036 m0 *1 3.99,40.6
X$2036 703 543 688 116 144 704 MUX2_X1
* cell instance $2037 m0 *1 5.32,40.6
X$2037 610 704 144 116 717 AND2_X1
* cell instance $2039 m0 *1 7.6,40.6
X$2039 706 705 665 116 144 723 MUX2_X1
* cell instance $2041 m0 *1 11.97,40.6
X$2041 116 1012 786 737 680 144 DFF_X1
* cell instance $2043 m0 *1 15.39,40.6
X$2043 499 116 144 753 CLKBUF_X2
* cell instance $2045 m0 *1 16.34,40.6
X$2045 707 441 709 116 144 708 MUX2_X1
* cell instance $2047 m0 *1 17.86,40.6
X$2047 499 708 144 116 726 AND2_X1
* cell instance $2049 m0 *1 18.81,40.6
X$2049 499 738 144 116 724 AND2_X1
* cell instance $2054 r0 *1 1.33,40.6
X$2054 730 441 776 116 144 732 MUX2_X1
* cell instance $2055 r0 *1 2.66,40.6
X$2055 369 732 144 116 767 AND2_X1
* cell instance $2059 r0 *1 3.42,40.6
X$2059 116 1088 752 733 644 144 DFF_X1
* cell instance $2060 r0 *1 6.65,40.6
X$2060 560 116 144 766 BUF_X1
* cell instance $2064 r0 *1 9.31,40.6
X$2064 734 705 768 116 144 735 MUX2_X1
* cell instance $2065 r0 *1 10.64,40.6
X$2065 753 735 144 116 778 AND2_X1
* cell instance $2068 r0 *1 12.54,40.6
X$2068 753 777 144 116 737 AND2_X1
* cell instance $2071 r0 *1 14.44,40.6
X$2071 116 1090 781 782 680 144 DFF_X1
* cell instance $2072 r0 *1 17.67,40.6
X$2072 800 441 739 116 144 738 MUX2_X1
* cell instance $2075 r0 *1 22.23,40.6
X$2075 769 666 740 116 144 710 MUX2_X1
* cell instance $2077 m0 *1 22.23,40.6
X$2077 116 1003 740 756 630 144 DFF_X1
* cell instance $2080 m0 *1 25.84,40.6
X$2080 116 1021 741 758 711 144 DFF_X1
* cell instance $2081 m0 *1 29.26,40.6
X$2081 116 1025 763 690 711 144 DFF_X1
* cell instance $2084 r0 *1 26.79,40.6
X$2084 689 760 144 116 758 AND2_X1
* cell instance $2088 r0 *1 29.64,40.6
X$2088 759 566 763 116 144 761 MUX2_X1
* cell instance $2091 m0 *1 36.1,40.6
X$2091 116 993 742 762 652 144 DFF_X1
* cell instance $2092 m0 *1 32.87,40.6
X$2092 116 1020 791 722 711 144 DFF_X1
* cell instance $2094 r0 *1 33.25,40.6
X$2094 566 116 144 770 CLKBUF_X3
* cell instance $2098 r0 *1 39.14,40.6
X$2098 691 792 144 116 771 AND2_X1
* cell instance $2100 m0 *1 39.71,40.6
X$2100 116 999 743 755 652 144 DFF_X1
* cell instance $2103 r0 *1 41.61,40.6
X$2103 757 653 743 116 144 744 MUX2_X1
* cell instance $2104 r0 *1 42.94,40.6
X$2104 714 116 144 757 BUF_X1
* cell instance $2106 m0 *1 43.32,40.6
X$2106 594 744 144 116 755 AND2_X1
* cell instance $2107 m0 *1 44.27,40.6
X$2107 594 720 144 116 754 AND2_X1
* cell instance $2109 r0 *1 43.51,40.6
X$2109 116 1058 713 754 652 144 DFF_X1
* cell instance $2111 m0 *1 45.41,40.6
X$2111 594 718 144 116 712 AND2_X1
* cell instance $2112 m0 *1 46.36,40.6
X$2112 745 653 713 116 144 720 MUX2_X1
* cell instance $2113 m0 *1 47.69,40.6
X$2113 772 653 793 116 144 718 MUX2_X1
* cell instance $2115 r0 *1 46.74,40.6
X$2115 594 751 144 116 775 AND2_X1
* cell instance $2116 r0 *1 47.5,40.6
X$2116 750 653 749 116 144 751 MUX2_X1
* cell instance $2122 r0 *1 33.82,1.4
X$2122 138 120 144 116 183 AND2_X1
* cell instance $2129 m0 *1 44.46,23.8
X$2129 116 957 437 457 359 144 DFF_X1
* cell instance $2131 m0 *1 47.69,23.8
X$2131 425 407 437 116 144 430 MUX2_X1
* cell instance $2133 r0 *1 44.27,23.8
X$2133 470 116 144 473 BUF_X1
* cell instance $2134 r0 *1 44.84,23.8
X$2134 490 407 452 116 144 491 MUX2_X1
* cell instance $2135 r0 *1 46.17,23.8
X$2135 452 116 144 475 BUF_X1
* cell instance $2137 r0 *1 47.12,23.8
X$2137 474 407 502 116 144 471 MUX2_X1
* cell instance $2138 r0 *1 48.45,23.8
X$2138 472 116 144 474 BUF_X1
* cell instance $2142 m0 *1 11.59,4.2
X$2142 116 974 125 168 171 144 DFF_X1
* cell instance $2143 m0 *1 14.82,4.2
X$2143 116 976 155 126 171 144 DFF_X1
* cell instance $2147 r0 *1 2.09,4.2
X$2147 201 116 144 184 BUF_X1
* cell instance $2153 m0 *1 24.32,4.2
X$2153 138 131 144 116 176 AND2_X1
* cell instance $2156 m0 *1 29.26,4.2
X$2156 134 133 121 116 144 180 MUX2_X1
* cell instance $2158 m0 *1 30.78,4.2
X$2158 182 133 135 116 144 136 MUX2_X1
* cell instance $2163 m0 *1 45.41,4.2
X$2163 116 996 163 145 139 144 DFF_X1
* cell instance $2167 r0 *1 26.41,4.2
X$2167 138 179 144 116 132 AND2_X1
* cell instance $2169 r0 *1 27.36,4.2
X$2169 138 180 144 116 192 AND2_X1
* cell instance $2170 r0 *1 28.12,4.2
X$2170 138 136 144 116 181 AND2_X1
* cell instance $2171 r0 *1 28.88,4.2
X$2171 116 1032 135 181 156 144 DFF_X1
* cell instance $2173 r0 *1 32.87,4.2
X$2173 116 1036 122 193 156 144 DFF_X1
* cell instance $2175 r0 *1 39.33,4.2
X$2175 116 1083 158 157 139 144 DFF_X1
* cell instance $2179 r0 *1 45.41,4.2
X$2179 116 1093 219 160 139 144 DFF_X1
.ENDS axi_lite_master

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT CLKBUF_X1 1 3 4
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X2 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT INV_X4 1 2 3
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2
