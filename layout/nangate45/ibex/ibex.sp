* cell ibex_core
* pin instr_rdata_i[17]
* pin instr_rdata_i[14]
* pin instr_rdata_i[11]
* pin instr_rdata_i[16]
* pin instr_rdata_i[13]
* pin instr_rdata_i[18]
* pin instr_rdata_i[12]
* pin instr_rdata_i[15]
* pin data_rdata_i[28]
* pin data_rdata_i[20]
* pin data_rdata_i[12]
* pin instr_rdata_i[10]
* pin instr_rdata_i[29]
* pin data_rdata_i[4]
* pin instr_rdata_i[30]
* pin instr_rdata_i[31]
* pin data_rdata_i[29]
* pin instr_rdata_i[26]
* pin data_rdata_i[21]
* pin data_rdata_i[13]
* pin instr_rdata_i[27]
* pin data_rdata_i[5]
* pin instr_rdata_i[9]
* pin instr_rdata_i[25]
* pin instr_rdata_i[28]
* pin data_rdata_i[8]
* pin data_rdata_i[24]
* pin data_rdata_i[16]
* pin data_rdata_i[0]
* pin instr_rdata_i[19]
* pin data_we_o
* pin instr_rdata_i[20]
* pin data_err_i
* pin data_req_o
* pin instr_rdata_i[2]
* pin instr_rdata_i[3]
* pin instr_rdata_i[22]
* pin instr_rdata_i[4]
* pin instr_rdata_i[6]
* pin instr_rdata_i[21]
* pin instr_rdata_i[5]
* pin instr_rdata_i[23]
* pin instr_rdata_i[24]
* pin instr_rdata_i[1]
* pin instr_rdata_i[8]
* pin instr_rdata_i[0]
* pin instr_rdata_i[7]
* pin instr_err_i
* pin instr_rvalid_i
* pin instr_req_o
* pin fetch_enable_i
* pin test_en_i
* pin core_sleep_o
* pin debug_req_i
* pin hart_id_i[0]
* pin hart_id_i[2]
* pin PWELL
* pin rst_ni
* pin NWELL
* pin clk_i
* pin hart_id_i[22]
* pin hart_id_i[26]
* pin hart_id_i[19]
* pin irq_fast_i[10]
* pin hart_id_i[30]
* pin irq_external_i
* pin hart_id_i[4]
* pin hart_id_i[29]
* pin irq_fast_i[11]
* pin hart_id_i[23]
* pin irq_fast_i[5]
* pin irq_fast_i[3]
* pin hart_id_i[11]
* pin irq_fast_i[6]
* pin irq_fast_i[7]
* pin irq_fast_i[8]
* pin hart_id_i[6]
* pin irq_software_i
* pin irq_fast_i[0]
* pin irq_fast_i[1]
* pin irq_fast_i[14]
* pin hart_id_i[21]
* pin hart_id_i[5]
* pin irq_fast_i[12]
* pin irq_fast_i[2]
* pin hart_id_i[10]
* pin irq_fast_i[13]
* pin irq_timer_i
* pin hart_id_i[18]
* pin hart_id_i[31]
* pin hart_id_i[7]
* pin irq_nm_i
* pin hart_id_i[25]
* pin irq_fast_i[9]
* pin hart_id_i[3]
* pin data_rdata_i[14]
* pin hart_id_i[20]
* pin hart_id_i[17]
* pin irq_fast_i[4]
* pin data_rdata_i[22]
* pin hart_id_i[8]
* pin hart_id_i[12]
* pin hart_id_i[15]
* pin data_rdata_i[27]
* pin data_rdata_i[11]
* pin data_rdata_i[19]
* pin data_rdata_i[3]
* pin hart_id_i[1]
* pin hart_id_i[13]
* pin data_rdata_i[6]
* pin data_rdata_i[30]
* pin hart_id_i[14]
* pin instr_gnt_i
* pin hart_id_i[9]
* pin hart_id_i[27]
* pin hart_id_i[24]
* pin data_rvalid_i
* pin data_rdata_i[9]
* pin hart_id_i[16]
* pin hart_id_i[28]
* pin data_rdata_i[7]
* pin data_rdata_i[17]
* pin data_rdata_i[15]
* pin data_rdata_i[18]
* pin data_rdata_i[10]
* pin data_rdata_i[31]
* pin boot_addr_i[8]
* pin data_rdata_i[23]
* pin data_rdata_i[2]
* pin data_rdata_i[26]
* pin data_rdata_i[25]
* pin data_rdata_i[1]
* pin boot_addr_i[9]
* pin boot_addr_i[13]
* pin boot_addr_i[15]
* pin boot_addr_i[16]
* pin boot_addr_i[20]
* pin boot_addr_i[14]
* pin boot_addr_i[10]
* pin boot_addr_i[19]
* pin boot_addr_i[28]
* pin boot_addr_i[11]
* pin boot_addr_i[23]
* pin boot_addr_i[31]
* pin boot_addr_i[24]
* pin boot_addr_i[21]
* pin boot_addr_i[17]
* pin boot_addr_i[30]
* pin data_gnt_i
* pin boot_addr_i[25]
* pin boot_addr_i[12]
* pin boot_addr_i[18]
* pin boot_addr_i[22]
* pin boot_addr_i[27]
* pin boot_addr_i[26]
* pin boot_addr_i[29]
* pin data_be_o[1]
* pin instr_addr_o[7]
* pin data_be_o[3]
* pin instr_addr_o[6]
* pin data_be_o[2]
* pin instr_addr_o[8]
* pin instr_addr_o[5]
* pin data_wdata_o[0]
* pin data_wdata_o[8]
* pin instr_addr_o[4]
* pin instr_addr_o[3]
* pin data_wdata_o[2]
* pin data_wdata_o[24]
* pin data_wdata_o[16]
* pin data_wdata_o[4]
* pin data_wdata_o[9]
* pin instr_addr_o[2]
* pin instr_addr_o[9]
* pin data_wdata_o[31]
* pin data_wdata_o[6]
* pin data_wdata_o[5]
* pin instr_addr_o[11]
* pin data_wdata_o[7]
* pin instr_addr_o[12]
* pin data_wdata_o[30]
* pin data_wdata_o[3]
* pin instr_addr_o[10]
* pin instr_addr_o[13]
* pin data_wdata_o[29]
* pin data_wdata_o[28]
* pin data_wdata_o[25]
* pin instr_addr_o[31]
* pin instr_addr_o[19]
* pin instr_addr_o[30]
* pin instr_addr_o[15]
* pin instr_addr_o[14]
* pin instr_addr_o[29]
* pin data_addr_o[4]
* pin data_addr_o[11]
* pin instr_addr_o[17]
* pin instr_addr_o[24]
* pin instr_addr_o[16]
* pin data_addr_o[9]
* pin instr_addr_o[23]
* pin instr_addr_o[18]
* pin instr_addr_o[21]
* pin data_addr_o[7]
* pin instr_addr_o[25]
* pin data_addr_o[6]
* pin data_addr_o[5]
* pin data_addr_o[15]
* pin data_addr_o[20]
* pin data_addr_o[3]
* pin instr_addr_o[28]
* pin instr_addr_o[27]
* pin data_addr_o[2]
* pin instr_addr_o[26]
* pin instr_addr_o[20]
* pin data_addr_o[31]
* pin instr_addr_o[22]
* pin data_addr_o[16]
* pin data_addr_o[10]
* pin data_addr_o[12]
* pin data_addr_o[18]
* pin data_addr_o[8]
* pin data_addr_o[14]
* pin data_addr_o[13]
* pin data_addr_o[17]
* pin data_addr_o[28]
* pin data_addr_o[19]
* pin data_addr_o[27]
* pin data_addr_o[21]
* pin data_addr_o[22]
* pin data_addr_o[26]
* pin data_addr_o[29]
* pin data_addr_o[25]
* pin data_addr_o[24]
* pin data_addr_o[30]
* pin data_addr_o[23]
* pin instr_addr_o[0]
* pin alert_minor_o
* pin data_addr_o[1]
* pin data_addr_o[0]
* pin alert_major_o
* pin instr_addr_o[1]
* pin data_wdata_o[19]
* pin data_wdata_o[26]
* pin data_wdata_o[15]
* pin data_wdata_o[10]
* pin data_wdata_o[12]
* pin data_wdata_o[17]
* pin data_wdata_o[13]
* pin data_wdata_o[14]
* pin data_wdata_o[20]
* pin data_wdata_o[21]
* pin data_wdata_o[1]
* pin data_wdata_o[18]
* pin data_wdata_o[22]
* pin data_wdata_o[11]
* pin data_wdata_o[23]
* pin data_wdata_o[27]
* pin data_be_o[0]
.SUBCKT ibex_core 1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16 17 18 19 20 21 22 23
+ 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 48 49
+ 50 51 52 53 54 55 56 77 108 109 272 2124 2193 2262 2264 2458 2595 2596 2685
+ 2687 2851 2854 2855 2992 3252 3253 3539 3678 3679 3843 3847 3961 3962 3963
+ 3964 4123 4272 4273 4386 4387 4388 4565 4566 4568 4695 4696 4766 4838 4839
+ 4840 4841 4842 4845 4848 4893 5010 5011 5012 5097 5098 5100 5164 5229 5230
+ 5231 5639 5640 5741 5863 5928 5929 6011 6012 6013 6150 6151 6152 6211 6279
+ 6342 6437 6438 6570 6787 7538 7683 7684 8126 8127 8297 8450 8451 8590 8591
+ 8736 8737 8738 8909 8910 9002 9081 9082 9086 9239 9384 9544 9717 10347 10501
+ 10502 10657 10835 10836 11187 11344 11345 11511 11634 11635 11636 11790 11961
+ 11962 11963 11964 12148 12149 12150 12306 12307 12308 12469 12470 12624 12625
+ 12773 12774 12920 12921 13087 13196 13197 13316 13317 13472 13473 13615 13616
+ 13617 13731 13732 13733 13856 13857 13971 13972 13973 13979 14099 14100 14245
+ 14246 14247 14368 14369 14370 14510 14511 14513 14630 14866 14867 15099 15206
+ 15207 15311 15312 15403 15506 15595 15596 15597 15694 15773 15774 15775 17860
+ 17910 17912 17949 17980 17981 18261 18263 18264 18265 18266 18267 18268 18269
+ 18270 18271 18272 18273 18274 18275 18276 18277 18278
* net 1 instr_rdata_i[17]
* net 2 instr_rdata_i[14]
* net 3 instr_rdata_i[11]
* net 4 instr_rdata_i[16]
* net 5 instr_rdata_i[13]
* net 6 instr_rdata_i[18]
* net 7 instr_rdata_i[12]
* net 8 instr_rdata_i[15]
* net 9 data_rdata_i[28]
* net 10 data_rdata_i[20]
* net 11 data_rdata_i[12]
* net 12 instr_rdata_i[10]
* net 13 instr_rdata_i[29]
* net 14 data_rdata_i[4]
* net 15 instr_rdata_i[30]
* net 16 instr_rdata_i[31]
* net 17 data_rdata_i[29]
* net 18 instr_rdata_i[26]
* net 19 data_rdata_i[21]
* net 20 data_rdata_i[13]
* net 21 instr_rdata_i[27]
* net 22 data_rdata_i[5]
* net 23 instr_rdata_i[9]
* net 24 instr_rdata_i[25]
* net 25 instr_rdata_i[28]
* net 26 data_rdata_i[8]
* net 27 data_rdata_i[24]
* net 28 data_rdata_i[16]
* net 29 data_rdata_i[0]
* net 30 instr_rdata_i[19]
* net 31 data_we_o
* net 32 instr_rdata_i[20]
* net 33 data_err_i
* net 34 data_req_o
* net 35 instr_rdata_i[2]
* net 36 instr_rdata_i[3]
* net 37 instr_rdata_i[22]
* net 38 instr_rdata_i[4]
* net 39 instr_rdata_i[6]
* net 40 instr_rdata_i[21]
* net 41 instr_rdata_i[5]
* net 42 instr_rdata_i[23]
* net 43 instr_rdata_i[24]
* net 44 instr_rdata_i[1]
* net 45 instr_rdata_i[8]
* net 46 instr_rdata_i[0]
* net 47 instr_rdata_i[7]
* net 48 instr_err_i
* net 49 instr_rvalid_i
* net 50 instr_req_o
* net 51 fetch_enable_i
* net 52 test_en_i
* net 53 core_sleep_o
* net 54 debug_req_i
* net 55 hart_id_i[0]
* net 56 hart_id_i[2]
* net 77 PWELL
* net 108 rst_ni
* net 109 NWELL
* net 272 clk_i
* net 2124 hart_id_i[22]
* net 2193 hart_id_i[26]
* net 2262 hart_id_i[19]
* net 2264 irq_fast_i[10]
* net 2458 hart_id_i[30]
* net 2595 irq_external_i
* net 2596 hart_id_i[4]
* net 2685 hart_id_i[29]
* net 2687 irq_fast_i[11]
* net 2851 hart_id_i[23]
* net 2854 irq_fast_i[5]
* net 2855 irq_fast_i[3]
* net 2992 hart_id_i[11]
* net 3252 irq_fast_i[6]
* net 3253 irq_fast_i[7]
* net 3539 irq_fast_i[8]
* net 3678 hart_id_i[6]
* net 3679 irq_software_i
* net 3843 irq_fast_i[0]
* net 3847 irq_fast_i[1]
* net 3961 irq_fast_i[14]
* net 3962 hart_id_i[21]
* net 3963 hart_id_i[5]
* net 3964 irq_fast_i[12]
* net 4123 irq_fast_i[2]
* net 4272 hart_id_i[10]
* net 4273 irq_fast_i[13]
* net 4386 irq_timer_i
* net 4387 hart_id_i[18]
* net 4388 hart_id_i[31]
* net 4565 hart_id_i[7]
* net 4566 irq_nm_i
* net 4568 hart_id_i[25]
* net 4695 irq_fast_i[9]
* net 4696 hart_id_i[3]
* net 4766 data_rdata_i[14]
* net 4838 hart_id_i[20]
* net 4839 hart_id_i[17]
* net 4840 irq_fast_i[4]
* net 4841 data_rdata_i[22]
* net 4842 hart_id_i[8]
* net 4845 hart_id_i[12]
* net 4848 hart_id_i[15]
* net 4893 data_rdata_i[27]
* net 5010 data_rdata_i[11]
* net 5011 data_rdata_i[19]
* net 5012 data_rdata_i[3]
* net 5097 hart_id_i[1]
* net 5098 hart_id_i[13]
* net 5100 data_rdata_i[6]
* net 5164 data_rdata_i[30]
* net 5229 hart_id_i[14]
* net 5230 instr_gnt_i
* net 5231 hart_id_i[9]
* net 5639 hart_id_i[27]
* net 5640 hart_id_i[24]
* net 5741 data_rvalid_i
* net 5863 data_rdata_i[9]
* net 5928 hart_id_i[16]
* net 5929 hart_id_i[28]
* net 6011 data_rdata_i[7]
* net 6012 data_rdata_i[17]
* net 6013 data_rdata_i[15]
* net 6150 data_rdata_i[18]
* net 6151 data_rdata_i[10]
* net 6152 data_rdata_i[31]
* net 6211 boot_addr_i[8]
* net 6279 data_rdata_i[23]
* net 6342 data_rdata_i[2]
* net 6437 data_rdata_i[26]
* net 6438 data_rdata_i[25]
* net 6570 data_rdata_i[1]
* net 6787 boot_addr_i[9]
* net 7538 boot_addr_i[13]
* net 7683 boot_addr_i[15]
* net 7684 boot_addr_i[16]
* net 8126 boot_addr_i[20]
* net 8127 boot_addr_i[14]
* net 8297 boot_addr_i[10]
* net 8450 boot_addr_i[19]
* net 8451 boot_addr_i[28]
* net 8590 boot_addr_i[11]
* net 8591 boot_addr_i[23]
* net 8736 boot_addr_i[31]
* net 8737 boot_addr_i[24]
* net 8738 boot_addr_i[21]
* net 8909 boot_addr_i[17]
* net 8910 boot_addr_i[30]
* net 9002 data_gnt_i
* net 9081 boot_addr_i[25]
* net 9082 boot_addr_i[12]
* net 9086 boot_addr_i[18]
* net 9239 boot_addr_i[22]
* net 9384 boot_addr_i[27]
* net 9544 boot_addr_i[26]
* net 9717 boot_addr_i[29]
* net 10347 data_be_o[1]
* net 10501 instr_addr_o[7]
* net 10502 data_be_o[3]
* net 10657 instr_addr_o[6]
* net 10835 data_be_o[2]
* net 10836 instr_addr_o[8]
* net 11187 instr_addr_o[5]
* net 11344 data_wdata_o[0]
* net 11345 data_wdata_o[8]
* net 11511 instr_addr_o[4]
* net 11634 instr_addr_o[3]
* net 11635 data_wdata_o[2]
* net 11636 data_wdata_o[24]
* net 11790 data_wdata_o[16]
* net 11961 data_wdata_o[4]
* net 11962 data_wdata_o[9]
* net 11963 instr_addr_o[2]
* net 11964 instr_addr_o[9]
* net 12148 data_wdata_o[31]
* net 12149 data_wdata_o[6]
* net 12150 data_wdata_o[5]
* net 12306 instr_addr_o[11]
* net 12307 data_wdata_o[7]
* net 12308 instr_addr_o[12]
* net 12469 data_wdata_o[30]
* net 12470 data_wdata_o[3]
* net 12624 instr_addr_o[10]
* net 12625 instr_addr_o[13]
* net 12773 data_wdata_o[29]
* net 12774 data_wdata_o[28]
* net 12920 data_wdata_o[25]
* net 12921 instr_addr_o[31]
* net 13087 instr_addr_o[19]
* net 13196 instr_addr_o[30]
* net 13197 instr_addr_o[15]
* net 13316 instr_addr_o[14]
* net 13317 instr_addr_o[29]
* net 13472 data_addr_o[4]
* net 13473 data_addr_o[11]
* net 13615 instr_addr_o[17]
* net 13616 instr_addr_o[24]
* net 13617 instr_addr_o[16]
* net 13731 data_addr_o[9]
* net 13732 instr_addr_o[23]
* net 13733 instr_addr_o[18]
* net 13856 instr_addr_o[21]
* net 13857 data_addr_o[7]
* net 13971 instr_addr_o[25]
* net 13972 data_addr_o[6]
* net 13973 data_addr_o[5]
* net 13979 data_addr_o[15]
* net 14099 data_addr_o[20]
* net 14100 data_addr_o[3]
* net 14245 instr_addr_o[28]
* net 14246 instr_addr_o[27]
* net 14247 data_addr_o[2]
* net 14368 instr_addr_o[26]
* net 14369 instr_addr_o[20]
* net 14370 data_addr_o[31]
* net 14510 instr_addr_o[22]
* net 14511 data_addr_o[16]
* net 14513 data_addr_o[10]
* net 14630 data_addr_o[12]
* net 14866 data_addr_o[18]
* net 14867 data_addr_o[8]
* net 15099 data_addr_o[14]
* net 15206 data_addr_o[13]
* net 15207 data_addr_o[17]
* net 15311 data_addr_o[28]
* net 15312 data_addr_o[19]
* net 15403 data_addr_o[27]
* net 15506 data_addr_o[21]
* net 15595 data_addr_o[22]
* net 15596 data_addr_o[26]
* net 15597 data_addr_o[29]
* net 15694 data_addr_o[25]
* net 15773 data_addr_o[24]
* net 15774 data_addr_o[30]
* net 15775 data_addr_o[23]
* net 17860 instr_addr_o[0]
* net 17910 alert_minor_o
* net 17912 data_addr_o[1]
* net 17949 data_addr_o[0]
* net 17980 alert_major_o
* net 17981 instr_addr_o[1]
* net 18261 data_wdata_o[19]
* net 18263 data_wdata_o[26]
* net 18264 data_wdata_o[15]
* net 18265 data_wdata_o[10]
* net 18266 data_wdata_o[12]
* net 18267 data_wdata_o[17]
* net 18268 data_wdata_o[13]
* net 18269 data_wdata_o[14]
* net 18270 data_wdata_o[20]
* net 18271 data_wdata_o[21]
* net 18272 data_wdata_o[1]
* net 18273 data_wdata_o[18]
* net 18274 data_wdata_o[22]
* net 18275 data_wdata_o[11]
* net 18276 data_wdata_o[23]
* net 18277 data_wdata_o[27]
* net 18278 data_be_o[0]
* cell instance $6 r0 *1 95.76,1.4
X$6 1 77 109 82 BUF_X2
* cell instance $11 r0 *1 96.71,1.4
X$11 2 77 109 320 BUF_X1
* cell instance $14 m0 *1 96.9,4.2
X$14 3 77 109 640 BUF_X1
* cell instance $20 r0 *1 97.28,1.4
X$20 4 77 109 196 CLKBUF_X2
* cell instance $26 r0 *1 98.23,1.4
X$26 5 77 109 83 BUF_X1
* cell instance $32 m0 *1 98.42,4.2
X$32 6 77 109 138 BUF_X1
* cell instance $38 m0 *1 99.56,4.2
X$38 7 77 109 351 BUF_X1
* cell instance $44 m0 *1 100.32,4.2
X$44 8 77 109 139 BUF_X1
* cell instance $50 m0 *1 100.89,4.2
X$50 9 77 109 213 CLKBUF_X2
* cell instance $56 r0 *1 99.94,1.4
X$56 10 77 109 57 BUF_X1
* cell instance $62 r0 *1 99.37,1.4
X$62 11 77 109 112 BUF_X1
* cell instance $72 r0 *1 103.74,1.4
X$72 12 77 109 119 BUF_X1
* cell instance $74 m0 *1 104.5,7
X$74 13 77 109 248 BUF_X1
* cell instance $80 m0 *1 101.27,7
X$80 14 77 109 276 BUF_X1
* cell instance $86 r0 *1 104.31,1.4
X$86 15 77 109 117 BUF_X1
* cell instance $92 m0 *1 105.26,7
X$92 16 77 109 324 BUF_X1
* cell instance $98 r0 *1 105.83,1.4
X$98 17 77 109 325 CLKBUF_X2
* cell instance $104 r0 *1 106.59,4.2
X$104 18 77 109 156 BUF_X1
* cell instance $110 r0 *1 107.35,4.2
X$110 19 77 109 250 BUF_X1
* cell instance $116 r0 *1 106.78,1.4
X$116 20 77 109 84 BUF_X1
* cell instance $122 r0 *1 105.26,1.4
X$122 21 77 109 215 BUF_X1
* cell instance $128 r0 *1 108.11,4.2
X$128 22 77 109 252 BUF_X1
* cell instance $134 r0 *1 110.01,1.4
X$134 23 77 109 86 BUF_X1
* cell instance $140 r0 *1 110.39,4.2
X$140 24 77 109 167 BUF_X1
* cell instance $146 r0 *1 111.15,4.2
X$146 25 77 109 58 BUF_X1
* cell instance $152 r0 *1 112.29,1.4
X$152 26 77 109 79 BUF_X2
* cell instance $158 r0 *1 113.05,1.4
X$158 27 77 109 125 CLKBUF_X2
* cell instance $164 r0 *1 113.81,4.2
X$164 28 77 109 254 BUF_X1
* cell instance $170 r0 *1 113.81,1.4
X$170 29 77 109 126 CLKBUF_X2
* cell instance $176 r0 *1 116.28,1.4
X$176 30 77 109 60 BUF_X1
* cell instance $182 m0 *1 117.23,4.2
X$182 169 77 109 31 BUF_X1
* cell instance $188 r0 *1 121.22,1.4
X$188 32 77 109 61 BUF_X1
* cell instance $194 r0 *1 120.08,1.4
X$194 33 77 109 129 BUF_X2
* cell instance $200 m0 *1 119.7,4.2
X$200 171 77 109 34 BUF_X1
* cell instance $206 m0 *1 117.8,4.2
X$206 35 77 109 444 BUF_X1
* cell instance $212 m0 *1 121.6,4.2
X$212 36 77 109 142 BUF_X1
* cell instance $218 r0 *1 123.88,1.4
X$218 37 77 109 90 BUF_X1
* cell instance $224 r0 *1 123.31,1.4
X$224 38 77 109 63 BUF_X1
* cell instance $230 m0 *1 123.69,4.2
X$230 39 77 109 359 BUF_X1
* cell instance $236 r0 *1 130.53,1.4
X$236 40 77 109 95 BUF_X1
* cell instance $242 m0 *1 130.15,4.2
X$242 41 77 109 143 BUF_X1
* cell instance $248 r0 *1 135.85,1.4
X$248 42 77 109 137 BUF_X1
* cell instance $254 m0 *1 132.62,4.2
X$254 43 77 109 175 BUF_X1
* cell instance $260 r0 *1 131.1,1.4
X$260 44 77 109 96 BUF_X1
* cell instance $266 m0 *1 134.52,4.2
X$266 45 77 109 212 BUF_X1
* cell instance $272 m0 *1 139.46,4.2
X$272 46 77 109 145 BUF_X1
* cell instance $278 m0 *1 140.22,4.2
X$278 47 77 109 146 BUF_X1
* cell instance $284 m0 *1 138.7,4.2
X$284 48 77 109 209 BUF_X2
* cell instance $290 r0 *1 147.82,1.4
X$290 49 77 109 133 CLKBUF_X2
* cell instance $296 r0 *1 155.04,1.4
X$296 100 77 109 50 BUF_X1
* cell instance $302 r0 *1 155.61,1.4
X$302 51 77 109 131 BUF_X1
* cell instance $308 m0 *1 159.6,4.2
X$308 52 77 109 162 BUF_X1
* cell instance $314 r0 *1 161.69,1.4
X$314 67 77 109 53 BUF_X1
* cell instance $320 r0 *1 166.25,1.4
X$320 54 77 109 99 BUF_X2
* cell instance $326 r0 *1 169.86,1.4
X$326 55 77 109 120 BUF_X1
* cell instance $332 r0 *1 175.18,1.4
X$332 56 77 109 115 BUF_X1
* cell instance $338 m0 *1 99.18,49
X$338 112 2650 57 77 109 2803 MUX2_X1
* cell instance $340 r0 *1 99.37,49
X$340 57 2808 2804 77 109 3015 NAND3_X1
* cell instance $343 m0 *1 95,43.4
X$343 57 2235 2329 77 109 2383 MUX2_X1
* cell instance $347 r0 *1 95.76,49
X$347 57 2649 2645 77 109 3289 MUX2_X1
* cell instance $360 r0 *1 108.49,18.2
X$360 351 887 58 77 109 1042 MUX2_X1
* cell instance $362 m0 *1 108.3,18.2
X$362 58 803 526 77 109 921 MUX2_X1
* cell instance $364 r0 *1 107.35,1.4
X$364 59 62 58 77 109 122 MUX2_X1
* cell instance $366 r0 *1 108.68,1.4
X$366 58 85 59 77 109 173 MUX2_X1
* cell instance $368 m0 *1 108.11,9.8
X$368 58 352 278 77 109 490 MUX2_X1
* cell instance $374 m0 *1 105.64,4.2
X$374 77 18301 59 122 140 109 DFF_X1
* cell instance $380 r0 *1 116.47,18.2
X$380 60 958 77 109 961 NAND2_X1
* cell instance $382 m0 *1 116.09,18.2
X$382 142 805 60 77 109 884 MUX2_X1
* cell instance $384 m0 *1 115.52,9.8
X$384 60 281 280 77 109 443 MUX2_X1
* cell instance $386 r0 *1 115.14,4.2
X$386 60 85 80 77 109 218 MUX2_X1
* cell instance $388 r0 *1 114.95,1.4
X$388 80 62 60 77 109 127 MUX2_X1
* cell instance $390 m0 *1 120.08,7
X$390 61 281 141 77 109 282 MUX2_X1
* cell instance $392 m0 *1 121.79,18.2
X$392 63 805 61 77 109 1006 MUX2_X1
* cell instance $396 m0 *1 120.27,4.2
X$396 61 85 81 77 109 170 MUX2_X1
* cell instance $398 r0 *1 121.79,1.4
X$398 81 62 61 77 109 128 MUX2_X1
* cell instance $400 m0 *1 119.51,21
X$400 61 1047 408 77 109 1093 MUX2_X1
* cell instance $407 m0 *1 101.65,4.2
X$407 154 62 156 77 109 114 MUX2_X1
* cell instance $409 m0 *1 134.52,7
X$409 332 77 109 62 CLKBUF_X3
* cell instance $411 r0 *1 110.96,1.4
X$411 87 62 167 77 109 124 MUX2_X1
* cell instance $414 r0 *1 136.42,1.4
X$414 135 62 137 77 109 136 MUX2_X1
* cell instance $416 r0 *1 129.2,1.4
X$416 94 62 95 77 109 64 MUX2_X1
* cell instance $418 m0 *1 131.29,4.2
X$418 134 62 175 77 109 65 MUX2_X1
* cell instance $422 r0 *1 124.64,1.4
X$422 91 62 90 77 109 92 MUX2_X1
* cell instance $424 r0 *1 101.46,4.2
X$424 214 62 215 77 109 246 MUX2_X1
* cell instance $441 r0 *1 121.6,15.4
X$441 63 645 713 77 109 930 MUX2_X1
* cell instance $444 m0 *1 122.74,9.8
X$444 496 358 63 77 109 560 MUX2_X1
* cell instance $446 m0 *1 122.74,12.6
X$446 63 450 496 77 109 688 MUX2_X1
* cell instance $453 r0 *1 125.97,1.4
X$453 77 18484 94 64 93 109 DFF_X1
* cell instance $458 r0 *1 131.86,1.4
X$458 77 18395 134 65 93 109 DFF_X1
* cell instance $460 r0 *1 156.75,1.4
X$460 101 67 109 77 66 AND2_X1
* cell instance $462 r0 *1 156.18,1.4
X$462 66 77 109 130 INV_X1
* cell instance $464 m0 *1 155.23,4.2
X$464 165 163 132 109 67 77 OAI21_X1
* cell instance $471 r0 *1 157.51,1.4
X$471 77 69 68 102 18999 70 109 DFFR_X2
* cell instance $473 m0 *1 158.46,7
X$473 341 178 342 77 68 109 AOI21_X1
* cell instance $477 m0 *1 162.07,7
X$477 77 69 18514 292 224 102 109 DFFR_X1
* cell instance $479 m0 *1 160.17,7
X$479 345 77 109 69 CLKBUF_X3
* cell instance $482 m0 *1 159.79,7
X$482 69 77 109 19125 INV_X1
* cell instance $485 r0 *1 155.61,4.2
X$485 77 69 221 102 19013 177 109 DFFR_X2
* cell instance $488 r0 *1 162.45,1.4
X$488 77 69 18842 123 202 102 109 DFFR_X1
* cell instance $491 m0 *1 160.17,4.2
X$491 77 69 161 102 18924 180 109 DFFR_X2
* cell instance $493 r0 *1 161.88,18.2
X$493 77 69 18841 1025 824 102 109 DFFR_X1
* cell instance $499 m0 *1 161.12,7
X$499 70 346 223 77 341 109 AOI21_X1
* cell instance $501 r0 *1 159.79,7
X$501 258 70 369 109 77 433 AND3_X1
* cell instance $505 m0 *1 173.85,9.8
X$505 77 310 375 515 377 70 109 AOI22_X4
* cell instance $507 m0 *1 159.03,9.8
X$507 70 258 369 77 457 109 NAND3_X4
* cell instance $512 r0 *1 170.81,1.4
X$512 77 157 18728 271 71 102 109 DFFR_X1
* cell instance $514 m0 *1 171,9.8
X$514 518 296 463 77 71 109 AOI21_X1
* cell instance $516 r0 *1 183.92,9.8
X$516 349 77 109 72 CLKBUF_X3
* cell instance $519 m0 *1 181.64,4.2
X$519 77 72 18689 153 200 102 109 DFFR_X1
* cell instance $521 r0 *1 180.31,21
X$521 77 72 1159 102 18971 1135 109 DFFR_X2
* cell instance $524 m0 *1 184.3,21
X$524 77 72 18531 1028 1031 102 109 DFFR_X1
* cell instance $526 r0 *1 178.41,9.8
X$526 72 77 109 19311 CLKBUF_X1
* cell instance $529 r0 *1 178.22,7
X$529 77 72 422 102 18966 376 109 DFFR_X2
* cell instance $531 r0 *1 178.6,4.2
X$531 77 72 183 102 18974 232 109 DFFR_X2
* cell instance $534 m0 *1 178.03,12.6
X$534 77 72 585 102 18918 542 109 DFFR_X2
* cell instance $536 r0 *1 177.65,1.4
X$536 77 72 116 102 19024 230 109 DFFR_X2
* cell instance $543 r0 *1 187.72,4.2
X$543 188 184 234 77 73 109 AOI21_X1
* cell instance $545 r0 *1 186.39,1.4
X$545 77 152 18806 113 73 102 109 DFFR_X1
* cell instance $547 r0 *1 184.3,23.8
X$547 1317 109 74 77 BUF_X4
* cell instance $549 r0 *1 190.57,4.2
X$549 74 109 184 77 BUF_X4
* cell instance $552 r0 *1 196.46,4.2
X$552 74 109 147 77 BUF_X4
* cell instance $554 m0 *1 198.36,4.2
X$554 77 240 109 74 BUF_X8
* cell instance $556 r0 *1 193.99,1.4
X$556 77 186 109 74 BUF_X8
* cell instance $558 m0 *1 189.62,21
X$558 981 1064 74 77 1065 109 AOI21_X1
* cell instance $560 r0 *1 185.44,18.2
X$560 898 1033 74 77 932 109 AOI21_X1
* cell instance $563 m0 *1 189.81,18.2
X$563 832 834 74 77 902 109 AOI21_X1
* cell instance $566 r0 *1 197.03,23.8
X$566 1066 74 1287 77 1403 109 AOI21_X1
* cell instance $569 r0 *1 196.46,15.4
X$569 74 109 741 77 BUF_X4
* cell instance $571 m0 *1 195.51,9.8
X$571 77 385 109 74 BUF_X8
* cell instance $585 r0 *1 199.69,4.2
X$585 197 147 193 77 75 109 AOI21_X1
* cell instance $587 r0 *1 200.26,1.4
X$587 77 76 18789 111 75 102 109 DFFR_X1
* cell instance $589 m0 *1 197.98,9.8
X$589 349 77 109 76 CLKBUF_X3
* cell instance $592 m0 *1 190.57,7
X$592 77 76 235 102 18956 236 109 DFFR_X2
* cell instance $594 m0 *1 194.18,4.2
X$594 77 76 199 102 18910 192 109 DFFR_X2
* cell instance $596 r0 *1 198.36,7
X$596 77 76 384 102 18996 323 109 DFFR_X2
* cell instance $599 r0 *1 196.27,7
X$599 76 77 109 19261 CLKBUF_X1
* cell instance $602 m0 *1 188.67,15.4
X$602 77 76 775 102 18948 832 109 DFFR_X2
* cell instance $605 r0 *1 194.37,9.8
X$605 77 76 18704 474 571 102 109 DFFR_X1
* cell instance $608 m0 *1 195.32,15.4
X$608 77 76 18602 769 771 102 109 DFFR_X1
* cell instance $617 m0 *1 231.99,138.6
X$617 10830 11184 109 77 11353 XNOR2_X1
* cell instance $618 m0 *1 231.04,138.6
X$618 11021 11176 11178 11181 77 109 11184 NAND4_X1
* cell instance $619 m0 *1 233.13,138.6
X$619 11191 10194 11353 77 109 11185 MUX2_X1
* cell instance $620 m0 *1 234.46,138.6
X$620 11193 77 109 11344 BUF_X1
* cell instance $622 r0 *1 231.04,138.6
X$622 10505 11021 10663 10830 77 109 11358 NAND4_X1
* cell instance $624 r0 *1 232.37,138.6
X$624 11021 10830 77 109 11341 NAND2_X1
* cell instance $627 r0 *1 233.51,138.6
X$627 10505 11180 10663 77 109 11342 NAND3_X1
* cell instance $629 m0 *1 235.6,138.6
X$629 11186 77 109 10196 CLKBUF_X3
* cell instance $631 m0 *1 236.55,138.6
X$631 11188 10498 11176 77 109 11343 MUX2_X1
* cell instance $635 r0 *1 236.93,138.6
X$635 11510 10498 11178 77 109 11633 MUX2_X1
* cell instance $638 m0 *1 238.26,138.6
X$638 11188 10500 11343 77 109 11190 MUX2_X1
* cell instance $639 r0 *1 238.45,138.6
X$639 11347 77 109 11345 BUF_X1
* cell instance $640 r0 *1 239.02,138.6
X$640 11343 77 109 11187 BUF_X1
* cell instance $642 m0 *1 165.49,138.6
X$642 6855 11066 11412 11158 4758 10236 77 109 OAI221_X2
* cell instance $643 m0 *1 164.92,138.6
X$643 11156 77 109 7369 INV_X2
* cell instance $644 m0 *1 167.58,138.6
X$644 11159 11321 77 109 11156 NAND2_X1
* cell instance $646 m0 *1 168.91,138.6
X$646 9287 77 109 9355 CLKBUF_X3
* cell instance $647 m0 *1 169.86,138.6
X$647 11406 9124 77 109 11059 NAND2_X1
* cell instance $648 m0 *1 170.43,138.6
X$648 11323 11404 6755 6855 11004 109 77 11237 OAI221_X1
* cell instance $650 m0 *1 171.76,138.6
X$650 9362 77 109 10424 CLKBUF_X3
* cell instance $651 m0 *1 172.71,138.6
X$651 9287 77 109 9597 CLKBUF_X3
* cell instance $652 m0 *1 173.66,138.6
X$652 11400 9361 77 109 11161 NAND2_X1
* cell instance $653 m0 *1 174.23,138.6
X$653 11401 9597 11162 77 109 11400 MUX2_X1
* cell instance $654 m0 *1 175.56,138.6
X$654 10424 77 109 9858 CLKBUF_X3
* cell instance $655 m0 *1 176.51,138.6
X$655 11118 77 109 11005 BUF_X1
* cell instance $658 m0 *1 161.69,138.6
X$658 6932 77 109 11155 INV_X1
* cell instance $660 r0 *1 161.88,138.6
X$660 11484 77 109 11243 INV_X1
* cell instance $661 r0 *1 162.26,138.6
X$661 11319 9597 11413 77 109 11415 MUX2_X1
* cell instance $662 m0 *1 162.64,138.6
X$662 11156 11243 11319 109 77 11413 HA_X1
* cell instance $665 r0 *1 163.59,138.6
X$665 11415 9361 77 109 11558 NAND2_X1
* cell instance $667 r0 *1 165.68,138.6
X$667 9360 77 109 9447 CLKBUF_X3
* cell instance $669 r0 *1 166.82,138.6
X$669 11320 77 109 11411 INV_X1
* cell instance $671 r0 *1 167.39,138.6
X$671 11409 9124 77 109 11321 NAND2_X1
* cell instance $674 r0 *1 168.53,138.6
X$674 7664 11320 11405 109 77 11408 HA_X1
* cell instance $675 r0 *1 170.43,138.6
X$675 11408 9597 11405 9447 77 109 11487 AOI22_X1
* cell instance $682 r0 *1 172.71,138.6
X$682 11548 9361 11161 109 10005 77 OAI21_X1
* cell instance $683 r0 *1 173.47,138.6
X$683 7371 11489 11401 109 77 11162 HA_X1
* cell instance $684 r0 *1 175.37,138.6
X$684 11541 9124 77 109 11398 NAND2_X1
* cell instance $687 r0 *1 176.51,138.6
X$687 9101 8754 77 109 11324 OR2_X1
* cell instance $689 m0 *1 179.17,138.6
X$689 10483 8106 11036 77 109 11230 MUX2_X1
* cell instance $690 m0 *1 177.46,138.6
X$690 11225 11163 77 7964 109 NAND2_X4
* cell instance $691 m0 *1 180.5,138.6
X$691 7238 8716 11201 77 109 11325 MUX2_X1
* cell instance $692 m0 *1 181.83,138.6
X$692 8477 77 109 10638 CLKBUF_X3
* cell instance $693 m0 *1 182.78,138.6
X$693 77 10638 11164 3676 18931 10485 109 DFFR_X2
* cell instance $695 r0 *1 177.65,138.6
X$695 11397 9124 77 109 11163 NAND2_X1
* cell instance $698 r0 *1 179.93,138.6
X$698 77 9593 11325 3676 19029 7238 109 DFFR_X2
* cell instance $700 r0 *1 184.3,138.6
X$700 11007 8716 11150 77 109 11326 MUX2_X1
* cell instance $702 m0 *1 191.52,138.6
X$702 7141 8716 11165 77 109 11393 MUX2_X1
* cell instance $703 m0 *1 187.34,138.6
X$703 77 11327 11227 3676 18928 10486 109 DFFR_X2
* cell instance $708 r0 *1 189.05,138.6
X$708 7422 8716 9236 77 109 11497 MUX2_X1
* cell instance $710 r0 *1 190.57,138.6
X$710 77 11327 11393 3676 18979 7141 109 DFFR_X2
* cell instance $712 r0 *1 195.13,138.6
X$712 9399 7968 77 109 11389 OR2_X1
* cell instance $713 m0 *1 195.7,138.6
X$713 11385 11219 77 109 10642 XOR2_X1
* cell instance $715 m0 *1 196.84,138.6
X$715 11214 11166 109 77 8162 XNOR2_X1
* cell instance $719 r0 *1 196.08,138.6
X$719 11150 11036 8111 11389 109 11536 77 OR4_X2
* cell instance $721 r0 *1 197.79,138.6
X$721 77 10646 11387 11383 10375 109 DFF_X1
* cell instance $722 m0 *1 202.35,138.6
X$722 11167 10336 11013 77 109 11382 MUX2_X1
* cell instance $723 m0 *1 199.12,138.6
X$723 77 11385 11167 11382 10375 109 DFF_X1
* cell instance $724 m0 *1 203.68,138.6
X$724 77 11214 11379 11380 10375 109 DFF_X1
* cell instance $725 m0 *1 206.91,138.6
X$725 11379 77 109 11008 CLKBUF_X2
* cell instance $727 m0 *1 208.43,138.6
X$727 11013 11328 11168 77 109 11170 NAND3_X1
* cell instance $729 r0 *1 201.02,138.6
X$729 11387 77 109 10520 BUF_X2
* cell instance $730 r0 *1 201.78,138.6
X$730 10520 10336 10819 77 109 11383 MUX2_X1
* cell instance $732 r0 *1 203.3,138.6
X$732 11041 10336 11328 77 109 11381 MUX2_X1
* cell instance $734 r0 *1 205.39,138.6
X$734 11008 10336 11168 77 109 11380 MUX2_X1
* cell instance $736 m0 *1 210.14,138.6
X$736 11329 10494 4185 3593 77 109 11503 NOR4_X1
* cell instance $737 m0 *1 209.57,138.6
X$737 11328 11168 77 109 11329 NAND2_X1
* cell instance $738 m0 *1 211.09,138.6
X$738 10517 77 109 11330 INV_X1
* cell instance $739 m0 *1 211.47,138.6
X$739 11170 10209 4185 3593 77 109 11375 NOR4_X1
* cell instance $741 m0 *1 212.61,138.6
X$741 11170 11330 77 109 10822 NOR2_X1
* cell instance $746 r0 *1 210.71,138.6
X$746 11330 11375 109 77 11331 XNOR2_X1
* cell instance $747 r0 *1 211.85,138.6
X$747 77 18477 10517 11504 11172 109 DFF_X1
* cell instance $749 m0 *1 214.32,138.6
X$749 10682 11204 109 77 11332 XNOR2_X1
* cell instance $751 r0 *1 215.27,138.6
X$751 11505 77 109 10682 BUF_X1
* cell instance $752 r0 *1 215.84,138.6
X$752 77 11337 6229 11333 8933 109 AOI21_X4
* cell instance $753 m0 *1 219.07,138.6
X$753 11173 77 109 11174 INV_X1
* cell instance $754 m0 *1 215.84,138.6
X$754 77 18352 11173 11370 11172 109 DFF_X1
* cell instance $755 m0 *1 219.45,138.6
X$755 77 11176 8932 11526 8933 109 AOI21_X4
* cell instance $757 m0 *1 222.11,138.6
X$757 4036 11177 11018 77 109 11336 OR3_X2
* cell instance $758 m0 *1 223.25,138.6
X$758 9251 9237 11201 77 10361 109 AOI21_X2
* cell instance $760 r0 *1 218.31,138.6
X$760 11173 11506 11371 77 109 11370 MUX2_X1
* cell instance $761 r0 *1 219.64,138.6
X$761 11197 11175 11371 109 77 11334 HA_X1
* cell instance $762 r0 *1 221.54,138.6
X$762 11176 11367 109 77 11335 XNOR2_X1
* cell instance $763 r0 *1 222.68,138.6
X$763 11334 77 109 11521 INV_X1
* cell instance $764 r0 *1 223.06,138.6
X$764 11178 11337 11334 77 109 11367 NAND3_X1
* cell instance $766 r0 *1 224.01,138.6
X$766 77 11521 8903 11338 11339 10505 109 NOR4_X4
* cell instance $767 m0 *1 225.91,138.6
X$767 8124 11507 77 109 11338 NOR2_X2
* cell instance $768 m0 *1 224.96,138.6
X$768 11338 8903 77 109 11178 NOR2_X2
* cell instance $769 m0 *1 226.86,138.6
X$769 10022 11179 8933 77 11360 109 AOI21_X2
* cell instance $770 m0 *1 228.19,138.6
X$770 11179 77 109 11362 INV_X1
* cell instance $771 m0 *1 228.57,138.6
X$771 11362 10034 9890 109 11180 77 OAI21_X1
* cell instance $776 r0 *1 227.43,138.6
X$776 11176 11337 77 109 11339 NAND2_X1
* cell instance $779 r0 *1 228.57,138.6
X$779 10194 77 109 11508 CLKBUF_X3
* cell instance $781 m0 *1 229.9,138.6
X$781 11176 11178 11181 77 109 11182 NAND3_X1
* cell instance $785 r0 *1 230.09,138.6
X$785 11358 11026 77 109 11340 NOR2_X1
* cell instance $787 m0 *1 188.86,163.8
X$787 13588 13457 13451 8719 13452 13503 109 77 AOI221_X2
* cell instance $788 m0 *1 187.72,163.8
X$788 13457 13587 13451 8957 13461 77 109 13586 AOI221_X1
* cell instance $789 m0 *1 190.95,163.8
X$789 13589 13112 13584 77 13587 109 AOI21_X1
* cell instance $790 m0 *1 191.71,163.8
X$790 13465 13345 13588 77 109 13590 MUX2_X1
* cell instance $791 m0 *1 193.04,163.8
X$791 13462 13454 77 109 13342 NAND2_X1
* cell instance $792 m0 *1 193.61,163.8
X$792 13644 13454 77 109 13494 NAND2_X1
* cell instance $793 m0 *1 194.18,163.8
X$793 77 13305 13640 13639 13642 3676 109 DFFR_X1
* cell instance $794 m0 *1 197.98,163.8
X$794 13591 13593 13592 109 13642 77 OAI21_X1
* cell instance $795 m0 *1 198.74,163.8
X$795 13595 13639 77 109 13592 NAND2_X1
* cell instance $796 m0 *1 199.31,163.8
X$796 13715 13593 13594 109 13638 77 OAI21_X1
* cell instance $797 m0 *1 200.07,163.8
X$797 13595 13596 77 109 13594 NAND2_X1
* cell instance $798 m0 *1 200.64,163.8
X$798 13598 13593 13599 109 13597 77 OAI21_X1
* cell instance $799 m0 *1 201.4,163.8
X$799 13595 13634 77 109 13599 NAND2_X1
* cell instance $801 m0 *1 202.16,163.8
X$801 13600 77 109 13873 INV_X1
* cell instance $805 r0 *1 187.91,163.8
X$805 13720 13585 77 109 13771 NOR2_X1
* cell instance $806 r0 *1 188.48,163.8
X$806 13769 7968 77 109 13766 NOR2_X1
* cell instance $807 r0 *1 189.05,163.8
X$807 1236 77 109 13718 CLKBUF_X3
* cell instance $808 r0 *1 190,163.8
X$808 13766 12972 13584 77 13339 109 AOI21_X1
* cell instance $809 r0 *1 190.76,163.8
X$809 13719 13115 13584 77 13588 109 AOI21_X1
* cell instance $810 r0 *1 191.52,163.8
X$810 13712 8957 77 109 13719 NOR2_X1
* cell instance $811 r0 *1 192.09,163.8
X$811 13712 6235 77 109 13589 NOR2_X1
* cell instance $813 r0 *1 193.04,163.8
X$813 13590 13454 77 109 13460 NAND2_X1
* cell instance $815 r0 *1 196.65,163.8
X$815 13640 77 109 13756 INV_X1
* cell instance $816 r0 *1 197.03,163.8
X$816 13756 13721 13758 77 13591 109 AOI21_X1
* cell instance $817 r0 *1 197.79,163.8
X$817 13330 77 109 13758 INV_X1
* cell instance $818 r0 *1 198.17,163.8
X$818 13635 13721 13755 77 13715 109 AOI21_X2
* cell instance $819 r0 *1 199.5,163.8
X$819 77 13305 13600 13634 13597 3676 109 DFFR_X1
* cell instance $820 r0 *1 203.3,163.8
X$820 77 13847 13872 13750 13753 3676 109 DFFR_X1
* cell instance $822 m0 *1 203.68,163.8
X$822 13720 13593 13601 109 13753 77 OAI21_X1
* cell instance $823 m0 *1 204.63,163.8
X$823 13595 13750 77 109 13601 NAND2_X1
* cell instance $824 m0 *1 205.2,163.8
X$824 13329 13602 77 109 13603 OR2_X1
* cell instance $825 m0 *1 205.96,163.8
X$825 77 13305 13629 13630 13604 3676 109 DFFR_X1
* cell instance $826 m0 *1 209.76,163.8
X$826 13630 13309 13628 13605 77 109 13632 AOI22_X1
* cell instance $827 m0 *1 210.71,163.8
X$827 13330 13602 13629 109 13628 77 OAI21_X1
* cell instance $829 m0 *1 212.23,163.8
X$829 13190 77 109 13605 CLKBUF_X3
* cell instance $830 m0 *1 213.18,163.8
X$830 13308 13722 13466 109 13465 77 OAI21_X1
* cell instance $832 m0 *1 214.13,163.8
X$832 77 13191 13627 13626 13606 3676 109 DFFR_X1
* cell instance $833 m0 *1 217.93,163.8
X$833 13626 13309 13714 13605 77 109 13485 AOI22_X1
* cell instance $834 m0 *1 218.88,163.8
X$834 10855 77 109 13191 CLKBUF_X3
* cell instance $838 r0 *1 207.29,163.8
X$838 13632 77 109 13604 INV_X1
* cell instance $839 r0 *1 207.67,163.8
X$839 13464 77 109 13595 CLKBUF_X3
* cell instance $842 r0 *1 216.22,163.8
X$842 13722 13602 13627 109 13714 77 OAI21_X1
* cell instance $845 r0 *1 217.93,163.8
X$845 13191 77 109 19283 CLKBUF_X1
* cell instance $846 r0 *1 218.5,163.8
X$846 77 18450 13723 13747 13191 109 DFF_X1
* cell instance $847 r0 *1 221.73,163.8
X$847 13723 11506 13724 77 109 13747 MUX2_X1
* cell instance $849 m0 *1 221.73,163.8
X$849 8749 13723 77 109 13624 NOR2_X1
* cell instance $851 m0 *1 223.25,163.8
X$851 13624 9728 77 109 13607 NOR2_X1
* cell instance $852 m0 *1 223.82,163.8
X$852 9710 13608 8749 109 77 13609 OAI21_X2
* cell instance $853 m0 *1 225.15,163.8
X$853 13609 10847 13310 77 109 13207 NAND3_X1
* cell instance $856 m0 *1 228.19,163.8
X$856 3822 12914 13622 109 13726 77 OAI21_X1
* cell instance $857 m0 *1 228.95,163.8
X$857 3822 13611 77 109 13622 NAND2_X1
* cell instance $860 r0 *1 223.06,163.8
X$860 13607 13744 109 77 13724 XNOR2_X1
* cell instance $861 r0 *1 224.2,163.8
X$861 13207 77 109 13745 INV_X1
* cell instance $862 r0 *1 224.58,163.8
X$862 13745 13312 77 109 13744 NAND2_X1
* cell instance $864 r0 *1 225.53,163.8
X$864 13312 13310 77 109 13725 NAND2_X1
* cell instance $869 r0 *1 227.62,163.8
X$869 13611 13201 13726 77 109 13741 MUX2_X1
* cell instance $870 r0 *1 228.95,163.8
X$870 77 18451 13727 13739 13854 109 DFF_X1
* cell instance $871 m0 *1 231.61,163.8
X$871 3822 12770 13612 109 13728 77 OAI21_X1
* cell instance $873 m0 *1 232.37,163.8
X$873 3822 13727 77 109 13612 NAND2_X1
* cell instance $874 m0 *1 232.94,163.8
X$874 13470 13613 12464 77 109 13614 MUX2_X1
* cell instance $876 r0 *1 232.18,163.8
X$876 13727 13201 13728 77 109 13739 MUX2_X1
* cell instance $878 r0 *1 233.7,163.8
X$878 13729 13613 12141 77 109 13736 MUX2_X1
* cell instance $879 m0 *1 234.84,163.8
X$879 13470 12305 13614 77 109 13471 MUX2_X1
* cell instance $881 m0 *1 236.17,163.8
X$881 13734 13613 12143 77 109 13855 MUX2_X1
* cell instance $884 r0 *1 235.03,163.8
X$884 13729 12305 13736 77 109 13737 MUX2_X1
* cell instance $885 r0 *1 236.36,163.8
X$885 77 18452 13734 13730 13476 109 DFF_X1
* cell instance $887 m0 *1 238.64,163.8
X$887 13614 77 109 13617 BUF_X1
* cell instance $890 m0 *1 192.85,93.8
X$890 7241 6941 6382 7140 77 2731 109 NAND4_X2
* cell instance $893 r0 *1 192.66,93.8
X$893 7240 6941 6382 7239 77 3942 109 NAND4_X2
* cell instance $894 r0 *1 194.37,93.8
X$894 1867 6770 7117 109 4259 77 OAI21_X1
* cell instance $895 m0 *1 196.27,93.8
X$895 6817 77 109 6945 CLKBUF_X3
* cell instance $896 m0 *1 194.94,93.8
X$896 3741 5212 6811 77 109 7271 MUX2_X1
* cell instance $899 r0 *1 195.51,93.8
X$899 77 6945 7271 992 19009 3741 109 DFFR_X2
* cell instance $900 m0 *1 198.93,93.8
X$900 6945 77 109 19220 CLKBUF_X1
* cell instance $901 m0 *1 197.6,93.8
X$901 5212 109 5509 77 BUF_X4
* cell instance $902 m0 *1 199.5,93.8
X$902 77 6945 18636 6995 7139 992 109 DFFR_X1
* cell instance $903 m0 *1 203.3,93.8
X$903 1867 5384 6994 109 7137 77 OAI21_X1
* cell instance $906 r0 *1 199.88,93.8
X$906 621 6770 7382 109 2509 77 OAI21_X1
* cell instance $908 r0 *1 201.02,93.8
X$908 77 6945 7383 3676 18981 3724 109 DFFR_X2
* cell instance $910 m0 *1 204.44,93.8
X$910 77 6642 7136 3676 18905 3326 109 DFFR_X2
* cell instance $912 m0 *1 210.9,93.8
X$912 5212 77 109 7242 CLKBUF_X3
* cell instance $913 m0 *1 211.85,93.8
X$913 759 5259 7243 109 7134 77 OAI21_X1
* cell instance $914 m0 *1 212.61,93.8
X$914 4379 6354 7134 77 109 7133 MUX2_X1
* cell instance $915 m0 *1 213.94,93.8
X$915 77 6946 7133 3676 18937 4379 109 DFFR_X2
* cell instance $916 m0 *1 218.12,93.8
X$916 2885 6209 3315 6340 77 109 7245 AOI22_X1
* cell instance $917 m0 *1 219.07,93.8
X$917 6354 6078 77 109 7263 NOR2_X1
* cell instance $919 m0 *1 225.72,93.8
X$919 6952 77 109 6500 CLKBUF_X3
* cell instance $920 m0 *1 226.67,93.8
X$920 759 5233 7129 109 7259 77 OAI21_X1
* cell instance $923 r0 *1 205.58,93.8
X$923 6642 77 109 19158 INV_X1
* cell instance $925 r0 *1 206.15,93.8
X$925 2886 77 109 7405 INV_X1
* cell instance $929 r0 *1 208.62,93.8
X$929 77 6642 18703 7244 7267 3676 109 DFFR_X1
* cell instance $930 r0 *1 212.42,93.8
X$930 4379 4552 7244 77 109 7267 MUX2_X1
* cell instance $933 r0 *1 215.65,93.8
X$933 5216 7116 7266 6492 7118 7265 109 77 AOI221_X2
* cell instance $935 r0 *1 218.12,93.8
X$935 7263 7242 7265 77 7264 109 AOI21_X1
* cell instance $936 r0 *1 218.88,93.8
X$936 77 6946 7264 3676 18997 6078 109 DFFR_X2
* cell instance $939 r0 *1 225.34,93.8
X$939 7246 4951 7259 77 109 7260 MUX2_X1
* cell instance $940 r0 *1 226.67,93.8
X$940 5393 5392 7245 109 7247 77 OAI21_X1
* cell instance $947 r0 *1 227.43,93.8
X$947 5233 7248 77 109 7129 NAND2_X1
* cell instance $948 m0 *1 231.61,93.8
X$948 7250 77 109 6782 INV_X1
* cell instance $949 m0 *1 227.81,93.8
X$949 77 6500 18685 7250 6781 992 109 DFFR_X1
* cell instance $951 m0 *1 232.18,93.8
X$951 6209 109 5237 77 BUF_X4
* cell instance $952 m0 *1 233.51,93.8
X$952 6949 5392 7127 109 7255 77 OAI21_X1
* cell instance $954 m0 *1 234.46,93.8
X$954 7252 4837 7120 77 109 7124 MUX2_X1
* cell instance $955 m0 *1 235.79,93.8
X$955 77 6210 6949 7121 7124 992 109 DFFR_X1
* cell instance $957 r0 *1 228,93.8
X$957 621 5233 7257 109 7547 77 OAI21_X1
* cell instance $959 r0 *1 229.14,93.8
X$959 4960 7249 77 109 7257 NAND2_X1
* cell instance $962 r0 *1 230.66,93.8
X$962 7387 7252 7255 5237 7250 7256 109 77 AOI221_X2
* cell instance $963 r0 *1 232.75,93.8
X$963 6623 5392 6948 109 7251 77 OAI21_X1
* cell instance $966 m0 *1 174.8,40.6
X$966 2111 375 1449 377 77 109 2112 AOI22_X1
* cell instance $967 m0 *1 170.62,40.6
X$967 77 2115 2149 1146 18922 2111 109 DFFR_X2
* cell instance $968 m0 *1 175.75,40.6
X$968 2112 2114 77 109 2113 NOR2_X1
* cell instance $970 m0 *1 176.51,40.6
X$970 2070 608 609 1178 77 109 2214 AOI22_X2
* cell instance $971 m0 *1 178.22,40.6
X$971 699 2177 77 109 2144 NOR2_X1
* cell instance $973 r0 *1 170.62,40.6
X$973 2115 77 109 19112 INV_X2
* cell instance $977 r0 *1 171.19,40.6
X$977 2179 1863 77 109 1283 NOR2_X2
* cell instance $979 r0 *1 172.33,40.6
X$979 2042 1672 2180 2181 2043 77 109 2149 AOI221_X1
* cell instance $980 r0 *1 173.47,40.6
X$980 2178 2114 1323 2184 2294 2182 77 109 OAI221_X2
* cell instance $981 r0 *1 175.56,40.6
X$981 349 77 109 2115 CLKBUF_X3
* cell instance $983 r0 *1 176.89,40.6
X$983 2214 2114 634 2177 2188 2183 77 109 OAI221_X2
* cell instance $984 r0 *1 178.98,40.6
X$984 1424 2114 587 2184 2186 2300 77 109 OAI221_X2
* cell instance $985 m0 *1 182.97,40.6
X$985 777 779 77 109 2116 OR2_X2
* cell instance $986 m0 *1 179.17,40.6
X$986 77 2115 18672 2070 2076 1146 109 DFFR_X1
* cell instance $987 m0 *1 183.92,40.6
X$987 2116 778 1201 77 109 NOR2_X4
* cell instance $989 m0 *1 187.15,40.6
X$989 1330 1863 2048 2140 2046 77 109 2117 AOI221_X1
* cell instance $990 m0 *1 188.29,40.6
X$990 77 1731 2117 1146 18934 2046 109 DFFR_X2
* cell instance $991 m0 *1 192.47,40.6
X$991 77 1713 18591 2138 2139 1146 109 DFFR_X1
* cell instance $992 m0 *1 196.27,40.6
X$992 1311 1462 2118 77 109 2064 MUX2_X1
* cell instance $996 r0 *1 181.07,40.6
X$996 2044 109 578 77 BUF_X4
* cell instance $998 r0 *1 182.78,40.6
X$998 2210 2356 2252 2177 777 779 77 109 1317 OAI33_X1
* cell instance $999 r0 *1 184.11,40.6
X$999 2116 2114 77 109 2210 NOR2_X1
* cell instance $1003 r0 *1 187.15,40.6
X$1003 1198 2185 2295 77 109 2296 MUX2_X1
* cell instance $1006 r0 *1 189.43,40.6
X$1006 2118 77 109 2253 INV_X1
* cell instance $1011 r0 *1 198.55,40.6
X$1011 1622 1621 2254 77 109 2290 MUX2_X1
* cell instance $1013 r0 *1 200.26,40.6
X$1013 1622 1892 2256 77 109 2255 MUX2_X1
* cell instance $1015 r0 *1 202.35,40.6
X$1015 77 2120 18853 2257 2135 1146 109 DFFR_X1
* cell instance $1016 m0 *1 202.73,40.6
X$1016 969 1621 2257 77 109 2135 MUX2_X1
* cell instance $1020 m0 *1 205.01,40.6
X$1020 399 1722 2132 77 109 2119 MUX2_X1
* cell instance $1021 m0 *1 206.34,40.6
X$1021 77 2120 18565 2132 2119 1146 109 DFFR_X1
* cell instance $1024 r0 *1 206.15,40.6
X$1024 77 2360 18871 2187 2205 1146 109 DFFR_X1
* cell instance $1026 r0 *1 210.33,40.6
X$1026 1084 1869 2187 77 109 2205 MUX2_X1
* cell instance $1030 r0 *1 214.32,40.6
X$1030 903 1621 2283 77 109 2286 MUX2_X1
* cell instance $1032 m0 *1 217.93,40.6
X$1032 77 1961 18595 2130 2131 992 109 DFFR_X1
* cell instance $1033 m0 *1 216.6,40.6
X$1033 788 1869 2130 77 109 2131 MUX2_X1
* cell instance $1036 r0 *1 217.17,40.6
X$1036 494 1630 2203 77 109 2284 MUX2_X1
* cell instance $1040 r0 *1 221.16,40.6
X$1040 693 1630 2189 77 109 2202 MUX2_X1
* cell instance $1041 r0 *1 222.49,40.6
X$1041 77 2051 18886 2189 2202 992 109 DFFR_X1
* cell instance $1042 m0 *1 223.06,40.6
X$1042 77 2051 2129 992 18950 2057 109 DFFR_X2
* cell instance $1052 r0 *1 227.62,40.6
X$1052 471 1621 2201 77 109 2279 MUX2_X1
* cell instance $1054 m0 *1 228.38,40.6
X$1054 751 1542 1370 2123 77 109 2190 AOI22_X1
* cell instance $1059 r0 *1 230.09,40.6
X$1059 1063 1621 2191 77 109 2192 MUX2_X1
* cell instance $1060 r0 *1 231.42,40.6
X$1060 77 1873 18723 2191 2192 992 109 DFFR_X1
* cell instance $1061 m0 *1 235.22,40.6
X$1061 77 1873 18571 2194 2126 992 109 DFFR_X1
* cell instance $1062 m0 *1 231.99,40.6
X$1062 77 1635 1542 2128 2123 1789 109 AOI22_X4
* cell instance $1063 m0 *1 239.02,40.6
X$1063 2124 77 109 2263 BUF_X1
* cell instance $1067 r0 *1 236.17,40.6
X$1067 1063 1462 2194 77 109 2126 MUX2_X1
* cell instance $1068 r0 *1 237.5,40.6
X$1068 999 77 109 1873 CLKBUF_X3
* cell instance $1069 r0 *1 238.45,40.6
X$1069 2193 77 109 2268 BUF_X1
* cell instance $1070 r0 *1 239.02,40.6
X$1070 1873 77 109 19284 CLKBUF_X1
* cell instance $1072 m0 *1 143.26,127.4
X$1072 7295 10306 10254 9999 77 109 10253 NAND4_X1
* cell instance $1073 m0 *1 142.31,127.4
X$1073 6872 77 109 10311 CLKBUF_X3
* cell instance $1077 m0 *1 149.53,127.4
X$1077 10418 9219 77 109 10169 NOR2_X2
* cell instance $1078 m0 *1 150.48,127.4
X$1078 77 10171 4492 9352 9349 109 AOI21_X4
* cell instance $1079 m0 *1 152.95,127.4
X$1079 9349 9352 8925 10165 77 109 10249 AOI22_X1
* cell instance $1081 m0 *1 154.09,127.4
X$1081 9353 10170 10316 10248 10171 9783 77 109 OAI221_X2
* cell instance $1084 r0 *1 142.5,127.4
X$1084 10313 4460 10310 77 10472 109 AOI21_X1
* cell instance $1085 r0 *1 143.26,127.4
X$1085 10313 3916 10310 77 10312 109 AOI21_X1
* cell instance $1086 r0 *1 144.02,127.4
X$1086 10313 4523 10310 77 10623 109 AOI21_X1
* cell instance $1089 r0 *1 146.68,127.4
X$1089 10560 9171 9516 77 6857 109 AOI21_X2
* cell instance $1091 r0 *1 148.77,127.4
X$1091 9350 9171 10558 9853 10175 10418 109 77 AOI221_X2
* cell instance $1092 r0 *1 150.86,127.4
X$1092 77 10557 10415 2300 9847 10410 109 NOR4_X4
* cell instance $1094 r0 *1 155.04,127.4
X$1094 10478 77 109 10412 INV_X1
* cell instance $1095 r0 *1 155.42,127.4
X$1095 5149 10628 10412 9858 77 109 10315 AOI22_X1
* cell instance $1096 r0 *1 156.37,127.4
X$1096 8497 9597 10317 9447 77 109 10551 AOI22_X1
* cell instance $1098 m0 *1 156.56,127.4
X$1098 10249 10240 9779 77 109 9852 NAND3_X1
* cell instance $1099 m0 *1 157.51,127.4
X$1099 10245 9360 9362 10246 9355 77 109 10172 AOI221_X1
* cell instance $1101 m0 *1 158.84,127.4
X$1101 10172 77 109 10318 INV_X1
* cell instance $1103 m0 *1 160.74,127.4
X$1103 10306 77 109 9602 INV_X2
* cell instance $1105 m0 *1 162.07,127.4
X$1105 4745 6398 19034 109 77 10174 HA_X1
* cell instance $1106 m0 *1 163.97,127.4
X$1106 10174 10166 10238 77 109 10240 MUX2_X1
* cell instance $1108 m0 *1 165.49,127.4
X$1108 9856 10002 10314 10004 10168 10913 109 77 AOI221_X2
* cell instance $1111 r0 *1 158.08,127.4
X$1111 10479 9856 10314 7045 10168 77 109 10632 AOI221_X1
* cell instance $1112 r0 *1 159.22,127.4
X$1112 10318 10547 8979 5002 9853 77 109 10109 AOI221_X1
* cell instance $1115 r0 *1 160.93,127.4
X$1115 7146 10408 10319 109 77 10320 HA_X1
* cell instance $1118 r0 *1 163.78,127.4
X$1118 10168 77 109 9287 CLKBUF_X3
* cell instance $1121 r0 *1 165.68,127.4
X$1121 10314 109 9362 77 BUF_X4
* cell instance $1123 r0 *1 167.39,127.4
X$1123 9359 10166 77 109 10481 NAND2_X1
* cell instance $1125 m0 *1 168.15,127.4
X$1125 10398 9393 9524 77 10098 109 AOI21_X1
* cell instance $1128 m0 *1 169.1,127.4
X$1128 10405 10180 9524 77 10003 109 AOI21_X1
* cell instance $1131 m0 *1 171.57,127.4
X$1131 6663 10177 10231 109 77 10229 HA_X1
* cell instance $1134 r0 *1 168.53,127.4
X$1134 10633 77 109 10321 INV_X1
* cell instance $1135 r0 *1 168.91,127.4
X$1135 10321 6927 10406 109 77 10404 HA_X1
* cell instance $1136 r0 *1 170.81,127.4
X$1136 10482 10404 10322 77 10405 109 AOI21_X1
* cell instance $1141 r0 *1 171.95,127.4
X$1141 10177 77 109 10402 INV_X1
* cell instance $1142 r0 *1 172.33,127.4
X$1142 6929 10402 19075 109 77 10323 HA_X1
* cell instance $1143 m0 *1 174.04,127.4
X$1143 10231 9447 9858 10229 9597 77 109 10400 AOI221_X1
* cell instance $1146 r0 *1 174.23,127.4
X$1146 10400 10323 10322 77 10398 109 AOI21_X1
* cell instance $1148 r0 *1 175.37,127.4
X$1148 10006 77 109 10396 BUF_X1
* cell instance $1149 m0 *1 175.75,127.4
X$1149 9285 109 8479 77 BUF_X4
* cell instance $1151 m0 *1 177.08,127.4
X$1151 9285 10178 9314 8889 10324 7664 77 109 OAI221_X2
* cell instance $1153 m0 *1 179.36,127.4
X$1153 6390 9861 5832 8152 6255 10012 109 77 AOI221_X2
* cell instance $1155 m0 *1 181.64,127.4
X$1155 10182 6427 9126 109 77 10394 AND3_X1
* cell instance $1157 m0 *1 182.78,127.4
X$1157 77 8105 109 9126 BUF_X8
* cell instance $1159 m0 *1 185.44,127.4
X$1159 10179 8106 10180 77 109 10327 MUX2_X1
* cell instance $1161 m0 *1 187.53,127.4
X$1161 10225 9694 8888 10328 77 109 10393 AOI22_X2
* cell instance $1162 m0 *1 189.24,127.4
X$1162 10390 6427 109 77 10225 AND2_X1
* cell instance $1163 m0 *1 190,127.4
X$1163 6427 77 109 9696 CLKBUF_X2
* cell instance $1165 m0 *1 191.52,127.4
X$1165 9058 10015 77 109 10178 NAND2_X1
* cell instance $1168 r0 *1 176.13,127.4
X$1168 6541 77 109 7871 INV_X2
* cell instance $1169 r0 *1 176.7,127.4
X$1169 10396 77 109 10083 INV_X2
* cell instance $1170 r0 *1 177.27,127.4
X$1170 8479 10326 9165 8889 10529 6541 77 109 OAI221_X2
* cell instance $1172 r0 *1 179.55,127.4
X$1172 6390 10701 5832 7197 6255 10378 109 77 AOI221_X2
* cell instance $1173 r0 *1 181.64,127.4
X$1173 6390 10483 5832 7338 6255 10330 109 77 AOI221_X2
* cell instance $1174 r0 *1 183.73,127.4
X$1174 6390 10325 5832 6430 6255 10379 109 77 AOI221_X2
* cell instance $1177 r0 *1 186.39,127.4
X$1177 77 10010 18895 10179 10327 3676 109 DFFR_X1
* cell instance $1179 r0 *1 190.38,127.4
X$1179 10328 8716 9101 77 109 10329 MUX2_X1
* cell instance $1180 r0 *1 191.71,127.4
X$1180 9058 10332 77 109 10326 NAND2_X1
* cell instance $1183 m0 *1 192.47,127.4
X$1183 10330 8582 10222 77 7578 109 AOI21_X1
* cell instance $1184 r0 *1 193.04,127.4
X$1184 10010 77 109 19177 INV_X1
* cell instance $1186 m0 *1 193.8,127.4
X$1186 9412 77 109 8582 CLKBUF_X3
* cell instance $1189 m0 *1 194.94,127.4
X$1189 10013 2428 10016 77 109 10181 MUX2_X1
* cell instance $1192 m0 *1 197.22,127.4
X$1192 10333 10382 9863 109 9704 77 NOR3_X2
* cell instance $1194 m0 *1 198.74,127.4
X$1194 10212 9865 77 109 10222 XOR2_X1
* cell instance $1198 r0 *1 194.75,127.4
X$1198 10386 8582 10331 77 7530 109 AOI21_X1
* cell instance $1202 r0 *1 196.84,127.4
X$1202 77 9864 10382 10333 9865 109 NOR3_X4
* cell instance $1203 r0 *1 199.5,127.4
X$1203 10378 8582 10519 77 7531 109 AOI21_X1
* cell instance $1204 m0 *1 200.45,127.4
X$1204 10379 9412 10219 77 5414 109 AOI21_X2
* cell instance $1207 m0 *1 201.97,127.4
X$1207 77 10218 10182 10216 10375 109 DFF_X1
* cell instance $1208 m0 *1 205.2,127.4
X$1208 10182 8614 10017 77 109 10216 MUX2_X1
* cell instance $1210 m0 *1 207.29,127.4
X$1210 77 10212 10211 10214 10018 109 DFF_X1
* cell instance $1211 m0 *1 210.52,127.4
X$1211 10211 77 109 10015 CLKBUF_X2
* cell instance $1212 m0 *1 211.28,127.4
X$1212 10018 77 109 19194 CLKBUF_X2
* cell instance $1217 r0 *1 201.59,127.4
X$1217 10488 8725 10334 77 109 8317 MUX2_X1
* cell instance $1218 r0 *1 202.92,127.4
X$1218 9865 10011 10015 77 109 10335 NAND3_X1
* cell instance $1220 r0 *1 203.87,127.4
X$1220 2900 77 109 10336 CLKBUF_X3
* cell instance $1223 r0 *1 205.77,127.4
X$1223 10332 10336 10340 77 109 10337 MUX2_X1
* cell instance $1225 r0 *1 207.48,127.4
X$1225 10015 10336 10338 77 109 10214 MUX2_X1
* cell instance $1226 r0 *1 208.81,127.4
X$1226 10332 10340 8725 109 77 6966 MUX2_X2
* cell instance $1228 r0 *1 210.9,127.4
X$1228 6952 77 109 10018 CLKBUF_X3
* cell instance $1229 r0 *1 211.85,127.4
X$1229 3593 4185 77 109 9375 OR2_X2
* cell instance $1231 m0 *1 212.42,127.4
X$1231 10015 8725 10338 77 109 6976 MUX2_X1
* cell instance $1232 m0 *1 213.94,127.4
X$1232 9867 109 2900 77 BUF_X4
* cell instance $1235 r0 *1 212.8,127.4
X$1235 4185 77 109 9068 CLKBUF_X3
* cell instance $1236 r0 *1 213.75,127.4
X$1236 2900 4307 10334 77 109 10339 NOR3_X1
* cell instance $1237 r0 *1 214.51,127.4
X$1237 10367 77 109 10334 BUF_X1
* cell instance $1241 m0 *1 219.64,127.4
X$1241 77 18361 10016 10185 10186 109 DFF_X1
* cell instance $1242 m0 *1 216.41,127.4
X$1242 77 18370 10017 10184 10186 109 DFF_X1
* cell instance $1244 r0 *1 216.41,127.4
X$1244 10340 10338 10183 109 77 10492 AND3_X1
* cell instance $1245 r0 *1 217.36,127.4
X$1245 4307 10365 9382 109 10020 77 OAI21_X1
* cell instance $1246 r0 *1 218.12,127.4
X$1246 10363 10209 77 109 10515 NOR2_X1
* cell instance $1248 r0 *1 221.73,127.4
X$1248 10361 10204 10187 77 10185 109 AOI21_X1
* cell instance $1249 r0 *1 222.49,127.4
X$1249 9541 9068 9066 77 109 10341 NOR3_X1
* cell instance $1250 r0 *1 223.25,127.4
X$1250 9873 77 109 10494 BUF_X2
* cell instance $1251 m0 *1 223.44,127.4
X$1251 9706 10341 109 77 10207 XNOR2_X1
* cell instance $1253 m0 *1 224.58,127.4
X$1253 10203 10204 10207 77 10357 109 AOI21_X1
* cell instance $1257 r0 *1 224.58,127.4
X$1257 9876 8933 77 109 10342 NOR2_X2
* cell instance $1258 r0 *1 225.53,127.4
X$1258 77 18394 10183 10509 9554 109 DFF_X1
* cell instance $1260 m0 *1 225.72,127.4
X$1260 77 18337 10188 10357 9554 109 DFF_X1
* cell instance $1261 m0 *1 229.14,127.4
X$1261 10190 10191 109 77 10203 AND2_X1
* cell instance $1262 m0 *1 229.9,127.4
X$1262 6952 77 109 9554 CLKBUF_X3
* cell instance $1263 m0 *1 230.85,127.4
X$1263 77 10193 8904 9246 10195 11021 109 NOR4_X4
* cell instance $1264 m0 *1 234.27,127.4
X$1264 10195 9246 77 109 10343 NOR2_X1
* cell instance $1265 m0 *1 234.84,127.4
X$1265 8904 10193 77 109 10344 NOR2_X1
* cell instance $1266 m0 *1 235.41,127.4
X$1266 10197 77 109 10347 BUF_X1
* cell instance $1271 r0 *1 228.76,127.4
X$1271 77 10847 10354 10190 10191 109 AOI21_X4
* cell instance $1274 r0 *1 231.8,127.4
X$1274 6206 10497 77 109 10195 NOR2_X2
* cell instance $1275 r0 *1 232.75,127.4
X$1275 10505 10343 77 109 10352 NAND2_X1
* cell instance $1276 r0 *1 233.32,127.4
X$1276 10344 10352 109 77 10028 XNOR2_X1
* cell instance $1279 m0 *1 100.13,113.4
X$1279 8981 7283 77 109 9035 NOR2_X1
* cell instance $1280 m0 *1 98.8,113.4
X$1280 9033 6371 8869 77 109 8981 MUX2_X1
* cell instance $1283 r0 *1 98.99,113.4
X$1283 9033 7642 8869 77 109 9143 MUX2_X1
* cell instance $1285 r0 *1 100.51,113.4
X$1285 9169 6131 9142 77 109 NOR2_X4
* cell instance $1286 m0 *1 101.27,113.4
X$1286 3293 8973 6182 109 77 9034 MUX2_X2
* cell instance $1288 m0 *1 102.98,113.4
X$1288 6417 8978 6182 109 77 9146 MUX2_X2
* cell instance $1290 m0 *1 106.21,113.4
X$1290 77 9036 8871 9149 8988 8201 109 DFFR_X1
* cell instance $1292 r0 *1 102.22,113.4
X$1292 9035 9308 7597 77 109 9157 NOR3_X1
* cell instance $1295 r0 *1 104.88,113.4
X$1295 9148 9027 8422 77 109 9151 MUX2_X1
* cell instance $1297 r0 *1 106.59,113.4
X$1297 9149 9152 8422 77 109 8988 MUX2_X1
* cell instance $1299 r0 *1 108.68,113.4
X$1299 9036 77 109 19293 CLKBUF_X1
* cell instance $1301 r0 *1 110.01,113.4
X$1301 9310 5311 9311 77 109 9155 MUX2_X1
* cell instance $1302 m0 *1 110.58,113.4
X$1302 8871 5311 8549 77 109 9037 MUX2_X1
* cell instance $1307 m0 *1 114.38,113.4
X$1307 77 8067 6100 109 BUF_X32
* cell instance $1309 m0 *1 123.88,113.4
X$1309 8875 6381 9163 77 109 NOR2_X4
* cell instance $1310 m0 *1 125.59,113.4
X$1310 8875 6381 77 9165 109 OR2_X4
* cell instance $1312 m0 *1 127.49,113.4
X$1312 8694 8888 77 109 8999 NOR2_X1
* cell instance $1314 m0 *1 128.25,113.4
X$1314 77 9000 6483 6873 8999 109 AOI21_X4
* cell instance $1315 m0 *1 130.72,113.4
X$1315 8829 109 9045 77 BUF_X4
* cell instance $1318 r0 *1 111.53,113.4
X$1318 9155 5960 9037 77 109 9038 MUX2_X1
* cell instance $1319 r0 *1 112.86,113.4
X$1319 9038 7597 9156 77 109 9039 MUX2_X1
* cell instance $1320 r0 *1 114.19,113.4
X$1320 7631 9039 9157 8818 6546 9139 77 109 OAI221_X2
* cell instance $1325 r0 *1 117.04,113.4
X$1325 9040 5311 8873 77 109 9041 MUX2_X1
* cell instance $1326 r0 *1 118.37,113.4
X$1326 9041 5960 9160 77 109 9156 MUX2_X1
* cell instance $1334 r0 *1 122.55,113.4
X$1334 8946 6520 9162 77 109 NOR2_X4
* cell instance $1335 r0 *1 124.26,113.4
X$1335 6520 8946 77 109 9314 OR2_X2
* cell instance $1336 r0 *1 125.21,113.4
X$1336 5895 109 8888 77 BUF_X4
* cell instance $1339 r0 *1 127.11,113.4
X$1339 5895 8694 77 109 9166 OR2_X1
* cell instance $1341 r0 *1 128.06,113.4
X$1341 9166 6874 77 109 9043 NOR2_X1
* cell instance $1343 r0 *1 128.82,113.4
X$1343 77 6874 9166 9172 9168 109 NOR3_X4
* cell instance $1345 r0 *1 131.86,113.4
X$1345 9043 6483 19062 109 77 9173 HA_X1
* cell instance $1346 m0 *1 134.14,113.4
X$1346 8655 9001 8879 7948 77 109 8268 OR4_X1
* cell instance $1347 m0 *1 132.43,113.4
X$1347 6744 7653 77 9044 109 NAND2_X4
* cell instance $1348 m0 *1 135.28,113.4
X$1348 8879 9001 9045 109 7952 77 NOR3_X2
* cell instance $1351 r0 *1 134.14,113.4
X$1351 9046 9172 7229 109 77 7948 MUX2_X2
* cell instance $1354 m0 *1 70.11,175
X$1354 5734 109 3364 77 BUF_X4
* cell instance $1355 m0 *1 66.31,175
X$1355 77 13553 14414 14660 14551 8687 109 DFFR_X1
* cell instance $1356 m0 *1 71.44,175
X$1356 8063 109 3611 77 BUF_X4
* cell instance $1358 m0 *1 74.29,175
X$1358 14140 7330 14555 77 109 14556 MUX2_X1
* cell instance $1360 m0 *1 75.81,175
X$1360 77 14475 14476 14555 14556 8687 109 DFFR_X1
* cell instance $1363 r0 *1 66.5,175
X$1363 14140 5656 14660 77 109 14551 MUX2_X1
* cell instance $1366 r0 *1 68.97,175
X$1366 14140 4905 14661 77 109 14599 MUX2_X1
* cell instance $1367 r0 *1 70.3,175
X$1367 77 14475 14413 14661 14599 8687 109 DFFR_X1
* cell instance $1370 r0 *1 77.9,175
X$1370 14600 4138 77 109 14903 NOR2_X1
* cell instance $1373 m0 *1 79.99,175
X$1373 14663 4138 14476 77 14665 109 AOI21_X1
* cell instance $1374 m0 *1 80.94,175
X$1374 77 13559 18552 14333 14558 8687 109 DFFR_X1
* cell instance $1377 r0 *1 80.37,175
X$1377 14333 11128 77 109 14663 NOR2_X1
* cell instance $1381 r0 *1 84.55,175
X$1381 77 9831 109 5740 BUF_X8
* cell instance $1383 m0 *1 85.12,175
X$1383 77 13559 14477 14419 14559 8687 109 DFFR_X1
* cell instance $1385 r0 *1 87.21,175
X$1385 14667 5740 14477 77 109 14669 MUX2_X1
* cell instance $1386 r0 *1 88.54,175
X$1386 14667 8645 14477 77 109 14668 MUX2_X1
* cell instance $1387 m0 *1 89.49,175
X$1387 14668 5734 14562 77 109 14670 MUX2_X1
* cell instance $1389 m0 *1 90.82,175
X$1389 14563 8063 14670 77 109 14478 MUX2_X1
* cell instance $1390 m0 *1 92.15,175
X$1390 14567 14047 14193 77 109 14427 MUX2_X1
* cell instance $1392 m0 *1 94.24,175
X$1392 77 13272 8993 109 BUF_X16
* cell instance $1395 r0 *1 90.06,175
X$1395 14721 8645 14601 77 109 14562 MUX2_X1
* cell instance $1398 r0 *1 92.34,175
X$1398 14565 4789 14602 77 109 14673 MUX2_X1
* cell instance $1399 r0 *1 93.67,175
X$1399 14602 8645 14603 77 109 14675 MUX2_X1
* cell instance $1400 r0 *1 95,175
X$1400 14672 5734 14675 77 109 14563 MUX2_X1
* cell instance $1401 r0 *1 96.33,175
X$1401 14429 4789 14603 77 109 14676 MUX2_X1
* cell instance $1404 m0 *1 99.56,175
X$1404 14571 13149 14440 77 109 14570 MUX2_X1
* cell instance $1406 m0 *1 100.89,175
X$1406 77 13687 14479 14571 14570 8201 109 DFFR_X1
* cell instance $1407 m0 *1 104.69,175
X$1407 14479 6584 14441 77 109 14572 MUX2_X1
* cell instance $1410 r0 *1 100.32,175
X$1410 14605 8645 14604 77 109 14672 MUX2_X1
* cell instance $1412 r0 *1 102.03,175
X$1412 9146 77 109 14140 BUF_X2
* cell instance $1413 r0 *1 102.79,175
X$1413 9146 77 109 14440 BUF_X2
* cell instance $1414 r0 *1 103.55,175
X$1414 14572 3978 14948 77 109 14569 MUX2_X1
* cell instance $1415 r0 *1 104.88,175
X$1415 14604 10449 14913 77 109 14573 MUX2_X1
* cell instance $1417 m0 *1 106.59,175
X$1417 14480 10299 14573 77 109 14481 MUX2_X1
* cell instance $1421 r0 *1 106.4,175
X$1421 8984 9030 7087 77 14724 109 NAND3_X4
* cell instance $1422 r0 *1 108.87,175
X$1422 14605 8209 14606 77 109 14482 MUX2_X1
* cell instance $1424 m0 *1 109.06,175
X$1424 14575 13002 14482 77 109 14725 MUX2_X1
* cell instance $1428 r0 *1 110.77,175
X$1428 77 14198 14604 14818 14813 8201 109 DFFR_X1
* cell instance $1429 m0 *1 113.62,175
X$1429 14440 8232 14581 77 109 14607 MUX2_X1
* cell instance $1430 m0 *1 112.29,175
X$1430 12722 8232 14577 77 109 14578 MUX2_X1
* cell instance $1433 m0 *1 115.9,175
X$1433 14026 77 109 14198 CLKBUF_X3
* cell instance $1434 m0 *1 116.85,175
X$1434 14198 77 109 19201 CLKBUF_X1
* cell instance $1437 r0 *1 114.76,175
X$1437 77 14198 14605 14581 14607 12731 109 DFFR_X1
* cell instance $1441 m0 *1 119.13,175
X$1441 77 13171 14586 14684 14585 12731 109 DFFR_X1
* cell instance $1442 m0 *1 117.8,175
X$1442 12722 8235 14582 77 109 14444 MUX2_X1
* cell instance $1450 r0 *1 122.17,175
X$1450 14684 13822 14484 77 109 14585 MUX2_X1
* cell instance $1452 m0 *1 123.31,175
X$1452 77 14726 14483 14584 14583 12731 109 DFFR_X1
* cell instance $1453 m0 *1 127.3,175
X$1453 14584 14206 14203 77 109 14583 MUX2_X1
* cell instance $1458 r0 *1 124.07,175
X$1458 13431 13823 6359 77 109 14685 MUX2_X1
* cell instance $1459 r0 *1 125.4,175
X$1459 14586 14200 14483 77 109 14688 MUX2_X1
* cell instance $1460 r0 *1 126.73,175
X$1460 15030 14485 14688 77 109 14687 MUX2_X1
* cell instance $1463 m0 *1 130.53,175
X$1463 11541 14338 11165 77 109 14691 MUX2_X1
* cell instance $1465 r0 *1 131.48,175
X$1465 14689 14608 14609 77 109 14696 MUX2_X1
* cell instance $1466 m0 *1 132.43,175
X$1466 77 14580 14693 14487 14579 12731 109 DFFR_X1
* cell instance $1468 m0 *1 136.23,175
X$1468 14487 14206 14488 77 109 14579 MUX2_X1
* cell instance $1470 r0 *1 132.81,175
X$1470 14610 14485 14692 77 109 14694 MUX2_X1
* cell instance $1471 r0 *1 134.14,175
X$1471 14687 14608 14694 77 109 14697 MUX2_X1
* cell instance $1472 r0 *1 135.47,175
X$1472 14693 14200 14695 77 109 14692 MUX2_X1
* cell instance $1473 r0 *1 136.8,175
X$1473 14697 14698 14696 77 109 14700 MUX2_X1
* cell instance $1474 m0 *1 138.51,175
X$1474 13437 77 109 14205 CLKBUF_X3
* cell instance $1475 m0 *1 137.94,175
X$1475 14205 77 109 19218 CLKBUF_X1
* cell instance $1477 m0 *1 139.65,175
X$1477 10702 13797 12541 77 109 14576 MUX2_X1
* cell instance $1478 m0 *1 140.98,175
X$1478 14576 14063 14612 77 109 14611 MUX2_X1
* cell instance $1481 m0 *1 143.26,175
X$1481 14574 13432 14489 77 109 14490 MUX2_X1
* cell instance $1484 r0 *1 138.13,175
X$1484 14826 14505 14700 77 109 13947 MUX2_X1
* cell instance $1485 r0 *1 139.46,175
X$1485 14340 77 109 14825 BUF_X1
* cell instance $1489 r0 *1 141.36,175
X$1489 77 14205 18873 14612 14611 12731 109 DFFR_X1
* cell instance $1491 m0 *1 145.92,175
X$1491 14340 13797 13668 77 109 14491 MUX2_X1
* cell instance $1495 r0 *1 146.11,175
X$1495 10556 13797 11684 77 109 14613 MUX2_X1
* cell instance $1498 m0 *1 147.63,175
X$1498 77 14493 18692 14566 14492 12731 109 DFFR_X1
* cell instance $1499 m0 *1 151.62,175
X$1499 77 11052 14208 14566 12996 13700 14443 14064 109 OAI222_X2
* cell instance $1500 m0 *1 154.28,175
X$1500 13292 109 13176 77 BUF_X4
* cell instance $1501 m0 *1 155.61,175
X$1501 77 4660 12999 5763 14734 109 NOR3_X4
* cell instance $1502 m0 *1 158.27,175
X$1502 14550 5763 14124 77 109 NOR2_X4
* cell instance $1503 m0 *1 159.98,175
X$1503 13447 13286 109 77 14690 AND2_X1
* cell instance $1504 m0 *1 160.74,175
X$1504 14494 77 109 13702 CLKBUF_X3
* cell instance $1505 m0 *1 161.69,175
X$1505 8265 8514 109 77 14557 AND2_X1
* cell instance $1506 m0 *1 162.45,175
X$1506 13575 14495 13706 77 14686 109 AOI21_X1
* cell instance $1507 m0 *1 163.21,175
X$1507 13232 109 11829 77 BUF_X4
* cell instance $1508 m0 *1 164.54,175
X$1508 14552 77 109 10415 INV_X4
* cell instance $1509 m0 *1 165.49,175
X$1509 14018 77 109 13070 CLKBUF_X3
* cell instance $1510 m0 *1 166.44,175
X$1510 14681 14553 13951 14067 77 109 14496 NAND4_X1
* cell instance $1511 m0 *1 167.39,175
X$1511 14682 10242 77 109 8714 NOR2_X2
* cell instance $1512 m0 *1 168.34,175
X$1512 14346 77 109 13300 CLKBUF_X3
* cell instance $1514 m0 *1 170.05,175
X$1514 77 10242 14544 14497 10113 109 NOR3_X4
* cell instance $1516 m0 *1 172.9,175
X$1516 14498 14616 14741 14432 14542 77 109 14618 AOI221_X1
* cell instance $1517 m0 *1 174.04,175
X$1517 14087 77 109 13706 CLKBUF_X3
* cell instance $1518 m0 *1 174.99,175
X$1518 14495 14550 77 109 13836 NOR2_X1
* cell instance $1519 m0 *1 175.56,175
X$1519 13300 11058 77 109 14349 NAND2_X1
* cell instance $1522 r0 *1 148.01,175
X$1522 14613 13432 14614 77 109 14701 MUX2_X1
* cell instance $1525 r0 *1 150.29,175
X$1525 77 12640 14208 14614 12996 13700 14677 13828 109 OAI222_X2
* cell instance $1526 r0 *1 152.95,175
X$1526 77 9163 14208 14612 12996 13700 14699 13829 109 OAI222_X2
* cell instance $1527 r0 *1 155.61,175
X$1527 12999 14816 6692 77 109 NOR2_X4
* cell instance $1528 r0 *1 157.32,175
X$1528 14560 77 109 14493 CLKBUF_X3
* cell instance $1530 r0 *1 158.46,175
X$1530 77 4660 109 14615 BUF_X8
* cell instance $1531 r0 *1 160.93,175
X$1531 13702 4660 77 109 14616 NOR2_X2
* cell instance $1533 r0 *1 162.07,175
X$1533 14683 13447 14738 109 77 9615 OAI21_X4
* cell instance $1534 r0 *1 164.54,175
X$1534 77 13447 109 5472 BUF_X8
* cell instance $1535 r0 *1 167.01,175
X$1535 13521 11829 14680 77 109 14682 MUX2_X1
* cell instance $1536 r0 *1 168.34,175
X$1536 13521 77 109 14617 INV_X1
* cell instance $1538 r0 *1 168.91,175
X$1538 14679 14678 109 8968 77 AND2_X4
* cell instance $1543 r0 *1 171.38,175
X$1543 77 14446 14618 12731 12816 14028 109 DFFR_X2
* cell instance $1546 r0 *1 176.13,175
X$1546 14671 14619 13295 109 77 14552 OAI21_X4
* cell instance $1547 m0 *1 177.65,175
X$1547 13300 14544 77 109 14674 NAND2_X1
* cell instance $1548 m0 *1 176.51,175
X$1548 11052 13359 14674 13070 14443 109 77 14535 OAI221_X1
* cell instance $1551 m0 *1 178.6,175
X$1551 9741 77 109 14543 BUF_X1
* cell instance $1552 r0 *1 178.6,175
X$1552 13361 14296 12989 77 14671 109 AOI21_X1
* cell instance $1553 r0 *1 179.36,175
X$1553 12640 77 109 11397 BUF_X1
* cell instance $1554 m0 *1 179.74,175
X$1554 14655 8037 14345 77 14666 109 AOI21_X1
* cell instance $1556 m0 *1 180.5,175
X$1556 14666 14353 14499 77 14620 109 AOI21_X1
* cell instance $1557 m0 *1 181.26,175
X$1557 14500 13706 14088 77 14499 109 AOI21_X1
* cell instance $1558 m0 *1 182.02,175
X$1558 14743 14087 77 109 14500 NOR2_X1
* cell instance $1561 m0 *1 183.54,175
X$1561 9399 14223 12896 77 109 14501 MUX2_X1
* cell instance $1564 r0 *1 180.12,175
X$1564 14501 13883 14351 10556 14079 14664 109 77 AOI221_X2
* cell instance $1565 r0 *1 182.21,175
X$1565 13959 9552 77 109 14662 NOR2_X1
* cell instance $1567 r0 *1 182.97,175
X$1567 14621 12989 13841 77 14744 109 AOI21_X1
* cell instance $1568 r0 *1 183.73,175
X$1568 13959 10556 77 109 14621 NOR2_X1
* cell instance $1569 r0 *1 184.3,175
X$1569 13842 77 109 14353 BUF_X2
* cell instance $1572 m0 *1 185.25,175
X$1572 14508 13345 14501 77 109 14537 MUX2_X1
* cell instance $1574 r0 *1 185.25,175
X$1574 14226 109 14079 77 BUF_X4
* cell instance $1576 r0 *1 186.96,175
X$1576 14353 77 109 13454 CLKBUF_X3
* cell instance $1578 m0 *1 187.72,175
X$1578 14535 14536 14418 77 14748 109 AOI21_X1
* cell instance $1579 r0 *1 187.91,175
X$1579 14079 109 13452 77 BUF_X4
* cell instance $1580 m0 *1 189.05,175
X$1580 14224 77 109 14340 BUF_X1
* cell instance $1582 m0 *1 189.62,175
X$1582 14534 13234 14223 77 14225 109 AOI21_X2
* cell instance $1583 m0 *1 190.95,175
X$1583 14225 13883 14357 9552 14226 14655 109 77 AOI221_X2
* cell instance $1584 m0 *1 193.04,175
X$1584 14357 109 14495 77 BUF_X4
* cell instance $1585 m0 *1 194.37,175
X$1585 13718 77 109 13844 CLKBUF_X3
* cell instance $1587 m0 *1 195.51,175
X$1587 14124 14081 14502 109 77 13464 OAI21_X2
* cell instance $1591 r0 *1 189.62,175
X$1591 11775 14084 14617 77 109 14656 MUX2_X1
* cell instance $1595 r0 *1 193.04,175
X$1595 13452 11437 14457 77 14622 109 AOI21_X1
* cell instance $1596 r0 *1 193.8,175
X$1596 14124 14457 77 109 14623 NAND2_X1
* cell instance $1597 r0 *1 194.37,175
X$1597 14623 11437 14652 109 14782 77 OAI21_X1
* cell instance $1598 r0 *1 195.13,175
X$1598 14263 14502 77 109 14652 NAND2_X1
* cell instance $1600 m0 *1 198.17,175
X$1600 13961 14503 77 109 14608 XNOR2_X2
* cell instance $1602 m0 *1 200.07,175
X$1602 14211 14457 14502 77 109 14625 NOR3_X1
* cell instance $1603 m0 *1 200.83,175
X$1603 14485 14627 13996 109 14503 77 NOR3_X2
* cell instance $1605 m0 *1 202.35,175
X$1605 14625 14505 77 109 14641 NAND2_X1
* cell instance $1606 m0 *1 202.92,175
X$1606 14504 14886 77 109 14531 NAND2_X1
* cell instance $1607 m0 *1 203.49,175
X$1607 14238 14531 77 109 14505 XNOR2_X2
* cell instance $1608 m0 *1 205.39,175
X$1608 14530 14627 19054 109 77 14396 HA_X1
* cell instance $1609 m0 *1 207.29,175
X$1609 14360 14124 14641 77 109 14529 MUX2_X1
* cell instance $1611 m0 *1 208.81,175
X$1611 77 14506 14528 14640 14529 3676 109 DFFR_X1
* cell instance $1612 m0 *1 212.61,175
X$1612 14528 77 109 14238 BUF_X2
* cell instance $1614 m0 *1 213.56,175
X$1614 77 14506 14524 14525 14507 3676 109 DFFR_X1
* cell instance $1615 m0 *1 217.36,175
X$1615 14397 13602 14524 109 14508 77 OAI21_X1
* cell instance $1618 r0 *1 199.12,175
X$1618 14608 14211 14457 14502 77 109 14624 NOR4_X1
* cell instance $1620 r0 *1 200.45,175
X$1620 14625 14200 77 109 14644 NAND2_X1
* cell instance $1621 r0 *1 201.02,175
X$1621 14627 14124 14644 77 109 14626 MUX2_X1
* cell instance $1625 r0 *1 204.82,175
X$1625 14530 14751 19071 109 77 14361 HA_X1
* cell instance $1626 r0 *1 206.72,175
X$1626 14752 14627 19070 109 77 14362 HA_X1
* cell instance $1629 r0 *1 210.52,175
X$1629 14394 14360 77 109 14753 NAND2_X1
* cell instance $1633 r0 *1 212.42,175
X$1633 14640 77 109 14360 BUF_X2
* cell instance $1634 r0 *1 213.18,175
X$1634 14362 14360 77 109 14509 NAND2_X1
* cell instance $1638 r0 *1 216.41,175
X$1638 14365 13308 14757 109 14756 77 OAI21_X1
* cell instance $1639 r0 *1 217.17,175
X$1639 14637 13309 14628 13605 77 109 14629 AOI22_X1
* cell instance $1640 r0 *1 218.12,175
X$1640 14629 77 109 14638 INV_X1
* cell instance $1641 m0 *1 218.69,175
X$1641 14509 13602 14521 109 14222 77 OAI21_X1
* cell instance $1646 r0 *1 218.5,175
X$1646 77 14758 14760 14637 14638 3676 109 DFFR_X1
* cell instance $1648 m0 *1 226.86,175
X$1648 77 18373 14366 14519 13854 109 DFF_X1
* cell instance $1656 m0 *1 231.42,175
X$1656 11150 77 109 14517 BUF_X1
* cell instance $1659 m0 *1 232.56,175
X$1659 8733 77 109 14514 BUF_X1
* cell instance $1661 m0 *1 233.13,175
X$1661 14517 77 109 14511 BUF_X1
* cell instance $1663 m0 *1 236.74,175
X$1663 9396 77 109 14634 BUF_X1
* cell instance $1669 r0 *1 237.12,175
X$1669 14634 77 109 14630 BUF_X1
* cell instance $1671 m0 *1 239.02,175
X$1671 14633 77 109 14513 BUF_X1
* cell instance $1672 m0 *1 238.45,175
X$1672 14514 77 109 14370 BUF_X1
* cell instance $1676 m0 *1 44.08,161
X$1676 4065 109 13408 77 BUF_X4
* cell instance $1677 m0 *1 42.75,161
X$1677 13496 13152 6726 109 13338 77 NOR3_X2
* cell instance $1678 m0 *1 45.41,161
X$1678 77 12860 18577 13154 13340 4086 109 DFFR_X1
* cell instance $1681 r0 *1 42.75,161
X$1681 13495 6997 77 109 13496 NOR2_X1
* cell instance $1683 r0 *1 43.51,161
X$1683 77 13429 13338 6726 13410 109 AOI21_X4
* cell instance $1685 r0 *1 46.36,161
X$1685 5020 109 9815 77 BUF_X4
* cell instance $1688 r0 *1 48.64,161
X$1688 13499 11448 9815 77 13498 109 AOI21_X1
* cell instance $1690 r0 *1 50.16,161
X$1690 9815 13411 77 109 13499 NOR2_X1
* cell instance $1692 m0 *1 51.3,161
X$1692 8529 13155 7764 11125 13223 77 109 13263 AOI221_X1
* cell instance $1697 m0 *1 54.91,161
X$1697 6369 13414 13226 77 12564 109 AOI21_X2
* cell instance $1701 r0 *1 51.87,161
X$1701 13500 13502 8671 77 109 13156 NOR3_X1
* cell instance $1703 r0 *1 53.01,161
X$1703 13413 6120 77 109 13502 NOR2_X1
* cell instance $1704 r0 *1 53.58,161
X$1704 13549 13355 13412 77 109 13413 MUX2_X1
* cell instance $1706 r0 *1 55.29,161
X$1706 6294 13550 5672 77 13414 109 AOI21_X1
* cell instance $1709 r0 *1 56.62,161
X$1709 13416 11448 10590 77 13415 109 AOI21_X1
* cell instance $1712 m0 *1 57.38,161
X$1712 77 11283 18581 13264 13506 4086 109 DFFR_X1
* cell instance $1713 m0 *1 61.37,161
X$1713 13265 7321 12861 77 13354 109 AOI21_X1
* cell instance $1715 m0 *1 62.32,161
X$1715 13357 8529 7764 8670 13354 13358 109 77 AOI221_X2
* cell instance $1717 m0 *1 64.6,161
X$1717 13266 5017 13511 77 109 11714 MUX2_X1
* cell instance $1719 m0 *1 66.12,161
X$1719 77 12571 12969 13267 13362 4086 109 DFFR_X1
* cell instance $1720 m0 *1 69.92,161
X$1720 11594 4905 13267 77 109 13362 MUX2_X1
* cell instance $1723 r0 *1 57.57,161
X$1723 10590 13417 77 109 13416 NOR2_X1
* cell instance $1726 r0 *1 58.71,161
X$1726 13641 10763 11129 77 13506 109 AOI21_X1
* cell instance $1730 r0 *1 59.47,161
X$1730 11129 13264 77 109 13641 NOR2_X1
* cell instance $1732 r0 *1 60.8,161
X$1732 13264 13355 77 109 13265 NOR2_X1
* cell instance $1733 r0 *1 61.37,161
X$1733 13264 12189 77 109 13418 NOR2_X1
* cell instance $1734 r0 *1 61.94,161
X$1734 13418 5039 12861 77 13509 109 AOI21_X1
* cell instance $1736 r0 *1 63.08,161
X$1736 5461 13509 13357 8403 77 109 13511 AOI22_X1
* cell instance $1738 r0 *1 64.22,161
X$1738 13512 10969 10590 77 13645 109 AOI21_X1
* cell instance $1741 r0 *1 66.12,161
X$1741 10590 13513 77 109 13512 NOR2_X1
* cell instance $1745 r0 *1 71.63,161
X$1745 13419 7332 12717 77 109 13514 MUX2_X1
* cell instance $1746 r0 *1 72.96,161
X$1746 77 12571 18716 13419 13514 8687 109 DFFR_X1
* cell instance $1747 m0 *1 74.48,161
X$1747 77 12571 13366 13364 13268 8687 109 DFFR_X1
* cell instance $1748 m0 *1 73.15,161
X$1748 13364 6983 13164 77 109 13268 MUX2_X1
* cell instance $1752 r0 *1 77.33,161
X$1752 13419 11128 77 109 13648 NOR2_X1
* cell instance $1753 r0 *1 77.9,161
X$1753 13366 77 109 13649 INV_X1
* cell instance $1754 r0 *1 78.28,161
X$1754 13420 13557 8672 109 13523 77 NOR3_X2
* cell instance $1756 m0 *1 78.66,161
X$1756 13040 109 8068 77 BUF_X4
* cell instance $1757 m0 *1 80.75,161
X$1757 13366 12867 8359 77 109 13369 NOR3_X1
* cell instance $1758 m0 *1 81.51,161
X$1758 8191 13368 13369 13044 13162 13163 77 109 13370 OAI33_X1
* cell instance $1759 m0 *1 82.84,161
X$1759 5967 8868 77 109 13558 NAND2_X1
* cell instance $1760 m0 *1 83.41,161
X$1760 13519 13146 12717 77 109 13372 MUX2_X1
* cell instance $1763 r0 *1 79.61,161
X$1763 13419 13272 77 109 13518 NOR2_X1
* cell instance $1764 r0 *1 80.18,161
X$1764 13772 13518 8239 77 109 13368 NOR3_X1
* cell instance $1766 r0 *1 81.13,161
X$1766 8070 8868 5455 77 109 NOR2_X4
* cell instance $1767 r0 *1 82.84,161
X$1767 77 12576 13269 13519 13372 8687 109 DFFR_X1
* cell instance $1768 m0 *1 86.07,161
X$1768 13165 8068 13269 77 109 13375 MUX2_X1
* cell instance $1770 m0 *1 87.4,161
X$1770 7877 12719 13376 13421 13379 77 109 OAI211_X2
* cell instance $1771 m0 *1 89.11,161
X$1771 13380 13243 13270 13379 109 13381 77 NOR4_X2
* cell instance $1774 r0 *1 88.16,161
X$1774 13375 13656 77 109 13270 NOR2_X1
* cell instance $1775 r0 *1 88.73,161
X$1775 13562 8209 8239 77 109 13380 NOR3_X1
* cell instance $1776 r0 *1 89.49,161
X$1776 13565 13381 13683 13370 109 13422 77 NOR4_X2
* cell instance $1778 m0 *1 91.39,161
X$1778 13166 8239 77 109 13271 NOR2_X1
* cell instance $1780 m0 *1 91.96,161
X$1780 13386 8349 13048 77 109 13385 MUX2_X1
* cell instance $1781 m0 *1 93.29,161
X$1781 13384 8847 13526 77 109 13386 MUX2_X1
* cell instance $1782 m0 *1 94.62,161
X$1782 13273 8672 13274 77 109 13275 MUX2_X1
* cell instance $1783 m0 *1 95.95,161
X$1783 77 6369 109 6901 BUF_X8
* cell instance $1785 r0 *1 91.58,161
X$1785 13423 8868 77 109 13660 NOR2_X1
* cell instance $1786 r0 *1 92.15,161
X$1786 13525 3611 13245 77 109 13273 MUX2_X1
* cell instance $1787 r0 *1 93.48,161
X$1787 13385 3611 13247 77 109 13274 MUX2_X1
* cell instance $1788 r0 *1 94.81,161
X$1788 77 9122 13662 8627 13275 109 AOI21_X4
* cell instance $1790 r0 *1 97.47,161
X$1790 77 12870 13047 13424 13529 8201 109 DFFR_X1
* cell instance $1791 m0 *1 98.99,161
X$1791 13391 9945 11573 77 109 13389 MUX2_X1
* cell instance $1793 m0 *1 100.32,161
X$1793 11594 8235 13392 77 109 13250 MUX2_X1
* cell instance $1795 m0 *1 101.84,161
X$1795 6125 13002 11132 77 12413 109 NAND3_X4
* cell instance $1796 m0 *1 104.31,161
X$1796 7167 77 109 13276 BUF_X2
* cell instance $1802 r0 *1 101.46,161
X$1802 77 12870 13384 13425 13532 8201 109 DFFR_X1
* cell instance $1804 r0 *1 105.45,161
X$1804 13276 6993 13533 77 109 13534 MUX2_X1
* cell instance $1805 r0 *1 106.78,161
X$1805 77 13819 13526 13533 13534 8201 109 DFFR_X1
* cell instance $1807 r0 *1 110.77,161
X$1807 12722 7636 13536 77 109 13664 MUX2_X1
* cell instance $1808 m0 *1 111.72,161
X$1808 13167 13002 13277 77 109 13395 MUX2_X1
* cell instance $1809 m0 *1 110.77,161
X$1809 8362 13395 6745 13426 109 77 12724 OAI22_X1
* cell instance $1810 m0 *1 113.05,161
X$1810 13427 9023 13277 77 109 13278 MUX2_X1
* cell instance $1811 m0 *1 114.38,161
X$1811 13278 4774 13170 77 109 13279 MUX2_X1
* cell instance $1812 m0 *1 115.71,161
X$1812 13279 5967 13397 77 109 13168 MUX2_X1
* cell instance $1813 m0 *1 117.04,161
X$1813 12722 6993 13398 77 109 13280 MUX2_X1
* cell instance $1816 m0 *1 122.17,161
X$1816 5163 5149 19032 109 77 13538 HA_X1
* cell instance $1820 r0 *1 112.48,161
X$1820 12416 13002 13427 77 109 13426 MUX2_X1
* cell instance $1827 r0 *1 115.14,161
X$1827 13567 10860 13428 77 109 13169 MUX2_X1
* cell instance $1829 r0 *1 117.99,161
X$1829 13537 10590 12095 77 109 13665 MUX2_X1
* cell instance $1834 r0 *1 121.41,161
X$1834 9341 77 109 13053 CLKBUF_X3
* cell instance $1835 r0 *1 122.36,161
X$1835 13053 77 109 19181 INV_X1
* cell instance $1837 r0 *1 122.93,161
X$1837 13429 77 109 14059 BUF_X2
* cell instance $1839 r0 *1 123.88,161
X$1839 13538 77 109 12419 BUF_X2
* cell instance $1840 r0 *1 124.64,161
X$1840 13539 77 109 12265 BUF_X2
* cell instance $1841 m0 *1 125.4,161
X$1841 11301 77 109 5149 INV_X4
* cell instance $1845 r0 *1 125.59,161
X$1845 6359 13281 7028 77 109 13540 MUX2_X1
* cell instance $1846 m0 *1 128.06,161
X$1846 11894 77 109 13396 BUF_X1
* cell instance $1847 m0 *1 126.73,161
X$1847 7968 13281 7029 77 109 13282 MUX2_X1
* cell instance $1850 r0 *1 126.92,161
X$1850 13540 13056 13283 77 109 13666 MUX2_X1
* cell instance $1851 r0 *1 128.25,161
X$1851 12585 11301 19072 109 77 13539 HA_X1
* cell instance $1852 m0 *1 129.96,161
X$1852 8719 12877 7053 77 109 13284 MUX2_X1
* cell instance $1854 m0 *1 131.29,161
X$1854 12877 77 109 13281 CLKBUF_X3
* cell instance $1858 m0 *1 136.23,161
X$1858 13056 77 109 12738 CLKBUF_X3
* cell instance $1859 m0 *1 137.18,161
X$1859 77 8572 109 4492 BUF_X8
* cell instance $1861 r0 *1 130.15,161
X$1861 8383 77 109 13541 BUF_X1
* cell instance $1862 r0 *1 130.72,161
X$1862 13284 13056 13371 77 109 13542 MUX2_X1
* cell instance $1864 r0 *1 132.24,161
X$1864 77 13430 18877 13371 13542 12731 109 DFFR_X1
* cell instance $1868 r0 *1 137.37,161
X$1868 12690 12734 11838 77 109 13433 MUX2_X1
* cell instance $1869 r0 *1 138.7,161
X$1869 13433 13432 13434 77 109 13669 MUX2_X1
* cell instance $1870 m0 *1 140.22,161
X$1870 77 13022 18574 13174 13394 12731 109 DFFR_X1
* cell instance $1873 m0 *1 144.21,161
X$1873 13175 13393 109 77 11682 XNOR2_X1
* cell instance $1874 m0 *1 145.35,161
X$1874 13175 13285 11309 13286 77 109 13058 NOR4_X1
* cell instance $1875 m0 *1 146.3,161
X$1875 13285 13286 77 109 13393 NOR2_X1
* cell instance $1878 r0 *1 140.03,161
X$1878 12585 13797 8383 77 109 13435 MUX2_X1
* cell instance $1879 r0 *1 141.36,161
X$1879 13435 13432 13569 77 109 13436 MUX2_X1
* cell instance $1880 r0 *1 142.69,161
X$1880 13437 77 109 13022 CLKBUF_X3
* cell instance $1881 r0 *1 143.64,161
X$1881 11838 13439 13434 13068 109 77 13438 OAI22_X1
* cell instance $1882 r0 *1 144.59,161
X$1882 7028 13439 13283 13068 109 77 13290 OAI22_X1
* cell instance $1884 m0 *1 148.96,161
X$1884 6693 12887 13388 77 109 12432 MUX2_X1
* cell instance $1885 m0 *1 148.01,161
X$1885 13181 77 109 12887 CLKBUF_X3
* cell instance $1886 m0 *1 150.29,161
X$1886 13390 13288 77 109 13061 NAND2_X1
* cell instance $1888 m0 *1 151.05,161
X$1888 13387 13288 77 109 13063 NAND2_X1
* cell instance $1889 m0 *1 151.62,161
X$1889 13907 13288 77 109 13179 NAND2_X1
* cell instance $1890 m0 *1 152.19,161
X$1890 13181 77 109 13288 BUF_X2
* cell instance $1891 m0 *1 152.95,161
X$1891 13383 13288 77 109 13289 NAND2_X1
* cell instance $1892 m0 *1 153.52,161
X$1892 13382 13288 77 109 13291 NAND2_X1
* cell instance $1893 m0 *1 154.09,161
X$1893 13531 13288 77 109 13377 NAND2_X1
* cell instance $1894 m0 *1 154.66,161
X$1894 13378 13288 77 109 13180 NAND2_X1
* cell instance $1898 r0 *1 149.53,161
X$1898 11140 12887 13440 109 13024 77 OAI21_X1
* cell instance $1899 r0 *1 150.29,161
X$1899 9805 13439 13535 109 13126 77 OAI21_X1
* cell instance $1900 r0 *1 151.05,161
X$1900 13571 12887 77 109 13535 NAND2_X1
* cell instance $1902 r0 *1 152,161
X$1902 13178 13367 13181 11261 13374 109 77 13440 OAI221_X1
* cell instance $1904 r0 *1 153.33,161
X$1904 13290 13441 13528 77 12536 109 AOI21_X1
* cell instance $1905 r0 *1 154.09,161
X$1905 13442 13288 77 109 13530 NAND2_X1
* cell instance $1907 r0 *1 154.85,161
X$1907 8462 13441 13530 109 13238 77 OAI21_X1
* cell instance $1908 r0 *1 155.61,161
X$1908 12887 77 109 13441 CLKBUF_X3
* cell instance $1909 m0 *1 156.75,161
X$1909 13373 12893 13181 10741 13374 109 77 12827 OAI221_X1
* cell instance $1910 m0 *1 155.61,161
X$1910 13373 13294 13181 12990 13374 109 77 12890 OAI221_X1
* cell instance $1912 m0 *1 158.65,161
X$1912 77 13297 13292 13371 13182 13178 13187 13527 109 OAI222_X2
* cell instance $1913 m0 *1 161.31,161
X$1913 4492 13573 13574 77 9779 109 AOI21_X2
* cell instance $1915 r0 *1 156.56,161
X$1915 13374 8333 13700 11676 109 77 13528 OAI22_X1
* cell instance $1917 r0 *1 157.89,161
X$1917 13438 13441 13443 77 12676 109 AOI21_X1
* cell instance $1918 r0 *1 158.65,161
X$1918 8333 77 109 13431 BUF_X1
* cell instance $1920 r0 *1 159.41,161
X$1920 13527 13065 77 109 13184 NOR2_X1
* cell instance $1921 r0 *1 159.98,161
X$1921 13444 13292 13182 109 77 13065 AND3_X1
* cell instance $1923 r0 *1 161.31,161
X$1923 77 10242 13445 13524 6551 109 NOR3_X4
* cell instance $1925 m0 *1 163.02,161
X$1925 13294 77 109 13293 INV_X1
* cell instance $1927 r0 *1 163.97,161
X$1927 13367 11829 77 109 13524 NOR2_X1
* cell instance $1928 m0 *1 164.73,161
X$1928 77 13118 13365 12731 12823 13294 109 DFFR_X2
* cell instance $1932 r0 *1 164.73,161
X$1932 77 9610 8572 13522 13446 109 AOI21_X4
* cell instance $1934 r0 *1 167.39,161
X$1934 13361 13295 13578 77 11067 109 AOI21_X2
* cell instance $1935 r0 *1 168.72,161
X$1935 13300 11485 77 109 13448 NAND2_X1
* cell instance $1936 r0 *1 169.29,161
X$1936 10741 13359 13448 13296 12893 109 77 13516 OAI221_X1
* cell instance $1937 m0 *1 169.48,161
X$1937 13296 13187 13298 13297 13299 13349 77 109 OAI221_X2
* cell instance $1939 m0 *1 171.57,161
X$1939 13300 13301 77 109 13299 NAND2_X1
* cell instance $1941 m0 *1 172.33,161
X$1941 13231 13301 77 109 8791 NOR2_X2
* cell instance $1943 m0 *1 173.47,161
X$1943 13300 11404 77 109 13360 NAND2_X1
* cell instance $1950 r0 *1 171.57,161
X$1950 13516 13507 13350 77 13117 109 AOI21_X1
* cell instance $1951 r0 *1 172.33,161
X$1951 13517 13295 77 109 13301 NOR2_X1
* cell instance $1953 r0 *1 173.09,161
X$1953 13449 13515 77 109 10901 NAND2_X1
* cell instance $1955 r0 *1 173.85,161
X$1955 13361 13447 12897 77 13449 109 AOI21_X1
* cell instance $1957 m0 *1 174.42,161
X$1957 13183 13359 13360 13296 13186 109 77 13356 OAI221_X1
* cell instance $1960 r0 *1 175.18,161
X$1960 13070 11244 77 109 13510 NAND2_X1
* cell instance $1961 r0 *1 175.75,161
X$1961 13444 77 109 13461 INV_X2
* cell instance $1962 m0 *1 176.13,161
X$1962 13300 11239 77 109 13353 NAND2_X1
* cell instance $1965 m0 *1 176.89,161
X$1965 13300 13229 77 109 13351 NAND2_X1
* cell instance $1966 m0 *1 177.46,161
X$1966 13296 13185 13298 9272 13351 13343 77 109 OAI221_X2
* cell instance $1967 m0 *1 179.55,161
X$1967 9122 13298 13353 13296 13072 109 77 13344 OAI221_X1
* cell instance $1968 m0 *1 180.69,161
X$1968 13450 13303 77 109 13350 NAND2_X1
* cell instance $1972 r0 *1 176.89,161
X$1972 13356 13508 13659 77 13230 109 AOI21_X1
* cell instance $1974 r0 *1 177.84,161
X$1974 13581 13298 13510 13296 11676 109 77 13505 OAI221_X1
* cell instance $1976 r0 *1 179.17,161
X$1976 13583 13580 13451 8717 13452 13508 109 77 AOI221_X2
* cell instance $1978 r0 *1 181.45,161
X$1978 13455 13580 13451 8718 13452 13507 109 77 AOI221_X2
* cell instance $1980 m0 *1 181.64,161
X$1980 13349 13348 13503 77 13302 109 AOI21_X1
* cell instance $1981 m0 *1 183.16,161
X$1981 13347 13454 77 109 13348 NAND2_X1
* cell instance $1982 m0 *1 183.73,161
X$1982 13336 13345 13455 77 109 13347 MUX2_X1
* cell instance $1986 r0 *1 183.73,161
X$1986 13505 13453 13504 77 13073 109 AOI21_X1
* cell instance $1989 r0 *1 185.63,161
X$1989 13456 13457 13451 7968 13461 13501 109 77 AOI221_X2
* cell instance $1990 m0 *1 186.96,161
X$1990 77 11327 13459 3676 13115 13072 109 DFFR_X2
* cell instance $1991 m0 *1 186.2,161
X$1991 13224 13342 13501 77 13346 109 AOI21_X1
* cell instance $1992 m0 *1 191.14,161
X$1992 13304 13345 13339 77 109 13462 MUX2_X1
* cell instance $1993 m0 *1 192.47,161
X$1993 77 13305 13341 3676 13112 13185 109 DFFR_X2
* cell instance $1997 r0 *1 187.91,161
X$1997 13344 13460 13586 77 13459 109 AOI21_X1
* cell instance $1998 r0 *1 188.67,161
X$1998 13339 13457 13451 6235 13461 13497 109 77 AOI221_X2
* cell instance $2000 r0 *1 190.95,161
X$2000 13343 13494 13497 77 13341 109 AOI21_X1
* cell instance $2002 r0 *1 191.9,161
X$2002 13189 13345 13587 77 109 13644 MUX2_X1
* cell instance $2003 r0 *1 193.23,161
X$2003 77 12880 8733 109 INV_X16
* cell instance $2004 r0 *1 196.46,161
X$2004 77 13305 13492 13596 13638 3676 109 DFFR_X1
* cell instance $2006 m0 *1 200.07,161
X$2006 77 13305 13306 13335 13337 3676 109 DFFR_X1
* cell instance $2007 m0 *1 204.06,161
X$2007 77 13305 13489 13333 13217 3676 109 DFFR_X1
* cell instance $2011 r0 *1 200.45,161
X$2011 13492 77 109 13635 INV_X1
* cell instance $2012 r0 *1 200.83,161
X$2012 13718 77 109 13305 CLKBUF_X3
* cell instance $2013 r0 *1 201.78,161
X$2013 13463 77 109 13337 INV_X1
* cell instance $2014 r0 *1 202.16,161
X$2014 13335 13464 13458 13190 77 109 13463 AOI22_X1
* cell instance $2015 r0 *1 203.11,161
X$2015 13633 13329 13306 109 13458 77 OAI21_X1
* cell instance $2018 r0 *1 205.77,161
X$2018 13333 13464 13336 13190 77 109 13490 AOI22_X1
* cell instance $2019 r0 *1 206.72,161
X$2019 13308 13330 13489 109 13336 77 OAI21_X1
* cell instance $2021 m0 *1 209.19,161
X$2021 13332 77 109 13307 INV_X1
* cell instance $2023 m0 *1 209.57,161
X$2023 13216 13309 13304 13190 77 109 13332 AOI22_X1
* cell instance $2024 m0 *1 210.52,161
X$2024 13308 13329 13188 109 13304 77 OAI21_X1
* cell instance $2027 m0 *1 212.23,161
X$2027 13328 77 109 13487 INV_X1
* cell instance $2028 m0 *1 212.61,161
X$2028 13486 13309 13465 13190 77 109 13328 AOI22_X1
* cell instance $2029 m0 *1 213.56,161
X$2029 1236 77 109 10855 CLKBUF_X3
* cell instance $2030 m0 *1 214.51,161
X$2030 10855 77 109 19083 INV_X4
* cell instance $2034 r0 *1 209.19,161
X$2034 13464 77 109 13309 CLKBUF_X3
* cell instance $2037 r0 *1 210.71,161
X$2037 77 13847 13466 13486 13487 3676 109 DFFR_X1
* cell instance $2040 r0 *1 215.65,161
X$2040 13485 77 109 13606 INV_X1
* cell instance $2041 r0 *1 216.03,161
X$2041 77 18442 13483 13469 13191 109 DFF_X1
* cell instance $2042 m0 *1 221.35,161
X$2042 13310 12911 109 77 13482 XNOR2_X1
* cell instance $2043 m0 *1 218.88,161
X$2043 9382 13468 8749 109 77 13310 OAI21_X4
* cell instance $2044 m0 *1 222.49,161
X$2044 13192 13312 77 109 13208 NAND2_X1
* cell instance $2046 m0 *1 223.25,161
X$2046 13207 13193 12911 77 109 13311 NOR3_X1
* cell instance $2047 m0 *1 224.01,161
X$2047 13085 12157 77 109 12911 NAND2_X2
* cell instance $2049 r0 *1 219.26,161
X$2049 13483 77 109 13468 INV_X1
* cell instance $2050 r0 *1 219.64,161
X$2050 13483 11506 13482 77 109 13469 MUX2_X1
* cell instance $2054 r0 *1 223.06,161
X$2054 9728 13624 77 109 13193 OR2_X1
* cell instance $2056 m0 *1 225.53,161
X$2056 11186 77 109 12302 CLKBUF_X3
* cell instance $2058 m0 *1 226.48,161
X$2058 10847 13085 13310 12157 77 109 13322 NAND4_X1
* cell instance $2061 m0 *1 229.14,161
X$2061 77 18336 13202 13320 13476 109 DFF_X1
* cell instance $2062 m0 *1 232.37,161
X$2062 13202 12305 13195 77 109 13320 MUX2_X1
* cell instance $2069 r0 *1 228.57,161
X$2069 8749 13610 77 109 10354 NOR2_X2
* cell instance $2072 r0 *1 231.23,161
X$2072 8584 77 109 13474 BUF_X1
* cell instance $2075 r0 *1 232.37,161
X$2075 7968 77 109 13475 BUF_X1
* cell instance $2076 r0 *1 232.94,161
X$2076 77 18414 13470 13471 13476 109 DFF_X1
* cell instance $2078 m0 *1 234.08,161
X$2078 13200 77 109 13613 CLKBUF_X3
* cell instance $2079 m0 *1 235.22,161
X$2079 13194 77 109 13317 BUF_X1
* cell instance $2080 m0 *1 235.79,161
X$2080 13314 10500 13315 77 109 13313 MUX2_X1
* cell instance $2082 r0 *1 236.17,161
X$2082 13474 77 109 13473 BUF_X1
* cell instance $2085 m0 *1 237.69,161
X$2085 13314 10498 13097 77 109 13315 MUX2_X1
* cell instance $2087 m0 *1 239.02,161
X$2087 12917 77 109 13197 BUF_X1
* cell instance $2089 r0 *1 237.88,161
X$2089 13475 77 109 13472 BUF_X1
* cell instance $2090 r0 *1 238.45,161
X$2090 13195 77 109 13316 BUF_X1
* cell instance $2091 r0 *1 239.02,161
X$2091 13315 77 109 13196 BUF_X1
* cell instance $2093 m0 *1 74.1,46.2
X$2093 2326 2484 77 109 2546 NAND2_X1
* cell instance $2095 m0 *1 74.67,46.2
X$2095 2546 2325 2415 109 77 2485 OAI21_X2
* cell instance $2096 m0 *1 76,46.2
X$2096 77 2229 2611 2484 2485 2157 109 DFFR_X1
* cell instance $2099 m0 *1 80.75,46.2
X$2099 2232 2407 2492 109 2549 77 OAI21_X1
* cell instance $2101 m0 *1 81.7,46.2
X$2101 2407 2550 77 109 2492 NAND2_X1
* cell instance $2104 m0 *1 84.55,46.2
X$2104 2232 2325 2416 109 2612 77 OAI21_X1
* cell instance $2105 m0 *1 85.31,46.2
X$2105 2325 2614 77 109 2416 NAND2_X1
* cell instance $2110 r0 *1 74.1,46.2
X$2110 2543 77 109 2229 CLKBUF_X3
* cell instance $2111 r0 *1 75.05,46.2
X$2111 2724 2407 2548 109 77 2871 OAI21_X4
* cell instance $2112 r0 *1 77.52,46.2
X$2112 2322 2725 77 109 2724 NAND2_X1
* cell instance $2114 r0 *1 79.61,46.2
X$2114 77 2378 2726 2550 2549 2157 109 DFFR_X1
* cell instance $2116 r0 *1 83.6,46.2
X$2116 77 2551 2643 2614 2612 2157 109 DFFR_X1
* cell instance $2118 r0 *1 87.59,46.2
X$2118 2417 2325 2644 109 2730 77 OAI21_X1
* cell instance $2119 r0 *1 88.35,46.2
X$2119 2325 2733 77 109 2644 NAND2_X1
* cell instance $2121 r0 *1 89.3,46.2
X$2121 166 77 109 18285 INV_X8
* cell instance $2123 m0 *1 90.06,46.2
X$2123 77 1663 2157 109 BUF_X32
* cell instance $2128 r0 *1 91.58,46.2
X$2128 2552 77 109 2090 CLKBUF_X3
* cell instance $2130 r0 *1 93.29,46.2
X$2130 2552 109 2235 77 BUF_X4
* cell instance $2131 r0 *1 94.62,46.2
X$2131 2329 2553 2287 2554 77 109 2646 AOI22_X1
* cell instance $2132 r0 *1 95.57,46.2
X$2132 112 2650 2329 77 109 2648 MUX2_X1
* cell instance $2136 r0 *1 98.23,46.2
X$2136 2645 2650 276 77 109 2652 MUX2_X1
* cell instance $2140 r0 *1 100.89,46.2
X$2140 2330 2553 2164 2554 77 109 2653 AOI22_X1
* cell instance $2142 m0 *1 102.22,46.2
X$2142 77 2234 18654 2555 2498 1663 109 DFFR_X1
* cell instance $2145 m0 *1 107.54,46.2
X$2145 2499 2093 77 109 2501 NOR2_X1
* cell instance $2146 m0 *1 108.11,46.2
X$2146 2500 1753 1307 77 2499 109 AOI21_X1
* cell instance $2147 m0 *1 108.87,46.2
X$2147 1124 2501 2419 2500 109 77 2657 OAI22_X2
* cell instance $2148 m0 *1 110.58,46.2
X$2148 2012 2420 109 77 2557 AND2_X1
* cell instance $2150 m0 *1 111.53,46.2
X$2150 2421 1154 2558 109 2623 77 OAI21_X1
* cell instance $2151 m0 *1 112.29,46.2
X$2151 2022 1980 2333 77 2556 109 AOI21_X1
* cell instance $2153 m0 *1 113.24,46.2
X$2153 1554 1154 2396 109 2559 77 OAI21_X1
* cell instance $2155 m0 *1 114.19,46.2
X$2155 2169 1476 2333 109 2422 77 OAI21_X1
* cell instance $2156 m0 *1 114.95,46.2
X$2156 1938 2422 2504 2012 77 109 2626 AOI22_X2
* cell instance $2158 m0 *1 116.85,46.2
X$2158 2303 858 1586 2093 77 109 2562 AOI22_X1
* cell instance $2160 r0 *1 102.22,46.2
X$2160 2554 2236 2806 2555 2553 2654 109 77 AOI221_X2
* cell instance $2163 r0 *1 104.88,46.2
X$2163 79 2655 2555 77 109 2743 MUX2_X1
* cell instance $2165 r0 *1 106.4,46.2
X$2165 2291 2655 126 77 109 2887 MUX2_X1
* cell instance $2168 r0 *1 108.3,46.2
X$2168 1307 77 109 2745 INV_X1
* cell instance $2169 r0 *1 108.68,46.2
X$2169 2303 1307 1124 2011 77 109 2888 AOI22_X2
* cell instance $2171 r0 *1 111.15,46.2
X$2171 2556 2557 1388 2099 109 77 2558 OAI22_X1
* cell instance $2172 r0 *1 112.1,46.2
X$2172 2623 2572 2557 2561 2559 2624 109 77 AOI221_X2
* cell instance $2174 r0 *1 114.38,46.2
X$2174 2093 2167 1938 109 2812 77 OAI21_X1
* cell instance $2179 r0 *1 115.33,46.2
X$2179 2563 2167 1098 109 2754 77 OAI21_X1
* cell instance $2181 r0 *1 116.28,46.2
X$2181 2627 2561 2562 77 2752 109 AOI21_X1
* cell instance $2183 r0 *1 117.42,46.2
X$2183 2303 1098 1503 1554 77 109 2755 AOI22_X2
* cell instance $2184 m0 *1 118.75,46.2
X$2184 2564 2563 2423 77 2506 109 AOI21_X1
* cell instance $2185 m0 *1 118.18,46.2
X$2185 2506 2170 77 109 2627 NOR2_X1
* cell instance $2186 m0 *1 119.51,46.2
X$2186 2424 858 2022 77 2564 109 AOI21_X1
* cell instance $2189 m0 *1 121.98,46.2
X$2189 2566 2012 1499 77 109 2425 NAND3_X1
* cell instance $2191 m0 *1 123.5,46.2
X$2191 2563 2513 2568 109 2567 77 OAI21_X1
* cell instance $2192 m0 *1 124.26,46.2
X$2192 2516 2421 2424 109 2568 77 OAI21_X1
* cell instance $2195 m0 *1 126.73,46.2
X$2195 1995 2518 2427 77 2571 109 AOI21_X1
* cell instance $2196 m0 *1 127.49,46.2
X$2196 1694 1651 77 109 2518 NAND2_X1
* cell instance $2197 m0 *1 128.06,46.2
X$2197 2518 2424 77 109 2517 NOR2_X1
* cell instance $2200 r0 *1 119.51,46.2
X$2200 2026 1649 2762 109 2892 77 OAI21_X1
* cell instance $2201 r0 *1 120.27,46.2
X$2201 2209 1098 2012 109 2762 77 OAI21_X1
* cell instance $2204 r0 *1 121.41,46.2
X$2204 2137 2240 2425 2426 2565 109 77 2658 OAI221_X1
* cell instance $2206 r0 *1 122.74,46.2
X$2206 1757 2566 2764 77 2569 109 AOI21_X1
* cell instance $2207 r0 *1 123.5,46.2
X$2207 1585 1344 1938 77 109 2659 NAND3_X1
* cell instance $2209 r0 *1 124.45,46.2
X$2209 2172 1938 1499 77 2766 109 AOI21_X1
* cell instance $2211 r0 *1 126.73,46.2
X$2211 1124 77 109 2570 INV_X1
* cell instance $2212 r0 *1 127.11,46.2
X$2212 2570 2571 2778 1995 1730 2518 77 109 2660 OAI33_X1
* cell instance $2213 r0 *1 128.44,46.2
X$2213 2563 2572 2101 77 2778 109 AOI21_X1
* cell instance $2215 m0 *1 129.01,46.2
X$2215 1477 2426 2026 2101 109 77 2630 OAI22_X1
* cell instance $2217 r0 *1 129.58,46.2
X$2217 2777 1440 2424 1939 2569 109 77 2775 OAI221_X1
* cell instance $2218 m0 *1 130.53,46.2
X$2218 1753 2421 1767 77 2777 109 AOI21_X1
* cell instance $2220 m0 *1 131.29,46.2
X$2220 1651 77 109 2421 CLKBUF_X3
* cell instance $2221 m0 *1 132.24,46.2
X$2221 2022 1340 1767 77 2573 109 AOI21_X1
* cell instance $2222 m0 *1 133,46.2
X$2222 2520 2428 1175 77 109 2522 MUX2_X1
* cell instance $2223 m0 *1 134.33,46.2
X$2223 77 2629 2520 2522 2343 109 DFF_X1
* cell instance $2228 r0 *1 131.86,46.2
X$2228 1690 2563 2572 1440 2573 109 77 2901 OAI221_X1
* cell instance $2232 r0 *1 138.32,46.2
X$2232 77 1844 18761 2772 2773 1663 109 DFFR_X1
* cell instance $2234 m0 *1 138.7,46.2
X$2234 2344 2429 2526 77 109 2773 NOR3_X1
* cell instance $2238 m0 *1 142.31,46.2
X$2238 77 1844 18620 2527 2625 1663 109 DFFR_X1
* cell instance $2241 r0 *1 142.31,46.2
X$2241 2772 109 216 77 BUF_X4
* cell instance $2244 m0 *1 146.49,46.2
X$2244 2527 77 109 2175 BUF_X2
* cell instance $2247 m0 *1 147.63,46.2
X$2247 77 2109 18597 2432 2528 1663 109 DFFR_X1
* cell instance $2248 m0 *1 151.62,46.2
X$2248 2432 77 109 2628 INV_X1
* cell instance $2249 m0 *1 152,46.2
X$2249 2434 2433 2179 2628 77 109 2532 NAND4_X1
* cell instance $2250 m0 *1 152.95,46.2
X$2250 2392 2532 2534 2533 2528 77 109 OAI211_X2
* cell instance $2254 r0 *1 149.15,46.2
X$2254 2154 2042 2043 77 109 2770 OR3_X1
* cell instance $2255 r0 *1 150.1,46.2
X$2255 2770 2574 109 77 2768 AND2_X1
* cell instance $2256 r0 *1 150.86,46.2
X$2256 2030 77 109 2765 INV_X1
* cell instance $2259 r0 *1 154.47,46.2
X$2259 2824 1189 1134 1845 77 109 2759 AOI22_X2
* cell instance $2260 m0 *1 155.23,46.2
X$2260 1158 2432 77 109 2534 NAND2_X1
* cell instance $2263 m0 *1 155.99,46.2
X$2263 2175 2575 2435 109 77 2350 AND3_X1
* cell instance $2264 m0 *1 156.94,46.2
X$2264 2175 2575 2249 2432 109 77 2576 AND4_X1
* cell instance $2268 r0 *1 156.75,46.2
X$2268 2575 1189 1134 1849 77 109 2761 AOI22_X2
* cell instance $2269 m0 *1 160.55,46.2
X$2269 2437 2351 2435 109 77 2536 AND3_X1
* cell instance $2270 m0 *1 158.46,46.2
X$2270 1863 1893 2662 2536 2175 2625 109 77 AOI221_X2
* cell instance $2271 m0 *1 161.5,46.2
X$2271 1917 1084 77 109 2352 NOR2_X1
* cell instance $2275 r0 *1 158.84,46.2
X$2275 2175 1776 77 109 2663 OR2_X1
* cell instance $2279 r0 *1 160.93,46.2
X$2279 2576 2435 109 77 2577 AND2_X1
* cell instance $2280 r0 *1 161.69,46.2
X$2280 2664 2042 2763 77 2622 109 AOI21_X1
* cell instance $2281 r0 *1 162.45,46.2
X$2281 1917 2665 77 109 2664 NAND2_X1
* cell instance $2283 m0 *1 164.16,46.2
X$2283 1158 759 77 109 2621 NOR2_X1
* cell instance $2284 m0 *1 163.21,46.2
X$2284 2437 77 109 2179 CLKBUF_X3
* cell instance $2287 m0 *1 165.68,46.2
X$2287 2438 2437 2433 2354 109 77 2579 AND4_X1
* cell instance $2288 m0 *1 166.82,46.2
X$2288 2354 2433 2179 77 109 2753 NAND3_X1
* cell instance $2290 m0 *1 167.77,46.2
X$2290 1863 2438 77 109 2440 NOR2_X1
* cell instance $2292 m0 *1 168.53,46.2
X$2292 2439 109 2252 77 BUF_X4
* cell instance $2295 m0 *1 170.81,46.2
X$2295 2438 1110 1824 980 77 109 2582 AOI22_X1
* cell instance $2298 r0 *1 164.54,46.2
X$2298 2079 1418 77 109 2760 OR2_X1
* cell instance $2300 r0 *1 165.68,46.2
X$2300 1917 554 77 109 2757 NOR2_X1
* cell instance $2301 r0 *1 166.25,46.2
X$2301 2579 2757 2440 2753 2758 109 77 AOI211_X2
* cell instance $2302 r0 *1 167.96,46.2
X$2302 77 2115 18797 2751 2758 1146 109 DFFR_X1
* cell instance $2306 r0 *1 171.76,46.2
X$2306 2751 77 109 2438 BUF_X1
* cell instance $2307 r0 *1 172.33,46.2
X$2307 2441 2436 77 109 2584 OR2_X1
* cell instance $2309 m0 *1 172.9,46.2
X$2309 2176 2441 77 109 2442 NOR2_X1
* cell instance $2310 r0 *1 173.09,46.2
X$2310 2389 2581 1241 2184 2737 2750 77 109 OAI221_X2
* cell instance $2312 m0 *1 173.85,46.2
X$2312 2441 109 2114 77 BUF_X4
* cell instance $2315 m0 *1 175.56,46.2
X$2315 1277 2443 77 109 2580 NOR2_X1
* cell instance $2317 r0 *1 176.13,46.2
X$2317 77 2619 2442 2669 2749 109 NOR3_X4
* cell instance $2319 m0 *1 176.51,46.2
X$2319 2146 2114 509 2184 2508 2620 77 109 OAI221_X2
* cell instance $2320 m0 *1 178.79,46.2
X$2320 2443 109 2184 77 BUF_X4
* cell instance $2321 m0 *1 180.12,46.2
X$2321 1320 2184 77 109 2619 NOR2_X1
* cell instance $2322 m0 *1 180.69,46.2
X$2322 2443 109 2177 77 BUF_X4
* cell instance $2323 m0 *1 182.02,46.2
X$2323 506 2177 77 109 2835 NOR2_X2
* cell instance $2324 m0 *1 182.97,46.2
X$2324 2252 77 109 2445 BUF_X2
* cell instance $2326 r0 *1 178.79,46.2
X$2326 1732 2581 77 109 2741 NOR2_X1
* cell instance $2327 r0 *1 179.36,46.2
X$2327 871 2184 77 109 2833 NOR2_X2
* cell instance $2328 r0 *1 180.31,46.2
X$2328 2582 2581 77 109 2834 NOR2_X1
* cell instance $2330 r0 *1 181.26,46.2
X$2330 77 2298 2741 2599 2740 109 NOR3_X4
* cell instance $2331 r0 *1 183.92,46.2
X$2331 420 2177 77 109 2836 NOR2_X1
* cell instance $2332 m0 *1 185.06,46.2
X$2332 77 1731 18606 2514 2515 1146 109 DFFR_X1
* cell instance $2333 m0 *1 184.11,46.2
X$2333 691 2177 77 109 2618 NOR2_X2
* cell instance $2337 m0 *1 192.85,46.2
X$2337 2181 2728 2510 109 2446 77 OAI21_X1
* cell instance $2339 m0 *1 195.13,46.2
X$2339 77 2447 18608 2673 2617 1146 109 DFFR_X1
* cell instance $2340 m0 *1 198.93,46.2
X$2340 77 2120 18605 2587 2613 1146 109 DFFR_X1
* cell instance $2341 m0 *1 202.73,46.2
X$2341 77 2120 18604 2376 2359 1146 109 DFFR_X1
* cell instance $2342 m0 *1 206.53,46.2
X$2342 77 2360 18592 2676 2448 1146 109 DFFR_X1
* cell instance $2347 r0 *1 185.06,46.2
X$2347 2616 2618 2739 77 109 NOR2_X4
* cell instance $2348 r0 *1 186.77,46.2
X$2348 1311 2185 2583 77 109 2914 MUX2_X1
* cell instance $2351 r0 *1 189.05,46.2
X$2351 77 1731 18718 2671 2735 1146 109 DFFR_X1
* cell instance $2352 r0 *1 192.85,46.2
X$2352 2671 2598 2357 2593 77 109 2734 AOI22_X1
* cell instance $2353 r0 *1 193.8,46.2
X$2353 1658 2728 2731 109 2672 77 OAI21_X1
* cell instance $2354 r0 *1 194.56,46.2
X$2354 2672 2585 2673 77 109 2617 MUX2_X1
* cell instance $2358 r0 *1 198.36,46.2
X$2358 2727 2586 2587 77 109 2613 MUX2_X1
* cell instance $2359 r0 *1 199.69,46.2
X$2359 2586 109 2588 77 BUF_X4
* cell instance $2361 r0 *1 202.54,46.2
X$2361 3135 2723 2610 77 109 2669 NAND3_X2
* cell instance $2362 r0 *1 203.87,46.2
X$2362 2120 77 109 19309 CLKBUF_X1
* cell instance $2366 r0 *1 205.77,46.2
X$2366 2446 2585 2676 77 109 2448 MUX2_X1
* cell instance $2367 r0 *1 207.1,46.2
X$2367 2673 2598 2259 2276 77 109 2675 AOI22_X1
* cell instance $2368 r0 *1 208.05,46.2
X$2368 2588 2720 2609 109 2714 77 OAI21_X1
* cell instance $2369 r0 *1 208.81,46.2
X$2369 77 2360 18821 2589 2714 1146 109 DFFR_X1
* cell instance $2370 m0 *1 213.56,46.2
X$2370 77 1961 18520 2590 2503 992 109 DFFR_X1
* cell instance $2371 m0 *1 212.23,46.2
X$2371 554 2258 2590 77 109 2503 MUX2_X1
* cell instance $2373 r0 *1 212.61,46.2
X$2373 2588 2589 77 109 2609 NAND2_X1
* cell instance $2375 r0 *1 213.56,46.2
X$2375 2589 2261 2276 2590 77 109 2884 AOI22_X2
* cell instance $2377 m0 *1 217.93,46.2
X$2377 77 1961 18522 2361 2449 992 109 DFFR_X1
* cell instance $2379 m0 *1 221.73,46.2
X$2379 685 2258 2450 77 109 2362 MUX2_X1
* cell instance $2381 m0 *1 223.25,46.2
X$2381 77 2051 18523 2592 2495 992 109 DFFR_X1
* cell instance $2382 m0 *1 227.05,46.2
X$2382 2604 1785 2591 77 109 2451 NAND3_X1
* cell instance $2384 m0 *1 228,46.2
X$2384 2491 2280 77 109 2487 NAND2_X1
* cell instance $2386 m0 *1 229.33,46.2
X$2386 77 2276 1787 2480 2592 2261 2452 2453 109 AOI222_X2
* cell instance $2389 r0 *1 218.31,46.2
X$2389 2709 109 1542 77 BUF_X4
* cell instance $2393 r0 *1 220.97,46.2
X$2393 77 2703 2705 2679 1795 2251 109 NAND4_X4
* cell instance $2394 r0 *1 224.39,46.2
X$2394 2701 2605 2592 77 109 2495 MUX2_X1
* cell instance $2401 r0 *1 228.19,46.2
X$2401 2696 2699 2588 77 2680 109 AOI21_X1
* cell instance $2402 r0 *1 228.95,46.2
X$2402 2682 77 109 2699 INV_X1
* cell instance $2404 r0 *1 230.09,46.2
X$2404 2695 2681 1629 2191 77 109 2693 AOI22_X2
* cell instance $2405 r0 *1 231.8,46.2
X$2405 77 2597 2692 2693 2369 2599 109 NAND4_X4
* cell instance $2406 m0 *1 235.79,46.2
X$2406 77 1873 18489 2454 2462 992 109 DFFR_X1
* cell instance $2407 m0 *1 233.13,46.2
X$2407 77 2593 1791 2468 2684 2598 2365 2453 109 AOI222_X2
* cell instance $2409 r0 *1 235.22,46.2
X$2409 2685 77 109 2368 BUF_X1
* cell instance $2410 r0 *1 235.79,46.2
X$2410 77 2593 2454 2597 2682 2598 2853 2453 109 AOI222_X2
* cell instance $2412 r0 *1 238.83,46.2
X$2412 2595 77 109 2689 BUF_X2
* cell instance $2414 m0 *1 152.95,197.4
X$2414 16108 16213 16110 109 16315 77 OAI21_X1
* cell instance $2415 m0 *1 152.38,197.4
X$2415 16315 15082 77 109 16410 NAND2_X1
* cell instance $2416 m0 *1 153.71,197.4
X$2416 13286 16213 16110 109 16316 77 OAI21_X1
* cell instance $2418 m0 *1 154.66,197.4
X$2418 16213 77 109 16214 CLKBUF_X3
* cell instance $2420 m0 *1 156.37,197.4
X$2420 13352 16214 16110 109 16406 77 OAI21_X1
* cell instance $2421 m0 *1 157.13,197.4
X$2421 15745 16320 16215 77 16317 109 AOI21_X2
* cell instance $2422 m0 *1 158.46,197.4
X$2422 15745 16318 16215 77 16402 109 AOI21_X1
* cell instance $2423 m0 *1 159.22,197.4
X$2423 16107 16114 77 109 16320 NAND2_X1
* cell instance $2425 m0 *1 159.98,197.4
X$2425 16110 77 109 16215 CLKBUF_X3
* cell instance $2428 m0 *1 162.64,197.4
X$2428 13119 16214 16215 109 16323 77 OAI21_X1
* cell instance $2430 m0 *1 163.59,197.4
X$2430 15487 109 16543 77 BUF_X4
* cell instance $2432 m0 *1 165.11,197.4
X$2432 15978 15299 77 109 16399 NAND2_X1
* cell instance $2433 m0 *1 165.68,197.4
X$2433 15745 16324 16215 77 16487 109 AOI21_X2
* cell instance $2436 m0 *1 147.25,197.4
X$2436 77 15749 18648 16314 16106 12731 109 DFFR_X1
* cell instance $2438 r0 *1 147.44,197.4
X$2438 16111 16316 109 77 16491 AND2_X1
* cell instance $2439 r0 *1 148.2,197.4
X$2439 16111 16408 109 77 16439 AND2_X1
* cell instance $2441 r0 *1 150.48,197.4
X$2441 16532 16410 109 77 16347 XNOR2_X1
* cell instance $2443 m0 *1 151.43,197.4
X$2443 16314 77 109 15881 BUF_X1
* cell instance $2444 r0 *1 151.62,197.4
X$2444 16347 16490 109 77 16008 XNOR2_X1
* cell instance $2448 r0 *1 154.09,197.4
X$2448 16111 16406 109 77 16441 AND2_X1
* cell instance $2449 r0 *1 154.85,197.4
X$2449 16348 16349 16443 109 77 16629 OAI21_X4
* cell instance $2450 r0 *1 157.32,197.4
X$2450 16403 16405 16535 77 109 16634 AND3_X4
* cell instance $2451 r0 *1 159.41,197.4
X$2451 15488 16348 16351 77 109 16636 NAND3_X1
* cell instance $2454 r0 *1 160.74,197.4
X$2454 16111 16323 109 77 16540 AND2_X1
* cell instance $2455 r0 *1 161.5,197.4
X$2455 16445 14852 16400 77 16113 109 NAND3_X4
* cell instance $2457 r0 *1 164.73,197.4
X$2457 15299 16352 16399 109 15196 77 OAI21_X1
* cell instance $2458 r0 *1 165.49,197.4
X$2458 16111 16396 109 77 16447 AND2_X1
* cell instance $2460 r0 *1 166.44,197.4
X$2460 15300 15295 109 77 16486 AND2_X1
* cell instance $2463 m0 *1 167.39,197.4
X$2463 12811 16214 16215 109 16396 77 OAI21_X1
* cell instance $2464 m0 *1 168.34,197.4
X$2464 15745 16217 16215 77 16218 109 AOI21_X1
* cell instance $2466 m0 *1 169.29,197.4
X$2466 15745 16219 16215 77 16319 109 AOI21_X2
* cell instance $2468 m0 *1 170.81,197.4
X$2468 15745 16115 16215 77 16393 109 AOI21_X1
* cell instance $2469 m0 *1 171.57,197.4
X$2469 12989 16214 16215 109 16394 77 OAI21_X1
* cell instance $2470 m0 *1 172.33,197.4
X$2470 12815 16214 16215 109 16221 77 OAI21_X1
* cell instance $2475 r0 *1 170.81,197.4
X$2475 16548 15488 77 109 15973 NAND2_X1
* cell instance $2480 r0 *1 171.57,197.4
X$2480 16111 16394 109 77 16836 AND2_X1
* cell instance $2482 r0 *1 172.52,197.4
X$2482 16111 16221 109 77 16484 AND2_X1
* cell instance $2484 r0 *1 173.47,197.4
X$2484 16485 16552 109 16014 77 XOR2_X2
* cell instance $2485 m0 *1 174.42,197.4
X$2485 15386 77 109 15300 CLKBUF_X3
* cell instance $2489 r0 *1 175.18,197.4
X$2489 16392 16551 16391 77 109 16452 OR3_X1
* cell instance $2490 r0 *1 176.13,197.4
X$2490 16392 16390 77 16615 109 OR2_X4
* cell instance $2491 m0 *1 177.84,197.4
X$2491 16300 77 109 16299 INV_X1
* cell instance $2492 m0 *1 176.51,197.4
X$2492 15490 109 16119 77 BUF_X4
* cell instance $2493 m0 *1 178.22,197.4
X$2493 15300 77 109 15299 CLKBUF_X3
* cell instance $2494 m0 *1 179.17,197.4
X$2494 16388 77 109 16293 INV_X1
* cell instance $2495 m0 *1 179.55,197.4
X$2495 15085 109 16126 77 BUF_X4
* cell instance $2497 m0 *1 181.07,197.4
X$2497 16222 16293 77 109 15428 XNOR2_X2
* cell instance $2498 m0 *1 182.97,197.4
X$2498 12811 15758 16042 109 16120 77 OAI21_X1
* cell instance $2499 m0 *1 183.73,197.4
X$2499 16288 16355 109 15532 77 XOR2_X2
* cell instance $2500 m0 *1 185.44,197.4
X$2500 15758 15422 77 109 16121 NOR2_X1
* cell instance $2501 m0 *1 186.01,197.4
X$2501 15707 77 109 16224 INV_X2
* cell instance $2503 m0 *1 186.77,197.4
X$2503 15707 109 16287 77 BUF_X4
* cell instance $2504 m0 *1 188.1,197.4
X$2504 16225 15887 77 109 16226 NAND2_X1
* cell instance $2506 r0 *1 177.84,197.4
X$2506 15490 77 109 16482 INV_X2
* cell instance $2507 r0 *1 178.41,197.4
X$2507 16390 15300 77 109 16453 NOR2_X1
* cell instance $2508 r0 *1 178.98,197.4
X$2508 16453 16481 77 109 15202 NAND2_X1
* cell instance $2509 r0 *1 179.55,197.4
X$2509 15085 77 109 16353 INV_X2
* cell instance $2510 r0 *1 180.12,197.4
X$2510 16386 16354 15299 109 15494 77 NOR3_X2
* cell instance $2511 r0 *1 181.45,197.4
X$2511 16455 16358 109 16354 77 AND2_X4
* cell instance $2512 r0 *1 183.16,197.4
X$2512 16355 16354 16357 109 77 16223 OAI21_X4
* cell instance $2513 r0 *1 185.63,197.4
X$2513 16356 16355 16384 77 16387 109 AOI21_X1
* cell instance $2514 r0 *1 186.39,197.4
X$2514 16455 16358 77 109 16386 NOR2_X1
* cell instance $2515 r0 *1 186.96,197.4
X$2515 16357 16358 77 109 16454 NOR2_X1
* cell instance $2517 r0 *1 187.72,197.4
X$2517 16359 16479 77 109 16227 NAND2_X1
* cell instance $2518 r0 *1 188.29,197.4
X$2518 16454 77 109 16384 INV_X1
* cell instance $2519 r0 *1 188.67,197.4
X$2519 16356 77 109 16286 INV_X1
* cell instance $2521 m0 *1 189.62,197.4
X$2521 77 16360 109 15762 BUF_X8
* cell instance $2522 m0 *1 189.05,197.4
X$2522 16260 16122 77 109 15888 NAND2_X1
* cell instance $2523 m0 *1 192.09,197.4
X$2523 77 16272 16278 16266 16277 16270 109 FA_X1
* cell instance $2524 m0 *1 195.13,197.4
X$2524 16224 16125 77 109 16272 NOR2_X1
* cell instance $2525 m0 *1 195.7,197.4
X$2525 77 15796 16602 16265 16269 16267 109 FA_X1
* cell instance $2527 m0 *1 198.93,197.4
X$2527 77 16265 16252 16022 16264 16129 109 FA_X1
* cell instance $2528 m0 *1 201.97,197.4
X$2528 16123 16229 77 109 16372 NOR2_X1
* cell instance $2529 m0 *1 202.54,197.4
X$2529 16462 77 109 16246 INV_X1
* cell instance $2530 m0 *1 202.92,197.4
X$2530 16224 16229 77 109 16021 NOR2_X1
* cell instance $2534 r0 *1 190.38,197.4
X$2534 77 16380 109 15837 BUF_X8
* cell instance $2535 r0 *1 192.85,197.4
X$2535 15762 109 15887 77 BUF_X4
* cell instance $2536 r0 *1 194.18,197.4
X$2536 16051 16360 77 109 16381 NAND2_X1
* cell instance $2539 r0 *1 195.89,197.4
X$2539 16477 77 109 16460 INV_X1
* cell instance $2542 r0 *1 196.84,197.4
X$2542 16543 16360 77 109 16267 NAND2_X1
* cell instance $2544 r0 *1 198.93,197.4
X$2544 16353 16229 77 109 16461 NOR2_X1
* cell instance $2546 r0 *1 200.26,197.4
X$2546 16353 16125 77 109 16374 NOR2_X1
* cell instance $2547 r0 *1 200.83,197.4
X$2547 77 16374 16128 16371 16372 16475 109 FA_X1
* cell instance $2549 m0 *1 204.06,197.4
X$2549 16592 77 109 16258 INV_X1
* cell instance $2552 m0 *1 204.63,197.4
X$2552 16258 15690 77 109 16257 NOR2_X1
* cell instance $2553 m0 *1 205.2,197.4
X$2553 16253 16257 16251 109 77 16362 HA_X1
* cell instance $2556 r0 *1 207.1,197.4
X$2556 16361 77 109 16586 INV_X1
* cell instance $2558 m0 *1 207.67,197.4
X$2558 16252 77 109 16250 INV_X1
* cell instance $2561 m0 *1 208.81,197.4
X$2561 16246 16250 16248 109 77 16232 HA_X1
* cell instance $2563 m0 *1 210.9,197.4
X$2563 16248 77 109 16023 INV_X1
* cell instance $2564 m0 *1 211.28,197.4
X$2564 16232 77 109 16233 INV_X1
* cell instance $2569 r0 *1 209.38,197.4
X$2569 77 16233 16369 16370 16472 16464 109 FA_X1
* cell instance $2572 r0 *1 214.32,197.4
X$2572 16370 77 109 16578 INV_X1
* cell instance $2573 r0 *1 214.7,197.4
X$2573 77 16369 16365 16135 16368 16465 109 FA_X1
* cell instance $2574 m0 *1 216.03,197.4
X$2574 16234 77 109 16368 INV_X1
* cell instance $2579 m0 *1 217.55,197.4
X$2579 16365 77 109 16241 INV_X1
* cell instance $2580 m0 *1 218.69,197.4
X$2580 16235 16241 15894 109 77 16236 HA_X1
* cell instance $2587 r0 *1 219.26,197.4
X$2587 16787 77 109 16235 INV_X1
* cell instance $2588 r0 *1 219.64,197.4
X$2588 16364 16468 109 15978 77 XOR2_X2
* cell instance $2590 r0 *1 221.54,197.4
X$2590 16363 16236 77 109 16569 NOR2_X1
* cell instance $2600 m0 *1 84.17,65.8
X$2600 2417 4318 4435 109 4511 77 OAI21_X1
* cell instance $2603 m0 *1 85.12,65.8
X$2603 4318 4436 77 109 4435 NAND2_X1
* cell instance $2607 m0 *1 88.16,65.8
X$2607 4512 2090 4330 77 109 4513 MUX2_X1
* cell instance $2608 m0 *1 89.49,65.8
X$2608 4652 2090 4331 77 109 4437 MUX2_X1
* cell instance $2611 r0 *1 83.98,65.8
X$2611 77 3908 4739 4436 4511 1663 109 DFFR_X1
* cell instance $2613 r0 *1 88.16,65.8
X$2613 77 4216 18746 4330 4513 1663 109 DFFR_X1
* cell instance $2616 m0 *1 91.96,65.8
X$2616 77 4216 18578 4516 4514 1663 109 DFFR_X1
* cell instance $2617 r0 *1 92.34,65.8
X$2617 4515 2552 4516 77 109 4514 MUX2_X1
* cell instance $2619 r0 *1 94.43,65.8
X$2619 4790 2553 4330 2554 77 109 4742 AOI22_X1
* cell instance $2621 r0 *1 95.76,65.8
X$2621 4516 2553 4331 2554 77 109 4655 AOI22_X1
* cell instance $2622 m0 *1 96.33,65.8
X$2622 4219 3627 4333 77 109 4440 MUX2_X1
* cell instance $2626 r0 *1 97.47,65.8
X$2626 4515 2952 2656 77 109 4654 NAND3_X1
* cell instance $2627 m0 *1 98.23,65.8
X$2627 4333 2649 77 109 4334 NOR2_X1
* cell instance $2630 r0 *1 98.23,65.8
X$2630 4653 2647 77 109 4656 NAND2_X1
* cell instance $2632 m0 *1 99.94,65.8
X$2632 4335 3302 4604 77 109 4445 MUX2_X1
* cell instance $2633 m0 *1 99.18,65.8
X$2633 4334 3387 4221 77 4604 109 AOI21_X1
* cell instance $2634 m0 *1 101.27,65.8
X$2634 4081 4334 4446 77 109 4517 OR3_X1
* cell instance $2636 m0 *1 103.74,65.8
X$2636 2656 2649 4005 109 77 4448 AND3_X1
* cell instance $2637 m0 *1 104.69,65.8
X$2637 4338 4448 3060 109 4339 77 OAI21_X1
* cell instance $2641 r0 *1 101.27,65.8
X$2641 3136 4336 4517 109 4743 77 OAI21_X1
* cell instance $2644 r0 *1 102.6,65.8
X$2644 4337 3628 2554 77 109 NOR2_X4
* cell instance $2645 r0 *1 104.31,65.8
X$2645 4518 77 109 4337 INV_X1
* cell instance $2646 r0 *1 104.69,65.8
X$2646 4005 4518 3907 77 109 4519 MUX2_X1
* cell instance $2647 m0 *1 106.02,65.8
X$2647 4450 4339 4340 4451 77 109 4449 NAND4_X1
* cell instance $2651 r0 *1 106.78,65.8
X$2651 4519 3628 4746 77 109 4520 MUX2_X1
* cell instance $2652 m0 *1 107.54,65.8
X$2652 4341 3915 4520 77 4451 109 NAND3_X4
* cell instance $2655 r0 *1 108.11,65.8
X$2655 4519 3302 4165 77 109 4925 MUX2_X1
* cell instance $2657 r0 *1 109.63,65.8
X$2657 4608 4521 3062 77 109 4522 MUX2_X1
* cell instance $2659 m0 *1 110.39,65.8
X$2659 4343 4521 3389 77 109 4224 MUX2_X1
* cell instance $2661 r0 *1 110.96,65.8
X$2661 77 4225 4609 4086 19001 4341 109 DFFR_X2
* cell instance $2663 m0 *1 112.86,65.8
X$2663 4747 4521 4341 77 109 4609 MUX2_X1
* cell instance $2664 m0 *1 114.76,65.8
X$2664 77 18331 4458 4342 4225 109 DFF_X1
* cell instance $2667 m0 *1 118.18,65.8
X$2667 4458 109 4523 77 BUF_X4
* cell instance $2669 m0 *1 125.59,65.8
X$2669 4614 4462 2968 77 109 4526 MUX2_X1
* cell instance $2674 r0 *1 115.14,65.8
X$2674 4610 77 109 2552 BUF_X2
* cell instance $2675 r0 *1 115.9,65.8
X$2675 3306 4523 77 109 4344 NAND2_X1
* cell instance $2676 r0 *1 116.47,65.8
X$2676 3998 77 109 4225 CLKBUF_X3
* cell instance $2679 r0 *1 118.56,65.8
X$2679 4524 4799 77 109 4610 OR2_X1
* cell instance $2680 r0 *1 119.32,65.8
X$2680 169 4521 4524 77 109 4659 MUX2_X1
* cell instance $2685 r0 *1 124.64,65.8
X$2685 4611 4525 77 109 4343 NOR2_X1
* cell instance $2687 r0 *1 125.59,65.8
X$2687 77 4615 4464 4526 4230 109 DFF_X1
* cell instance $2688 m0 *1 127.49,65.8
X$2688 4464 77 109 4614 BUF_X2
* cell instance $2690 m0 *1 128.25,65.8
X$2690 3816 3634 4614 77 109 4465 NAND3_X2
* cell instance $2691 m0 *1 129.58,65.8
X$2691 4528 109 4347 77 BUF_X4
* cell instance $2692 m0 *1 130.91,65.8
X$2692 4615 3756 3632 109 77 4599 MUX2_X2
* cell instance $2693 m0 *1 132.62,65.8
X$2693 3035 4234 4087 77 4617 109 AOI21_X1
* cell instance $2694 m0 *1 133.38,65.8
X$2694 2430 77 109 4230 CLKBUF_X3
* cell instance $2695 m0 *1 134.33,65.8
X$2695 77 4468 4349 4617 4230 109 DFF_X1
* cell instance $2696 m0 *1 137.56,65.8
X$2696 4349 77 109 4470 BUF_X1
* cell instance $2698 m0 *1 138.32,65.8
X$2698 4468 3632 2907 77 109 4472 MUX2_X1
* cell instance $2699 m0 *1 139.65,65.8
X$2699 77 3818 18570 4476 4618 1146 109 DFFR_X1
* cell instance $2701 m0 *1 143.64,65.8
X$2701 3210 109 4307 77 BUF_X4
* cell instance $2702 m0 *1 144.97,65.8
X$2702 77 3818 18545 4481 4760 1146 109 DFFR_X1
* cell instance $2703 m0 *1 148.77,65.8
X$2703 4352 2395 77 109 4353 NOR2_X1
* cell instance $2704 m0 *1 149.34,65.8
X$2704 4481 77 109 4533 CLKBUF_X3
* cell instance $2705 m0 *1 150.29,65.8
X$2705 4358 4354 4237 77 109 NOR2_X4
* cell instance $2706 m0 *1 152,65.8
X$2706 4483 4354 4358 109 77 4239 OAI21_X2
* cell instance $2707 m0 *1 153.33,65.8
X$2707 4814 4355 77 109 4486 NOR2_X1
* cell instance $2708 m0 *1 153.9,65.8
X$2708 77 4356 4057 4304 4480 3658 109 NAND4_X4
* cell instance $2709 m0 *1 157.32,65.8
X$2709 4356 4357 4298 109 4535 77 OAI21_X1
* cell instance $2710 m0 *1 158.08,65.8
X$2710 3648 4358 4354 77 109 4241 NOR3_X1
* cell instance $2711 m0 *1 158.84,65.8
X$2711 3650 4616 77 109 3825 NAND2_X1
* cell instance $2712 m0 *1 159.41,65.8
X$2712 4753 4108 4055 4239 4247 109 77 AOI211_X2
* cell instance $2713 m0 *1 161.12,65.8
X$2713 4539 4044 77 109 4488 NAND2_X1
* cell instance $2714 m0 *1 161.69,65.8
X$2714 4540 4492 77 109 4671 NAND2_X1
* cell instance $2715 m0 *1 162.26,65.8
X$2715 4489 4357 4360 77 4361 109 AOI21_X1
* cell instance $2717 m0 *1 163.21,65.8
X$2717 4361 4244 3930 3656 77 109 4607 NAND4_X1
* cell instance $2719 m0 *1 164.35,65.8
X$2719 4489 4360 77 109 3932 NOR2_X2
* cell instance $2721 m0 *1 165.49,65.8
X$2721 4057 3931 77 109 4105 NAND2_X2
* cell instance $2723 m0 *1 166.63,65.8
X$2723 77 3779 4362 4059 4489 4360 109 OR4_X4
* cell instance $2724 m0 *1 169.1,65.8
X$2724 3829 4607 109 77 4606 AND2_X1
* cell instance $2725 m0 *1 169.86,65.8
X$2725 3937 4295 109 77 4250 AND2_X1
* cell instance $2726 m0 *1 170.62,65.8
X$2726 3926 4106 3937 109 77 4364 AND3_X1
* cell instance $2727 m0 *1 171.57,65.8
X$2727 3519 3926 4106 109 77 4544 AND3_X1
* cell instance $2729 m0 *1 172.71,65.8
X$2729 3648 3646 77 109 4252 NAND2_X2
* cell instance $2730 m0 *1 173.66,65.8
X$2730 77 3658 4163 4466 2983 109 NOR3_X4
* cell instance $2732 m0 *1 176.51,65.8
X$2732 4051 4105 4163 77 109 4603 OR3_X1
* cell instance $2735 r0 *1 128.82,65.8
X$2735 4806 4752 4662 77 109 4661 NOR3_X1
* cell instance $2736 r0 *1 129.58,65.8
X$2736 4088 4090 3918 109 4527 77 NOR3_X2
* cell instance $2737 r0 *1 130.91,65.8
X$2737 77 4465 4234 4528 4233 5068 109 NOR4_X4
* cell instance $2739 r0 *1 134.71,65.8
X$2739 4347 4348 4662 77 109 5073 NAND3_X2
* cell instance $2740 r0 *1 136.04,65.8
X$2740 77 4091 109 4349 BUF_X8
* cell instance $2741 r0 *1 138.51,65.8
X$2741 77 4090 4525 4529 169 109 NOR3_X4
* cell instance $2742 r0 *1 141.17,65.8
X$2742 77 4530 4664 4755 4663 4185 109 NAND4_X4
* cell instance $2743 r0 *1 144.59,65.8
X$2743 4756 4530 4757 77 109 4618 NAND3_X1
* cell instance $2744 r0 *1 145.35,65.8
X$2744 4476 109 4097 77 BUF_X4
* cell instance $2745 r0 *1 146.68,65.8
X$2745 4665 4531 4352 77 4759 109 AOI21_X1
* cell instance $2746 r0 *1 147.44,65.8
X$2746 4622 4525 77 109 4763 NAND2_X1
* cell instance $2747 r0 *1 148.01,65.8
X$2747 4478 4351 109 77 4624 AND2_X1
* cell instance $2748 r0 *1 148.77,65.8
X$2748 4666 4532 4485 77 109 4764 NOR3_X1
* cell instance $2749 r0 *1 149.53,65.8
X$2749 4531 4533 4667 77 109 4666 NAND3_X1
* cell instance $2750 r0 *1 150.29,65.8
X$2750 4666 4352 4667 4533 109 77 4668 OAI22_X1
* cell instance $2751 r0 *1 151.24,65.8
X$2751 4621 4619 77 109 4761 NOR2_X1
* cell instance $2752 r0 *1 151.81,65.8
X$2752 4531 4534 4533 77 109 4669 NAND3_X1
* cell instance $2753 r0 *1 152.57,65.8
X$2753 4097 77 109 4667 INV_X4
* cell instance $2754 r0 *1 153.52,65.8
X$2754 3352 4477 77 109 4762 NAND2_X1
* cell instance $2756 r0 *1 154.28,65.8
X$2756 77 3925 4758 4529 4057 109 NOR3_X4
* cell instance $2757 r0 *1 156.94,65.8
X$2757 163 4537 109 77 4532 AND2_X1
* cell instance $2758 r0 *1 157.7,65.8
X$2758 4535 4536 4044 109 4188 77 OAI21_X1
* cell instance $2759 r0 *1 158.46,65.8
X$2759 3650 4357 4358 4354 77 109 4536 NOR4_X1
* cell instance $2760 r0 *1 159.41,65.8
X$2760 4537 163 77 109 4352 NAND2_X1
* cell instance $2762 r0 *1 160.17,65.8
X$2762 4754 4538 77 109 4670 NOR2_X1
* cell instance $2764 r0 *1 161.12,65.8
X$2764 3824 3519 4541 109 4242 77 OAI21_X1
* cell instance $2765 r0 *1 161.88,65.8
X$2765 4612 4055 77 109 4542 NAND2_X1
* cell instance $2766 r0 *1 162.45,65.8
X$2766 77 4054 4363 4297 3930 109 NOR3_X4
* cell instance $2767 r0 *1 165.11,65.8
X$2767 3589 4298 4054 77 109 4674 NOR3_X1
* cell instance $2769 r0 *1 166.06,65.8
X$2769 4297 3925 4108 77 4543 109 AOI21_X1
* cell instance $2770 r0 *1 166.82,65.8
X$2770 4363 4106 4543 109 77 4675 AND3_X1
* cell instance $2771 r0 *1 167.77,65.8
X$2771 4543 3881 4363 77 109 4744 NAND3_X1
* cell instance $2772 r0 *1 168.53,65.8
X$2772 4820 4674 4051 3646 3829 77 109 OAI211_X2
* cell instance $2773 r0 *1 170.24,65.8
X$2773 4605 4606 2591 4741 77 3780 109 NAND4_X2
* cell instance $2777 r0 *1 171.95,65.8
X$2777 4544 3831 4815 77 109 4560 NAND3_X2
* cell instance $2778 r0 *1 173.28,65.8
X$2778 3646 4740 3647 3656 3761 77 109 OAI211_X2
* cell instance $2780 r0 *1 175.37,65.8
X$2780 4941 163 4545 109 4478 77 NOR3_X2
* cell instance $2783 m0 *1 178.79,65.8
X$2783 4365 3658 77 109 4426 NOR2_X2
* cell instance $2786 r0 *1 178.98,65.8
X$2786 4603 77 109 4553 CLKBUF_X3
* cell instance $2787 r0 *1 179.93,65.8
X$2787 4602 4573 4042 77 109 4821 MUX2_X1
* cell instance $2788 m0 *1 180.31,65.8
X$2788 3404 77 109 19255 CLKBUF_X1
* cell instance $2791 m0 *1 182.02,65.8
X$2791 4601 77 109 4461 INV_X1
* cell instance $2792 m0 *1 181.26,65.8
X$2792 4367 4461 4369 109 4366 77 OAI21_X1
* cell instance $2794 m0 *1 182.59,65.8
X$2794 4368 4367 4369 109 4459 77 OAI21_X1
* cell instance $2796 m0 *1 183.54,65.8
X$2796 4370 4547 77 109 4369 NAND2_X1
* cell instance $2797 m0 *1 184.11,65.8
X$2797 3406 4598 4547 4370 77 109 4455 AOI22_X1
* cell instance $2798 m0 *1 185.06,65.8
X$2798 4600 4455 4372 109 4452 77 OAI21_X1
* cell instance $2799 m0 *1 185.82,65.8
X$2799 4447 4374 4373 77 4454 109 AOI21_X1
* cell instance $2800 m0 *1 186.58,65.8
X$2800 77 4452 1146 4374 3147 109 DFFS_X2
* cell instance $2801 m0 *1 190.57,65.8
X$2801 4374 4552 4375 77 109 4444 MUX2_X1
* cell instance $2802 m0 *1 191.9,65.8
X$2802 3348 77 109 19088 INV_X4
* cell instance $2804 m0 *1 194.37,65.8
X$2804 77 4376 18615 4377 4439 1146 109 DFFR_X1
* cell instance $2808 r0 *1 181.26,65.8
X$2808 4042 4683 4546 77 109 4677 MUX2_X1
* cell instance $2809 r0 *1 182.59,65.8
X$2809 4602 4678 4546 4548 77 109 4601 AOI22_X1
* cell instance $2810 r0 *1 183.54,65.8
X$2810 4373 4678 4679 77 4371 109 AOI21_X1
* cell instance $2811 r0 *1 184.3,65.8
X$2811 4679 4373 77 109 4547 NOR2_X1
* cell instance $2812 r0 *1 184.87,65.8
X$2812 4374 77 109 4600 INV_X1
* cell instance $2813 r0 *1 185.25,65.8
X$2813 4678 4549 4548 77 4598 109 AOI21_X1
* cell instance $2815 r0 *1 186.39,65.8
X$2815 4373 4736 4018 4678 77 109 4597 AOI22_X1
* cell instance $2816 r0 *1 187.34,65.8
X$2816 4596 4549 4550 77 109 4736 NAND3_X1
* cell instance $2819 r0 *1 190,65.8
X$2819 4375 77 109 4549 INV_X1
* cell instance $2821 r0 *1 190.57,65.8
X$2821 4018 4134 77 109 4734 NOR2_X1
* cell instance $2822 r0 *1 191.14,65.8
X$2822 1236 77 109 3348 CLKBUF_X3
* cell instance $2823 r0 *1 192.09,65.8
X$2823 77 4376 18893 4680 4729 1146 109 DFFR_X1
* cell instance $2824 r0 *1 195.89,65.8
X$2824 4554 4681 4682 109 4439 77 OAI21_X1
* cell instance $2825 r0 *1 196.65,65.8
X$2825 4554 4377 77 109 4682 NAND2_X1
* cell instance $2827 r0 *1 197.6,65.8
X$2827 4377 4683 4830 77 109 4726 MUX2_X1
* cell instance $2829 r0 *1 200.45,65.8
X$2829 4433 4683 4591 77 109 4555 MUX2_X1
* cell instance $2830 r0 *1 201.78,65.8
X$2830 77 4262 18809 4591 4555 992 109 DFFR_X1
* cell instance $2832 m0 *1 202.35,65.8
X$2832 3944 5219 4577 4378 77 4110 109 NAND4_X2
* cell instance $2833 m0 *1 204.63,65.8
X$2833 4433 77 109 4589 INV_X1
* cell instance $2835 m0 *1 205.01,65.8
X$2835 77 4262 18618 4433 4556 992 109 DFFR_X1
* cell instance $2836 m0 *1 208.81,65.8
X$2836 77 4426 4431 3413 4374 3407 1368 2983 109 AOI222_X2
* cell instance $2838 m0 *1 212.99,65.8
X$2838 77 4426 4567 4378 4380 3233 1881 2983 109 AOI222_X2
* cell instance $2839 m0 *1 215.65,65.8
X$2839 77 4381 4865 2591 1646 3138 109 NAND4_X4
* cell instance $2840 m0 *1 219.07,65.8
X$2840 4422 2605 3952 77 109 4267 MUX2_X1
* cell instance $2843 r0 *1 205.58,65.8
X$2843 4590 4724 4589 4554 77 109 4556 AOI22_X1
* cell instance $2844 r0 *1 206.53,65.8
X$2844 4554 4561 77 109 4590 NOR2_X1
* cell instance $2847 r0 *1 208.81,65.8
X$2847 5371 4685 4553 1086 3761 109 77 4012 OAI221_X1
* cell instance $2849 r0 *1 210.14,65.8
X$2849 4688 3092 3670 77 109 4722 MUX2_X1
* cell instance $2853 r0 *1 213.56,65.8
X$2853 4688 2981 4557 4426 77 109 3947 AOI22_X1
* cell instance $2857 r0 *1 215.84,65.8
X$2857 4583 3233 4581 2363 77 109 3091 AOI22_X1
* cell instance $2860 r0 *1 218.69,65.8
X$2860 399 4691 4689 77 109 4690 MUX2_X1
* cell instance $2862 r0 *1 220.4,65.8
X$2862 4550 77 109 4271 INV_X2
* cell instance $2864 r0 *1 221.16,65.8
X$2864 4560 4718 77 109 4559 NOR2_X1
* cell instance $2865 m0 *1 221.73,65.8
X$2865 4861 77 109 4283 INV_X1
* cell instance $2868 m0 *1 222.3,65.8
X$2868 4833 3233 4697 2363 77 109 3238 AOI22_X1
* cell instance $2869 m0 *1 223.25,65.8
X$2869 4269 4382 77 109 4576 NOR2_X2
* cell instance $2870 m0 *1 224.2,65.8
X$2870 4382 77 109 4561 INV_X1
* cell instance $2871 m0 *1 224.58,65.8
X$2871 4134 4271 77 109 3954 NAND2_X2
* cell instance $2872 m0 *1 225.53,65.8
X$2872 4134 77 109 4562 INV_X1
* cell instance $2873 m0 *1 225.91,65.8
X$2873 4550 4562 4121 3545 3956 4383 77 109 OAI221_X2
* cell instance $2874 m0 *1 228,65.8
X$2874 77 4563 18655 4403 4413 3676 109 DFFR_X1
* cell instance $2875 m0 *1 231.8,65.8
X$2875 3233 109 2681 77 BUF_X4
* cell instance $2876 m0 *1 233.13,65.8
X$2876 4570 2605 4394 77 109 4385 MUX2_X1
* cell instance $2877 m0 *1 234.46,65.8
X$2877 77 3677 18613 4394 4385 992 109 DFFR_X1
* cell instance $2878 m0 *1 238.26,65.8
X$2878 3847 77 109 3118 CLKBUF_X2
* cell instance $2879 m0 *1 239.02,65.8
X$2879 4388 77 109 4384 BUF_X1
* cell instance $2882 r0 *1 223.25,65.8
X$2882 4560 4706 77 109 4268 NOR2_X1
* cell instance $2883 r0 *1 223.82,65.8
X$2883 4560 4715 77 109 3548 NOR2_X1
* cell instance $2884 r0 *1 224.39,65.8
X$2884 4561 4383 3982 109 77 4714 OAI21_X2
* cell instance $2885 r0 *1 225.72,65.8
X$2885 4271 4573 4562 4382 109 77 4710 OAI22_X1
* cell instance $2891 r0 *1 227.24,65.8
X$2891 4553 109 4577 77 BUF_X4
* cell instance $2893 r0 *1 228.95,65.8
X$2893 77 4563 4706 4704 4571 992 109 DFFR_X1
* cell instance $2894 r0 *1 232.75,65.8
X$2894 77 3677 4694 4701 4703 992 109 DFFR_X1
* cell instance $2895 r0 *1 236.55,65.8
X$2895 4568 77 109 3104 BUF_X1
* cell instance $2896 r0 *1 237.12,65.8
X$2896 4696 77 109 4567 BUF_X1
* cell instance $2897 r0 *1 237.69,65.8
X$2897 4565 77 109 4431 BUF_X1
* cell instance $2899 r0 *1 238.64,65.8
X$2899 4566 77 109 4134 CLKBUF_X3
* cell instance $2980 r0 *1 1.33,79.8
X$2980 5863 77 109 4652 BUF_X2
* cell instance $2981 r0 *1 2.09,79.8
X$2981 77 4894 5570 5932 5931 2157 109 DFFR_X1
* cell instance $2985 m0 *1 3.42,79.8
X$2985 5932 5726 4767 77 109 5931 MUX2_X1
* cell instance $2989 m0 *1 5.13,79.8
X$2989 5570 5506 5571 77 109 5934 MUX2_X1
* cell instance $2991 m0 *1 9.69,79.8
X$2991 5864 3603 5441 77 109 5935 MUX2_X1
* cell instance $2994 m0 *1 12.73,79.8
X$2994 77 5103 5719 5718 5797 2157 109 DFFR_X1
* cell instance $2995 m0 *1 16.53,79.8
X$2995 5718 2633 4897 77 109 5797 MUX2_X1
* cell instance $2999 r0 *1 5.89,79.8
X$2999 77 4894 5864 5865 5933 2157 109 DFFR_X1
* cell instance $3000 r0 *1 9.69,79.8
X$3000 5865 5726 2540 77 109 5933 MUX2_X1
* cell instance $3002 r0 *1 11.21,79.8
X$3002 5717 3370 5935 77 109 5867 MUX2_X1
* cell instance $3005 r0 *1 16.34,79.8
X$3005 77 5103 5868 6087 5938 2157 109 DFFR_X1
* cell instance $3011 m0 *1 3.8,135.8
X$3011 10837 10198 10425 77 109 11022 MUX2_X1
* cell instance $3014 m0 *1 6.08,135.8
X$3014 10838 9178 10659 77 109 10945 MUX2_X1
* cell instance $3015 m0 *1 7.41,135.8
X$3015 10945 6158 10426 77 109 10946 MUX2_X1
* cell instance $3018 m0 *1 10.45,135.8
X$3018 10752 3594 11024 77 109 10842 MUX2_X1
* cell instance $3022 r0 *1 1.33,135.8
X$3022 77 11262 11192 11101 11189 4909 109 DFFR_X1
* cell instance $3028 r0 *1 6.27,135.8
X$3028 11102 8005 11192 77 109 11103 MUX2_X1
* cell instance $3031 r0 *1 8.17,135.8
X$3031 11104 3599 10946 77 109 11105 MUX2_X1
* cell instance $3034 r0 *1 11.21,135.8
X$3034 77 11028 11108 11194 11106 4909 109 DFFR_X1
* cell instance $3035 m0 *1 13.11,135.8
X$3035 77 11028 11032 11031 11107 4909 109 DFFR_X1
* cell instance $3038 r0 *1 15.01,135.8
X$3038 10752 3784 11031 77 109 11107 MUX2_X1
* cell instance $3039 r0 *1 16.34,135.8
X$3039 11195 4708 10429 77 109 11196 MUX2_X1
* cell instance $3040 m0 *1 17.48,135.8
X$3040 11032 4138 10947 77 109 10948 MUX2_X1
* cell instance $3042 m0 *1 18.81,135.8
X$3042 10948 6158 10846 77 109 11034 MUX2_X1
* cell instance $3043 m0 *1 20.14,135.8
X$3043 10849 5522 10753 77 109 10949 MUX2_X1
* cell instance $3044 m0 *1 21.47,135.8
X$3044 11034 3599 10754 77 109 11199 MUX2_X1
* cell instance $3049 m0 *1 32.87,135.8
X$3049 10852 10952 10676 77 109 10954 MUX2_X1
* cell instance $3052 r0 *1 18.05,135.8
X$3052 11032 5660 10947 77 109 11198 MUX2_X1
* cell instance $3056 r0 *1 20.71,135.8
X$3056 11198 6017 10949 77 109 10950 MUX2_X1
* cell instance $3057 r0 *1 22.04,135.8
X$3057 10950 5818 10755 77 109 11110 MUX2_X1
* cell instance $3059 r0 *1 23.75,135.8
X$3059 11199 6299 11105 77 109 11213 MUX2_X1
* cell instance $3061 r0 *1 25.46,135.8
X$3061 11202 5577 10425 77 109 11203 MUX2_X1
* cell instance $3062 r0 *1 26.79,135.8
X$3062 77 10951 11111 11202 11203 4909 109 DFFR_X1
* cell instance $3065 r0 *1 31.16,135.8
X$3065 11111 10952 11112 77 109 11206 MUX2_X1
* cell instance $3066 r0 *1 32.49,135.8
X$3066 11111 5522 11112 77 109 10953 MUX2_X1
* cell instance $3067 r0 *1 33.82,135.8
X$3067 11206 9895 10954 77 109 11115 MUX2_X1
* cell instance $3068 m0 *1 34.77,135.8
X$3068 10953 6017 10856 77 109 10955 MUX2_X1
* cell instance $3070 m0 *1 36.1,135.8
X$3070 77 10951 18596 10757 11038 4909 109 DFFR_X1
* cell instance $3071 m0 *1 39.9,135.8
X$3071 10957 109 7321 77 BUF_X4
* cell instance $3073 m0 *1 41.99,135.8
X$3073 10958 10763 9834 77 11043 109 AOI21_X1
* cell instance $3074 m0 *1 42.75,135.8
X$3074 9834 10959 77 109 10958 NOR2_X1
* cell instance $3076 m0 *1 44.84,135.8
X$3076 7878 10759 77 109 10758 NAND2_X1
* cell instance $3077 m0 *1 45.41,135.8
X$3077 10133 7059 10278 77 109 10960 MUX2_X1
* cell instance $3079 m0 *1 46.93,135.8
X$3079 9972 7765 10961 109 10861 77 OAI21_X1
* cell instance $3081 m0 *1 47.88,135.8
X$3081 7878 10761 77 109 10961 NAND2_X1
* cell instance $3082 m0 *1 48.45,135.8
X$3082 10136 6083 10964 77 109 10963 MUX2_X1
* cell instance $3083 m0 *1 49.78,135.8
X$3083 10136 10952 10964 77 109 11224 MUX2_X1
* cell instance $3086 r0 *1 35.53,135.8
X$3086 10955 7764 77 109 10956 NAND2_X1
* cell instance $3087 r0 *1 36.1,135.8
X$3087 6694 10956 11114 109 77 11210 AND3_X1
* cell instance $3089 r0 *1 37.24,135.8
X$3089 9570 7876 11115 77 11040 109 AOI21_X1
* cell instance $3090 r0 *1 38,135.8
X$3090 7876 11215 11040 109 11216 77 OAI21_X1
* cell instance $3093 r0 *1 39.71,135.8
X$3093 77 11116 11117 10959 11043 9814 109 DFFR_X1
* cell instance $3094 r0 *1 43.51,135.8
X$3094 6299 109 7597 77 BUF_X4
* cell instance $3096 r0 *1 45.03,135.8
X$3096 10133 9178 10278 77 109 11222 MUX2_X1
* cell instance $3099 r0 *1 47.5,135.8
X$3099 10762 6083 10962 77 109 11119 MUX2_X1
* cell instance $3100 r0 *1 48.83,135.8
X$3100 10762 10952 10962 77 109 10965 MUX2_X1
* cell instance $3101 r0 *1 50.16,135.8
X$3101 10965 5275 11224 77 109 11120 MUX2_X1
* cell instance $3103 m0 *1 51.68,135.8
X$3103 10674 77 109 9974 CLKBUF_X3
* cell instance $3105 m0 *1 52.63,135.8
X$3105 9974 77 109 19155 INV_X1
* cell instance $3108 r0 *1 53.01,135.8
X$3108 11226 9972 8548 77 11378 109 AOI21_X1
* cell instance $3113 m0 *1 3.61,152.6
X$3113 77 12552 12393 12553 12627 4909 109 DFFR_X1
* cell instance $3114 m0 *1 7.41,152.6
X$3114 12553 5167 11979 77 109 12627 MUX2_X1
* cell instance $3118 m0 *1 13.49,152.6
X$3118 12474 2400 11857 77 109 12475 MUX2_X1
* cell instance $3123 r0 *1 2.85,152.6
X$3123 77 12552 12700 12777 12775 4909 109 DFFR_X1
* cell instance $3127 r0 *1 6.65,152.6
X$3127 12699 12153 12700 77 109 12778 MUX2_X1
* cell instance $3129 r0 *1 8.36,152.6
X$3129 12701 12240 12778 77 109 12557 MUX2_X1
* cell instance $3132 r0 *1 10.26,152.6
X$3132 77 12555 12702 12554 12780 9814 109 DFFR_X1
* cell instance $3133 r0 *1 14.06,152.6
X$3133 12554 4768 11979 77 109 12780 MUX2_X1
* cell instance $3135 r0 *1 15.58,152.6
X$3135 12702 12066 12703 77 109 12785 MUX2_X1
* cell instance $3136 m0 *1 18.05,152.6
X$3136 77 12555 12706 12556 12632 9814 109 DFFR_X1
* cell instance $3137 m0 *1 16.72,152.6
X$3137 12243 12240 12478 77 109 12396 MUX2_X1
* cell instance $3139 m0 *1 22.61,152.6
X$3139 12394 3043 12633 77 109 12558 MUX2_X1
* cell instance $3140 m0 *1 23.94,152.6
X$3140 77 12069 12397 12633 12558 9814 109 DFFR_X1
* cell instance $3143 r0 *1 16.91,152.6
X$3143 12702 12189 12703 77 109 12705 MUX2_X1
* cell instance $3144 r0 *1 18.24,152.6
X$3144 12556 4126 11857 77 109 12632 MUX2_X1
* cell instance $3145 r0 *1 19.57,152.6
X$3145 10273 109 12394 77 BUF_X4
* cell instance $3148 r0 *1 21.85,152.6
X$3148 12705 5513 12707 77 109 12790 MUX2_X1
* cell instance $3149 r0 *1 23.18,152.6
X$3149 12853 10065 12790 77 109 12710 MUX2_X1
* cell instance $3151 r0 *1 27.55,152.6
X$3151 6816 109 12709 77 BUF_X4
* cell instance $3155 m0 *1 31.35,152.6
X$3155 12637 5020 11980 77 109 12559 MUX2_X1
* cell instance $3157 m0 *1 32.68,152.6
X$3157 77 11704 12398 12637 12559 9814 109 DFFR_X1
* cell instance $3158 m0 *1 36.48,152.6
X$3158 9570 7876 12249 77 12492 109 AOI21_X1
* cell instance $3159 m0 *1 37.24,152.6
X$3159 12643 109 12640 77 BUF_X4
* cell instance $3160 m0 *1 38.57,152.6
X$3160 12485 7631 12710 9801 12642 12643 77 109 OAI221_X2
* cell instance $3161 m0 *1 40.66,152.6
X$3161 77 11116 12560 12400 12333 9814 109 DFFR_X1
* cell instance $3162 m0 *1 44.46,152.6
X$3162 9824 12796 77 109 12647 NOR2_X1
* cell instance $3164 r0 *1 31.54,152.6
X$3164 77 4784 109 12072 BUF_X8
* cell instance $3166 r0 *1 34.2,152.6
X$3166 77 12072 10966 109 BUF_X16
* cell instance $3167 r0 *1 38.95,152.6
X$3167 77 10957 109 12072 BUF_X8
* cell instance $3168 r0 *1 41.42,152.6
X$3168 9810 12792 12250 109 12178 77 OAI21_X1
* cell instance $3170 r0 *1 42.37,152.6
X$3170 12647 10583 9824 77 12645 109 AOI21_X1
* cell instance $3171 r0 *1 43.13,152.6
X$3171 12793 10952 12858 77 109 12795 MUX2_X1
* cell instance $3172 r0 *1 44.46,152.6
X$3172 5167 109 9824 77 BUF_X4
* cell instance $3173 m0 *1 45.6,152.6
X$3173 12560 12066 12497 77 109 12402 MUX2_X1
* cell instance $3175 m0 *1 46.93,152.6
X$3175 12797 9326 12402 77 109 12498 MUX2_X1
* cell instance $3178 r0 *1 45.79,152.6
X$3178 12795 5275 12401 77 109 12651 MUX2_X1
* cell instance $3181 r0 *1 48.07,152.6
X$3181 77 12860 12562 12561 12711 4086 109 DFFR_X1
* cell instance $3182 m0 *1 50.16,152.6
X$3182 12651 6719 77 109 12403 NAND2_X1
* cell instance $3183 m0 *1 49.4,152.6
X$3183 12652 11448 6975 77 12711 109 AOI21_X1
* cell instance $3184 m0 *1 50.73,152.6
X$3184 6975 12561 77 109 12652 NOR2_X1
* cell instance $3187 m0 *1 52.25,152.6
X$3187 12562 10966 12712 77 109 12655 MUX2_X1
* cell instance $3191 r0 *1 52.44,152.6
X$3191 12562 6627 12712 77 109 12802 MUX2_X1
* cell instance $3193 m0 *1 54.15,152.6
X$3193 12656 8407 12655 77 109 12253 MUX2_X1
* cell instance $3195 m0 *1 55.48,152.6
X$3195 77 12564 12506 11406 12566 6652 109 AOI22_X4
* cell instance $3198 r0 *1 54.15,152.6
X$3198 12563 6091 12802 77 109 12503 MUX2_X1
* cell instance $3199 r0 *1 55.48,152.6
X$3199 12714 6627 12565 77 109 12563 MUX2_X1
* cell instance $3200 r0 *1 56.81,152.6
X$3200 12714 10966 12565 77 109 12656 MUX2_X1
* cell instance $3202 r0 *1 58.33,152.6
X$3202 12567 11448 6524 77 12805 109 AOI21_X1
* cell instance $3207 r0 *1 59.47,152.6
X$3207 6524 12808 77 109 12567 NOR2_X1
* cell instance $3208 m0 *1 60.42,152.6
X$3208 11128 109 6627 77 BUF_X4
* cell instance $3209 m0 *1 59.85,152.6
X$3209 11708 77 109 19223 CLKBUF_X1
* cell instance $3210 m0 *1 61.75,152.6
X$3210 10674 77 109 11708 CLKBUF_X3
* cell instance $3211 m0 *1 62.7,152.6
X$3211 12568 10132 9985 77 12659 109 AOI21_X1
* cell instance $3213 m0 *1 64.98,152.6
X$3213 12406 8349 12569 77 109 12512 MUX2_X1
* cell instance $3214 m0 *1 66.31,152.6
X$3214 12569 10957 12570 77 109 12254 MUX2_X1
* cell instance $3218 m0 *1 70.11,152.6
X$3218 11594 7330 12665 77 109 12664 MUX2_X1
* cell instance $3219 m0 *1 71.44,152.6
X$3219 77 11593 12407 12665 12664 4086 109 DFFR_X1
* cell instance $3222 r0 *1 60.04,152.6
X$3222 77 11708 12569 12715 12659 4086 109 DFFR_X1
* cell instance $3223 r0 *1 63.84,152.6
X$3223 77 11708 12570 12813 12810 4086 109 DFFR_X1
* cell instance $3225 r0 *1 68.4,152.6
X$3225 77 12571 12817 12818 12814 4086 109 DFFR_X1
* cell instance $3227 r0 *1 72.58,152.6
X$3227 77 6091 109 9429 BUF_X8
* cell instance $3229 r0 *1 75.24,152.6
X$3229 77 11593 13039 12821 12820 8687 109 DFFR_X1
* cell instance $3230 m0 *1 78.85,152.6
X$3230 12407 6371 77 109 12670 NAND2_X1
* cell instance $3232 m0 *1 79.42,152.6
X$3232 11594 6888 12573 77 109 12572 MUX2_X1
* cell instance $3233 m0 *1 80.75,152.6
X$3233 6383 12573 12670 109 12256 77 OAI21_X1
* cell instance $3234 m0 *1 81.51,152.6
X$3234 6140 12573 12574 109 12520 77 OAI21_X1
* cell instance $3235 m0 *1 82.27,152.6
X$3235 12407 8984 77 109 12574 NAND2_X1
* cell instance $3238 m0 *1 84.55,152.6
X$3238 8868 109 6236 77 BUF_X4
* cell instance $3239 m0 *1 85.88,152.6
X$3239 12675 6318 12672 109 77 12410 OAI21_X2
* cell instance $3240 m0 *1 87.21,152.6
X$3240 12020 6369 12408 109 77 12575 OAI21_X2
* cell instance $3241 m0 *1 88.54,152.6
X$3241 12531 6983 12095 77 109 12409 MUX2_X1
* cell instance $3242 m0 *1 89.87,152.6
X$3242 6268 11132 77 8191 109 NAND2_X4
* cell instance $3245 m0 *1 92.53,152.6
X$3245 11594 8008 12679 77 109 12677 MUX2_X1
* cell instance $3246 m0 *1 93.86,152.6
X$3246 77 12576 12577 12679 12677 8201 109 DFFR_X1
* cell instance $3249 m0 *1 98.61,152.6
X$3249 12540 7877 12577 77 109 12411 MUX2_X1
* cell instance $3250 m0 *1 99.94,152.6
X$3250 12835 5275 12578 77 109 12257 MUX2_X1
* cell instance $3251 m0 *1 101.27,152.6
X$3251 12683 8367 8249 77 109 12684 NOR3_X1
* cell instance $3252 m0 *1 102.03,152.6
X$3252 12684 12412 77 109 12414 NOR2_X2
* cell instance $3255 r0 *1 79.8,152.6
X$3255 77 11291 18726 12573 12572 8687 109 DFFR_X1
* cell instance $3258 r0 *1 84.74,152.6
X$3258 7167 77 109 12717 BUF_X2
* cell instance $3261 r0 *1 87.4,152.6
X$3261 5479 6318 12716 77 12675 109 AOI21_X1
* cell instance $3263 r0 *1 88.54,152.6
X$3263 11132 12719 77 109 8355 NAND2_X1
* cell instance $3264 r0 *1 89.11,152.6
X$3264 77 6125 109 12719 BUF_X8
* cell instance $3265 r0 *1 91.58,152.6
X$3265 7342 77 109 12719 INV_X2
* cell instance $3266 r0 *1 92.15,152.6
X$3266 77 18431 12987 7605 12828 109 DFF_X1
* cell instance $3268 r0 *1 95.57,152.6
X$3268 12535 10952 12540 77 109 12835 MUX2_X1
* cell instance $3269 r0 *1 96.9,152.6
X$3269 77 7926 109 12831 BUF_X8
* cell instance $3272 r0 *1 100.32,152.6
X$3272 13131 11461 12868 77 109 12829 MUX2_X1
* cell instance $3275 r0 *1 102.22,152.6
X$3275 7087 12579 11881 109 77 12415 OAI21_X2
* cell instance $3277 m0 *1 103.36,152.6
X$3277 12410 12414 12225 12415 109 77 6558 AND4_X2
* cell instance $3278 m0 *1 104.88,152.6
X$3278 77 12261 12540 12839 12580 8201 109 DFFR_X1
* cell instance $3280 m0 *1 109.44,152.6
X$3280 7023 2931 12840 77 109 12581 MUX2_X1
* cell instance $3281 m0 *1 110.77,152.6
X$3281 77 5275 109 10860 BUF_X8
* cell instance $3282 m0 *1 113.24,152.6
X$3282 12693 9631 12095 77 109 12695 MUX2_X1
* cell instance $3283 m0 *1 114.57,152.6
X$3283 12261 77 109 19214 CLKBUF_X1
* cell instance $3285 m0 *1 115.33,152.6
X$3285 77 12261 12582 12693 12695 4086 109 DFFR_X1
* cell instance $3286 m0 *1 119.13,152.6
X$3286 12582 8421 12696 77 109 12544 MUX2_X1
* cell instance $3287 m0 *1 120.46,152.6
X$3287 77 13053 12696 12548 12418 4086 109 DFFR_X1
* cell instance $3289 m0 *1 124.45,152.6
X$3289 77 11895 8000 12697 12728 12268 12266 6564 109 AOI222_X2
* cell instance $3291 m0 *1 127.3,152.6
X$3291 9805 12421 77 109 12698 NOR2_X1
* cell instance $3293 m0 *1 128.06,152.6
X$3293 12550 12421 77 109 12551 NOR2_X1
* cell instance $3295 m0 *1 128.82,152.6
X$3295 77 11895 9902 12583 12099 12689 12266 6869 109 AOI222_X2
* cell instance $3296 m0 *1 131.48,152.6
X$3296 77 11895 12550 12692 12099 8462 12266 12388 109 AOI222_X2
* cell instance $3297 m0 *1 134.14,152.6
X$3297 77 12472 12694 12100 12692 109 AOI21_X4
* cell instance $3299 m0 *1 136.8,152.6
X$3299 11165 8754 9245 12691 77 109 12545 OR4_X1
* cell instance $3300 m0 *1 137.94,152.6
X$3300 9396 9236 9552 12425 77 109 12736 OR4_X1
* cell instance $3301 m0 *1 139.08,152.6
X$3301 9236 77 109 12690 BUF_X1
* cell instance $3302 m0 *1 139.65,152.6
X$3302 11438 77 109 12689 BUF_X1
* cell instance $3303 m0 *1 140.22,152.6
X$3303 11837 12688 12428 12429 12687 12269 109 77 AOI221_X2
* cell instance $3304 m0 *1 142.31,152.6
X$3304 12584 12430 12685 109 77 12687 HA_X1
* cell instance $3305 m0 *1 144.21,152.6
X$3305 12429 12685 77 109 11734 NAND2_X2
* cell instance $3306 m0 *1 145.16,152.6
X$3306 77 5002 109 12585 BUF_X8
* cell instance $3307 m0 *1 147.63,152.6
X$3307 12586 12433 11679 77 109 12584 MUX2_X1
* cell instance $3309 m0 *1 150.48,152.6
X$3309 12587 11908 12681 77 109 12509 MUX2_X1
* cell instance $3312 m0 *1 153.52,152.6
X$3312 12678 9046 12116 109 77 12430 OAI21_X2
* cell instance $3313 m0 *1 154.85,152.6
X$3313 12588 10530 109 77 12745 XNOR2_X1
* cell instance $3316 r0 *1 103.55,152.6
X$3316 12838 6318 5415 77 109 12579 NOR3_X1
* cell instance $3319 r0 *1 105.45,152.6
X$3319 12839 10590 11573 77 109 12580 MUX2_X1
* cell instance $3322 r0 *1 109.06,152.6
X$3322 7023 77 109 12095 BUF_X2
* cell instance $3324 r0 *1 110.2,152.6
X$3324 77 12261 12723 12840 12581 8201 109 DFFR_X1
* cell instance $3325 r0 *1 114,152.6
X$3325 8244 12725 12724 77 109 12263 OR3_X2
* cell instance $3329 r0 *1 115.14,152.6
X$3329 9422 77 109 12841 BUF_X1
* cell instance $3333 r0 *1 117.04,152.6
X$3333 12842 9667 12722 77 109 12727 MUX2_X1
* cell instance $3334 r0 *1 118.37,152.6
X$3334 12582 8345 12696 77 109 12547 MUX2_X1
* cell instance $3335 r0 *1 119.7,152.6
X$3335 8000 77 109 12844 BUF_X1
* cell instance $3341 r0 *1 122.55,152.6
X$3341 11846 109 11892 77 BUF_X4
* cell instance $3345 r0 *1 125.21,152.6
X$3345 77 12875 12420 12729 12728 12101 12266 12236 109 AOI222_X2
* cell instance $3346 r0 *1 127.87,152.6
X$3346 77 12602 12698 12100 12697 109 AOI21_X4
* cell instance $3348 r0 *1 130.72,152.6
X$3348 77 12626 12423 12100 12583 109 AOI21_X4
* cell instance $3351 r0 *1 133.76,152.6
X$3351 7053 11892 77 109 12694 NOR2_X1
* cell instance $3353 r0 *1 135.09,152.6
X$3353 11094 12732 77 109 12843 XNOR2_X2
* cell instance $3354 r0 *1 136.99,152.6
X$3354 77 12880 109 12843 BUF_X8
* cell instance $3355 r0 *1 139.46,152.6
X$3355 12801 12735 9556 12736 109 10997 77 NOR4_X2
* cell instance $3356 r0 *1 141.17,152.6
X$3356 11685 77 109 12388 BUF_X1
* cell instance $3357 r0 *1 141.74,152.6
X$3357 11734 77 109 12688 INV_X1
* cell instance $3358 r0 *1 142.12,152.6
X$3358 12738 12882 77 109 12739 NAND2_X1
* cell instance $3359 r0 *1 142.69,152.6
X$3359 77 11837 12686 11301 12430 12584 109 FA_X1
* cell instance $3361 r0 *1 146.49,152.6
X$3361 12680 12830 12741 109 77 12428 HA_X1
* cell instance $3363 r0 *1 148.58,152.6
X$3363 12588 10622 109 77 12742 XNOR2_X1
* cell instance $3364 r0 *1 149.72,152.6
X$3364 12682 12270 13062 77 109 12747 MUX2_X1
* cell instance $3365 r0 *1 151.05,152.6
X$3365 12588 11246 109 77 12836 XNOR2_X1
* cell instance $3368 r0 *1 153.33,152.6
X$3368 12834 12116 12744 77 12680 109 AOI21_X1
* cell instance $3371 r0 *1 155.04,152.6
X$3371 12745 11908 12833 77 109 12660 MUX2_X1
* cell instance $3372 r0 *1 156.37,152.6
X$3372 10630 12116 12589 109 12830 77 OAI21_X1
* cell instance $3373 r0 *1 157.13,152.6
X$3373 12588 11320 109 77 13013 XNOR2_X1
* cell instance $3374 r0 *1 158.27,152.6
X$3374 12588 10408 109 77 13014 XNOR2_X1
* cell instance $3375 m0 *1 159.6,152.6
X$3375 12113 12116 12676 77 12515 109 AOI21_X2
* cell instance $3378 r0 *1 159.41,152.6
X$3378 12592 77 109 11908 CLKBUF_X3
* cell instance $3379 r0 *1 160.36,152.6
X$3379 12588 11148 109 77 12749 XNOR2_X1
* cell instance $3381 m0 *1 161.31,152.6
X$3381 12588 10177 109 77 12674 XNOR2_X1
* cell instance $3382 r0 *1 161.5,152.6
X$3382 12588 10633 109 77 13009 XNOR2_X1
* cell instance $3383 r0 *1 162.64,152.6
X$3383 12592 77 109 12273 CLKBUF_X3
* cell instance $3384 m0 *1 163.97,152.6
X$3384 4758 12591 12671 109 77 8979 OAI21_X2
* cell instance $3385 m0 *1 162.83,152.6
X$3385 12588 10007 109 77 12825 XNOR2_X1
* cell instance $3388 r0 *1 163.78,152.6
X$3388 12674 12270 12673 77 109 12490 MUX2_X1
* cell instance $3389 r0 *1 165.11,152.6
X$3389 8264 12750 5716 109 12591 77 OAI21_X1
* cell instance $3391 m0 *1 165.68,152.6
X$3391 12592 109 12116 77 BUF_X4
* cell instance $3393 r0 *1 166.06,152.6
X$3393 12751 5472 77 109 12671 NOR2_X1
* cell instance $3395 r0 *1 166.82,152.6
X$3395 12592 77 109 12275 CLKBUF_X3
* cell instance $3396 m0 *1 167.58,152.6
X$3396 12592 77 109 12030 BUF_X2
* cell instance $3401 r0 *1 167.77,152.6
X$3401 12823 12596 12595 77 109 12594 OR3_X1
* cell instance $3403 r0 *1 168.91,152.6
X$3403 12593 12596 12595 77 109 12523 OR3_X1
* cell instance $3404 r0 *1 169.86,152.6
X$3404 12753 12596 12595 77 109 12118 OR3_X1
* cell instance $3406 r0 *1 171,152.6
X$3406 12752 12273 6929 109 77 12758 OAI21_X2
* cell instance $3411 r0 *1 172.52,152.6
X$3411 12819 12596 12595 77 109 12597 OR3_X1
* cell instance $3413 m0 *1 172.52,152.6
X$3413 12030 7369 12597 109 12668 77 OAI21_X1
* cell instance $3416 m0 *1 175.75,152.6
X$3416 12515 12668 12667 109 77 12445 HA_X1
* cell instance $3418 m0 *1 177.84,152.6
X$3418 12667 77 109 12121 BUF_X2
* cell instance $3419 m0 *1 178.6,152.6
X$3419 12666 77 109 11933 CLKBUF_X2
* cell instance $3420 m0 *1 179.36,152.6
X$3420 12275 7368 12812 109 12601 77 OAI21_X1
* cell instance $3424 r0 *1 173.66,152.6
X$3424 12816 12596 12595 77 109 12669 OR3_X1
* cell instance $3426 r0 *1 174.8,152.6
X$3426 12815 12596 12595 77 109 12119 OR3_X1
* cell instance $3428 r0 *1 176.13,152.6
X$3428 12273 7871 12599 109 12807 77 OAI21_X1
* cell instance $3429 r0 *1 176.89,152.6
X$3429 12811 12596 12595 77 109 12599 OR3_X1
* cell instance $3432 r0 *1 178.41,152.6
X$3432 12601 12747 12666 109 77 11760 HA_X1
* cell instance $3436 m0 *1 182.02,152.6
X$3436 12275 7285 12756 109 12662 77 OAI21_X1
* cell instance $3437 m0 *1 183.54,152.6
X$3437 12663 77 109 11769 BUF_X2
* cell instance $3438 m0 *1 184.3,152.6
X$3438 12661 77 109 12281 BUF_X2
* cell instance $3441 r0 *1 182.21,152.6
X$3441 12662 12809 12661 109 77 12451 HA_X1
* cell instance $3444 r0 *1 185.06,152.6
X$3444 11036 77 109 12804 BUF_X1
* cell instance $3445 r0 *1 185.63,152.6
X$3445 12660 12807 12603 109 77 12604 HA_X1
* cell instance $3446 r0 *1 187.53,152.6
X$3446 12604 12603 12451 77 12658 109 AOI21_X1
* cell instance $3447 r0 *1 188.29,152.6
X$3447 12759 12603 77 109 12608 NAND2_X1
* cell instance $3448 m0 *1 188.86,152.6
X$3448 12603 77 109 12448 INV_X1
* cell instance $3449 m0 *1 188.48,152.6
X$3449 12604 77 109 12507 INV_X1
* cell instance $3450 m0 *1 189.24,152.6
X$3450 12448 12449 12507 109 12605 77 OAI21_X1
* cell instance $3452 r0 *1 188.86,152.6
X$3452 8477 77 109 11327 CLKBUF_X3
* cell instance $3453 r0 *1 189.81,152.6
X$3453 12606 12607 77 109 11036 XNOR2_X2
* cell instance $3454 m0 *1 192.47,152.6
X$3454 12448 12453 77 109 12600 XNOR2_X2
* cell instance $3455 m0 *1 190.38,152.6
X$3455 12607 12507 12452 12608 12657 12455 77 109 OAI221_X2
* cell instance $3456 m0 *1 194.37,152.6
X$3456 12289 12335 77 109 12654 XNOR2_X2
* cell instance $3457 m0 *1 196.27,152.6
X$3457 11807 12653 12338 109 12456 77 OAI21_X1
* cell instance $3459 m0 *1 197.79,152.6
X$3459 12286 12289 77 109 12457 NAND2_X1
* cell instance $3460 m0 *1 198.36,152.6
X$3460 12338 12457 12609 109 12650 77 OAI21_X1
* cell instance $3461 m0 *1 199.12,152.6
X$3461 12650 12612 12613 11951 12648 12649 109 77 AOI221_X2
* cell instance $3462 m0 *1 201.21,152.6
X$3462 11949 77 109 12646 BUF_X1
* cell instance $3463 m0 *1 201.78,152.6
X$3463 12293 11769 77 109 12494 NAND2_X1
* cell instance $3465 m0 *1 202.54,152.6
X$3465 12461 12458 12491 12455 12611 109 77 AOI211_X2
* cell instance $3466 m0 *1 204.25,152.6
X$3466 12614 12611 109 77 12130 AND2_X1
* cell instance $3467 m0 *1 205.01,152.6
X$3467 11951 12613 12459 109 12644 77 OAI21_X1
* cell instance $3469 m0 *1 205.96,152.6
X$3469 12614 12615 12644 109 77 12460 AND3_X1
* cell instance $3470 m0 *1 206.91,152.6
X$3470 12488 77 109 12614 INV_X1
* cell instance $3471 m0 *1 207.29,152.6
X$3471 12613 77 109 12641 INV_X1
* cell instance $3472 m0 *1 207.67,152.6
X$3472 12615 12639 12641 109 77 12461 OAI21_X2
* cell instance $3476 m0 *1 211.47,152.6
X$3476 12462 3884 77 109 12135 NOR2_X1
* cell instance $3479 m0 *1 212.99,152.6
X$3479 10855 77 109 12134 CLKBUF_X3
* cell instance $3480 m0 *1 213.94,152.6
X$3480 8607 12636 8124 109 77 12466 OAI21_X2
* cell instance $3481 m0 *1 215.27,152.6
X$3481 8124 12616 77 109 12482 NOR2_X1
* cell instance $3482 m0 *1 215.84,152.6
X$3482 12464 12466 77 109 12463 NAND2_X1
* cell instance $3485 m0 *1 217.36,152.6
X$3485 77 18341 12617 12634 12134 109 DFF_X1
* cell instance $3486 m0 *1 220.59,152.6
X$3486 11508 12617 77 109 12788 NOR2_X1
* cell instance $3488 m0 *1 221.35,152.6
X$3488 12617 77 109 12480 INV_X1
* cell instance $3490 m0 *1 221.92,152.6
X$3490 12298 12167 109 77 12465 AND2_X1
* cell instance $3493 r0 *1 191.9,152.6
X$3493 10556 12600 12654 11775 109 12801 77 OR4_X2
* cell instance $3494 r0 *1 193.23,152.6
X$3494 12600 109 10665 77 BUF_X4
* cell instance $3496 r0 *1 194.75,152.6
X$3496 12608 12454 77 109 12286 NOR2_X1
* cell instance $3497 r0 *1 195.32,152.6
X$3497 12654 109 9862 77 BUF_X4
* cell instance $3499 r0 *1 197.41,152.6
X$3499 12761 12289 12798 77 12609 109 AOI21_X2
* cell instance $3500 r0 *1 198.74,152.6
X$3500 12649 12794 11807 109 77 12903 OAI21_X4
* cell instance $3501 r0 *1 201.21,152.6
X$3501 12648 12291 12761 77 12610 109 AOI21_X1
* cell instance $3502 r0 *1 201.97,152.6
X$3502 12610 77 109 12458 INV_X1
* cell instance $3503 r0 *1 202.35,152.6
X$3503 12293 12291 77 109 12762 NAND2_X1
* cell instance $3504 r0 *1 202.92,152.6
X$3504 12291 11951 109 77 12612 AND2_X2
* cell instance $3505 r0 *1 203.87,152.6
X$3505 12490 12758 12459 109 77 12764 HA_X1
* cell instance $3506 r0 *1 205.77,152.6
X$3506 12614 12644 12615 77 12765 109 AOI21_X1
* cell instance $3509 r0 *1 207.1,152.6
X$3509 12764 77 109 12615 INV_X1
* cell instance $3511 r0 *1 207.86,152.6
X$3511 12459 77 109 12639 INV_X2
* cell instance $3515 r0 *1 210.52,152.6
X$3515 77 18475 12616 12791 12134 109 DFF_X1
* cell instance $3516 r0 *1 213.75,152.6
X$3516 12134 77 109 19318 CLKBUF_X1
* cell instance $3518 r0 *1 214.51,152.6
X$3518 12616 11508 12635 77 109 12791 MUX2_X1
* cell instance $3519 r0 *1 215.84,152.6
X$3519 12638 77 109 12636 INV_X1
* cell instance $3521 r0 *1 216.41,152.6
X$3521 12464 12768 77 109 12635 XOR2_X1
* cell instance $3523 r0 *1 217.74,152.6
X$3523 11783 12297 12466 109 77 12768 AND3_X1
* cell instance $3524 r0 *1 218.69,152.6
X$3524 9378 77 109 9401 INV_X2
* cell instance $3527 r0 *1 220.21,152.6
X$3527 12788 11508 12787 77 12634 109 AOI21_X1
* cell instance $3529 r0 *1 221.73,152.6
X$3529 12467 12786 77 109 12787 XOR2_X1
* cell instance $3530 r0 *1 222.87,152.6
X$3530 12296 12465 12157 77 109 12786 NAND3_X1
* cell instance $3532 m0 *1 223.06,152.6
X$3532 12467 12167 12298 12296 77 12784 109 NAND4_X2
* cell instance $3534 r0 *1 225.15,152.6
X$3534 77 12618 12914 12784 12770 13085 109 NOR4_X4
* cell instance $3535 m0 *1 225.91,152.6
X$3535 12619 12296 12467 12465 77 109 12769 NAND4_X1
* cell instance $3536 m0 *1 225.15,152.6
X$3536 12301 10654 77 109 12618 OR2_X1
* cell instance $3537 m0 *1 226.86,152.6
X$3537 10654 12301 77 109 12619 NOR2_X1
* cell instance $3544 m0 *1 228.57,152.6
X$3544 12630 11508 12771 77 109 12620 MUX2_X1
* cell instance $3545 m0 *1 230.09,152.6
X$3545 10034 12630 77 109 12631 NOR2_X1
* cell instance $3547 m0 *1 230.85,152.6
X$3547 10192 12631 77 109 12770 OR2_X2
* cell instance $3550 m0 *1 233.51,152.6
X$3550 12629 12305 12622 77 109 12779 MUX2_X1
* cell instance $3552 m0 *1 235.6,152.6
X$3552 12628 12304 11026 77 12473 109 AOI21_X1
* cell instance $3553 m0 *1 236.36,152.6
X$3553 77 18344 12468 12623 12621 109 DFF_X1
* cell instance $3557 r0 *1 229.14,152.6
X$3557 77 18428 12630 12620 12621 109 DFF_X1
* cell instance $3559 r0 *1 232.75,152.6
X$3559 77 18393 12629 12779 12621 109 DFF_X1
* cell instance $3560 r0 *1 235.98,152.6
X$3560 11186 77 109 12621 CLKBUF_X3
* cell instance $3561 r0 *1 236.93,152.6
X$3561 12304 12468 77 109 12628 NOR2_X1
* cell instance $3562 r0 *1 237.5,152.6
X$3562 12622 77 109 12625 BUF_X1
* cell instance $3563 r0 *1 238.07,152.6
X$3563 12626 77 109 12470 BUF_X1
* cell instance $3564 r0 *1 238.64,152.6
X$3564 12602 77 109 12469 BUF_X1
* cell instance $3574 r0 *1 2.66,155.4
X$3574 77 12552 12699 12923 12922 4909 109 DFFR_X1
* cell instance $3579 m0 *1 3.23,155.4
X$3579 12394 6214 12777 77 109 12775 MUX2_X1
* cell instance $3581 r0 *1 6.46,155.4
X$3581 11858 6280 12923 77 109 12922 MUX2_X1
* cell instance $3582 m0 *1 7.79,155.4
X$3582 12845 11461 12846 77 109 12701 MUX2_X1
* cell instance $3583 m0 *1 6.46,155.4
X$3583 12699 12072 12700 77 109 11795 MUX2_X1
* cell instance $3586 m0 *1 12.35,155.4
X$3586 9961 77 109 12555 CLKBUF_X3
* cell instance $3587 m0 *1 13.3,155.4
X$3587 77 12555 12703 12704 12927 9814 109 DFFR_X1
* cell instance $3588 m0 *1 17.1,155.4
X$3588 12704 4708 12065 77 109 12927 MUX2_X1
* cell instance $3590 r0 *1 7.79,155.4
X$3590 12845 12072 12846 77 109 12062 MUX2_X1
* cell instance $3593 r0 *1 11.4,155.4
X$3593 12847 2633 11857 77 109 13025 MUX2_X1
* cell instance $3594 r0 *1 12.73,155.4
X$3594 77 13257 109 12072 BUF_X8
* cell instance $3595 r0 *1 15.2,155.4
X$3595 12848 3786 11857 77 109 12849 MUX2_X1
* cell instance $3596 r0 *1 16.53,155.4
X$3596 13091 12189 13027 77 109 12929 MUX2_X1
* cell instance $3597 r0 *1 17.86,155.4
X$3597 12555 77 109 19276 CLKBUF_X1
* cell instance $3598 r0 *1 18.43,155.4
X$3598 77 12555 12851 12850 12930 9814 109 DFFR_X1
* cell instance $3599 m0 *1 19,155.4
X$3599 12785 9326 12928 77 109 12931 MUX2_X1
* cell instance $3601 m0 *1 20.33,155.4
X$3601 12706 11276 12851 77 109 12928 MUX2_X1
* cell instance $3602 m0 *1 21.66,155.4
X$3602 12706 12189 12851 77 109 12707 MUX2_X1
* cell instance $3603 m0 *1 22.99,155.4
X$3603 12852 7619 12931 77 109 11703 MUX2_X1
* cell instance $3608 r0 *1 23.18,155.4
X$3608 6091 109 3995 77 BUF_X4
* cell instance $3610 r0 *1 24.7,155.4
X$3610 12932 4708 13096 77 109 12854 MUX2_X1
* cell instance $3611 r0 *1 26.03,155.4
X$3611 9961 77 109 12069 CLKBUF_X3
* cell instance $3612 m0 *1 26.41,155.4
X$3612 12934 7468 12394 77 109 12708 MUX2_X1
* cell instance $3614 m0 *1 27.74,155.4
X$3614 77 12069 12248 12934 12708 9814 109 DFFR_X1
* cell instance $3618 r0 *1 30.78,155.4
X$3618 77 12072 10138 109 BUF_X16
* cell instance $3619 m0 *1 32.11,155.4
X$3619 12792 6885 11980 77 109 12936 MUX2_X1
* cell instance $3621 m0 *1 33.44,155.4
X$3621 77 12856 18584 12792 12936 9814 109 DFFR_X1
* cell instance $3622 m0 *1 37.24,155.4
X$3622 10674 77 109 11704 CLKBUF_X3
* cell instance $3623 m0 *1 38.19,155.4
X$3623 77 10440 109 12072 BUF_X8
* cell instance $3624 m0 *1 40.66,155.4
X$3624 77 11704 12858 12796 12645 9814 109 DFFR_X1
* cell instance $3627 m0 *1 45.41,155.4
X$3627 3786 109 9985 77 BUF_X4
* cell instance $3628 m0 *1 46.74,155.4
X$3628 4065 109 9667 77 BUF_X4
* cell instance $3630 m0 *1 48.83,155.4
X$3630 12955 11448 6380 77 12954 109 AOI21_X1
* cell instance $3631 m0 *1 49.59,155.4
X$3631 77 12860 12712 12713 12954 4086 109 DFFR_X1
* cell instance $3632 m0 *1 53.39,155.4
X$3632 6380 12713 77 109 12955 NOR2_X1
* cell instance $3636 m0 *1 56.43,155.4
X$3636 13033 11448 6820 77 12956 109 AOI21_X1
* cell instance $3637 m0 *1 57.19,155.4
X$3637 77 11708 12565 12808 12805 4086 109 DFFR_X1
* cell instance $3640 r0 *1 35.53,155.4
X$3640 77 12856 12941 12855 12938 9814 109 DFFR_X1
* cell instance $3641 r0 *1 39.33,155.4
X$3641 3786 109 13098 77 BUF_X4
* cell instance $3642 r0 *1 40.66,155.4
X$3642 12248 9337 77 109 13102 NAND2_X1
* cell instance $3645 r0 *1 42.37,155.4
X$3645 12945 10583 9631 77 12944 109 AOI21_X1
* cell instance $3647 r0 *1 43.51,155.4
X$3647 9631 12948 77 109 12945 NOR2_X1
* cell instance $3649 r0 *1 44.46,155.4
X$3649 12793 12066 12858 77 109 12797 MUX2_X1
* cell instance $3651 r0 *1 46.17,155.4
X$3651 12859 7469 10583 77 12949 109 AOI21_X1
* cell instance $3653 r0 *1 47.12,155.4
X$3653 7469 12950 77 109 12859 NOR2_X1
* cell instance $3656 r0 *1 49.59,155.4
X$3656 3782 109 9832 77 BUF_X4
* cell instance $3658 r0 *1 53.96,155.4
X$3658 77 12860 12714 13034 12956 4086 109 DFFR_X1
* cell instance $3659 r0 *1 57.76,155.4
X$3659 77 11283 12861 13111 13110 4086 109 DFFR_X1
* cell instance $3665 r0 *1 62.51,155.4
X$3665 12862 10969 6983 77 12958 109 AOI21_X1
* cell instance $3667 m0 *1 62.89,155.4
X$3667 9985 12715 77 109 12568 NOR2_X1
* cell instance $3668 m0 *1 64.22,155.4
X$3668 12961 10132 9667 77 12810 109 AOI21_X1
* cell instance $3671 r0 *1 63.65,155.4
X$3671 6983 13037 77 109 12862 NOR2_X1
* cell instance $3673 m0 *1 65.55,155.4
X$3673 9667 12813 77 109 12961 NOR2_X1
* cell instance $3678 m0 *1 68.59,155.4
X$3678 11594 5252 12818 77 109 12814 MUX2_X1
* cell instance $3679 m0 *1 69.92,155.4
X$3679 12863 12189 12817 77 109 12864 MUX2_X1
* cell instance $3680 m0 *1 71.25,155.4
X$3680 12864 5513 12967 77 109 12358 MUX2_X1
* cell instance $3681 m0 *1 72.58,155.4
X$3681 12863 9831 12817 77 109 12974 MUX2_X1
* cell instance $3682 m0 *1 73.91,155.4
X$3682 12821 6975 12717 77 109 12820 MUX2_X1
* cell instance $3687 r0 *1 67.83,155.4
X$3687 77 12571 12865 13114 12962 4086 109 DFFR_X1
* cell instance $3688 r0 *1 71.63,155.4
X$3688 12865 12189 12969 77 109 12967 MUX2_X1
* cell instance $3690 r0 *1 73.15,155.4
X$3690 12865 9831 12969 77 109 12971 MUX2_X1
* cell instance $3696 m0 *1 3.04,175
X$3696 14038 6280 14512 77 109 14631 MUX2_X1
* cell instance $3698 m0 *1 5.13,175
X$3698 77 13800 14516 14372 14515 9814 109 DFFR_X1
* cell instance $3700 m0 *1 9.12,175
X$3700 14588 4309 14516 77 109 14520 MUX2_X1
* cell instance $3701 m0 *1 10.45,175
X$3701 14459 9326 14518 77 109 14635 MUX2_X1
* cell instance $3706 r0 *1 1.33,175
X$3706 77 13800 14588 14512 14631 9814 109 DFFR_X1
* cell instance $3713 r0 *1 7.6,175
X$3713 14587 14187 14043 77 109 14632 MUX2_X1
* cell instance $3715 r0 *1 9.12,175
X$3715 14588 6083 14516 77 109 14518 MUX2_X1
* cell instance $3718 r0 *1 11.4,175
X$3718 14635 6704 14762 77 109 14636 MUX2_X1
* cell instance $3719 r0 *1 12.73,175
X$3719 14765 10860 14703 77 109 14378 MUX2_X1
* cell instance $3721 m0 *1 15.77,175
X$3721 77 14168 14313 14522 14523 9814 109 DFFR_X1
* cell instance $3722 m0 *1 14.44,175
X$3722 14038 3784 14522 77 109 14523 MUX2_X1
* cell instance $3725 r0 *1 17.29,175
X$3725 77 9895 109 7156 BUF_X8
* cell instance $3728 m0 *1 19.95,175
X$3728 14313 13257 14253 77 109 14460 MUX2_X1
* cell instance $3730 r0 *1 20.71,175
X$3730 14704 13257 14589 77 109 14590 MUX2_X1
* cell instance $3732 m0 *1 21.66,175
X$3732 14460 5410 14526 77 109 14527 MUX2_X1
* cell instance $3733 m0 *1 23.18,175
X$3733 13984 77 109 19156 INV_X1
* cell instance $3734 m0 *1 23.56,175
X$3734 14461 77 109 13984 CLKBUF_X3
* cell instance $3735 m0 *1 24.51,175
X$3735 14038 5178 14639 77 109 14462 MUX2_X1
* cell instance $3736 m0 *1 25.84,175
X$3736 77 13984 14463 14639 14462 9814 109 DFFR_X1
* cell instance $3738 m0 *1 29.83,175
X$3738 14463 4784 14315 77 109 14464 MUX2_X1
* cell instance $3739 m0 *1 31.16,175
X$3739 14464 5410 14532 77 109 14595 MUX2_X1
* cell instance $3743 m0 *1 34.96,175
X$3743 14038 6716 14643 77 109 14465 MUX2_X1
* cell instance $3745 m0 *1 37.05,175
X$3745 14461 77 109 14318 CLKBUF_X3
* cell instance $3746 m0 *1 38,175
X$3746 14318 77 109 19222 CLKBUF_X1
* cell instance $3750 r0 *1 22.23,175
X$3750 14590 5410 14591 77 109 14592 MUX2_X1
* cell instance $3751 r0 *1 23.56,175
X$3751 14527 3482 14592 77 109 14642 MUX2_X1
* cell instance $3756 r0 *1 30.59,175
X$3756 14593 7156 14594 77 109 14649 MUX2_X1
* cell instance $3757 r0 *1 31.92,175
X$3757 14773 3482 14595 77 109 14596 MUX2_X1
* cell instance $3758 r0 *1 33.25,175
X$3758 14596 4210 14642 77 109 14646 MUX2_X1
* cell instance $3759 r0 *1 34.58,175
X$3759 14636 7917 77 109 14645 NOR2_X1
* cell instance $3761 r0 *1 35.91,175
X$3761 14645 14466 7997 109 14777 77 NOR3_X2
* cell instance $3762 r0 *1 37.24,175
X$3762 77 14318 14468 14651 14647 4086 109 DFFR_X1
* cell instance $3763 m0 *1 39.9,175
X$3763 14467 9810 14468 77 109 14538 MUX2_X1
* cell instance $3766 m0 *1 41.42,175
X$3766 14467 9812 14468 77 109 14392 MUX2_X1
* cell instance $3768 m0 *1 42.94,175
X$3768 14538 6120 14539 77 109 14045 MUX2_X1
* cell instance $3770 r0 *1 41.04,175
X$3770 14649 6294 6383 77 109 14648 NOR3_X1
* cell instance $3771 r0 *1 41.8,175
X$3771 14651 14046 13675 77 109 14647 MUX2_X1
* cell instance $3775 m0 *1 44.65,175
X$3775 77 14708 14470 14653 14541 4086 109 DFFR_X1
* cell instance $3776 r0 *1 45.03,175
X$3776 14653 14047 14043 77 109 14541 MUX2_X1
* cell instance $3779 r0 *1 48.64,175
X$3779 14470 13355 14597 77 109 14654 MUX2_X1
* cell instance $3781 m0 *1 48.83,175
X$3781 14470 10435 14597 77 109 14469 MUX2_X1
* cell instance $3782 r0 *1 49.97,175
X$3782 14654 7620 77 109 14471 NOR2_X1
* cell instance $3784 m0 *1 50.54,175
X$3784 77 14710 14322 14401 14403 4086 109 DFFR_X1
* cell instance $3790 r0 *1 54.91,175
X$3790 14322 4784 14323 77 109 14658 MUX2_X1
* cell instance $3792 m0 *1 55.48,175
X$3792 14472 4784 14546 77 109 14657 MUX2_X1
* cell instance $3795 r0 *1 57.19,175
X$3795 14658 5410 14657 77 109 14659 MUX2_X1
* cell instance $3797 m0 *1 57.19,175
X$3797 14545 7156 14473 77 109 14547 MUX2_X1
* cell instance $3799 m0 *1 59.09,175
X$3799 14547 5017 14474 77 109 14548 MUX2_X1
* cell instance $3806 r0 *1 60.04,175
X$3806 14659 3482 14598 77 109 14793 MUX2_X1
* cell instance $3808 m0 *1 61.75,175
X$3808 14048 4905 14549 77 109 14409 MUX2_X1
* cell instance $3810 m0 *1 63.08,175
X$3810 3373 109 7156 77 BUF_X4
* cell instance $3814 r0 *1 63.08,175
X$3814 8858 109 5672 77 BUF_X4
* cell instance $3820 m0 *1 3.61,93.8
X$3820 4193 7054 7123 77 109 7122 MUX2_X1
* cell instance $3823 r0 *1 1.33,93.8
X$3823 77 6875 7176 7254 7253 4909 109 DFFR_X1
* cell instance $3830 r0 *1 5.13,93.8
X$3830 2932 6876 7254 77 109 7253 MUX2_X1
* cell instance $3831 m0 *1 9.12,93.8
X$3831 7055 6701 6878 77 109 7126 MUX2_X1
* cell instance $3832 m0 *1 5.32,93.8
X$3832 77 6875 7055 6877 7125 4909 109 DFFR_X1
* cell instance $3834 m0 *1 13.49,93.8
X$3834 7128 3782 6572 77 109 7056 MUX2_X1
* cell instance $3835 m0 *1 14.82,93.8
X$3835 77 6710 7058 7128 7056 4909 109 DFFR_X1
* cell instance $3836 m0 *1 18.62,93.8
X$3836 7057 6290 7058 77 109 7130 MUX2_X1
* cell instance $3837 m0 *1 19.95,93.8
X$3837 7057 7059 7058 77 109 7060 MUX2_X1
* cell instance $3841 r0 *1 6.65,93.8
X$3841 5174 7054 7177 77 109 7394 MUX2_X1
* cell instance $3846 r0 *1 10.83,93.8
X$3846 6572 7178 7179 77 109 7395 MUX2_X1
* cell instance $3847 r0 *1 12.16,93.8
X$3847 7070 109 7054 77 BUF_X4
* cell instance $3852 r0 *1 17.86,93.8
X$3852 7180 77 109 6710 CLKBUF_X3
* cell instance $3853 r0 *1 18.81,93.8
X$3853 6710 77 109 19166 INV_X1
* cell instance $3857 r0 *1 21.85,93.8
X$3857 6572 2931 7261 77 109 7258 MUX2_X1
* cell instance $3858 r0 *1 23.18,93.8
X$3858 77 6710 6884 7261 7258 4909 109 DFFR_X1
* cell instance $3859 m0 *1 24.89,93.8
X$3859 3887 109 4770 77 BUF_X4
* cell instance $3861 m0 *1 26.22,93.8
X$3861 6883 109 6572 77 BUF_X4
* cell instance $3865 r0 *1 27.93,93.8
X$3865 77 7464 7181 7061 7262 4909 109 DFFR_X1
* cell instance $3867 m0 *1 27.93,93.8
X$3867 7061 5020 7062 77 109 7262 MUX2_X1
* cell instance $3869 m0 *1 31.92,93.8
X$3869 7183 6885 7062 77 109 7182 MUX2_X1
* cell instance $3870 m0 *1 31.16,93.8
X$3870 5870 77 109 7062 BUF_X2
* cell instance $3871 m0 *1 33.25,93.8
X$3871 7063 109 6719 77 BUF_X4
* cell instance $3874 r0 *1 31.92,93.8
X$3874 77 6232 18828 7183 7182 4909 109 DFFR_X1
* cell instance $3875 m0 *1 35.34,93.8
X$3875 7138 7064 4193 77 109 7184 MUX2_X1
* cell instance $3876 m0 *1 34.96,93.8
X$3876 6232 77 109 19123 INV_X1
* cell instance $3877 m0 *1 36.67,93.8
X$3877 6645 77 109 6232 CLKBUF_X3
* cell instance $3879 r0 *1 35.72,93.8
X$3879 77 6232 7185 7138 7184 4909 109 DFFR_X1
* cell instance $3881 m0 *1 38,93.8
X$3881 7065 7135 7202 109 77 7268 MUX2_X2
* cell instance $3882 m0 *1 39.9,93.8
X$3882 77 7269 18527 6968 7066 4909 109 DFFR_X1
* cell instance $3886 r0 *1 41.23,93.8
X$3886 77 4773 6022 109 BUF_X16
* cell instance $3887 m0 *1 44.27,93.8
X$3887 77 7269 7324 6977 7067 4909 109 DFFR_X1
* cell instance $3890 m0 *1 48.26,93.8
X$3890 7068 6584 6893 77 109 7272 MUX2_X1
* cell instance $3892 m0 *1 49.78,93.8
X$3892 7272 3978 7142 77 109 7188 MUX2_X1
* cell instance $3893 m0 *1 51.11,93.8
X$3893 6979 6584 7069 77 109 7142 MUX2_X1
* cell instance $3895 m0 *1 52.63,93.8
X$3895 6293 6042 77 7178 109 NAND2_X4
* cell instance $3898 r0 *1 45.98,93.8
X$3898 6100 109 7059 77 BUF_X4
* cell instance $3900 r0 *1 47.69,93.8
X$3900 7068 6701 6893 77 109 7186 MUX2_X1
* cell instance $3902 r0 *1 49.21,93.8
X$3902 7186 6014 7187 77 109 7408 MUX2_X1
* cell instance $3904 r0 *1 52.06,93.8
X$3904 5950 6293 77 7189 109 NAND2_X4
* cell instance $3906 r0 *1 54.15,93.8
X$3906 5875 5738 7273 109 7409 77 OAI21_X1
* cell instance $3907 r0 *1 54.91,93.8
X$3907 6833 7190 77 109 7273 NAND2_X1
* cell instance $3908 r0 *1 55.48,93.8
X$3908 77 6894 7412 7281 6984 4909 109 DFFR_X1
* cell instance $3909 m0 *1 57.19,93.8
X$3909 5875 6262 7072 109 6984 77 OAI21_X1
* cell instance $3910 m0 *1 55.48,93.8
X$3910 6298 6293 77 7070 109 NAND2_X4
* cell instance $3911 m0 *1 57.95,93.8
X$3911 6720 7281 77 109 7072 NAND2_X1
* cell instance $3913 m0 *1 58.71,93.8
X$3913 6159 109 7279 77 BUF_X4
* cell instance $3915 m0 *1 60.23,93.8
X$3915 6894 77 109 19107 INV_X2
* cell instance $3916 m0 *1 60.8,93.8
X$3916 6645 77 109 6894 CLKBUF_X3
* cell instance $3925 r0 *1 60.04,93.8
X$3925 7192 6022 7191 77 109 7413 MUX2_X1
* cell instance $3927 r0 *1 61.75,93.8
X$3927 7192 6371 7191 77 109 7193 MUX2_X1
* cell instance $3928 m0 *1 63.08,93.8
X$3928 6298 3000 77 109 7327 NAND2_X2
* cell instance $3929 m0 *1 62.13,93.8
X$3929 3000 6042 77 109 7194 NAND2_X2
* cell instance $3931 m0 *1 64.22,93.8
X$3931 77 6170 7192 7284 7075 4909 109 DFFR_X1
* cell instance $3932 m0 *1 68.02,93.8
X$3932 6725 109 6823 77 BUF_X4
* cell instance $3933 m0 *1 69.35,93.8
X$3933 6720 109 6262 77 BUF_X4
* cell instance $3934 m0 *1 70.68,93.8
X$3934 3613 7286 77 109 7150 NAND2_X1
* cell instance $3935 m0 *1 71.25,93.8
X$3935 6168 7197 7001 77 109 NOR2_X4
* cell instance $3937 r0 *1 63.08,93.8
X$3937 7193 7283 7074 77 109 7582 MUX2_X1
* cell instance $3940 r0 *1 64.98,93.8
X$3940 5875 7165 7195 109 7075 77 OAI21_X1
* cell instance $3941 r0 *1 65.74,93.8
X$3941 7194 7284 77 109 7195 NAND2_X1
* cell instance $3942 r0 *1 66.31,93.8
X$3942 5181 5950 77 109 7196 NAND2_X1
* cell instance $3944 r0 *1 67.07,93.8
X$3944 7194 77 109 7165 CLKBUF_X3
* cell instance $3945 r0 *1 68.02,93.8
X$3945 6034 5950 77 7330 109 NAND2_X4
* cell instance $3947 r0 *1 69.92,93.8
X$3947 6030 6034 77 6888 109 NAND2_X4
* cell instance $3949 r0 *1 71.82,93.8
X$3949 77 6170 6835 7286 7288 1663 109 DFFR_X1
* cell instance $3951 m0 *1 73.34,93.8
X$3951 7150 6661 3619 109 77 7288 OAI21_X4
* cell instance $3952 r0 *1 75.62,93.8
X$3952 77 3048 109 6452 BUF_X8
* cell instance $3953 m0 *1 76.95,93.8
X$3953 7076 4509 7290 77 109 NOR2_X4
* cell instance $3954 m0 *1 76.19,93.8
X$3954 7153 5827 109 77 7077 AND2_X1
* cell instance $3955 m0 *1 78.66,93.8
X$3955 6896 77 109 7076 INV_X1
* cell instance $3956 m0 *1 79.04,93.8
X$3956 7076 109 4643 77 BUF_X4
* cell instance $3957 m0 *1 80.37,93.8
X$3957 6586 109 7292 77 BUF_X4
* cell instance $3959 m0 *1 81.89,93.8
X$3959 3993 7156 3278 77 109 7158 MUX2_X1
* cell instance $3960 m0 *1 83.22,93.8
X$3960 7079 4643 7158 77 109 7198 MUX2_X1
* cell instance $3961 m0 *1 84.55,93.8
X$3961 7160 7161 77 109 7080 NAND2_X1
* cell instance $3963 m0 *1 88.16,93.8
X$3963 7163 4789 7162 77 109 7203 MUX2_X1
* cell instance $3964 m0 *1 89.49,93.8
X$3964 7082 4789 7081 77 109 7204 MUX2_X1
* cell instance $3966 m0 *1 93.86,93.8
X$3966 7163 5311 7082 77 109 7206 MUX2_X1
* cell instance $3968 m0 *1 96.71,93.8
X$3968 4327 7165 7083 109 7207 77 OAI21_X1
* cell instance $3969 m0 *1 97.47,93.8
X$3969 7165 7301 77 109 7083 NAND2_X1
* cell instance $3972 m0 *1 99.75,93.8
X$3972 7085 6742 77 109 7208 NOR2_X1
* cell instance $3974 m0 *1 100.51,93.8
X$3974 7084 4327 7086 109 7210 77 OAI21_X1
* cell instance $3975 m0 *1 101.27,93.8
X$3975 7084 7303 77 109 7086 NAND2_X1
* cell instance $3977 m0 *1 102.03,93.8
X$3977 6734 5892 7152 109 77 7167 OAI21_X4
* cell instance $3978 m0 *1 104.5,93.8
X$3978 77 6866 109 7087 BUF_X8
* cell instance $3981 r0 *1 78.09,93.8
X$3981 3906 109 3978 77 BUF_X4
* cell instance $3983 r0 *1 79.61,93.8
X$3983 77 5451 109 7077 BUF_X8
* cell instance $3985 r0 *1 82.27,93.8
X$3985 3993 7335 6300 77 109 7428 MUX2_X1
* cell instance $3987 r0 *1 83.79,93.8
X$3987 5462 6972 7200 109 7199 77 OAI21_X1
* cell instance $3988 r0 *1 84.55,93.8
X$3988 7201 7426 77 109 7200 NAND2_X1
* cell instance $3991 r0 *1 85.69,93.8
X$3991 7198 7202 77 109 7486 NOR2_X1
* cell instance $3993 r0 *1 87.78,93.8
X$3993 7162 6591 7081 77 109 7431 MUX2_X1
* cell instance $3995 r0 *1 89.49,93.8
X$3995 7203 4914 7204 77 109 7594 MUX2_X1
* cell instance $3996 r0 *1 90.82,93.8
X$3996 77 7205 7438 7437 7433 1663 109 DFFR_X1
* cell instance $3999 r0 *1 95.19,93.8
X$3999 3445 77 109 6671 CLKBUF_X3
* cell instance $4001 r0 *1 96.52,93.8
X$4001 77 6455 7209 7301 7207 1663 109 DFFR_X1
* cell instance $4002 r0 *1 100.32,93.8
X$4002 77 7337 7445 7303 7210 1663 109 DFFR_X1
* cell instance $4003 r0 *1 104.12,93.8
X$4003 77 18427 7341 7211 6135 109 DFF_X1
* cell instance $4005 m0 *1 109.44,93.8
X$4005 77 7170 6135 6903 7291 109 DFF_X2
* cell instance $4006 m0 *1 108.11,93.8
X$4006 7197 4462 3065 77 109 7211 MUX2_X1
* cell instance $4007 m0 *1 113.05,93.8
X$4007 4087 3144 7304 109 7170 77 OAI21_X1
* cell instance $4008 m0 *1 113.81,93.8
X$4008 3306 7283 77 109 7304 NAND2_X1
* cell instance $4011 r0 *1 108.87,93.8
X$4011 7202 4462 2746 77 109 7600 MUX2_X1
* cell instance $4015 r0 *1 112.29,93.8
X$4015 77 7308 7343 7306 6135 109 DFF_X1
* cell instance $4022 r0 *1 115.52,93.8
X$4022 7308 77 109 7307 INV_X1
* cell instance $4024 m0 *1 115.52,93.8
X$4024 7307 6464 7087 77 109 7173 MUX2_X1
* cell instance $4025 m0 *1 118.37,93.8
X$4025 6739 77 109 19102 INV_X2
* cell instance $4028 r0 *1 116.28,93.8
X$4028 77 6738 6739 7448 7213 109 DFF_X2
* cell instance $4029 m0 *1 119.51,93.8
X$4029 77 7312 7089 4804 6739 109 DFF_X1
* cell instance $4031 m0 *1 122.74,93.8
X$4031 7215 3746 3632 109 77 7175 MUX2_X2
* cell instance $4032 m0 *1 124.45,93.8
X$4032 7312 109 6469 77 BUF_X4
* cell instance $4033 m0 *1 125.78,93.8
X$4033 5993 77 109 7217 BUF_X2
* cell instance $4034 m0 *1 126.54,93.8
X$4034 4523 4460 3916 6907 109 7314 77 NOR4_X2
* cell instance $4035 m0 *1 128.25,93.8
X$4035 7451 77 109 7346 INV_X1
* cell instance $4036 m0 *1 128.63,93.8
X$4036 77 5476 5475 7094 7218 7316 109 NOR4_X4
* cell instance $4037 m0 *1 132.05,93.8
X$4037 5748 5557 5711 109 77 6744 OAI21_X2
* cell instance $4038 m0 *1 133.38,93.8
X$4038 3998 77 109 6008 CLKBUF_X3
* cell instance $4039 m0 *1 134.33,93.8
X$4039 6469 77 109 5557 INV_X4
* cell instance $4040 m0 *1 135.28,93.8
X$4040 6601 77 109 7315 BUF_X2
* cell instance $4042 r0 *1 119.89,93.8
X$4042 3998 77 109 6739 CLKBUF_X3
* cell instance $4045 r0 *1 121.22,93.8
X$4045 7215 77 109 7311 INV_X1
* cell instance $4046 r0 *1 121.6,93.8
X$4046 77 7216 109 7089 BUF_X8
* cell instance $4047 r0 *1 124.07,93.8
X$4047 7311 7217 7216 5861 7218 109 77 AOI211_X2
* cell instance $4048 r0 *1 125.78,93.8
X$4048 5472 7449 7345 5896 77 109 6147 AOI22_X2
* cell instance $4049 r0 *1 127.49,93.8
X$4049 7089 77 109 7787 BUF_X1
* cell instance $4050 r0 *1 128.06,93.8
X$4050 6008 77 109 19096 INV_X4
* cell instance $4051 r0 *1 129.01,93.8
X$4051 6466 6145 77 109 7454 OR2_X2
* cell instance $4052 r0 *1 129.96,93.8
X$4052 7218 7094 5476 4890 5297 5603 77 109 7317 OAI33_X1
* cell instance $4053 r0 *1 131.29,93.8
X$4053 7344 6464 77 109 7171 OR2_X1
* cell instance $4054 r0 *1 132.05,93.8
X$4054 7219 5563 6469 77 109 7220 MUX2_X1
* cell instance $4055 r0 *1 133.38,93.8
X$4055 77 7347 109 5009 BUF_X8
* cell instance $4056 r0 *1 135.85,93.8
X$4056 3916 6699 7454 77 109 6468 OR3_X1
* cell instance $4057 m0 *1 137.75,93.8
X$4057 6903 3632 3472 77 109 6928 MUX2_X1
* cell instance $4058 m0 *1 136.42,93.8
X$4058 6436 7095 6870 109 77 7169 OAI21_X2
* cell instance $4059 m0 *1 139.08,93.8
X$4059 7097 109 7096 77 BUF_X4
* cell instance $4060 m0 *1 140.41,93.8
X$4060 7100 109 7159 77 BUF_X4
* cell instance $4061 m0 *1 141.74,93.8
X$4061 6472 6751 7221 77 109 NOR2_X4
* cell instance $4062 m0 *1 143.45,93.8
X$4062 6751 6472 77 109 7097 OR2_X1
* cell instance $4064 r0 *1 136.8,93.8
X$4064 6466 77 109 6144 INV_X2
* cell instance $4066 r0 *1 137.56,93.8
X$4066 7096 109 7226 77 BUF_X4
* cell instance $4067 r0 *1 138.89,93.8
X$4067 7097 6750 7100 77 7313 109 AOI21_X2
* cell instance $4069 r0 *1 140.98,93.8
X$4069 6913 6915 7352 109 7351 77 OAI21_X1
* cell instance $4070 r0 *1 141.74,93.8
X$4070 7221 6750 7159 77 7309 109 AOI21_X2
* cell instance $4072 m0 *1 144.97,93.8
X$4072 7050 7099 77 7100 109 NAND2_X4
* cell instance $4073 m0 *1 144.59,93.8
X$4073 6748 77 109 7044 INV_X1
* cell instance $4074 m0 *1 146.68,93.8
X$4074 6860 6056 7164 77 6258 109 AOI21_X1
* cell instance $4076 m0 *1 147.63,93.8
X$4076 7101 7157 7224 7102 7048 7104 77 109 7223 OAI33_X1
* cell instance $4077 m0 *1 148.96,93.8
X$4077 77 7224 7103 7104 7105 7096 7302 7225 109 OAI222_X2
* cell instance $4079 m0 *1 151.81,93.8
X$4079 7155 7100 7296 77 109 7105 MUX2_X1
* cell instance $4082 r0 *1 144.97,93.8
X$4082 7050 77 109 7305 CLKBUF_X3
* cell instance $4083 r0 *1 145.92,93.8
X$4083 7101 7157 77 109 7222 NOR2_X1
* cell instance $4084 r0 *1 146.49,93.8
X$4084 6859 6191 6472 6751 7305 7507 77 109 OAI221_X2
* cell instance $4085 r0 *1 148.58,93.8
X$4085 7102 7048 77 109 7103 OR2_X1
* cell instance $4086 r0 *1 149.34,93.8
X$4086 6472 6751 3882 109 7104 77 OAI21_X1
* cell instance $4087 r0 *1 150.1,93.8
X$4087 6472 6751 6920 109 7224 77 OAI21_X1
* cell instance $4088 r0 *1 150.86,93.8
X$4088 6753 6915 6913 77 109 7102 NOR3_X1
* cell instance $4090 r0 *1 152,93.8
X$4090 7107 6914 7228 77 109 7354 MUX2_X1
* cell instance $4091 r0 *1 153.33,93.8
X$4091 7360 3882 7228 77 109 7227 MUX2_X1
* cell instance $4092 m0 *1 153.71,93.8
X$4092 7227 7100 7106 77 109 7362 MUX2_X1
* cell instance $4095 m0 *1 155.23,93.8
X$4095 7363 7159 6924 77 109 7298 MUX2_X1
* cell instance $4096 m0 *1 156.56,93.8
X$4096 6859 77 109 4100 INV_X2
* cell instance $4098 m0 *1 157.89,93.8
X$4098 7108 6923 6603 6926 7297 109 77 AOI211_X2
* cell instance $4100 r0 *1 154.66,93.8
X$4100 7300 7298 7226 109 77 7299 MUX2_X2
* cell instance $4103 r0 *1 156.94,93.8
X$4103 7108 6603 7295 77 7296 109 AOI21_X2
* cell instance $4104 r0 *1 158.27,93.8
X$4104 7230 7229 7231 77 109 6752 MUX2_X1
* cell instance $4109 m0 *1 3.04,96.6
X$4109 7180 77 109 6875 CLKBUF_X3
* cell instance $4110 m0 *1 3.99,96.6
X$4110 77 6875 6878 7177 7394 4909 109 DFFR_X1
* cell instance $4111 m0 *1 7.79,96.6
X$4111 77 6875 7318 7179 7395 4909 109 DFFR_X1
* cell instance $4112 m0 *1 11.59,96.6
X$4112 77 6710 7612 7396 7397 4909 109 DFFR_X1
* cell instance $4113 m0 *1 15.39,96.6
X$4113 6572 7189 7396 77 109 7397 MUX2_X1
* cell instance $4114 m0 *1 16.72,96.6
X$4114 7401 4843 7062 77 109 7319 MUX2_X1
* cell instance $4119 r0 *1 2.85,96.6
X$4119 3484 7054 7540 77 109 7539 MUX2_X1
* cell instance $4126 r0 *1 10.83,96.6
X$4126 6572 7410 7543 77 109 7458 MUX2_X1
* cell instance $4130 r0 *1 13.49,96.6
X$4130 7189 109 6214 77 BUF_X4
* cell instance $4133 r0 *1 18.05,96.6
X$4133 77 7459 7460 7401 7319 4909 109 DFFR_X1
* cell instance $4134 m0 *1 22.99,96.6
X$4134 7320 5167 7062 77 109 7399 MUX2_X1
* cell instance $4135 m0 *1 19.19,96.6
X$4135 77 7459 7461 7320 7399 4909 109 DFFR_X1
* cell instance $4142 r0 *1 22.23,96.6
X$4142 7460 6591 7461 77 109 7550 MUX2_X1
* cell instance $4143 r0 *1 23.56,96.6
X$4143 7460 7477 7461 77 109 7462 MUX2_X1
* cell instance $4147 r0 *1 26.98,96.6
X$4147 77 7464 7466 7467 7554 4909 109 DFFR_X1
* cell instance $4148 r0 *1 30.78,96.6
X$4148 7467 5110 7062 77 109 7554 MUX2_X1
* cell instance $4150 r0 *1 32.3,96.6
X$4150 7470 7469 7062 77 109 7557 MUX2_X1
* cell instance $4151 r0 *1 33.63,96.6
X$4151 77 6232 7472 7470 7557 4909 109 DFFR_X1
* cell instance $4152 m0 *1 36.29,96.6
X$4152 5578 7338 77 109 7699 NAND2_X1
* cell instance $4157 r0 *1 37.81,96.6
X$4157 7472 7321 77 109 7564 NAND2_X1
* cell instance $4158 r0 *1 38.38,96.6
X$4158 7561 6887 7565 109 7621 77 OAI21_X1
* cell instance $4159 m0 *1 39.33,96.6
X$4159 7185 7403 77 109 7563 NAND2_X1
* cell instance $4160 m0 *1 38.76,96.6
X$4160 7185 7321 77 109 7565 NAND2_X1
* cell instance $4163 r0 *1 39.14,96.6
X$4163 6371 6887 7563 109 7623 77 OAI21_X1
* cell instance $4164 r0 *1 39.9,96.6
X$4164 7472 6383 77 109 7473 NAND2_X1
* cell instance $4165 r0 *1 40.47,96.6
X$4165 6389 7183 7473 109 7625 77 OAI21_X1
* cell instance $4166 r0 *1 41.23,96.6
X$4166 7064 109 7468 77 BUF_X4
* cell instance $4167 r0 *1 42.56,96.6
X$4167 5039 109 7403 77 BUF_X4
* cell instance $4168 m0 *1 47.12,96.6
X$4168 7201 7322 77 109 6892 NAND2_X1
* cell instance $4169 m0 *1 43.32,96.6
X$4169 77 7269 7323 7322 7270 4909 109 DFFR_X1
* cell instance $4170 m0 *1 47.69,96.6
X$4170 7323 6701 7324 77 109 7325 MUX2_X1
* cell instance $4172 m0 *1 50.54,96.6
X$4172 6030 6293 77 7410 109 NAND2_X4
* cell instance $4173 m0 *1 52.25,96.6
X$4173 77 6978 7573 7190 7409 4909 109 DFFR_X1
* cell instance $4175 m0 *1 59.09,96.6
X$4175 7413 5575 7073 77 109 7577 MUX2_X1
* cell instance $4176 m0 *1 60.42,96.6
X$4176 5029 7331 7481 109 7480 77 OAI21_X1
* cell instance $4177 m0 *1 61.18,96.6
X$4177 77 6894 7581 7417 7326 4909 109 DFFR_X1
* cell instance $4178 m0 *1 64.98,96.6
X$4178 7196 5875 7328 109 7326 77 OAI21_X1
* cell instance $4179 m0 *1 65.74,96.6
X$4179 7084 7417 77 109 7328 NAND2_X1
* cell instance $4182 m0 *1 67.26,96.6
X$4182 6030 5181 77 109 7329 NAND2_X2
* cell instance $4183 m0 *1 68.21,96.6
X$4183 5181 6030 109 77 7332 AND2_X2
* cell instance $4184 m0 *1 69.16,96.6
X$4184 7327 77 109 7331 CLKBUF_X3
* cell instance $4185 m0 *1 70.11,96.6
X$4185 7332 109 6885 77 BUF_X4
* cell instance $4186 m0 *1 71.44,96.6
X$4186 77 6661 109 3621 BUF_X8
* cell instance $4187 m0 *1 73.91,96.6
X$4187 7421 5738 6661 109 77 7419 OAI21_X2
* cell instance $4188 m0 *1 75.24,96.6
X$4188 3619 6302 7151 109 7423 77 OAI21_X1
* cell instance $4189 m0 *1 76,96.6
X$4189 77 6585 7333 7005 7423 1663 109 DFFR_X1
* cell instance $4190 m0 *1 79.8,96.6
X$4190 5962 77 109 6585 CLKBUF_X3
* cell instance $4191 m0 *1 80.75,96.6
X$4191 6300 5275 7333 77 109 7334 MUX2_X1
* cell instance $4193 m0 *1 82.27,96.6
X$4193 3278 7335 7333 77 109 7427 MUX2_X1
* cell instance $4195 m0 *1 83.79,96.6
X$4195 77 6585 7162 7426 7199 1663 109 DFFR_X1
* cell instance $4197 m0 *1 87.78,96.6
X$4197 7430 6719 6729 77 109 7336 MUX2_X1
* cell instance $4199 m0 *1 89.3,96.6
X$4199 7432 5729 7431 77 109 7430 MUX2_X1
* cell instance $4201 r0 *1 43.89,96.6
X$4201 7064 109 7469 77 BUF_X4
* cell instance $4204 r0 *1 46.36,96.6
X$4204 5029 6972 7474 109 7706 77 OAI21_X1
* cell instance $4205 r0 *1 47.12,96.6
X$4205 7201 7568 77 109 7474 NAND2_X1
* cell instance $4207 r0 *1 48.07,96.6
X$4207 7323 6584 7324 77 109 7475 MUX2_X1
* cell instance $4209 r0 *1 49.78,96.6
X$4209 5029 6890 7570 109 7476 77 OAI21_X1
* cell instance $4211 r0 *1 50.73,96.6
X$4211 7160 7569 77 109 7570 NAND2_X1
* cell instance $4214 r0 *1 51.87,96.6
X$4214 6978 77 109 19119 INV_X2
* cell instance $4216 r0 *1 53.96,96.6
X$4216 7573 7477 6581 77 109 7478 MUX2_X1
* cell instance $4217 r0 *1 55.29,96.6
X$4217 7573 7403 6581 77 109 7574 MUX2_X1
* cell instance $4218 r0 *1 56.62,96.6
X$4218 7412 7403 7071 77 109 7576 MUX2_X1
* cell instance $4219 r0 *1 57.95,96.6
X$4219 7574 5960 7576 77 109 7479 MUX2_X1
* cell instance $4224 r0 *1 59.66,96.6
X$4224 77 6894 7191 7579 7480 4909 109 DFFR_X1
* cell instance $4225 r0 *1 63.46,96.6
X$4225 7581 7321 77 109 7715 NAND2_X1
* cell instance $4227 r0 *1 64.22,96.6
X$4227 7582 7580 77 109 7482 NAND2_X1
* cell instance $4229 r0 *1 64.98,96.6
X$4229 7581 6372 77 109 7483 NAND2_X1
* cell instance $4233 r0 *1 68.21,96.6
X$4233 7330 77 109 7084 CLKBUF_X3
* cell instance $4234 r0 *1 69.16,96.6
X$4234 7721 6262 6399 109 77 7725 OAI21_X4
* cell instance $4237 r0 *1 72.2,96.6
X$4237 77 6585 7777 7585 7419 1663 109 DFFR_X1
* cell instance $4238 r0 *1 76,96.6
X$4238 6585 77 109 19314 CLKBUF_X1
* cell instance $4240 r0 *1 76.95,96.6
X$4240 6452 109 3183 77 BUF_X4
* cell instance $4241 r0 *1 78.28,96.6
X$4241 77 6585 7484 7485 7729 1663 109 DFFR_X1
* cell instance $4242 r0 *1 82.08,96.6
X$4242 3709 7485 77 109 7587 NAND2_X1
* cell instance $4243 r0 *1 82.65,96.6
X$4243 2726 7447 7484 77 109 7589 MUX2_X1
* cell instance $4245 r0 *1 84.17,96.6
X$4245 77 7427 6184 6745 7428 7590 7589 7592 109 OAI222_X2
* cell instance $4247 r0 *1 87.59,96.6
X$4247 7591 5039 7487 77 109 7432 MUX2_X1
* cell instance $4248 r0 *1 88.92,96.6
X$4248 7438 7335 7591 77 109 7735 MUX2_X1
* cell instance $4249 r0 *1 90.25,96.6
X$4249 7489 7335 7487 77 109 7488 MUX2_X1
* cell instance $4250 m0 *1 91.2,96.6
X$4250 6302 7165 7436 109 7433 77 OAI21_X1
* cell instance $4253 m0 *1 92.72,96.6
X$4253 7165 7437 77 109 7436 NAND2_X1
* cell instance $4254 m0 *1 93.29,96.6
X$4254 77 7337 7489 7595 7439 1663 109 DFFR_X1
* cell instance $4255 m0 *1 97.09,96.6
X$4255 7331 7440 77 109 7491 NAND2_X1
* cell instance $4258 m0 *1 99.94,96.6
X$4258 7209 5039 7493 77 109 7339 MUX2_X1
* cell instance $4259 m0 *1 101.27,96.6
X$4259 7339 5729 7166 77 109 7340 MUX2_X1
* cell instance $4264 r0 *1 92.53,96.6
X$4264 7438 5311 7489 77 109 7490 MUX2_X1
* cell instance $4265 r0 *1 93.86,96.6
X$4265 7490 5960 7206 77 109 7736 MUX2_X1
* cell instance $4266 r0 *1 95.19,96.6
X$4266 6671 77 109 18287 INV_X8
* cell instance $4269 r0 *1 97.47,96.6
X$4269 77 7337 7493 7440 7492 1663 109 DFFR_X1
* cell instance $4271 r0 *1 101.46,96.6
X$4271 5184 7597 7340 77 109 7494 MUX2_X1
* cell instance $4272 r0 *1 102.79,96.6
X$4272 7342 7495 6268 77 109 NOR2_X4
* cell instance $4273 m0 *1 103.93,96.6
X$4273 77 7446 6683 5594 7444 109 AOI21_X4
* cell instance $4276 r0 *1 104.5,96.6
X$4276 7495 109 7447 77 BUF_X4
* cell instance $4279 r0 *1 106.4,96.6
X$4279 4449 7599 6182 109 77 7598 MUX2_X2
* cell instance $4280 m0 *1 106.97,96.6
X$4280 7341 109 7495 77 BUF_X4
* cell instance $4284 m0 *1 108.87,96.6
X$4284 77 7202 109 6291 BUF_X8
* cell instance $4290 r0 *1 109.06,96.6
X$4290 77 7600 6135 7602 7496 109 DFF_X2
* cell instance $4293 r0 *1 113.24,96.6
X$4293 4087 2624 7601 109 7648 77 OAI21_X1
* cell instance $4294 m0 *1 114.19,96.6
X$4294 7343 109 7342 77 BUF_X4
* cell instance $4296 m0 *1 115.52,96.6
X$4296 7338 4462 2142 77 109 7306 MUX2_X1
* cell instance $4304 r0 *1 117.8,96.6
X$4304 7561 4462 2213 77 109 7605 MUX2_X1
* cell instance $4305 m0 *1 119.32,96.6
X$4305 77 3916 4523 4460 7213 7450 109 NOR4_X4
* cell instance $4306 m0 *1 117.99,96.6
X$4306 7213 109 6699 77 BUF_X4
* cell instance $4308 m0 *1 122.93,96.6
X$4308 6569 3630 3317 77 109 7607 MUX2_X1
* cell instance $4309 m0 *1 124.26,96.6
X$4309 7091 7344 6740 7174 77 109 7449 NAND4_X1
* cell instance $4310 m0 *1 125.21,96.6
X$4310 7450 77 109 7091 BUF_X1
* cell instance $4311 m0 *1 125.78,96.6
X$4311 7091 6740 7499 7174 77 109 7345 NAND4_X1
* cell instance $4312 m0 *1 126.73,96.6
X$4312 7091 6144 7174 77 109 7348 NAND3_X2
* cell instance $4313 m0 *1 128.06,96.6
X$4313 5990 5896 6569 109 7451 77 OAI21_X1
* cell instance $4314 m0 *1 128.82,96.6
X$4314 6145 7347 7348 6469 5475 5476 77 109 7456 OAI33_X1
* cell instance $4315 m0 *1 130.15,96.6
X$4315 77 7651 7457 7608 7456 109 AOI21_X4
* cell instance $4316 m0 *1 132.62,96.6
X$4316 5713 5566 7220 109 77 7457 AND3_X1
* cell instance $4317 m0 *1 133.57,96.6
X$4317 6148 5553 77 109 7093 NAND2_X1
* cell instance $4318 m0 *1 134.14,96.6
X$4318 3916 6699 4460 4523 109 7349 77 OR4_X2
* cell instance $4321 r0 *1 119.13,96.6
X$4321 6595 77 109 7497 BUF_X2
* cell instance $4323 r0 *1 120.27,96.6
X$4323 7448 77 109 7344 CLKBUF_X2
* cell instance $4325 r0 *1 121.22,96.6
X$4325 77 7215 7606 7607 6739 109 DFF_X1
* cell instance $4326 r0 *1 124.45,96.6
X$4326 7606 77 109 7649 BUF_X2
* cell instance $4327 r0 *1 125.21,96.6
X$4327 5711 7498 77 109 7609 OR2_X1
* cell instance $4328 r0 *1 125.97,96.6
X$4328 2900 109 4462 77 BUF_X4
* cell instance $4329 r0 *1 127.3,96.6
X$4329 7500 7498 77 109 7094 NOR2_X2
* cell instance $4331 r0 *1 128.44,96.6
X$4331 7498 6698 77 109 7608 NOR2_X2
* cell instance $4332 r0 *1 129.39,96.6
X$4332 7454 7092 7347 6469 5475 5476 77 109 7610 OAI33_X1
* cell instance $4333 r0 *1 130.72,96.6
X$4333 77 7610 7608 7790 7220 7653 109 AOI22_X4
* cell instance $4335 r0 *1 134.14,96.6
X$4335 7454 7349 7793 77 109 NOR2_X4
* cell instance $4339 r0 *1 137.18,96.6
X$4339 7096 109 7502 77 BUF_X4
* cell instance $4340 r0 *1 138.51,96.6
X$4340 7441 7750 77 109 7599 NOR2_X1
* cell instance $4341 m0 *1 140.22,96.6
X$4341 7351 7350 77 109 7356 NAND2_X1
* cell instance $4342 m0 *1 138.89,96.6
X$4342 7221 109 7357 77 BUF_X4
* cell instance $4343 m0 *1 140.79,96.6
X$4343 7351 7350 7226 77 109 7455 NAND3_X1
* cell instance $4344 m0 *1 141.55,96.6
X$4344 7353 7100 7354 77 109 7355 MUX2_X1
* cell instance $4347 m0 *1 143.83,96.6
X$4347 7355 7097 7356 77 109 7453 MUX2_X1
* cell instance $4349 m0 *1 145.35,96.6
X$4349 7358 7222 7355 7357 7049 7452 77 109 OAI221_X2
* cell instance $4351 m0 *1 147.63,96.6
X$4351 7359 6914 7443 77 109 7508 MUX2_X1
* cell instance $4353 m0 *1 149.15,96.6
X$4353 7368 7232 6930 77 109 7359 MUX2_X1
* cell instance $4354 m0 *1 150.48,96.6
X$4354 7359 6923 7366 77 109 7503 MUX2_X1
* cell instance $4356 m0 *1 152,96.6
X$4356 7360 6914 7361 77 109 7353 MUX2_X1
* cell instance $4358 m0 *1 154.85,96.6
X$4358 6923 7364 77 109 7596 OR2_X1
* cell instance $4359 m0 *1 155.61,96.6
X$4359 7361 6920 7364 77 109 7365 MUX2_X1
* cell instance $4361 m0 *1 157.13,96.6
X$4361 7364 6920 7512 77 109 7352 MUX2_X1
* cell instance $4362 m0 *1 158.46,96.6
X$4362 6398 7232 7285 77 109 7364 MUX2_X1
* cell instance $4363 m0 *1 159.79,96.6
X$4363 7367 6602 7442 109 77 7444 OAI21_X2
* cell instance $4367 r0 *1 139.84,96.6
X$4367 6913 6915 7503 109 7796 77 OAI21_X1
* cell instance $4368 r0 *1 140.6,96.6
X$4368 7503 7305 7504 77 109 7350 NAND3_X1
* cell instance $4369 r0 *1 141.36,96.6
X$4369 7504 7305 7352 109 77 7655 AND3_X1
* cell instance $4373 r0 *1 143.64,96.6
X$4373 7504 7050 7505 109 77 7743 AND3_X1
* cell instance $4374 r0 *1 144.59,96.6
X$4374 7502 7355 7455 109 7506 77 OAI21_X1
* cell instance $4376 r0 *1 145.54,96.6
X$4376 7357 5552 77 109 7358 NAND2_X1
* cell instance $4377 r0 *1 146.11,96.6
X$4377 7099 77 109 7504 BUF_X2
* cell instance $4378 r0 *1 146.87,96.6
X$4378 7604 7504 7305 77 7048 109 AOI21_X2
* cell instance $4379 r0 *1 148.2,96.6
X$4379 7099 7050 7508 109 77 7509 AND3_X1
* cell instance $4380 r0 *1 149.15,96.6
X$4380 6913 6915 7508 109 7733 77 OAI21_X1
* cell instance $4381 r0 *1 149.91,96.6
X$4381 7509 7221 7100 7510 7741 109 77 AOI211_X2
* cell instance $4384 r0 *1 153.52,96.6
X$4384 7509 7159 7510 77 7883 109 AOI21_X1
* cell instance $4385 r0 *1 154.28,96.6
X$4385 6920 7361 7596 109 7511 77 OAI21_X1
* cell instance $4388 r0 *1 155.99,96.6
X$4388 7365 7310 7510 77 109 7661 MUX2_X1
* cell instance $4390 r0 *1 157.51,96.6
X$4390 7512 6920 7366 77 109 7510 MUX2_X1
* cell instance $4393 r0 *1 159.41,96.6
X$4393 7368 7516 6930 77 109 7513 MUX2_X1
* cell instance $4395 r0 *1 160.93,96.6
X$4395 7515 6920 7513 77 109 7514 MUX2_X1
* cell instance $4396 r0 *1 162.26,96.6
X$4396 7515 6923 7593 77 109 7505 MUX2_X1
* cell instance $4397 m0 *1 163.21,96.6
X$4397 7369 7232 7517 77 109 7443 MUX2_X1
* cell instance $4400 r0 *1 163.59,96.6
X$4400 7369 7516 7517 77 109 7515 MUX2_X1
* cell instance $4401 m0 *1 165.11,96.6
X$4401 3154 77 109 7442 INV_X1
* cell instance $4404 r0 *1 164.92,96.6
X$4404 7518 7516 7519 77 109 7593 MUX2_X1
* cell instance $4405 m0 *1 166.06,96.6
X$4405 2747 6755 77 109 7441 NOR2_X1
* cell instance $4407 m0 *1 166.63,96.6
X$4407 7232 109 6926 77 BUF_X4
* cell instance $4408 m0 *1 167.96,96.6
X$4408 7235 7232 7370 77 109 7366 MUX2_X1
* cell instance $4409 m0 *1 169.29,96.6
X$4409 77 494 7435 7369 3154 109 AOI21_X4
* cell instance $4411 r0 *1 166.25,96.6
X$4411 7520 7232 7521 77 109 7512 MUX2_X1
* cell instance $4413 r0 *1 167.96,96.6
X$4413 7235 7516 7370 77 109 7522 MUX2_X1
* cell instance $4416 r0 *1 170.43,96.6
X$4416 7112 6926 7586 77 109 7523 MUX2_X1
* cell instance $4421 m0 *1 173.47,96.6
X$4421 7434 6200 77 109 7435 NOR2_X1
* cell instance $4422 m0 *1 172.14,96.6
X$4422 6764 7369 6604 77 109 7434 MUX2_X1
* cell instance $4424 m0 *1 174.8,96.6
X$4424 7235 77 109 7371 INV_X2
* cell instance $4425 m0 *1 175.37,96.6
X$4425 6764 7518 6931 77 109 7429 MUX2_X1
* cell instance $4426 m0 *1 176.7,96.6
X$4426 77 6659 7429 2747 1658 7524 109 OAI22_X4
* cell instance $4427 m0 *1 179.93,96.6
X$4427 7114 77 109 7285 INV_X2
* cell instance $4428 m0 *1 180.5,96.6
X$4428 6761 77 109 6931 CLKBUF_X2
* cell instance $4429 m0 *1 181.26,96.6
X$4429 7372 109 405 77 BUF_X4
* cell instance $4431 m0 *1 182.78,96.6
X$4431 7667 77 109 6933 INV_X1
* cell instance $4434 r0 *1 173.28,96.6
X$4434 7370 77 109 7237 INV_X2
* cell instance $4436 r0 *1 174.04,96.6
X$4436 7524 77 109 7518 INV_X2
* cell instance $4437 r0 *1 174.61,96.6
X$4437 77 685 7588 7519 2387 109 AOI21_X4
* cell instance $4439 r0 *1 177.27,96.6
X$4439 6931 7664 6764 77 109 7714 MUX2_X1
* cell instance $4440 r0 *1 178.6,96.6
X$4440 6931 7586 6764 77 109 7713 MUX2_X1
* cell instance $4441 r0 *1 179.93,96.6
X$4441 6764 7368 6931 77 109 7584 MUX2_X1
* cell instance $4442 r0 *1 181.26,96.6
X$4442 7525 6659 77 109 7811 NOR2_X1
* cell instance $4445 r0 *1 182.4,96.6
X$4445 7666 7368 2920 77 7526 109 AOI21_X2
* cell instance $4446 r0 *1 183.73,96.6
X$4446 7526 109 554 77 BUF_X4
* cell instance $4447 m0 *1 184.49,96.6
X$4447 7668 77 109 7373 INV_X1
* cell instance $4449 m0 *1 184.87,96.6
X$4449 6937 6556 5492 7527 6485 7376 77 109 OAI221_X2
* cell instance $4450 m0 *1 186.96,96.6
X$4450 7583 5492 6936 6937 4033 109 77 7378 OAI221_X1
* cell instance $4453 r0 *1 185.06,96.6
X$4453 7813 5492 6485 6937 3759 109 77 7418 OAI221_X1
* cell instance $4454 r0 *1 186.2,96.6
X$4454 7528 77 109 7527 INV_X1
* cell instance $4456 r0 *1 186.77,96.6
X$4456 7815 77 109 7583 INV_X1
* cell instance $4457 r0 *1 187.15,96.6
X$4457 7669 109 788 77 BUF_X4
* cell instance $4458 r0 *1 188.48,96.6
X$4458 6937 3744 5492 8444 6485 7572 77 109 OAI221_X2
* cell instance $4460 m0 *1 189.24,96.6
X$4460 7422 77 109 7420 INV_X1
* cell instance $4461 m0 *1 190.19,96.6
X$4461 7374 7418 6941 6382 77 109 6940 NAND4_X1
* cell instance $4463 m0 *1 191.14,96.6
X$4463 7377 6941 6382 7276 77 3351 109 NAND4_X2
* cell instance $4464 m0 *1 192.85,96.6
X$4464 7378 7416 6941 6382 77 109 6812 NAND4_X1
* cell instance $4465 m0 *1 193.8,96.6
X$4465 7415 6941 7379 7376 77 4161 109 NAND4_X2
* cell instance $4467 m0 *1 195.7,96.6
X$4467 7414 5621 7379 77 109 4021 NAND3_X1
* cell instance $4471 r0 *1 191.71,96.6
X$4471 1398 6770 7529 109 3453 77 OAI21_X1
* cell instance $4472 r0 *1 192.47,96.6
X$4472 7578 5621 7379 77 109 7529 NAND3_X1
* cell instance $4473 r0 *1 193.23,96.6
X$4473 7575 5621 7379 77 109 2510 NAND3_X1
* cell instance $4474 r0 *1 193.99,96.6
X$4474 5524 77 109 7379 CLKBUF_X3
* cell instance $4475 r0 *1 194.94,96.6
X$4475 7705 5621 7379 7572 77 4438 109 NAND4_X2
* cell instance $4476 r0 *1 196.65,96.6
X$4476 7530 5621 7379 77 109 3745 NAND3_X1
* cell instance $4478 m0 *1 196.84,96.6
X$4478 4832 77 109 6770 CLKBUF_X3
* cell instance $4479 r0 *1 197.41,96.6
X$4479 7571 5621 7379 77 109 3140 NAND3_X1
* cell instance $4480 m0 *1 198.36,96.6
X$4480 1330 6770 7381 109 3730 77 OAI21_X1
* cell instance $4484 r0 *1 198.55,96.6
X$4484 7567 5621 7379 77 109 7381 NAND3_X1
* cell instance $4485 r0 *1 199.31,96.6
X$4485 7531 5621 7379 77 109 7566 NAND3_X1
* cell instance $4486 m0 *1 199.69,96.6
X$4486 7411 5621 7379 77 109 7382 NAND3_X1
* cell instance $4489 r0 *1 200.07,96.6
X$4489 7566 578 6770 109 77 2701 OAI21_X2
* cell instance $4490 m0 *1 201.02,96.6
X$4490 7372 6239 7407 6368 7384 77 109 7383 AOI221_X1
* cell instance $4492 m0 *1 202.16,96.6
X$4492 3724 77 109 7384 INV_X1
* cell instance $4495 m0 *1 203.49,96.6
X$4495 7405 5631 7532 109 7406 77 OAI21_X1
* cell instance $4496 m0 *1 204.25,96.6
X$4496 6817 77 109 6642 CLKBUF_X3
* cell instance $4497 m0 *1 205.2,96.6
X$4497 77 6642 7406 3676 18906 2886 109 DFFR_X2
* cell instance $4501 m0 *1 211.85,96.6
X$4501 6778 4832 7244 6492 77 109 7243 AOI22_X1
* cell instance $4504 m0 *1 214.51,96.6
X$4504 5499 77 109 7385 INV_X1
* cell instance $4508 r0 *1 203.3,96.6
X$4508 6336 7675 788 6239 77 109 7532 AOI22_X1
* cell instance $4511 r0 *1 205.39,96.6
X$4511 6336 7820 1084 6239 77 109 7559 AOI22_X1
* cell instance $4513 r0 *1 206.72,96.6
X$4513 6336 7533 471 6239 77 109 7562 AOI22_X1
* cell instance $4515 r0 *1 208.05,96.6
X$4515 7560 5631 7562 109 7702 77 OAI21_X1
* cell instance $4517 r0 *1 209,96.6
X$4517 6336 7991 554 6239 77 109 7558 AOI22_X1
* cell instance $4520 r0 *1 211.09,96.6
X$4520 2999 77 109 7560 INV_X1
* cell instance $4521 r0 *1 211.47,96.6
X$4521 5776 7534 77 109 7266 NOR2_X1
* cell instance $4523 r0 *1 212.42,96.6
X$4523 7385 5631 7559 109 7676 77 OAI21_X1
* cell instance $4524 r0 *1 213.18,96.6
X$4524 7556 5631 7558 109 7555 77 OAI21_X1
* cell instance $4525 r0 *1 213.94,96.6
X$4525 3125 77 109 7556 INV_X1
* cell instance $4526 r0 *1 214.32,96.6
X$4526 77 6946 7555 3676 19026 3125 109 DFFR_X2
* cell instance $4527 m0 *1 215.46,96.6
X$4527 6952 77 109 6946 CLKBUF_X3
* cell instance $4529 m0 *1 216.41,96.6
X$4529 6946 77 109 19197 CLKBUF_X1
* cell instance $4532 m0 *1 218.31,96.6
X$4532 3125 6209 3996 6340 77 109 7402 AOI22_X1
* cell instance $4537 m0 *1 221.73,96.6
X$4537 4963 5392 7402 109 7386 77 OAI21_X1
* cell instance $4538 m0 *1 222.49,96.6
X$4538 77 6500 4715 7400 7548 992 109 DFFR_X1
* cell instance $4539 m0 *1 226.29,96.6
X$4539 4960 7400 77 109 7388 NAND2_X1
* cell instance $4540 m0 *1 226.86,96.6
X$4540 77 6500 5381 7249 7398 992 109 DFFR_X1
* cell instance $4541 m0 *1 230.66,96.6
X$4541 5524 5381 5773 77 109 7389 NAND3_X1
* cell instance $4545 r0 *1 218.69,96.6
X$4545 554 4691 7552 77 109 7553 MUX2_X1
* cell instance $4547 r0 *1 220.21,96.6
X$4547 7535 4951 7553 77 109 7696 MUX2_X1
* cell instance $4549 r0 *1 221.92,96.6
X$4549 7386 7535 7387 77 7551 109 AOI21_X1
* cell instance $4552 r0 *1 224.39,96.6
X$4552 7549 4951 7536 77 109 7548 MUX2_X1
* cell instance $4553 r0 *1 225.72,96.6
X$4553 405 5233 7388 109 7536 77 OAI21_X1
* cell instance $4559 r0 *1 227.62,96.6
X$4559 7544 4837 7547 77 109 7398 MUX2_X1
* cell instance $4562 r0 *1 229.9,96.6
X$4562 7249 5271 6202 77 109 7545 OR3_X1
* cell instance $4563 r0 *1 230.85,96.6
X$4563 7545 7389 6067 77 109 7546 NAND3_X1
* cell instance $4566 r0 *1 232.18,96.6
X$4566 578 5259 7542 109 7541 77 OAI21_X1
* cell instance $4567 m0 *1 233.32,96.6
X$4567 77 6210 6623 7391 7390 992 109 DFFR_X1
* cell instance $4568 m0 *1 232.56,96.6
X$4568 578 5233 7392 109 7393 77 OAI21_X1
* cell instance $4569 m0 *1 237.12,96.6
X$4569 4960 7391 77 109 7392 NAND2_X1
* cell instance $4572 r0 *1 232.94,96.6
X$4572 7688 4837 7393 77 109 7390 MUX2_X1
* cell instance $4574 r0 *1 234.46,96.6
X$4574 6792 5509 7541 77 109 7537 MUX2_X1
* cell instance $4575 r0 *1 235.79,96.6
X$4575 77 6210 18870 6792 7537 992 109 DFFR_X1
* cell instance $4581 m0 *1 3.61,127.4
X$4581 9961 77 109 9790 CLKBUF_X3
* cell instance $4584 m0 *1 5.51,127.4
X$4584 10199 5167 9546 77 109 10031 MUX2_X1
* cell instance $4588 r0 *1 1.33,127.4
X$4588 77 9790 10351 10270 10349 4909 109 DFFR_X1
* cell instance $4592 r0 *1 5.13,127.4
X$4592 77 9790 10504 10271 10348 4909 109 DFFR_X1
* cell instance $4593 r0 *1 8.93,127.4
X$4593 10271 5301 10425 77 109 10348 MUX2_X1
* cell instance $4594 m0 *1 10.45,127.4
X$4594 77 9956 9960 10126 10201 4909 109 DFFR_X1
* cell instance $4596 m0 *1 14.25,127.4
X$4596 10126 2400 9546 77 109 10201 MUX2_X1
* cell instance $4599 m0 *1 17.29,127.4
X$4599 2459 109 10508 77 BUF_X4
* cell instance $4600 m0 *1 18.62,127.4
X$4600 10127 3048 9959 77 109 10128 MUX2_X1
* cell instance $4601 m0 *1 19.95,127.4
X$4601 10128 7156 10202 77 109 10205 MUX2_X1
* cell instance $4602 m0 *1 21.28,127.4
X$4602 10200 109 10129 77 BUF_X4
* cell instance $4607 r0 *1 13.49,127.4
X$4607 10356 2459 9546 77 109 10353 MUX2_X1
* cell instance $4608 r0 *1 14.82,127.4
X$4608 77 9956 10127 10356 10353 4909 109 DFFR_X1
* cell instance $4611 r0 *1 19.19,127.4
X$4611 77 9957 10432 10358 10355 4909 109 DFFR_X1
* cell instance $4614 r0 *1 23.56,127.4
X$4614 10358 2631 10429 77 109 10355 MUX2_X1
* cell instance $4615 m0 *1 27.55,127.4
X$4615 10360 5020 9473 77 109 10272 MUX2_X1
* cell instance $4616 m0 *1 23.75,127.4
X$4616 77 9957 10130 10359 10206 4909 109 DFFR_X1
* cell instance $4619 m0 *1 30.59,127.4
X$4619 10130 10129 10210 77 109 10208 MUX2_X1
* cell instance $4620 m0 *1 31.92,127.4
X$4620 10130 4287 10210 77 109 9797 MUX2_X1
* cell instance $4622 m0 *1 34.01,127.4
X$4622 6883 109 10131 77 BUF_X4
* cell instance $4626 m0 *1 40.09,127.4
X$4626 10213 8670 77 109 10276 NOR2_X1
* cell instance $4627 m0 *1 40.66,127.4
X$4627 10215 10369 6294 77 109 9100 NOR3_X1
* cell instance $4628 m0 *1 41.42,127.4
X$4628 7403 109 6389 77 BUF_X4
* cell instance $4629 m0 *1 42.75,127.4
X$4629 10277 10217 5017 77 109 10369 NOR3_X1
* cell instance $4630 m0 *1 43.51,127.4
X$4630 3861 109 9812 77 BUF_X4
* cell instance $4632 m0 *1 45.03,127.4
X$4632 10132 6890 10221 109 10371 77 OAI21_X1
* cell instance $4634 m0 *1 45.98,127.4
X$4634 7160 10134 77 109 10221 NAND2_X1
* cell instance $4638 m0 *1 49.02,127.4
X$4638 9972 6890 10135 109 10372 77 OAI21_X1
* cell instance $4639 m0 *1 49.78,127.4
X$4639 7160 10373 77 109 10135 NAND2_X1
* cell instance $4644 r0 *1 25.84,127.4
X$4644 10359 5110 9546 77 109 10206 MUX2_X1
* cell instance $4646 r0 *1 27.93,127.4
X$4646 77 9968 10210 10360 10272 4909 109 DFFR_X1
* cell instance $4649 r0 *1 32.68,127.4
X$4649 10674 77 109 9968 CLKBUF_X3
* cell instance $4652 r0 *1 34.2,127.4
X$4652 10362 5020 8051 77 109 10364 MUX2_X1
* cell instance $4653 r0 *1 35.53,127.4
X$4653 77 9968 10434 10362 10364 4909 109 DFFR_X1
* cell instance $4656 r0 *1 39.9,127.4
X$4656 10274 6902 77 109 10275 NOR2_X1
* cell instance $4657 r0 *1 40.47,127.4
X$4657 10275 10276 10368 77 109 10370 NOR3_X1
* cell instance $4658 r0 *1 41.23,127.4
X$4658 10691 10370 6742 77 109 10366 NOR3_X1
* cell instance $4659 r0 *1 41.99,127.4
X$4659 10522 7020 77 109 10277 NOR2_X1
* cell instance $4660 r0 *1 42.56,127.4
X$4660 77 10279 10278 10134 10371 1663 109 DFFR_X1
* cell instance $4662 r0 *1 46.55,127.4
X$4662 77 10279 10964 10373 10372 1663 109 DFFR_X1
* cell instance $4664 r0 *1 50.54,127.4
X$4664 77 10279 10281 10137 10374 1663 109 DFFR_X1
* cell instance $4666 m0 *1 52.25,127.4
X$4666 5314 7765 10224 109 10374 77 OAI21_X1
* cell instance $4667 m0 *1 53.58,127.4
X$4667 7878 10137 77 109 10224 NAND2_X1
* cell instance $4671 m0 *1 55.1,127.4
X$4671 9807 10138 10063 77 109 10381 MUX2_X1
* cell instance $4672 m0 *1 56.43,127.4
X$4672 10281 10138 10139 77 109 10377 MUX2_X1
* cell instance $4674 m0 *1 59.28,127.4
X$4674 9582 10138 6824 77 109 10284 MUX2_X1
* cell instance $4678 r0 *1 54.53,127.4
X$4678 5314 7767 10280 109 10438 77 OAI21_X1
* cell instance $4680 r0 *1 55.48,127.4
X$4680 7922 10376 77 109 10280 NAND2_X1
* cell instance $4682 r0 *1 56.24,127.4
X$4682 10281 9812 10139 77 109 10380 MUX2_X1
* cell instance $4684 r0 *1 57.95,127.4
X$4684 10380 5513 77 109 10282 NOR2_X1
* cell instance $4686 r0 *1 58.71,127.4
X$4686 10377 10283 10381 77 109 10383 MUX2_X1
* cell instance $4690 r0 *1 60.04,127.4
X$4690 10284 10283 10285 77 109 10385 MUX2_X1
* cell instance $4691 r0 *1 61.37,127.4
X$4691 10383 10368 10385 77 109 10384 MUX2_X1
* cell instance $4692 m0 *1 61.94,127.4
X$4692 10143 10440 10144 77 109 10285 MUX2_X1
* cell instance $4694 m0 *1 63.27,127.4
X$4694 9582 10142 6824 77 109 10286 MUX2_X1
* cell instance $4695 m0 *1 64.6,127.4
X$4695 10143 10142 10144 77 109 10227 MUX2_X1
* cell instance $4696 m0 *1 65.93,127.4
X$4696 10227 7020 77 109 10388 NOR2_X1
* cell instance $4699 m0 *1 69.73,127.4
X$4699 77 10442 10235 10233 10391 9814 109 DFFR_X1
* cell instance $4700 m0 *1 73.53,127.4
X$4700 9440 77 109 9763 CLKBUF_X3
* cell instance $4701 m0 *1 74.48,127.4
X$4701 77 9763 10290 10234 10232 4086 109 DFFR_X1
* cell instance $4703 r0 *1 62.7,127.4
X$4703 10384 6997 77 109 10141 NOR2_X1
* cell instance $4705 r0 *1 64.79,127.4
X$4705 10286 5461 77 109 10287 NOR2_X1
* cell instance $4706 r0 *1 65.36,127.4
X$4706 10388 10287 8858 77 109 10145 NOR3_X1
* cell instance $4708 r0 *1 66.31,127.4
X$4708 9813 4639 10441 109 10387 77 OAI21_X1
* cell instance $4709 r0 *1 67.07,127.4
X$4709 10132 3794 10389 109 10288 77 OAI21_X1
* cell instance $4712 r0 *1 68.78,127.4
X$4712 77 10200 109 9023 BUF_X8
* cell instance $4713 r0 *1 71.25,127.4
X$4713 3709 10392 77 109 10389 NAND2_X1
* cell instance $4716 r0 *1 72.96,127.4
X$4716 10146 9492 9632 77 10391 109 AOI21_X1
* cell instance $4717 r0 *1 73.72,127.4
X$4717 10235 3861 9981 77 109 10289 MUX2_X1
* cell instance $4718 r0 *1 75.05,127.4
X$4718 10289 7292 77 109 10537 NOR2_X1
* cell instance $4720 m0 *1 79.99,127.4
X$4720 10147 10149 10148 77 109 10243 MUX2_X1
* cell instance $4721 m0 *1 78.66,127.4
X$4721 9981 7495 10290 77 109 10148 MUX2_X1
* cell instance $4723 m0 *1 82.08,127.4
X$4723 77 9924 9820 10241 10237 8687 109 DFFR_X1
* cell instance $4724 m0 *1 85.88,127.4
X$4724 9985 10241 77 109 10239 NOR2_X1
* cell instance $4727 m0 *1 87.4,127.4
X$4727 10244 9492 9503 77 10291 109 AOI21_X1
* cell instance $4730 m0 *1 89.11,127.4
X$4730 9503 10150 77 109 10244 NOR2_X1
* cell instance $4733 r0 *1 79.42,127.4
X$4733 9983 3603 10290 77 109 10395 MUX2_X1
* cell instance $4738 r0 *1 86.45,127.4
X$4738 77 9924 10397 10150 10291 8687 109 DFFR_X1
* cell instance $4739 m0 *1 90.25,127.4
X$4739 10292 8068 10397 77 109 10247 MUX2_X1
* cell instance $4741 m0 *1 91.58,127.4
X$4741 10247 8069 77 109 10151 NOR2_X1
* cell instance $4742 m0 *1 92.15,127.4
X$4742 10151 9826 8250 77 109 10153 NOR3_X1
* cell instance $4744 m0 *1 93.1,127.4
X$4744 10250 10152 6474 77 109 NOR2_X4
* cell instance $4748 m0 *1 97.28,127.4
X$4748 9986 77 109 19139 INV_X1
* cell instance $4749 m0 *1 97.66,127.4
X$4749 10251 9152 10157 77 109 10252 MUX2_X1
* cell instance $4750 m0 *1 98.99,127.4
X$4750 77 9986 10156 10251 10252 8201 109 DFFR_X1
* cell instance $4753 m0 *1 103.74,127.4
X$4753 10156 9831 10296 77 109 10256 MUX2_X1
* cell instance $4754 m0 *1 105.07,127.4
X$4754 10257 8689 10256 77 109 10297 MUX2_X1
* cell instance $4756 m0 *1 107.16,127.4
X$4756 6554 77 109 10157 BUF_X2
* cell instance $4758 m0 *1 108.68,127.4
X$4758 10261 9832 9989 77 109 10158 MUX2_X1
* cell instance $4759 m0 *1 110.01,127.4
X$4759 77 9833 10409 10261 10158 8201 109 DFFR_X1
* cell instance $4761 r0 *1 90.25,127.4
X$4761 10292 3603 10397 77 109 10399 MUX2_X1
* cell instance $4762 r0 *1 91.58,127.4
X$4762 10099 3978 10399 77 109 10401 MUX2_X1
* cell instance $4763 r0 *1 92.91,127.4
X$4763 77 9986 10293 10294 10403 8687 109 DFFR_X1
* cell instance $4764 r0 *1 96.71,127.4
X$4764 10294 6524 10157 77 109 10403 MUX2_X1
* cell instance $4767 r0 *1 98.99,127.4
X$4767 77 10273 5848 10410 5594 109 AOI21_X4
* cell instance $4768 r0 *1 101.46,127.4
X$4768 77 10605 10296 10407 10295 8201 109 DFFR_X1
* cell instance $4773 r0 *1 110.77,127.4
X$4773 9341 77 109 9833 CLKBUF_X3
* cell instance $4777 r0 *1 113.05,127.4
X$4777 10409 9895 10266 77 109 10411 MUX2_X1
* cell instance $4778 m0 *1 114.38,127.4
X$4778 77 9833 10266 10122 10264 4086 109 DFFR_X1
* cell instance $4781 r0 *1 114.38,127.4
X$4781 7202 6389 10411 77 10298 109 AOI21_X1
* cell instance $4786 r0 *1 115.33,127.4
X$4786 10409 10299 10262 77 109 10300 MUX2_X1
* cell instance $4787 r0 *1 116.66,127.4
X$4787 10262 5275 10159 77 109 10413 MUX2_X1
* cell instance $4789 m0 *1 118.75,127.4
X$4789 77 8692 10159 10414 10267 4086 109 DFFR_X1
* cell instance $4792 m0 *1 124.07,127.4
X$4792 10269 10160 9042 109 77 10197 MUX2_X2
* cell instance $4795 r0 *1 118.94,127.4
X$4795 9989 7279 10414 77 109 10267 MUX2_X1
* cell instance $4800 r0 *1 123.5,127.4
X$4800 5002 5330 10269 109 77 10735 HA_X1
* cell instance $4802 m0 *1 126.92,127.4
X$4802 9992 9508 9509 109 77 10416 AND3_X1
* cell instance $4803 m0 *1 126.16,127.4
X$4803 9044 9508 9506 77 109 10301 NOR3_X1
* cell instance $4804 m0 *1 127.87,127.4
X$4804 9505 9508 9675 109 77 10417 AND3_X1
* cell instance $4807 r0 *1 126.35,127.4
X$4807 10416 10301 8829 109 77 10302 MUX2_X2
* cell instance $4808 r0 *1 128.06,127.4
X$4808 10417 10303 8829 109 77 9994 MUX2_X2
* cell instance $4810 m0 *1 129.2,127.4
X$4810 9505 77 109 9992 INV_X2
* cell instance $4811 m0 *1 129.96,127.4
X$4811 9839 10268 9506 10265 77 109 10259 AOI22_X1
* cell instance $4812 m0 *1 130.91,127.4
X$4812 9838 9512 77 109 10263 NOR2_X1
* cell instance $4813 m0 *1 131.48,127.4
X$4813 9996 9510 77 109 9998 NAND2_X1
* cell instance $4814 m0 *1 132.05,127.4
X$4814 9997 10265 9045 9001 109 77 10260 OAI22_X1
* cell instance $4816 m0 *1 133.19,127.4
X$4816 9675 9512 10161 77 109 10421 NAND3_X1
* cell instance $4818 m0 *1 134.14,127.4
X$4818 8879 10259 77 109 10254 OR2_X1
* cell instance $4819 m0 *1 134.9,127.4
X$4819 8879 9512 77 109 10163 NOR2_X2
* cell instance $4821 m0 *1 136.04,127.4
X$4821 10161 9045 9511 77 109 10164 MUX2_X1
* cell instance $4822 m0 *1 137.37,127.4
X$4822 9839 10255 10305 109 10162 77 OAI21_X1
* cell instance $4823 m0 *1 138.13,127.4
X$4823 10163 10164 109 77 10314 AND2_X2
* cell instance $4824 m0 *1 139.08,127.4
X$4824 10164 10163 77 10166 109 NAND2_X4
* cell instance $4827 r0 *1 129.96,127.4
X$4827 9506 77 109 10304 INV_X1
* cell instance $4828 r0 *1 130.34,127.4
X$4828 9992 8829 10304 77 109 10572 MUX2_X1
* cell instance $4829 r0 *1 131.67,127.4
X$4829 9505 77 109 10161 BUF_X2
* cell instance $4830 r0 *1 132.43,127.4
X$4830 9841 9675 9998 109 77 10420 AND3_X1
* cell instance $4831 r0 *1 133.38,127.4
X$4831 9673 9841 10304 77 109 10419 NOR3_X1
* cell instance $4832 r0 *1 134.14,127.4
X$4832 10419 10420 9045 109 10422 77 OAI21_X1
* cell instance $4833 r0 *1 134.9,127.4
X$4833 9001 9045 9673 109 10423 77 NOR3_X2
* cell instance $4834 r0 *1 136.23,127.4
X$4834 9045 10421 10422 109 10569 77 OAI21_X1
* cell instance $4835 r0 *1 136.99,127.4
X$4835 10162 10163 77 109 10306 NAND2_X2
* cell instance $4836 r0 *1 137.94,127.4
X$4836 10307 10567 10424 77 10308 109 AOI21_X1
* cell instance $4838 r0 *1 138.89,127.4
X$4838 8733 10165 109 77 10309 AND2_X1
* cell instance $4839 r0 *1 139.65,127.4
X$4839 10308 10309 77 109 8997 OR2_X1
* cell instance $4842 m0 *1 141.17,127.4
X$4842 7169 77 109 10313 BUF_X2
* cell instance $4848 m0 *1 3.8,102.2
X$4848 2932 6280 7910 77 109 7978 MUX2_X1
* cell instance $4851 r0 *1 1.33,102.2
X$4851 77 7914 7911 7910 7978 4909 109 DFFR_X1
* cell instance $4857 m0 *1 50.35,113.4
X$4857 8949 8847 6244 77 109 9109 MUX2_X1
* cell instance $4859 m0 *1 53.39,113.4
X$4859 77 8676 8849 8850 8953 1663 109 DFFR_X1
* cell instance $4862 r0 *1 50.35,113.4
X$4862 8405 6083 9015 77 109 9014 MUX2_X1
* cell instance $4863 r0 *1 51.68,113.4
X$4863 8405 8847 9015 77 109 9016 MUX2_X1
* cell instance $4866 r0 *1 54.72,113.4
X$4866 6988 9271 77 109 9017 NAND2_X1
* cell instance $4867 r0 *1 55.29,113.4
X$4867 9017 6730 4907 109 77 9274 OAI21_X4
* cell instance $4868 r0 *1 57.76,113.4
X$4868 8849 8666 9185 77 109 8852 MUX2_X1
* cell instance $4870 m0 *1 58.33,113.4
X$4870 8852 6902 77 109 8851 NOR2_X1
* cell instance $4871 m0 *1 60.42,113.4
X$4871 77 8855 9018 8854 8956 1663 109 DFFR_X1
* cell instance $4872 m0 *1 64.22,113.4
X$4872 77 8855 9117 8857 9116 1663 109 DFFR_X1
* cell instance $4873 m0 *1 68.02,113.4
X$4873 7084 3793 8856 109 9116 77 OAI21_X1
* cell instance $4874 m0 *1 68.78,113.4
X$4874 7084 8857 77 109 8856 NAND2_X1
* cell instance $4880 r0 *1 59.47,113.4
X$4880 9018 8535 8853 77 109 9114 MUX2_X1
* cell instance $4881 r0 *1 60.8,113.4
X$4881 9018 8666 8853 77 109 9278 MUX2_X1
* cell instance $4884 r0 *1 65.36,113.4
X$4884 5132 77 109 9019 INV_X1
* cell instance $4886 r0 *1 66.12,113.4
X$4886 9187 8463 9117 77 9119 109 AOI21_X1
* cell instance $4888 r0 *1 67.26,113.4
X$4888 9120 8229 77 109 9187 NOR2_X1
* cell instance $4890 r0 *1 68.02,113.4
X$4890 3793 7775 9021 109 9288 77 OAI21_X1
* cell instance $4891 r0 *1 68.78,113.4
X$4891 7775 9120 77 109 9021 NAND2_X1
* cell instance $4893 m0 *1 69.92,113.4
X$4893 5962 77 109 8537 CLKBUF_X3
* cell instance $4895 m0 *1 70.87,113.4
X$4895 77 8537 8683 8792 8859 4086 109 DFFR_X1
* cell instance $4896 m0 *1 74.67,113.4
X$4896 77 9491 8797 8965 8860 4086 109 DFFR_X1
* cell instance $4897 m0 *1 78.47,113.4
X$4897 8967 77 109 8798 CLKBUF_X3
* cell instance $4898 m0 *1 79.42,113.4
X$4898 8862 8858 7292 77 109 9025 NAND3_X1
* cell instance $4899 m0 *1 80.18,113.4
X$4899 9025 5967 8868 8863 77 8969 109 NAND4_X2
* cell instance $4900 m0 *1 81.89,113.4
X$4900 8861 4789 8797 77 109 9131 MUX2_X1
* cell instance $4902 m0 *1 83.41,113.4
X$4902 8865 9132 9026 77 109 8807 NOR3_X1
* cell instance $4903 m0 *1 84.17,113.4
X$4903 77 9028 8975 9136 8866 4086 109 DFFR_X1
* cell instance $4904 m0 *1 87.97,113.4
X$4904 3569 5740 8975 77 109 9138 MUX2_X1
* cell instance $4906 r0 *1 70.87,113.4
X$4906 6988 77 109 6730 CLKBUF_X3
* cell instance $4907 r0 *1 71.82,113.4
X$4907 77 8537 9022 9190 9290 4086 109 DFFR_X1
* cell instance $4909 r0 *1 76,113.4
X$4909 8861 4205 9022 77 109 9129 MUX2_X1
* cell instance $4911 r0 *1 77.71,113.4
X$4911 6452 109 9023 77 BUF_X4
* cell instance $4912 r0 *1 79.04,113.4
X$4912 9022 7447 9024 77 109 9133 MUX2_X1
* cell instance $4916 r0 *1 83.03,113.4
X$4916 9131 8993 9030 77 109 9132 NOR3_X1
* cell instance $4917 r0 *1 83.79,113.4
X$4917 9133 7590 77 109 9026 NOR2_X1
* cell instance $4921 r0 *1 85.69,113.4
X$4921 9137 9029 9027 77 8866 109 AOI21_X1
* cell instance $4923 r0 *1 86.64,113.4
X$4923 9027 9136 77 109 9137 NOR2_X1
* cell instance $4926 r0 *1 87.78,113.4
X$4926 8063 109 4632 77 BUF_X4
* cell instance $4927 r0 *1 89.11,113.4
X$4927 9138 3622 77 109 9194 NOR2_X1
* cell instance $4928 r0 *1 89.68,113.4
X$4928 8069 109 9030 77 BUF_X4
* cell instance $4929 m0 *1 89.87,113.4
X$4929 8063 8868 7006 77 109 NOR2_X4
* cell instance $4933 r0 *1 91.01,113.4
X$4933 7087 6174 77 109 9031 NAND2_X2
* cell instance $4934 r0 *1 91.96,113.4
X$4934 77 7936 109 8068 BUF_X8
* cell instance $4935 m0 *1 92.91,113.4
X$4935 77 6296 109 8868 BUF_X8
* cell instance $4940 r0 *1 94.62,113.4
X$4940 77 9028 9033 9306 9032 8687 109 DFFR_X1
* cell instance $4948 r0 *1 2.09,105
X$4948 8300 4843 5514 77 109 8298 MUX2_X1
* cell instance $4953 r0 *1 3.8,105
X$4953 77 7914 8452 8131 8215 4909 109 DFFR_X1
* cell instance $4955 m0 *1 3.99,105
X$4955 8131 5167 4770 77 109 8215 MUX2_X1
* cell instance $4956 m0 *1 5.51,105
X$4956 8130 6014 7979 77 109 8302 MUX2_X1
* cell instance $4958 m0 *1 7.03,105
X$4958 7914 77 109 19199 CLKBUF_X1
* cell instance $4959 m0 *1 7.6,105
X$4959 8050 8349 7913 77 109 8217 MUX2_X1
* cell instance $4960 m0 *1 8.93,105
X$4960 8132 4843 8051 77 109 8133 MUX2_X1
* cell instance $4961 m0 *1 10.26,105
X$4961 77 7914 8218 8132 8133 4909 109 DFFR_X1
* cell instance $4964 r0 *1 7.79,105
X$4964 8302 6704 8216 77 109 8314 MUX2_X1
* cell instance $4969 r0 *1 14.25,105
X$4969 8218 4138 8219 77 109 8454 MUX2_X1
* cell instance $4971 m0 *1 14.44,105
X$4971 7915 7760 7757 77 109 8220 MUX2_X1
* cell instance $4973 m0 *1 16.34,105
X$4973 77 7459 8055 8138 8054 4909 109 DFFR_X1
* cell instance $4976 m0 *1 20.33,105
X$4976 8055 8005 8056 77 109 8306 MUX2_X1
* cell instance $4977 m0 *1 21.66,105
X$4977 8055 6591 8056 77 109 8141 MUX2_X1
* cell instance $4978 m0 *1 22.99,105
X$4978 8306 7760 8223 77 109 8057 MUX2_X1
* cell instance $4979 m0 *1 24.32,105
X$4979 8141 5729 8142 77 109 7918 MUX2_X1
* cell instance $4980 m0 *1 25.65,105
X$4980 6883 109 8051 77 BUF_X4
* cell instance $4981 m0 *1 26.98,105
X$4981 8309 5110 4770 77 109 8145 MUX2_X1
* cell instance $4982 m0 *1 28.31,105
X$4982 77 7464 8225 8309 8145 4909 109 DFFR_X1
* cell instance $4986 r0 *1 16.91,105
X$4986 5444 7410 8456 77 109 8221 MUX2_X1
* cell instance $4988 r0 *1 18.62,105
X$4988 3445 77 109 7180 CLKBUF_X3
* cell instance $4989 r0 *1 19.57,105
X$4989 5444 7189 8307 77 109 8394 MUX2_X1
* cell instance $4991 r0 *1 21.66,105
X$4991 8222 6591 8395 77 109 8142 MUX2_X1
* cell instance $4992 r0 *1 22.99,105
X$4992 8222 7477 8395 77 109 8223 MUX2_X1
* cell instance $4996 r0 *1 26.79,105
X$4996 8310 7468 3484 77 109 8311 MUX2_X1
* cell instance $4997 r0 *1 28.12,105
X$4997 77 7464 8224 8310 8311 4909 109 DFFR_X1
* cell instance $4999 m0 *1 32.68,105
X$4999 77 7464 8155 8149 8148 4909 109 DFFR_X1
* cell instance $5002 m0 *1 37.24,105
X$5002 5174 7330 8158 77 109 8226 MUX2_X1
* cell instance $5007 r0 *1 35.15,105
X$5007 8314 7917 77 109 8315 NOR2_X1
* cell instance $5008 r0 *1 35.72,105
X$5008 8315 8318 7997 109 8396 77 NOR3_X2
* cell instance $5010 r0 *1 37.43,105
X$5010 77 6232 8227 8158 8226 4909 109 DFFR_X1
* cell instance $5011 r0 *1 41.23,105
X$5011 6968 8229 77 109 8401 NOR2_X1
* cell instance $5013 r0 *1 41.99,105
X$5013 6968 3041 77 109 8468 NOR2_X1
* cell instance $5015 m0 *1 43.7,105
X$5015 3445 77 109 6645 CLKBUF_X3
* cell instance $5016 m0 *1 42.75,105
X$5016 6645 77 109 19086 INV_X4
* cell instance $5017 m0 *1 44.65,105
X$5017 7178 109 7765 77 BUF_X4
* cell instance $5019 m0 *1 46.17,105
X$5019 7878 8059 77 109 8325 NAND2_X1
* cell instance $5021 m0 *1 46.93,105
X$5021 8060 7912 8230 77 109 8160 MUX2_X1
* cell instance $5023 m0 *1 48.45,105
X$5023 8160 3978 7475 77 109 8062 MUX2_X1
* cell instance $5025 m0 *1 49.97,105
X$5025 8062 3611 7188 77 109 8330 MUX2_X1
* cell instance $5027 m0 *1 51.49,105
X$5027 8163 7917 77 109 8234 NOR2_X1
* cell instance $5028 m0 *1 52.06,105
X$5028 7410 109 6972 77 BUF_X4
* cell instance $5029 m0 *1 53.39,105
X$5029 7178 109 8232 77 BUF_X4
* cell instance $5031 r0 *1 43.32,105
X$5031 77 7269 8060 8059 8324 4909 109 DFFR_X1
* cell instance $5032 r0 *1 47.12,105
X$5032 8060 6701 8230 77 109 8061 MUX2_X1
* cell instance $5036 r0 *1 50.54,105
X$5036 3793 6262 8231 109 8473 77 OAI21_X1
* cell instance $5038 r0 *1 51.68,105
X$5038 6720 8406 77 109 8231 NAND2_X1
* cell instance $5041 r0 *1 53.2,105
X$5041 7189 109 8235 77 BUF_X4
* cell instance $5042 r0 *1 54.53,105
X$5042 77 6978 8408 8332 8331 1663 109 DFFR_X1
* cell instance $5044 m0 *1 55.1,105
X$5044 7410 109 8166 77 BUF_X4
* cell instance $5045 m0 *1 57,105
X$5045 77 6978 8335 8064 8010 1663 109 DFFR_X1
* cell instance $5047 m0 *1 60.8,105
X$5047 77 8019 8337 8169 8013 1663 109 DFFR_X1
* cell instance $5049 r0 *1 58.33,105
X$5049 6988 8332 77 109 8475 NAND2_X1
* cell instance $5050 r0 *1 58.9,105
X$5050 77 8334 8233 4588 8152 109 AOI21_X4
* cell instance $5058 r0 *1 64.22,105
X$5058 77 8019 8489 8339 8338 1663 109 DFFR_X1
* cell instance $5059 m0 *1 65.17,105
X$5059 7196 3788 8171 109 8338 77 OAI21_X1
* cell instance $5063 m0 *1 66.88,105
X$5063 7084 8339 77 109 8171 NAND2_X1
* cell instance $5065 m0 *1 68.21,105
X$5065 5962 77 109 8019 CLKBUF_X3
* cell instance $5066 m0 *1 69.16,105
X$5066 8341 7196 6661 109 77 8340 OAI21_X4
* cell instance $5067 m0 *1 71.63,105
X$5067 7084 8236 77 109 8341 NAND2_X1
* cell instance $5068 m0 *1 72.2,105
X$5068 8344 7329 6538 109 77 8237 OAI21_X4
* cell instance $5069 m0 *1 74.67,105
X$5069 7775 8177 77 109 8344 NAND2_X1
* cell instance $5070 m0 *1 75.24,105
X$5070 6171 77 109 8346 INV_X1
* cell instance $5071 m0 *1 75.62,105
X$5071 8177 4205 77 109 8066 NOR2_X1
* cell instance $5072 m0 *1 76.19,105
X$5072 8066 8345 8065 77 8491 109 AOI21_X1
* cell instance $5074 m0 *1 77.14,105
X$5074 5135 4643 77 109 7928 NAND2_X1
* cell instance $5076 m0 *1 77.9,105
X$5076 5672 109 7876 77 BUF_X4
* cell instance $5077 m0 *1 79.23,105
X$5077 8352 8063 8179 77 109 8238 MUX2_X1
* cell instance $5079 r0 *1 68.02,105
X$5079 77 8019 8065 8236 8340 1663 109 DFFR_X1
* cell instance $5081 r0 *1 72.01,105
X$5081 77 8019 18763 8177 8237 1663 109 DFFR_X1
* cell instance $5083 r0 *1 76,105
X$5083 8347 77 109 3445 CLKBUF_X3
* cell instance $5084 r0 *1 76.95,105
X$5084 3906 109 8349 77 BUF_X4
* cell instance $5085 r0 *1 78.28,105
X$5085 8540 3906 8541 77 109 8352 MUX2_X1
* cell instance $5087 r0 *1 79.8,105
X$5087 8068 8065 109 77 8354 AND2_X1
* cell instance $5088 r0 *1 80.56,105
X$5088 8177 3500 77 109 8240 NOR2_X1
* cell instance $5089 m0 *1 81.51,105
X$5089 6837 8069 77 109 8184 NOR2_X1
* cell instance $5090 m0 *1 80.94,105
X$5090 8176 8239 77 109 8183 NOR2_X1
* cell instance $5092 r0 *1 81.13,105
X$5092 8354 8240 8069 77 109 8414 NOR3_X1
* cell instance $5093 r0 *1 81.89,105
X$5093 8351 8069 77 109 8356 NOR2_X1
* cell instance $5095 m0 *1 82.65,105
X$5095 8355 8183 8071 8244 8184 7078 77 109 8357 OAI33_X1
* cell instance $5098 r0 *1 82.65,105
X$5098 6171 6276 8359 77 109 8241 NOR3_X1
* cell instance $5099 r0 *1 83.41,105
X$5099 77 7205 8246 8242 8072 4086 109 DFFR_X1
* cell instance $5100 m0 *1 84.55,105
X$5100 5592 7765 8358 109 8072 77 OAI21_X1
* cell instance $5104 m0 *1 87.02,105
X$5104 5592 7767 8186 109 8243 77 OAI21_X1
* cell instance $5105 m0 *1 87.78,105
X$5105 7922 8245 77 109 8186 NAND2_X1
* cell instance $5108 r0 *1 87.21,105
X$5108 77 7205 8247 8245 8243 4086 109 DFFR_X1
* cell instance $5109 m0 *1 90.25,105
X$5109 8366 8363 3875 77 8073 109 AOI21_X1
* cell instance $5110 m0 *1 89.49,105
X$5110 8362 7730 8080 109 7930 77 OAI21_X1
* cell instance $5111 m0 *1 91.01,105
X$5111 8365 5536 8074 77 109 6674 MUX2_X1
* cell instance $5112 m0 *1 92.34,105
X$5112 8367 6459 77 109 8075 NOR2_X1
* cell instance $5114 m0 *1 93.1,105
X$5114 8076 6593 8191 8369 8078 8366 109 77 AOI221_X2
* cell instance $5115 m0 *1 95.19,105
X$5115 5043 8080 6129 8081 77 109 8194 AOI22_X2
* cell instance $5117 r0 *1 91.01,105
X$5117 8246 5318 8247 77 109 8365 MUX2_X1
* cell instance $5119 r0 *1 92.72,105
X$5119 8246 7642 8247 77 109 8370 MUX2_X1
* cell instance $5121 r0 *1 94.24,105
X$5121 8417 8079 77 109 8372 NOR2_X1
* cell instance $5122 r0 *1 94.81,105
X$5122 8079 109 6694 77 BUF_X4
* cell instance $5125 r0 *1 97.09,105
X$5125 8370 8079 7641 77 109 8371 MUX2_X1
* cell instance $5126 m0 *1 98.61,105
X$5126 8197 5479 8196 8367 8194 6693 77 109 OAI221_X2
* cell instance $5127 m0 *1 97.28,105
X$5127 5589 109 7642 77 BUF_X4
* cell instance $5129 m0 *1 100.89,105
X$5129 8369 8198 8250 8375 8083 77 109 8082 AOI221_X1
* cell instance $5132 r0 *1 98.42,105
X$5132 6007 8371 8248 109 8196 77 OAI21_X1
* cell instance $5133 r0 *1 99.18,105
X$5133 8372 7208 8249 109 8248 77 OAI21_X1
* cell instance $5137 r0 *1 101.27,105
X$5137 8376 6983 8686 77 109 8379 MUX2_X1
* cell instance $5138 r0 *1 102.6,105
X$5138 77 7337 8513 8376 8379 8201 109 DFFR_X1
* cell instance $5139 m0 *1 103.36,105
X$5139 7495 109 7877 77 BUF_X4
* cell instance $5141 m0 *1 104.69,105
X$5141 77 6883 8381 5892 5890 109 AOI21_X4
* cell instance $5143 r0 *1 106.4,105
X$5143 5285 5892 8368 109 77 8251 OAI21_X2
* cell instance $5144 m0 *1 107.73,105
X$5144 8251 2931 8040 77 109 8200 MUX2_X1
* cell instance $5147 r0 *1 107.73,105
X$5147 8251 77 109 8686 BUF_X2
* cell instance $5150 r0 *1 109.44,105
X$5150 8250 7087 77 109 8244 NAND2_X2
* cell instance $5151 m0 *1 109.63,105
X$5151 7938 7844 7939 77 109 8202 MUX2_X1
* cell instance $5153 m0 *1 110.96,105
X$5153 7902 5729 8202 77 109 8382 MUX2_X1
* cell instance $5155 m0 *1 113.05,105
X$5155 7647 8166 8207 77 109 8085 MUX2_X1
* cell instance $5157 m0 *1 114.57,105
X$5157 77 6900 8257 8207 8085 4086 109 DFFR_X1
* cell instance $5159 r0 *1 110.39,105
X$5159 7903 8689 8252 77 109 8253 MUX2_X1
* cell instance $5160 r0 *1 111.72,105
X$5160 6185 6318 8031 77 109 NOR2_X4
* cell instance $5161 r0 *1 113.43,105
X$5161 8382 7597 8384 77 109 8254 MUX2_X1
* cell instance $5167 r0 *1 116.47,105
X$5167 8255 7844 8424 77 109 8256 MUX2_X1
* cell instance $5168 r0 *1 117.8,105
X$5168 8256 5960 8386 77 109 8384 MUX2_X1
* cell instance $5170 m0 *1 118.75,105
X$5170 77 206 8258 8259 8210 4086 109 DFFR_X1
* cell instance $5171 m0 *1 124.07,105
X$5171 7216 77 109 5748 INV_X4
* cell instance $5173 m0 *1 125.21,105
X$5173 7652 8260 77 109 4611 NAND2_X2
* cell instance $5175 m0 *1 126.35,105
X$5175 8260 109 6698 77 BUF_X4
* cell instance $5176 m0 *1 127.68,105
X$5176 8045 8426 8087 109 8261 77 OAI21_X1
* cell instance $5177 m0 *1 128.44,105
X$5177 8212 8088 8389 77 109 8262 AND3_X4
* cell instance $5178 m0 *1 130.53,105
X$5178 8266 77 109 8518 BUF_X1
* cell instance $5180 m0 *1 131.29,105
X$5180 7652 5711 5563 77 109 NOR2_X4
* cell instance $5182 m0 *1 133.19,105
X$5182 77 8264 5990 7174 7943 8265 109 NOR4_X4
* cell instance $5183 m0 *1 136.61,105
X$5183 8091 7313 7797 7749 77 109 8385 AOI22_X1
* cell instance $5184 m0 *1 137.56,105
X$5184 8032 7948 77 109 8561 NOR2_X1
* cell instance $5186 r0 *1 119.13,105
X$5186 8257 7844 8258 77 109 8386 MUX2_X1
* cell instance $5190 r0 *1 121.22,105
X$5190 7647 8235 8259 77 109 8210 MUX2_X1
* cell instance $5192 r0 *1 122.74,105
X$5192 77 7216 5472 109 BUF_X16
* cell instance $5193 r0 *1 127.49,105
X$5193 5711 77 109 8260 INV_X1
* cell instance $5194 r0 *1 127.87,105
X$5194 77 6001 8390 7501 8263 8556 109 NAND4_X4
* cell instance $5195 r0 *1 131.29,105
X$5195 4660 7756 8387 8214 77 109 8389 AOI22_X1
* cell instance $5197 r0 *1 132.43,105
X$5197 5748 109 8264 77 BUF_X4
* cell instance $5198 r0 *1 133.76,105
X$5198 8515 8428 4660 109 8388 77 OAI21_X1
* cell instance $5199 r0 *1 134.52,105
X$5199 8388 7653 6467 77 109 8263 NAND3_X1
* cell instance $5200 r0 *1 135.28,105
X$5200 8087 77 109 8266 BUF_X1
* cell instance $5201 r0 *1 135.85,105
X$5201 8385 8560 8089 77 109 8267 MUX2_X1
* cell instance $5203 r0 *1 137.56,105
X$5203 8091 7313 8374 7096 7749 8507 109 77 AOI221_X2
* cell instance $5204 m0 *1 138.7,105
X$5204 7226 77 109 7797 CLKBUF_X3
* cell instance $5206 m0 *1 139.65,105
X$5206 8206 8378 8203 77 109 8380 MUX2_X1
* cell instance $5208 r0 *1 139.65,105
X$5208 6872 8383 6436 109 77 6746 OAI21_X2
* cell instance $5210 r0 *1 141.17,105
X$5210 8268 7096 77 109 8435 NOR2_X2
* cell instance $5212 m0 *1 141.36,105
X$5212 77 7309 8091 8430 8192 7357 109 AOI22_X4
* cell instance $5213 r0 *1 142.12,105
X$5213 77 8433 8435 7226 8192 109 AOI21_X4
* cell instance $5215 r0 *1 144.78,105
X$5215 8268 7797 7802 77 8269 109 AOI21_X1
* cell instance $5217 m0 *1 144.97,105
X$5217 8015 7802 8096 77 109 8270 MUX2_X1
* cell instance $5219 r0 *1 145.73,105
X$5219 8270 7226 8272 77 109 8505 MUX2_X1
* cell instance $5220 m0 *1 147.63,105
X$5220 7884 7952 109 77 8271 AND2_X2
* cell instance $5221 m0 *1 146.68,105
X$5221 7952 7884 77 109 7894 NAND2_X2
* cell instance $5223 m0 *1 148.77,105
X$5223 6396 77 109 7879 INV_X2
* cell instance $5225 m0 *1 149.53,105
X$5225 7098 7052 7507 6260 6414 8502 109 77 AOI221_X2
* cell instance $5227 m0 *1 151.81,105
X$5227 8096 7310 8181 77 109 8195 MUX2_X1
* cell instance $5229 m0 *1 153.33,105
X$5229 8181 7802 8097 77 109 8272 MUX2_X1
* cell instance $5234 r0 *1 147.63,105
X$5234 8377 77 109 8374 CLKBUF_X3
* cell instance $5235 r0 *1 148.58,105
X$5235 77 7098 7052 8432 6260 6414 109 AOI22_X4
* cell instance $5237 r0 *1 152.19,105
X$5237 7797 8195 8273 8097 8364 8434 77 109 OAI221_X2
* cell instance $5238 r0 *1 154.28,105
X$5238 7159 7502 77 109 8273 NAND2_X1
* cell instance $5240 r0 *1 155.61,105
X$5240 8348 7802 7502 77 109 8364 NAND3_X1
* cell instance $5242 m0 *1 155.8,105
X$5242 8022 7502 8020 77 109 8438 MUX2_X1
* cell instance $5243 m0 *1 157.89,105
X$5243 6763 77 109 7230 INV_X2
* cell instance $5244 m0 *1 158.46,105
X$5244 7230 7805 7231 77 109 8098 MUX2_X1
* cell instance $5245 m0 *1 159.79,105
X$5245 8098 7662 8185 77 109 8097 MUX2_X1
* cell instance $5247 m0 *1 161.31,105
X$5247 8099 7797 77 109 8640 NOR2_X1
* cell instance $5251 m0 *1 164.35,105
X$5251 7662 8100 8278 109 8277 77 OAI21_X1
* cell instance $5252 m0 *1 165.11,105
X$5252 3882 8102 77 109 8278 OR2_X1
* cell instance $5255 m0 *1 167.58,105
X$5255 8101 7662 8490 77 8181 109 AOI21_X1
* cell instance $5256 m0 *1 168.34,105
X$5256 8102 7662 77 109 8101 NOR2_X1
* cell instance $5259 r0 *1 156.56,105
X$5259 8020 7226 8350 77 109 8361 MUX2_X1
* cell instance $5263 r0 *1 160.55,105
X$5263 8276 7159 77 109 8496 NOR2_X1
* cell instance $5264 r0 *1 161.12,105
X$5264 8350 7797 8353 77 109 8494 MUX2_X1
* cell instance $5265 r0 *1 162.45,105
X$5265 8276 7802 8492 77 109 8353 MUX2_X1
* cell instance $5266 r0 *1 163.78,105
X$5266 8277 7802 77 109 8493 NOR2_X1
* cell instance $5267 r0 *1 164.35,105
X$5267 8342 7802 8277 77 109 8350 MUX2_X1
* cell instance $5268 r0 *1 165.68,105
X$5268 6401 8439 6483 77 109 8279 MUX2_X1
* cell instance $5270 r0 *1 167.39,105
X$5270 6763 8439 7146 77 109 8280 MUX2_X1
* cell instance $5271 r0 *1 168.72,105
X$5271 7719 7805 7664 77 109 8343 MUX2_X1
* cell instance $5272 m0 *1 169.48,105
X$5272 6392 7805 6927 77 109 8102 MUX2_X1
* cell instance $5275 m0 *1 171,105
X$5275 8014 77 109 7519 INV_X4
* cell instance $5277 m0 *1 172.14,105
X$5277 4758 8104 7784 77 109 8281 NOR3_X1
* cell instance $5278 m0 *1 172.9,105
X$5278 8172 6005 7040 77 109 8174 MUX2_X1
* cell instance $5279 m0 *1 174.23,105
X$5279 77 8105 8174 6605 8173 8283 109 AOI22_X4
* cell instance $5280 m0 *1 177.46,105
X$5280 8281 8105 8282 7815 77 109 8284 AOI22_X2
* cell instance $5281 m0 *1 179.17,105
X$5281 8084 8105 77 109 8329 NOR2_X1
* cell instance $5282 m0 *1 179.74,105
X$5282 7709 77 109 8172 INV_X1
* cell instance $5284 r0 *1 170.05,105
X$5284 8343 7662 8336 77 109 8342 MUX2_X1
* cell instance $5289 r0 *1 171.57,105
X$5289 7112 8439 7586 77 109 8336 MUX2_X1
* cell instance $5290 r0 *1 172.9,105
X$5290 4758 8104 7602 77 109 8486 NOR3_X1
* cell instance $5291 r0 *1 173.66,105
X$5291 8484 8482 6762 77 109 NOR2_X4
* cell instance $5292 r0 *1 175.37,105
X$5292 8282 6696 7813 8104 109 77 8442 OAI22_X1
* cell instance $5294 r0 *1 176.7,105
X$5294 8084 109 8333 77 BUF_X4
* cell instance $5295 r0 *1 178.03,105
X$5295 8284 8329 8478 109 77 6763 OAI21_X4
* cell instance $5297 m0 *1 180.5,105
X$5297 7667 7965 6235 77 109 8328 MUX2_X1
* cell instance $5299 r0 *1 180.5,105
X$5299 77 8285 18775 7667 8328 3676 109 DFFR_X1
* cell instance $5300 m0 *1 184.11,105
X$5300 8107 7965 8111 77 109 8108 MUX2_X1
* cell instance $5301 m0 *1 183.73,105
X$5301 8107 77 109 7813 INV_X1
* cell instance $5302 m0 *1 185.44,105
X$5302 77 7816 18630 8107 8108 3676 109 DFFR_X1
* cell instance $5304 m0 *1 190.76,105
X$5304 8167 8110 77 109 7277 NAND2_X1
* cell instance $5305 m0 *1 191.33,105
X$5305 8165 8110 77 109 7275 NAND2_X1
* cell instance $5308 m0 *1 193.61,105
X$5308 8322 8110 77 109 7240 NAND2_X1
* cell instance $5309 m0 *1 194.18,105
X$5309 77 7816 18627 8112 7969 3676 109 DFFR_X1
* cell instance $5311 m0 *1 198.17,105
X$5311 77 8320 8113 3676 18908 3562 109 DFFR_X2
* cell instance $5313 m0 *1 202.54,105
X$5313 77 7971 8116 3676 18914 3666 109 DFFR_X2
* cell instance $5317 r0 *1 184.87,105
X$5317 6255 109 8327 77 BUF_X4
* cell instance $5318 r0 *1 186.2,105
X$5318 6466 8327 8286 6391 77 109 8326 AOI22_X1
* cell instance $5321 r0 *1 189.05,105
X$5321 8326 6485 77 109 8319 NAND2_X1
* cell instance $5324 r0 *1 190.57,105
X$5324 7861 8445 8323 109 77 8287 HA_X1
* cell instance $5325 r0 *1 192.47,105
X$5325 8289 3637 8323 77 8288 109 AOI21_X1
* cell instance $5326 r0 *1 193.23,105
X$5326 3637 8321 77 109 8289 NOR2_X1
* cell instance $5327 r0 *1 193.8,105
X$5327 8471 8110 77 109 7416 NAND2_X1
* cell instance $5328 r0 *1 194.37,105
X$5328 8313 5913 8321 77 109 6378 MUX2_X1
* cell instance $5332 r0 *1 199.69,105
X$5332 6485 8290 8319 109 5412 77 OAI21_X1
* cell instance $5333 r0 *1 200.45,105
X$5333 3666 6496 8316 77 109 8467 MUX2_X1
* cell instance $5336 r0 *1 202.73,105
X$5336 8317 4832 8316 5228 77 109 8291 AOI22_X1
* cell instance $5339 r0 *1 205.58,105
X$5339 3996 4552 8118 77 109 8466 MUX2_X1
* cell instance $5340 r0 *1 206.91,105
X$5340 77 7971 8312 3676 18976 3996 109 DFFR_X2
* cell instance $5341 m0 *1 207.29,105
X$5341 6817 77 109 7971 CLKBUF_X3
* cell instance $5343 m0 *1 208.24,105
X$5343 8119 7242 7992 77 8312 109 AOI21_X1
* cell instance $5344 m0 *1 209,105
X$5344 7242 3996 77 109 8119 NOR2_X1
* cell instance $5346 m0 *1 210.14,105
X$5346 8147 7242 7970 77 8292 109 AOI21_X1
* cell instance $5348 m0 *1 210.9,105
X$5348 77 7971 8292 3676 18961 3315 109 DFFR_X2
* cell instance $5352 r0 *1 211.66,105
X$5352 3315 4552 8146 77 109 8293 MUX2_X1
* cell instance $5354 r0 *1 214.51,105
X$5354 6207 4552 8294 77 109 8446 MUX2_X1
* cell instance $5356 m0 *1 215.46,105
X$5356 8143 7242 7972 77 8308 109 AOI21_X1
* cell instance $5357 m0 *1 216.41,105
X$5357 7242 6207 77 109 8143 NOR2_X1
* cell instance $5360 r0 *1 215.84,105
X$5360 77 7824 8308 3676 18990 6207 109 DFFR_X2
* cell instance $5361 m0 *1 218.31,105
X$5361 77 7824 8122 992 18964 4410 109 DFFR_X2
* cell instance $5364 m0 *1 223.25,105
X$5364 77 7982 18634 8125 8139 992 109 DFFR_X1
* cell instance $5368 m0 *1 231.04,105
X$5368 8588 4837 7974 77 109 8134 MUX2_X1
* cell instance $5371 m0 *1 234.08,105
X$5371 8297 77 109 7246 BUF_X1
* cell instance $5374 r0 *1 220.21,105
X$5374 1398 5384 8305 109 8461 77 OAI21_X1
* cell instance $5377 r0 *1 222.87,105
X$5377 6952 77 109 19092 INV_X4
* cell instance $5381 r0 *1 226.29,105
X$5381 621 5259 8304 109 8460 77 OAI21_X1
* cell instance $5385 r0 *1 227.05,105
X$5385 3700 6496 8295 77 109 8303 MUX2_X1
* cell instance $5386 r0 *1 228.38,105
X$5386 77 7976 18729 8295 8303 992 109 DFFR_X1
* cell instance $5390 r0 *1 233.51,105
X$5390 8450 77 109 7549 BUF_X1
* cell instance $5391 r0 *1 234.08,105
X$5391 5637 5509 8301 77 109 8299 MUX2_X1
* cell instance $5392 m0 *1 235.98,105
X$5392 1381 5384 8128 109 8301 77 OAI21_X1
* cell instance $5393 m0 *1 235.03,105
X$5393 6952 77 109 7976 CLKBUF_X3
* cell instance $5394 m0 *1 236.74,105
X$5394 7976 77 109 19250 CLKBUF_X1
* cell instance $5395 m0 *1 237.31,105
X$5395 8127 77 109 8129 BUF_X1
* cell instance $5399 r0 *1 235.41,105
X$5399 77 7976 8299 992 18989 5637 109 DFFR_X2
* cell instance $5406 r0 *1 1.33,138.6
X$5406 77 11262 11102 11346 11348 4909 109 DFFR_X1
* cell instance $5411 m0 *1 3.99,138.6
X$5411 10752 6214 11101 77 109 11189 MUX2_X1
* cell instance $5412 r0 *1 5.13,138.6
X$5412 10752 6280 11346 77 109 11348 MUX2_X1
* cell instance $5413 m0 *1 5.89,138.6
X$5413 11102 9178 11192 77 109 11349 MUX2_X1
* cell instance $5415 m0 *1 7.22,138.6
X$5415 11263 7760 11103 77 109 11350 MUX2_X1
* cell instance $5417 m0 *1 8.74,138.6
X$5417 11350 9175 10751 77 109 11351 MUX2_X1
* cell instance $5421 r0 *1 7.22,138.6
X$5421 11264 6158 11349 77 109 11104 MUX2_X1
* cell instance $5424 r0 *1 10.45,138.6
X$5424 77 11028 11356 11514 11352 4909 109 DFFR_X1
* cell instance $5425 m0 *1 12.16,138.6
X$5425 11194 4768 10425 77 109 11106 MUX2_X1
* cell instance $5429 r0 *1 14.25,138.6
X$5429 77 11028 11265 11355 11354 4909 109 DFFR_X1
* cell instance $5430 m0 *1 14.82,138.6
X$5430 77 11028 11267 11195 11196 4909 109 DFFR_X1
* cell instance $5433 m0 *1 18.81,138.6
X$5433 11108 7059 11267 77 109 11268 MUX2_X1
* cell instance $5434 m0 *1 20.14,138.6
X$5434 11268 6017 11109 77 109 11272 MUX2_X1
* cell instance $5436 m0 *1 21.66,138.6
X$5436 11269 5818 11272 77 109 11359 MUX2_X1
* cell instance $5438 m0 *1 23.75,138.6
X$5438 11359 5959 11110 77 109 11211 MUX2_X1
* cell instance $5441 r0 *1 18.05,138.6
X$5441 11265 5660 11356 77 109 11266 MUX2_X1
* cell instance $5442 r0 *1 19.38,138.6
X$5442 11108 9976 11267 77 109 11357 MUX2_X1
* cell instance $5445 r0 *1 21.28,138.6
X$5445 11270 5660 11271 77 109 11109 MUX2_X1
* cell instance $5446 r0 *1 22.61,138.6
X$5446 11270 9976 11271 77 109 11522 MUX2_X1
* cell instance $5450 r0 *1 25.27,138.6
X$5450 11361 4631 10429 77 109 11273 MUX2_X1
* cell instance $5451 r0 *1 26.6,138.6
X$5451 77 10951 11274 11361 11273 4909 109 DFFR_X1
* cell instance $5452 m0 *1 29.83,138.6
X$5452 77 10951 11112 11363 11205 4909 109 DFFR_X1
* cell instance $5453 m0 *1 28.5,138.6
X$5453 11363 5805 10425 77 109 11205 MUX2_X1
* cell instance $5455 r0 *1 30.4,138.6
X$5455 10674 77 109 10951 CLKBUF_X3
* cell instance $5456 r0 *1 31.35,138.6
X$5456 10951 77 109 19310 CLKBUF_X1
* cell instance $5459 r0 *1 33.06,138.6
X$5459 11351 7617 77 109 11364 NOR2_X1
* cell instance $5460 r0 *1 33.63,138.6
X$5460 77 10951 18889 11443 11531 9814 109 DFFR_X1
* cell instance $5461 m0 *1 35.34,138.6
X$5461 77 11212 11365 8152 11211 109 AOI21_X4
* cell instance $5462 m0 *1 34.01,138.6
X$5462 11364 11210 7022 109 11365 77 NOR3_X2
* cell instance $5464 m0 *1 38,138.6
X$5464 11213 9742 11113 9801 11216 11366 77 109 OAI221_X2
* cell instance $5465 m0 *1 40.09,138.6
X$5465 11366 109 11118 77 BUF_X4
* cell instance $5468 m0 *1 43.13,138.6
X$5468 11218 11276 10760 77 109 11372 MUX2_X1
* cell instance $5469 m0 *1 44.46,138.6
X$5469 11218 9178 10760 77 109 11277 MUX2_X1
* cell instance $5471 m0 *1 45.98,138.6
X$5471 11372 11278 10960 77 109 11374 MUX2_X1
* cell instance $5474 m0 *1 49.02,138.6
X$5474 11119 9326 10963 77 109 11280 MUX2_X1
* cell instance $5477 r0 *1 37.81,138.6
X$5477 7618 11274 7619 7620 11533 109 77 11114 OAI221_X1
* cell instance $5478 r0 *1 38.95,138.6
X$5478 7703 11535 11274 7643 109 77 11215 OAI22_X1
* cell instance $5482 r0 *1 41.23,138.6
X$5482 11369 10763 9503 77 11368 109 AOI21_X1
* cell instance $5484 r0 *1 42.18,138.6
X$5484 9503 11275 77 109 11369 NOR2_X1
* cell instance $5487 r0 *1 43.7,138.6
X$5487 11117 9178 11446 77 109 11373 MUX2_X1
* cell instance $5489 r0 *1 45.79,138.6
X$5489 11277 6158 11222 77 109 11279 MUX2_X1
* cell instance $5493 r0 *1 49.59,138.6
X$5493 11281 11448 9152 77 11376 109 AOI21_X1
* cell instance $5494 r0 *1 50.35,138.6
X$5494 9152 11377 77 109 11281 NOR2_X1
* cell instance $5496 m0 *1 50.73,138.6
X$5496 11120 7876 77 109 11449 NAND2_X1
* cell instance $5499 m0 *1 51.68,138.6
X$5499 77 9974 11451 11121 11378 9814 109 DFFR_X1
* cell instance $5500 m0 *1 56.05,138.6
X$5500 11122 8407 11229 77 109 11282 MUX2_X1
* cell instance $5502 m0 *1 57.38,138.6
X$5502 8986 77 109 9972 CLKBUF_X3
* cell instance $5505 m0 *1 62.89,138.6
X$5505 11285 8229 11123 77 109 11390 MUX2_X1
* cell instance $5506 m0 *1 64.22,138.6
X$5506 11233 10969 9152 77 11232 109 AOI21_X1
* cell instance $5509 r0 *1 57,138.6
X$5509 8986 77 109 10583 CLKBUF_X3
* cell instance $5510 r0 *1 57.95,138.6
X$5510 8986 77 109 11448 CLKBUF_X3
* cell instance $5515 r0 *1 60.42,138.6
X$5515 11386 10969 9829 77 11384 109 AOI21_X1
* cell instance $5517 r0 *1 61.94,138.6
X$5517 9829 11284 77 109 11386 NOR2_X1
* cell instance $5519 r0 *1 62.7,138.6
X$5519 11285 10200 11123 77 109 11391 MUX2_X1
* cell instance $5522 r0 *1 64.6,138.6
X$5522 77 10974 11287 11286 11388 9814 109 DFFR_X1
* cell instance $5523 m0 *1 66.31,138.6
X$5523 11124 10132 8548 77 11388 109 AOI21_X1
* cell instance $5525 m0 *1 67.07,138.6
X$5525 8548 11286 77 109 11124 NOR2_X1
* cell instance $5526 m0 *1 67.64,138.6
X$5526 11390 11125 11235 77 109 11127 MUX2_X1
* cell instance $5527 m0 *1 68.97,138.6
X$5527 10971 8671 11127 77 109 11457 MUX2_X1
* cell instance $5529 m0 *1 73.34,138.6
X$5529 11288 3565 11129 77 11236 109 AOI21_X1
* cell instance $5530 m0 *1 74.1,138.6
X$5530 11129 11063 77 109 11288 NOR2_X1
* cell instance $5534 m0 *1 78.66,138.6
X$5534 6452 109 11563 77 BUF_X4
* cell instance $5537 m0 *1 80.94,138.6
X$5537 9440 77 109 19103 INV_X2
* cell instance $5538 m0 *1 81.51,138.6
X$5538 3445 77 109 9440 CLKBUF_X3
* cell instance $5539 m0 *1 82.46,138.6
X$5539 11396 3565 9832 77 11238 109 AOI21_X1
* cell instance $5541 r0 *1 68.4,138.6
X$5541 11126 10200 11287 77 109 11392 MUX2_X1
* cell instance $5542 r0 *1 69.73,138.6
X$5542 9440 77 109 10974 CLKBUF_X3
* cell instance $5543 r0 *1 70.68,138.6
X$5543 10974 77 109 19175 INV_X1
* cell instance $5544 r0 *1 71.06,138.6
X$5544 7332 109 11129 77 BUF_X4
* cell instance $5546 r0 *1 72.58,138.6
X$5546 11557 9832 11289 77 109 11560 MUX2_X1
* cell instance $5548 r0 *1 74.67,138.6
X$5548 11289 6993 11562 77 109 11290 MUX2_X1
* cell instance $5551 r0 *1 77.14,138.6
X$5551 11289 7279 11394 77 109 11292 MUX2_X1
* cell instance $5552 r0 *1 78.47,138.6
X$5552 77 11291 11597 11394 11292 8687 109 DFFR_X1
* cell instance $5553 r0 *1 82.27,138.6
X$5553 8239 109 8069 77 BUF_X4
* cell instance $5554 r0 *1 83.6,138.6
X$5554 9832 11395 77 109 11396 NOR2_X1
* cell instance $5555 m0 *1 87.4,138.6
X$5555 11295 6380 11293 77 109 11245 MUX2_X1
* cell instance $5556 m0 *1 83.6,138.6
X$5556 77 11078 11294 11295 11245 8687 109 DFFR_X1
* cell instance $5557 m0 *1 88.73,138.6
X$5557 9440 77 109 11078 CLKBUF_X3
* cell instance $5559 m0 *1 89.87,138.6
X$5559 5479 11132 8028 77 109 NOR2_X4
* cell instance $5560 m0 *1 91.58,138.6
X$5560 77 11296 11464 11402 11403 8201 109 DFFR_X1
* cell instance $5561 m0 *1 95.38,138.6
X$5561 11132 7342 77 8367 109 NAND2_X4
* cell instance $5565 r0 *1 84.55,138.6
X$5565 11399 6975 11293 77 109 11459 MUX2_X1
* cell instance $5569 r0 *1 87.21,138.6
X$5569 11460 3624 11294 77 109 11720 MUX2_X1
* cell instance $5570 r0 *1 88.54,138.6
X$5570 11078 77 109 19260 CLKBUF_X1
* cell instance $5574 r0 *1 91.77,138.6
X$5574 9034 77 109 11289 BUF_X2
* cell instance $5575 r0 *1 92.53,138.6
X$5575 11402 8548 11289 77 109 11403 MUX2_X1
* cell instance $5578 r0 *1 94.43,138.6
X$5578 77 11296 11463 11297 11407 8201 109 DFFR_X1
* cell instance $5579 m0 *1 99.56,138.6
X$5579 77 10605 18499 10783 11133 8201 109 DFFR_X1
* cell instance $5580 m0 *1 98.23,138.6
X$5580 10783 11129 10781 77 109 11133 MUX2_X1
* cell instance $5583 r0 *1 98.23,138.6
X$5583 11297 9152 11573 77 109 11407 MUX2_X1
* cell instance $5586 r0 *1 100.7,138.6
X$5586 11299 9834 10781 77 109 11298 MUX2_X1
* cell instance $5587 r0 *1 102.03,138.6
X$5587 77 10605 11410 11299 11298 8201 109 DFFR_X1
* cell instance $5588 m0 *1 106.59,138.6
X$5588 10977 8689 11300 77 109 10784 MUX2_X1
* cell instance $5589 m0 *1 105.26,138.6
X$5589 11410 9337 11135 77 109 10978 MUX2_X1
* cell instance $5593 r0 *1 105.83,138.6
X$5593 11410 9831 11135 77 109 11300 MUX2_X1
* cell instance $5596 r0 *1 108.11,138.6
X$5596 11417 8548 11293 77 109 11414 MUX2_X1
* cell instance $5597 r0 *1 109.44,138.6
X$5597 77 11416 11467 11417 11414 8201 109 DFFR_X1
* cell instance $5598 m0 *1 114.19,138.6
X$5598 77 11416 11138 11254 11137 4086 109 DFFR_X1
* cell instance $5599 m0 *1 112.86,138.6
X$5599 11254 9945 10781 77 109 11137 MUX2_X1
* cell instance $5600 m0 *1 117.99,138.6
X$5600 11138 10299 10981 77 109 11255 MUX2_X1
* cell instance $5601 m0 *1 119.32,138.6
X$5601 11420 10590 10781 77 109 11422 MUX2_X1
* cell instance $5602 m0 *1 120.65,138.6
X$5602 77 10982 11139 11420 11422 4086 109 DFFR_X1
* cell instance $5605 m0 *1 125.4,138.6
X$5605 11257 109 11140 77 BUF_X4
* cell instance $5607 m0 *1 126.92,138.6
X$5607 77 11193 11425 10789 11140 109 AOI21_X4
* cell instance $5609 m0 *1 129.58,138.6
X$5609 77 10791 9168 9000 11303 5716 109 OR4_X4
* cell instance $5610 m0 *1 132.05,138.6
X$5610 77 10928 11260 10469 10996 11431 109 OAI211_X4
* cell instance $5611 m0 *1 135.28,138.6
X$5611 11434 10990 11304 77 10931 109 AOI21_X1
* cell instance $5619 r0 *1 118.18,138.6
X$5619 11138 6291 10981 77 109 11419 MUX2_X1
* cell instance $5621 r0 *1 119.7,138.6
X$5621 11419 7283 11580 77 109 11424 MUX2_X1
* cell instance $5626 r0 *1 124.83,138.6
X$5626 11424 4643 77 109 10984 NAND2_X1
* cell instance $5627 r0 *1 125.4,138.6
X$5627 5002 11301 19081 109 77 10985 HA_X1
* cell instance $5628 r0 *1 127.3,138.6
X$5628 77 11347 11577 10789 6474 109 AOI21_X4
* cell instance $5630 r0 *1 129.96,138.6
X$5630 10989 10987 77 109 11143 NOR2_X1
* cell instance $5631 r0 *1 130.53,138.6
X$5631 10790 10791 10987 10617 109 77 11430 AND4_X1
* cell instance $5632 r0 *1 131.67,138.6
X$5632 10930 10469 77 109 11302 NOR2_X1
* cell instance $5634 r0 *1 132.62,138.6
X$5634 10989 10790 10791 77 11432 109 AOI21_X1
* cell instance $5635 r0 *1 133.38,138.6
X$5635 11094 11574 11432 10794 77 109 11431 AOI22_X2
* cell instance $5637 r0 *1 135.28,138.6
X$5637 10989 10930 10469 77 109 11304 NOR3_X1
* cell instance $5640 m0 *1 136.42,138.6
X$5640 10989 10993 10930 10469 77 109 11434 NOR4_X1
* cell instance $5644 r0 *1 137.37,138.6
X$5644 7035 7095 5861 77 109 11572 NOR3_X1
* cell instance $5646 m0 *1 138.7,138.6
X$5646 7035 7095 7597 77 109 11305 NOR3_X1
* cell instance $5648 m0 *1 139.46,138.6
X$5648 7035 7095 6546 77 109 11569 NOR3_X1
* cell instance $5650 r0 *1 138.89,138.6
X$5650 11306 10230 10797 11305 11307 11160 77 109 OAI221_X2
* cell instance $5651 m0 *1 141.93,138.6
X$5651 10725 11089 77 109 11437 NOR2_X2
* cell instance $5652 m0 *1 140.6,138.6
X$5652 10470 109 11306 77 BUF_X4
* cell instance $5654 r0 *1 140.98,138.6
X$5654 10230 109 11438 77 BUF_X4
* cell instance $5655 r0 *1 142.31,138.6
X$5655 10311 109 11307 77 BUF_X4
* cell instance $5656 m0 *1 144.02,138.6
X$5656 11251 11308 77 109 11148 NOR2_X2
* cell instance $5657 m0 *1 143.26,138.6
X$5657 8462 10470 10311 109 11250 77 OAI21_X1
* cell instance $5659 m0 *1 145.16,138.6
X$5659 11309 10253 109 77 11147 AND2_X1
* cell instance $5660 m0 *1 145.92,138.6
X$5660 10253 11309 77 109 11144 NAND2_X1
* cell instance $5662 m0 *1 146.68,138.6
X$5662 11144 109 6855 77 BUF_X4
* cell instance $5663 m0 *1 148.01,138.6
X$5663 11436 77 109 10624 INV_X1
* cell instance $5664 m0 *1 148.39,138.6
X$5664 11145 77 109 11435 INV_X1
* cell instance $5665 m0 *1 148.77,138.6
X$5665 5716 11433 4492 11147 11146 11436 109 77 AOI221_X2
* cell instance $5667 m0 *1 151.05,138.6
X$5667 11428 11147 77 109 11149 NAND2_X1
* cell instance $5669 m0 *1 151.81,138.6
X$5669 11313 7524 19045 109 77 11429 HA_X1
* cell instance $5671 r0 *1 143.64,138.6
X$5671 10313 7561 10310 77 11565 109 AOI21_X1
* cell instance $5672 r0 *1 144.4,138.6
X$5672 10313 6120 10310 77 11476 109 AOI21_X1
* cell instance $5673 r0 *1 145.16,138.6
X$5673 11250 11477 77 109 11320 NOR2_X2
* cell instance $5674 r0 *1 146.11,138.6
X$5674 11478 11479 11439 109 77 11310 HA_X1
* cell instance $5675 r0 *1 148.01,138.6
X$5675 11310 9287 11439 9360 77 109 11311 AOI22_X1
* cell instance $5676 r0 *1 148.96,138.6
X$5676 11201 10165 11435 9362 77 109 11312 AOI22_X1
* cell instance $5677 r0 *1 149.91,138.6
X$5677 9362 11311 11312 109 11146 77 OAI21_X1
* cell instance $5679 r0 *1 152.19,138.6
X$5679 11483 77 109 11313 INV_X1
* cell instance $5682 r0 *1 153.52,138.6
X$5682 11429 9355 11314 9447 77 109 11315 AOI22_X1
* cell instance $5683 m0 *1 154.85,138.6
X$5683 11165 10165 11316 10424 77 109 11426 AOI22_X1
* cell instance $5684 m0 *1 154.09,138.6
X$5684 9858 11315 11426 109 11428 77 OAI21_X1
* cell instance $5688 r0 *1 155.04,138.6
X$5688 11564 77 109 11316 INV_X1
* cell instance $5690 m0 *1 157.51,138.6
X$5690 6603 77 109 11317 INV_X1
* cell instance $5691 m0 *1 156.18,138.6
X$5691 11427 6855 11151 109 77 8825 OAI21_X2
* cell instance $5692 m0 *1 157.89,138.6
X$5692 11144 10808 11244 11559 109 77 9626 OAI22_X1
* cell instance $5695 r0 *1 156.56,138.6
X$5695 6543 11303 109 77 11914 XNOR2_X1
* cell instance $5696 r0 *1 157.7,138.6
X$5696 11317 10807 11423 109 77 11418 HA_X1
* cell instance $5698 m0 *1 159.22,138.6
X$5698 11318 9361 11421 77 109 11072 MUX2_X1
* cell instance $5700 r0 *1 159.6,138.6
X$5700 11418 9597 11423 9447 77 109 11421 AOI22_X1
* cell instance $5704 r0 *1 236.36,1.4
X$5704 108 77 109 110 CLKBUF_X1
* cell instance $5707 m0 *1 1.33,116.2
X$5707 77 8661 9174 8833 8912 4909 109 DFFR_X1
* cell instance $5709 m0 *1 5.13,116.2
X$5709 9003 7054 9241 77 109 9385 MUX2_X1
* cell instance $5720 r0 *1 4.18,116.2
X$5720 77 8661 9315 9241 9385 4909 109 DFFR_X1
* cell instance $5721 r0 *1 7.98,116.2
X$5721 9174 7477 9004 77 109 9316 MUX2_X1
* cell instance $5722 m0 *1 8.55,116.2
X$5722 9174 3048 9004 77 109 9551 MUX2_X1
* cell instance $5727 m0 *1 19.19,116.2
X$5727 9318 3048 9244 77 109 9394 MUX2_X1
* cell instance $5729 m0 *1 20.71,116.2
X$5729 9320 3048 9006 77 109 9176 MUX2_X1
* cell instance $5735 r0 *1 14.06,116.2
X$5735 9390 2633 8837 77 109 9317 MUX2_X1
* cell instance $5736 r0 *1 15.39,116.2
X$5736 7180 77 109 9005 CLKBUF_X3
* cell instance $5737 r0 *1 16.34,116.2
X$5737 9005 77 109 19281 CLKBUF_X1
* cell instance $5740 r0 *1 19.19,116.2
X$5740 9318 5310 9244 77 109 9395 MUX2_X1
* cell instance $5741 r0 *1 20.52,116.2
X$5741 9320 5951 9006 77 109 9557 MUX2_X1
* cell instance $5742 r0 *1 21.85,116.2
X$5742 9176 7156 9394 77 109 9319 MUX2_X1
* cell instance $5744 m0 *1 24.13,116.2
X$5744 9250 5951 8838 77 109 9481 MUX2_X1
* cell instance $5746 m0 *1 25.46,116.2
X$5746 9250 6591 8838 77 109 9254 MUX2_X1
* cell instance $5748 m0 *1 27.55,116.2
X$5748 9482 109 9007 77 BUF_X4
* cell instance $5751 m0 *1 29.83,116.2
X$5751 9321 6591 9322 77 109 9255 MUX2_X1
* cell instance $5752 m0 *1 31.16,116.2
X$5752 9254 5729 9255 77 109 9257 MUX2_X1
* cell instance $5755 r0 *1 26.6,116.2
X$5755 77 8664 9321 9094 9253 4909 109 DFFR_X1
* cell instance $5758 r0 *1 31.35,116.2
X$5758 77 8525 9322 9323 9400 4909 109 DFFR_X1
* cell instance $5759 m0 *1 33.06,116.2
X$5759 6645 77 109 8525 CLKBUF_X3
* cell instance $5761 m0 *1 34.01,116.2
X$5761 9007 4905 9323 77 109 9400 MUX2_X1
* cell instance $5765 r0 *1 35.53,116.2
X$5765 9007 6888 9403 77 109 9324 MUX2_X1
* cell instance $5767 m0 *1 39.52,116.2
X$5767 7876 8156 9260 109 9177 77 OAI21_X1
* cell instance $5768 m0 *1 38.76,116.2
X$5768 9570 5672 5657 77 9260 109 AOI21_X1
* cell instance $5771 m0 *1 40.85,116.2
X$5771 77 9263 9179 6652 7268 109 AOI21_X4
* cell instance $5773 m0 *1 43.32,116.2
X$5773 77 8674 9010 9106 9405 4909 109 DFFR_X1
* cell instance $5774 m0 *1 47.12,116.2
X$5774 7878 9266 77 109 9180 NAND2_X1
* cell instance $5775 m0 *1 47.69,116.2
X$5775 9181 6701 9182 77 109 9183 MUX2_X1
* cell instance $5776 m0 *1 49.02,116.2
X$5776 9183 6014 9012 77 109 9268 MUX2_X1
* cell instance $5777 m0 *1 50.35,116.2
X$5777 8848 9326 9014 77 109 9184 MUX2_X1
* cell instance $5779 m0 *1 51.87,116.2
X$5779 9109 8349 9016 77 109 9273 MUX2_X1
* cell instance $5780 m0 *1 53.2,116.2
X$5780 77 8676 9185 9271 9274 1663 109 DFFR_X1
* cell instance $5781 m0 *1 57,116.2
X$5781 8849 8345 9185 77 109 9275 MUX2_X1
* cell instance $5782 m0 *1 58.33,116.2
X$5782 9275 7292 77 109 9279 NOR2_X1
* cell instance $5784 r0 *1 40.66,116.2
X$5784 7638 6369 9257 77 9325 109 AOI21_X1
* cell instance $5788 r0 *1 43.51,116.2
X$5788 9326 109 8670 77 BUF_X4
* cell instance $5789 r0 *1 44.84,116.2
X$5789 6645 77 109 8674 CLKBUF_X3
* cell instance $5790 r0 *1 45.79,116.2
X$5790 9013 6972 4907 109 77 9405 OAI21_X4
* cell instance $5791 r0 *1 48.26,116.2
X$5791 9181 8847 9182 77 109 9408 MUX2_X1
* cell instance $5792 r0 *1 49.59,116.2
X$5792 8674 77 109 19170 INV_X1
* cell instance $5795 r0 *1 50.54,116.2
X$5795 9268 6704 9184 77 109 9409 MUX2_X1
* cell instance $5796 r0 *1 51.87,116.2
X$5796 9409 7917 77 109 9417 NOR2_X1
* cell instance $5799 r0 *1 53.58,116.2
X$5799 9411 8063 9273 77 109 9424 MUX2_X1
* cell instance $5800 r0 *1 54.91,116.2
X$5800 6645 77 109 8676 CLKBUF_X3
* cell instance $5801 r0 *1 55.86,116.2
X$5801 5314 6730 9327 109 9415 77 OAI21_X1
* cell instance $5802 r0 *1 56.62,116.2
X$5802 6730 9419 77 109 9327 NAND2_X1
* cell instance $5809 m0 *1 59.47,116.2
X$5809 9277 9276 5959 77 109 9418 NOR3_X1
* cell instance $5812 m0 *1 60.42,116.2
X$5812 8851 9280 8671 77 109 9276 NOR3_X1
* cell instance $5814 m0 *1 61.37,116.2
X$5814 9278 8670 77 109 9280 NOR2_X1
* cell instance $5816 m0 *1 62.13,116.2
X$5816 9114 4320 77 109 9282 NOR2_X1
* cell instance $5818 m0 *1 62.89,116.2
X$5818 9279 9282 3694 77 109 9283 NOR3_X1
* cell instance $5820 m0 *1 63.84,116.2
X$5820 9019 8529 6866 8407 9119 9277 109 77 AOI221_X2
* cell instance $5822 m0 *1 66.12,116.2
X$5822 9186 9283 8672 109 9489 77 NOR3_X2
* cell instance $5824 r0 *1 59.28,116.2
X$5824 9417 9418 7997 109 9420 77 NOR3_X2
* cell instance $5826 r0 *1 61.37,116.2
X$5826 77 9422 9420 4421 7026 109 AOI21_X4
* cell instance $5827 r0 *1 63.84,116.2
X$5827 5962 77 109 8855 CLKBUF_X3
* cell instance $5828 r0 *1 64.79,116.2
X$5828 9424 6236 77 109 9428 NOR2_X1
* cell instance $5829 r0 *1 65.36,116.2
X$5829 8855 77 109 19183 INV_X1
* cell instance $5831 r0 *1 65.93,116.2
X$5831 9019 7290 8070 9429 9427 9186 109 77 AOI221_X2
* cell instance $5832 m0 *1 71.63,116.2
X$5832 6988 9190 77 109 9189 NAND2_X1
* cell instance $5833 m0 *1 67.83,116.2
X$5833 77 8537 18566 9120 9288 4086 109 DFFR_X1
* cell instance $5834 m0 *1 72.2,116.2
X$5834 9189 6730 6538 109 77 9290 OAI21_X4
* cell instance $5836 r0 *1 68.02,116.2
X$5836 9188 3896 9117 77 9427 109 AOI21_X1
* cell instance $5837 r0 *1 68.78,116.2
X$5837 9120 9023 77 109 9188 NOR2_X1
* cell instance $5839 r0 *1 69.73,116.2
X$5839 3710 7329 9329 109 9431 77 OAI21_X1
* cell instance $5840 r0 *1 70.49,116.2
X$5840 7775 9490 77 109 9329 NAND2_X1
* cell instance $5844 m0 *1 75.62,116.2
X$5844 9296 6890 5316 109 77 9436 OAI21_X4
* cell instance $5845 m0 *1 75.05,116.2
X$5845 7160 9294 77 109 9296 NAND2_X1
* cell instance $5846 m0 *1 78.09,116.2
X$5846 9129 8070 3373 77 109 8863 NAND3_X1
* cell instance $5848 m0 *1 79.04,116.2
X$5848 77 8864 109 6452 BUF_X8
* cell instance $5852 r0 *1 75.24,116.2
X$5852 77 9491 9024 9294 9436 4086 109 DFFR_X1
* cell instance $5854 r0 *1 79.23,116.2
X$5854 77 9491 9437 9331 9330 4086 109 DFFR_X1
* cell instance $5856 r0 *1 83.22,116.2
X$5856 77 9028 9333 9332 9300 4086 109 DFFR_X1
* cell instance $5858 m0 *1 84.17,116.2
X$5858 9301 9029 9152 77 9300 109 AOI21_X1
* cell instance $5859 m0 *1 85.69,116.2
X$5859 9152 9332 77 109 9301 NOR2_X1
* cell instance $5861 m0 *1 86.45,116.2
X$5861 8867 3373 9334 77 109 9191 MUX2_X1
* cell instance $5865 r0 *1 87.21,116.2
X$5865 9333 8068 9193 77 109 9496 MUX2_X1
* cell instance $5867 r0 *1 88.73,116.2
X$5867 9440 77 109 9028 CLKBUF_X3
* cell instance $5868 m0 *1 92.72,116.2
X$5868 6975 9442 77 109 9303 NOR2_X1
* cell instance $5869 m0 *1 88.92,116.2
X$5869 77 9028 9193 9335 9302 8687 109 DFFR_X1
* cell instance $5870 m0 *1 93.29,116.2
X$5870 9306 6820 8422 77 109 9032 MUX2_X1
* cell instance $5871 m0 *1 94.62,116.2
X$5871 9303 9029 6975 77 9304 109 AOI21_X1
* cell instance $5872 m0 *1 95.38,116.2
X$5872 9305 6975 8422 77 109 9307 MUX2_X1
* cell instance $5874 r0 *1 89.68,116.2
X$5874 9192 9194 6130 77 109 9443 NOR3_X1
* cell instance $5875 r0 *1 90.44,116.2
X$5875 9444 9029 8548 77 9302 109 AOI21_X1
* cell instance $5877 r0 *1 91.58,116.2
X$5877 77 9028 9445 9442 9304 8687 109 DFFR_X1
* cell instance $5878 r0 *1 95.38,116.2
X$5878 8684 77 109 9029 CLKBUF_X3
* cell instance $5880 m0 *1 100.89,116.2
X$5880 9143 8689 9453 77 109 9309 MUX2_X1
* cell instance $5881 m0 *1 97.09,116.2
X$5881 77 8544 9451 9305 9307 8687 109 DFFR_X1
* cell instance $5882 m0 *1 102.22,116.2
X$5882 9195 7627 77 109 9308 NOR2_X1
* cell instance $5883 m0 *1 102.79,116.2
X$5883 77 9036 9311 9148 9151 8201 109 DFFR_X1
* cell instance $5884 m0 *1 106.59,116.2
X$5884 77 9036 9310 9197 9196 8201 109 DFFR_X1
* cell instance $5885 m0 *1 110.39,116.2
X$5885 9310 7642 9311 77 109 9154 MUX2_X1
* cell instance $5888 m0 *1 112.67,116.2
X$5888 77 9036 9040 9312 9198 4086 109 DFFR_X1
* cell instance $5889 m0 *1 116.47,116.2
X$5889 9199 5311 9200 77 109 9160 MUX2_X1
* cell instance $5890 m0 *1 117.8,116.2
X$5890 9199 8421 9200 77 109 8874 MUX2_X1
* cell instance $5892 m0 *1 119.32,116.2
X$5892 8876 9824 8686 77 109 9161 MUX2_X1
* cell instance $5893 m0 *1 120.65,116.2
X$5893 77 8692 9200 9313 9201 4086 109 DFFR_X1
* cell instance $5895 m0 *1 124.64,116.2
X$5895 8262 77 109 9345 INV_X2
* cell instance $5896 m0 *1 125.21,116.2
X$5896 8262 9461 19060 109 77 9202 HA_X1
* cell instance $5897 m0 *1 127.11,116.2
X$5897 5861 6698 77 8512 109 NAND2_X4
* cell instance $5898 m0 *1 128.82,116.2
X$5898 7651 8695 77 109 9507 NAND2_X2
* cell instance $5900 m0 *1 129.96,116.2
X$5900 9203 7908 7651 109 77 9204 AND3_X1
* cell instance $5903 r0 *1 98.23,116.2
X$5903 8544 77 109 19295 CLKBUF_X1
* cell instance $5904 r0 *1 98.8,116.2
X$5904 9341 77 109 8544 CLKBUF_X3
* cell instance $5905 r0 *1 99.75,116.2
X$5905 9451 7642 9336 77 109 9453 MUX2_X1
* cell instance $5907 r0 *1 101.46,116.2
X$5907 9451 9337 9336 77 109 9195 MUX2_X1
* cell instance $5909 r0 *1 103.17,116.2
X$5909 5311 109 9337 77 BUF_X4
* cell instance $5912 r0 *1 105.64,116.2
X$5912 9197 9829 8422 77 109 9196 MUX2_X1
* cell instance $5913 r0 *1 106.97,116.2
X$5913 9338 5311 9339 77 109 9456 MUX2_X1
* cell instance $5915 r0 *1 108.68,116.2
X$5915 9341 77 109 9036 CLKBUF_X3
* cell instance $5917 r0 *1 109.82,116.2
X$5917 9340 6125 9309 77 109 9457 MUX2_X1
* cell instance $5918 r0 *1 111.15,116.2
X$5918 9456 5960 9342 77 109 9458 MUX2_X1
* cell instance $5919 r0 *1 112.48,116.2
X$5919 9312 9631 8686 77 109 9198 MUX2_X1
* cell instance $5926 r0 *1 115.14,116.2
X$5926 9458 7597 9459 77 109 8872 MUX2_X1
* cell instance $5928 r0 *1 117.99,116.2
X$5928 9343 5960 9344 77 109 9459 MUX2_X1
* cell instance $5930 r0 *1 119.7,116.2
X$5930 9313 9503 8686 77 109 9201 MUX2_X1
* cell instance $5934 r0 *1 122.93,116.2
X$5934 9341 77 109 8692 CLKBUF_X3
* cell instance $5936 r0 *1 124.26,116.2
X$5936 8556 77 109 9461 INV_X4
* cell instance $5937 r0 *1 125.21,116.2
X$5937 9345 9461 19066 109 77 9462 HA_X1
* cell instance $5940 r0 *1 127.68,116.2
X$5940 9463 77 109 9346 INV_X1
* cell instance $5941 r0 *1 128.06,116.2
X$5941 8262 8556 9463 109 77 9638 HA_X1
* cell instance $5942 r0 *1 129.96,116.2
X$5942 9346 7908 109 77 9464 AND2_X1
* cell instance $5944 r0 *1 130.91,116.2
X$5944 9464 9204 8696 109 77 9465 MUX2_X2
* cell instance $5945 m0 *1 131.48,116.2
X$5945 6483 77 109 9172 INV_X2
* cell instance $5947 m0 *1 132.05,116.2
X$5947 7653 6744 109 77 9509 AND2_X1
* cell instance $5951 r0 *1 133.19,116.2
X$5951 6660 8016 77 9469 109 OR2_X4
* cell instance $5953 m0 *1 133.19,116.2
X$5953 9124 6660 8016 109 77 9284 OAI21_X2
* cell instance $5955 r0 *1 134.9,116.2
X$5955 77 9438 9468 5594 9205 5287 109 NAND4_X4
* cell instance $5957 m0 *1 135.66,116.2
X$5957 9207 8267 77 109 9205 OR2_X1
* cell instance $5958 m0 *1 136.99,116.2
X$5958 8431 9207 9514 8562 9515 109 77 9206 OAI221_X1
* cell instance $5960 m0 *1 138.13,116.2
X$5960 8882 8431 9208 109 9209 77 OAI21_X1
* cell instance $5961 m0 *1 138.89,116.2
X$5961 8564 8882 77 109 9208 NAND2_X1
* cell instance $5962 m0 *1 139.46,116.2
X$5962 8706 8439 77 109 9207 NAND2_X1
* cell instance $5963 m0 *1 140.03,116.2
X$5963 8271 77 109 8564 CLKBUF_X3
* cell instance $5966 m0 *1 141.93,116.2
X$5966 8378 9210 77 109 8650 NAND2_X2
* cell instance $5968 m0 *1 143.07,116.2
X$5968 8374 9210 77 109 8811 NAND2_X2
* cell instance $5970 m0 *1 144.21,116.2
X$5970 9210 8378 7891 77 109 9211 OR3_X1
* cell instance $5972 m0 *1 145.35,116.2
X$5972 9212 9213 9349 9211 77 6856 109 NAND4_X2
* cell instance $5973 m0 *1 147.06,116.2
X$5973 9211 9212 9213 77 109 9051 NAND3_X1
* cell instance $5975 m0 *1 148.01,116.2
X$5975 8374 9210 77 109 9214 NOR2_X1
* cell instance $5976 m0 *1 148.58,116.2
X$5976 6260 6414 77 9210 109 NAND2_X4
* cell instance $5978 r0 *1 138.32,116.2
X$5978 9467 8699 77 109 9468 NAND2_X1
* cell instance $5979 r0 *1 138.89,116.2
X$5979 8882 9353 9208 109 9467 77 OAI21_X1
* cell instance $5980 r0 *1 139.65,116.2
X$5980 8378 109 8429 77 BUF_X4
* cell instance $5982 r0 *1 141.17,116.2
X$5982 7894 8560 8433 77 109 9347 MUX2_X1
* cell instance $5985 r0 *1 143.64,116.2
X$5985 9347 8705 7295 109 9289 77 NOR3_X2
* cell instance $5986 r0 *1 144.97,116.2
X$5986 7891 8429 7506 77 109 9350 MUX2_X1
* cell instance $5988 r0 *1 146.49,116.2
X$5988 7891 8374 9351 109 9637 77 OAI21_X1
* cell instance $5990 r0 *1 147.63,116.2
X$5990 7891 8650 77 109 9441 NOR2_X1
* cell instance $5992 r0 *1 148.39,116.2
X$5992 6414 6260 109 77 9351 AND2_X2
* cell instance $5994 r0 *1 149.72,116.2
X$5994 6414 6260 8271 109 77 9352 AND3_X2
* cell instance $5995 m0 *1 151.24,116.2
X$5995 8373 8650 77 109 9293 NOR2_X1
* cell instance $5996 m0 *1 150.67,116.2
X$5996 9214 8095 77 109 9215 NAND2_X1
* cell instance $5999 r0 *1 150.86,116.2
X$5999 7225 7737 8378 109 77 9353 MUX2_X2
* cell instance $6000 r0 *1 152.57,116.2
X$6000 7737 8429 8025 77 109 9455 MUX2_X1
* cell instance $6002 m0 *1 153.71,116.2
X$6002 8882 9299 9215 109 9354 77 OAI21_X1
* cell instance $6003 m0 *1 155.23,116.2
X$6003 8811 77 109 9216 INV_X1
* cell instance $6006 r0 *1 154.66,116.2
X$6006 8025 9216 9150 9353 8504 9624 109 77 AOI221_X2
* cell instance $6008 m0 *1 155.99,116.2
X$6008 8635 8432 8189 109 77 9449 AND3_X1
* cell instance $6010 r0 *1 157.13,116.2
X$6010 8271 8432 77 109 9356 OR2_X1
* cell instance $6011 m0 *1 157.51,116.2
X$6011 8811 8095 8574 77 109 9450 NOR3_X1
* cell instance $6014 m0 *1 158.46,116.2
X$6014 9219 9218 8884 8704 9297 7367 77 109 OAI221_X2
* cell instance $6016 r0 *1 157.89,116.2
X$6016 9450 9452 9519 9449 109 9297 77 NOR4_X2
* cell instance $6019 m0 *1 160.93,116.2
X$6019 9147 9219 9295 109 77 6681 OAI21_X2
* cell instance $6022 m0 *1 164.73,116.2
X$6022 8704 9051 9293 9140 9292 6672 77 109 OAI221_X2
* cell instance $6027 r0 *1 161.69,116.2
X$6027 9448 9355 9144 9447 77 109 9446 AOI22_X1
* cell instance $6029 r0 *1 165.68,116.2
X$6029 9356 8439 77 109 9140 NAND2_X1
* cell instance $6032 r0 *1 167.2,116.2
X$6032 9356 8635 77 109 9358 NAND2_X1
* cell instance $6033 r0 *1 167.77,116.2
X$6033 9360 7037 9362 7148 9355 9607 109 77 AOI221_X2
* cell instance $6034 m0 *1 168.91,116.2
X$6034 9291 9287 9135 77 109 9359 MUX2_X1
* cell instance $6036 m0 *1 170.24,116.2
X$6036 6392 77 109 9222 INV_X1
* cell instance $6037 m0 *1 170.62,116.2
X$6037 3931 9222 9221 109 77 9223 HA_X1
* cell instance $6038 m0 *1 172.52,116.2
X$6038 4613 7112 9364 109 77 9224 HA_X1
* cell instance $6039 m0 *1 174.42,116.2
X$6039 6471 5553 77 109 9285 NAND2_X2
* cell instance $6041 r0 *1 169.86,116.2
X$6041 9289 3523 9773 109 9438 77 NOR3_X2
* cell instance $6045 r0 *1 171.19,116.2
X$6045 9221 9355 9223 77 109 9363 MUX2_X1
* cell instance $6046 r0 *1 172.52,116.2
X$6046 9360 9055 9362 8886 9287 9691 109 77 AOI221_X2
* cell instance $6049 r0 *1 175.56,116.2
X$6049 9281 6872 9434 8479 9284 6396 77 109 OAI221_X2
* cell instance $6050 m0 *1 177.84,116.2
X$6050 9227 77 109 9281 INV_X1
* cell instance $6051 m0 *1 175.75,116.2
X$6051 9225 9226 7287 77 109 7036 OR3_X4
* cell instance $6053 r0 *1 177.65,116.2
X$6053 8479 9432 8037 8889 9365 7146 77 109 OAI221_X2
* cell instance $6054 m0 *1 179.55,116.2
X$6054 77 8105 9270 9433 9272 9124 7667 8282 109 AOI222_X2
* cell instance $6055 m0 *1 178.6,116.2
X$6055 9128 77 109 7112 CLKBUF_X3
* cell instance $6057 r0 *1 179.74,116.2
X$6057 9433 77 109 6392 CLKBUF_X3
* cell instance $6058 r0 *1 180.69,116.2
X$6058 8104 9259 77 109 9434 NAND2_X1
* cell instance $6061 r0 *1 181.83,116.2
X$6061 77 7966 18865 9227 9430 3676 109 DFFR_X1
* cell instance $6062 m0 *1 182.78,116.2
X$6062 8104 9228 77 109 9432 NAND2_X1
* cell instance $6065 m0 *1 183.54,116.2
X$6065 9227 7965 9243 77 109 9430 MUX2_X1
* cell instance $6067 m0 *1 185.44,116.2
X$6067 4523 8327 9227 6391 77 109 9230 AOI22_X1
* cell instance $6069 m0 *1 186.39,116.2
X$6069 8105 9269 109 77 9225 AND2_X1
* cell instance $6072 r0 *1 187.15,116.2
X$6072 9426 8716 8925 77 109 9366 MUX2_X1
* cell instance $6073 m0 *1 187.72,116.2
X$6073 9058 109 8104 77 BUF_X4
* cell instance $6077 m0 *1 190,116.2
X$6077 8618 9696 109 77 9269 AND2_X1
* cell instance $6080 m0 *1 193.04,116.2
X$6080 9267 9229 109 7010 77 XOR2_X2
* cell instance $6081 m0 *1 194.75,116.2
X$6081 9059 9061 77 109 9267 NAND2_X1
* cell instance $6082 m0 *1 195.32,116.2
X$6082 77 9113 9265 9112 8320 109 DFF_X1
* cell instance $6083 m0 *1 198.55,116.2
X$6083 9265 77 109 9061 CLKBUF_X2
* cell instance $6086 m0 *1 202.54,116.2
X$6086 9228 8614 9261 77 109 9264 MUX2_X1
* cell instance $6087 m0 *1 203.87,116.2
X$6087 9373 9865 9228 77 109 9232 NAND3_X1
* cell instance $6088 m0 *1 204.63,116.2
X$6088 9233 6936 9230 77 109 5408 MUX2_X1
* cell instance $6089 m0 *1 205.96,116.2
X$6089 9228 5913 109 77 9262 AND2_X1
* cell instance $6094 r0 *1 191.14,116.2
X$6094 77 9229 9421 9414 9425 109 DFF_X1
* cell instance $6095 r0 *1 194.37,116.2
X$6095 9059 9423 9369 9061 77 109 9367 NAND4_X1
* cell instance $6096 r0 *1 195.32,116.2
X$6096 9421 77 109 9369 BUF_X1
* cell instance $6097 r0 *1 195.89,116.2
X$6097 9416 8110 77 109 7705 NAND2_X1
* cell instance $6098 r0 *1 196.46,116.2
X$6098 9369 8893 9371 77 109 9414 MUX2_X1
* cell instance $6099 r0 *1 197.79,116.2
X$6099 9369 8616 9371 77 109 7675 MUX2_X1
* cell instance $6101 r0 *1 199.31,116.2
X$6101 77 9578 9228 9264 8320 109 DFF_X1
* cell instance $6103 r0 *1 202.73,116.2
X$6103 9228 9259 9373 109 77 9534 AND3_X1
* cell instance $6106 r0 *1 204.25,116.2
X$6106 9407 9232 109 77 9233 XNOR2_X1
* cell instance $6108 r0 *1 206.15,116.2
X$6108 77 9407 9259 9406 9108 109 DFF_X1
* cell instance $6109 m0 *1 207.29,116.2
X$6109 9262 9261 8895 77 7534 109 AOI21_X2
* cell instance $6114 m0 *1 209.95,116.2
X$6114 9375 109 4087 77 BUF_X4
* cell instance $6118 m0 *1 212.23,116.2
X$6118 9259 9234 8725 109 77 5236 MUX2_X2
* cell instance $6120 r0 *1 210.14,116.2
X$6120 9375 109 3306 77 BUF_X4
* cell instance $6121 r0 *1 211.47,116.2
X$6121 9259 8614 9234 77 109 9406 MUX2_X1
* cell instance $6123 r0 *1 213.56,116.2
X$6123 9368 8725 9376 77 109 5378 MUX2_X1
* cell instance $6124 m0 *1 215.27,116.2
X$6124 77 18378 9063 9258 7824 109 DFF_X1
* cell instance $6125 m0 *1 214.32,116.2
X$6125 9235 8726 77 109 9078 NAND2_X2
* cell instance $6126 m0 *1 218.5,116.2
X$6126 9063 77 109 9256 INV_X1
* cell instance $6129 r0 *1 214.89,116.2
X$6129 3593 77 109 9066 CLKBUF_X3
* cell instance $6130 r0 *1 215.84,116.2
X$6130 9379 9063 77 109 9377 NAND2_X1
* cell instance $6131 r0 *1 216.41,116.2
X$6131 9377 3306 2348 109 9402 77 OAI21_X1
* cell instance $6132 r0 *1 217.17,116.2
X$6132 9378 9379 4307 8893 109 77 9404 OAI22_X1
* cell instance $6133 r0 *1 218.12,116.2
X$6133 9256 9404 9401 9402 77 109 9258 AOI22_X1
* cell instance $6136 r0 *1 219.64,116.2
X$6136 77 18390 9376 9381 7982 109 DFF_X1
* cell instance $6137 m0 *1 220.97,116.2
X$6137 9252 8749 77 109 9542 NAND2_X1
* cell instance $6140 m0 *1 222.3,116.2
X$6140 7551 8124 77 109 9251 NAND2_X1
* cell instance $6142 m0 *1 223.06,116.2
X$6142 3592 9247 77 9382 109 OR2_X4
* cell instance $6146 r0 *1 224.01,116.2
X$6146 9399 8734 7131 7387 7549 9876 109 77 AOI221_X2
* cell instance $6147 m0 *1 225.34,116.2
X$6147 9249 77 109 8894 CLKBUF_X2
* cell instance $6150 m0 *1 226.29,116.2
X$6150 9236 8734 7247 7387 8129 9248 109 77 AOI221_X2
* cell instance $6152 m0 *1 228.57,116.2
X$6152 9246 2394 9076 77 8905 109 AOI21_X1
* cell instance $6154 m0 *1 229.52,116.2
X$6154 9245 9237 7828 7387 8588 9247 109 77 AOI221_X2
* cell instance $6155 m0 *1 231.61,116.2
X$6155 9243 9237 5510 8587 5387 9391 109 77 AOI221_X2
* cell instance $6156 m0 *1 233.7,116.2
X$6156 8896 9090 109 77 9242 XNOR2_X1
* cell instance $6157 m0 *1 234.84,116.2
X$6157 8904 2394 9242 77 9240 109 AOI21_X1
* cell instance $6159 r0 *1 226.1,116.2
X$6159 3592 9248 77 109 9398 OR2_X2
* cell instance $6164 r0 *1 227.24,116.2
X$6164 6088 5107 8587 77 9397 109 AOI21_X1
* cell instance $6165 r0 *1 228,116.2
X$6165 7387 109 8587 77 BUF_X4
* cell instance $6166 r0 *1 229.33,116.2
X$6166 9396 8734 6088 7387 5107 10024 109 77 AOI221_X2
* cell instance $6167 r0 *1 231.42,116.2
X$6167 9393 9237 6215 8587 6217 9548 109 77 AOI221_X2
* cell instance $6169 r0 *1 233.7,116.2
X$6169 2526 9387 8743 109 9386 77 OAI21_X1
* cell instance $6173 r0 *1 235.79,116.2
X$6173 6952 77 109 8735 CLKBUF_X3
* cell instance $6175 m0 *1 235.98,116.2
X$6175 77 18383 9238 9240 8735 109 DFF_X1
* cell instance $6176 r0 *1 236.74,116.2
X$6176 9239 77 109 7688 BUF_X1
* cell instance $6177 r0 *1 237.31,116.2
X$6177 9384 77 109 6217 BUF_X1
* cell instance $6179 r0 *1 238.26,116.2
X$6179 9081 77 109 8588 BUF_X1
* cell instance $6180 r0 *1 238.83,116.2
X$6180 9238 77 109 8896 CLKBUF_X2
* cell instance $6183 m0 *1 1.33,107.8
X$6183 77 7914 8391 8300 8298 4909 109 DFFR_X1
* cell instance $6186 m0 *1 5.89,107.8
X$6186 8391 5506 8452 77 109 8522 MUX2_X1
* cell instance $6187 m0 *1 7.22,107.8
X$6187 8391 7912 8452 77 109 8392 MUX2_X1
* cell instance $6189 m0 *1 10.07,107.8
X$6189 8455 5167 8051 77 109 8393 MUX2_X1
* cell instance $6190 m0 *1 11.4,107.8
X$6190 77 7914 8219 8455 8393 4909 109 DFFR_X1
* cell instance $6192 m0 *1 15.96,107.8
X$6192 77 7459 8222 8456 8221 4909 109 DFFR_X1
* cell instance $6193 m0 *1 19.76,107.8
X$6193 77 7459 8395 8307 8394 4909 109 DFFR_X1
* cell instance $6198 m0 *1 29.07,107.8
X$6198 8399 6885 4770 77 109 8459 MUX2_X1
* cell instance $6199 m0 *1 30.4,107.8
X$6199 77 7464 18503 8399 8459 4909 109 DFFR_X1
* cell instance $6202 m0 *1 35.91,107.8
X$6202 77 8462 8396 7026 4404 109 AOI21_X4
* cell instance $6203 m0 *1 38.38,107.8
X$6203 8155 77 109 8465 INV_X1
* cell instance $6204 m0 *1 38.76,107.8
X$6204 4967 77 109 8397 INV_X1
* cell instance $6210 r0 *1 2.66,107.8
X$6210 77 8661 8739 8593 8592 4909 109 DFFR_X1
* cell instance $6214 r0 *1 6.46,107.8
X$6214 8522 6014 8523 77 109 8216 MUX2_X1
* cell instance $6217 r0 *1 14.25,107.8
X$6217 8218 8005 8219 77 109 8748 MUX2_X1
* cell instance $6219 r0 *1 15.96,107.8
X$6219 8454 6158 8594 77 109 8524 MUX2_X1
* cell instance $6223 r0 *1 19.95,107.8
X$6223 7180 77 109 19094 INV_X4
* cell instance $6225 r0 *1 23.94,107.8
X$6225 8596 5577 5514 77 109 8597 MUX2_X1
* cell instance $6228 r0 *1 28.69,107.8
X$6228 8599 5020 4770 77 109 8526 MUX2_X1
* cell instance $6229 r0 *1 30.02,107.8
X$6229 77 8525 8527 8599 8526 4909 109 DFFR_X1
* cell instance $6232 r0 *1 34.77,107.8
X$6232 8225 8666 8527 77 109 8605 MUX2_X1
* cell instance $6233 r0 *1 36.1,107.8
X$6233 8225 8535 8527 77 109 8610 MUX2_X1
* cell instance $6234 r0 *1 37.43,107.8
X$6234 8602 8757 5959 77 109 8318 NOR3_X1
* cell instance $6235 r0 *1 38.19,107.8
X$6235 8605 6902 77 109 8528 NOR2_X1
* cell instance $6237 r0 *1 38.95,107.8
X$6237 8529 8397 6866 8407 8606 77 109 8602 AOI221_X1
* cell instance $6238 m0 *1 40.28,107.8
X$6238 8399 8229 77 109 8398 NOR2_X1
* cell instance $6239 m0 *1 39.52,107.8
X$6239 8398 8463 8224 77 8606 109 AOI21_X1
* cell instance $6241 m0 *1 41.04,107.8
X$6241 8401 8463 8227 77 8400 109 AOI21_X1
* cell instance $6242 m0 *1 41.8,107.8
X$6242 8468 6290 8227 77 8531 109 AOI21_X1
* cell instance $6243 m0 *1 42.56,107.8
X$6243 8402 6290 8224 77 8470 109 AOI21_X1
* cell instance $6244 m0 *1 43.32,107.8
X$6244 8399 8345 77 109 8402 NOR2_X1
* cell instance $6247 r0 *1 40.09,107.8
X$6247 8529 8465 6866 8407 8400 77 109 8530 AOI221_X1
* cell instance $6248 r0 *1 41.23,107.8
X$6248 8530 8764 5959 77 109 8228 NOR3_X1
* cell instance $6249 r0 *1 41.99,107.8
X$6249 8610 7292 77 109 8765 NOR2_X1
* cell instance $6250 r0 *1 42.56,107.8
X$6250 8397 8403 8070 3373 8470 8673 109 77 AOI221_X2
* cell instance $6251 r0 *1 44.65,107.8
X$6251 77 8674 8230 8532 8472 4909 109 DFFR_X1
* cell instance $6253 m0 *1 45.03,107.8
X$6253 4904 7765 8325 109 8324 77 OAI21_X1
* cell instance $6255 m0 *1 46.74,107.8
X$6255 4904 7767 8404 109 8472 77 OAI21_X1
* cell instance $6256 m0 *1 47.5,107.8
X$6256 7922 8532 77 109 8404 NAND2_X1
* cell instance $6258 m0 *1 48.64,107.8
X$6258 77 6978 8405 8406 8473 4909 109 DFFR_X1
* cell instance $6261 m0 *1 53.96,107.8
X$6261 4904 6730 8475 109 8331 77 OAI21_X1
* cell instance $6262 m0 *1 54.72,107.8
X$6262 8330 6236 77 109 8485 NOR2_X2
* cell instance $6263 m0 *1 55.67,107.8
X$6263 4904 6823 8619 109 8476 77 OAI21_X1
* cell instance $6267 r0 *1 50.16,107.8
X$6267 6007 109 7760 77 BUF_X4
* cell instance $6270 r0 *1 53.77,107.8
X$6270 77 8676 8534 8533 8476 1663 109 DFFR_X1
* cell instance $6271 m0 *1 57.38,107.8
X$6271 8534 8229 8408 77 109 8536 MUX2_X1
* cell instance $6272 m0 *1 56.81,107.8
X$6272 6725 8533 77 109 8619 NAND2_X1
* cell instance $6273 m0 *1 58.71,107.8
X$6273 8234 8410 7997 109 8233 77 NOR3_X2
* cell instance $6274 m0 *1 60.04,107.8
X$6274 8480 8409 5959 77 109 8410 NOR3_X1
* cell instance $6275 m0 *1 60.8,107.8
X$6275 8337 3861 8335 77 109 8481 MUX2_X1
* cell instance $6276 m0 *1 62.13,107.8
X$6276 5406 8369 6866 8407 8483 8480 109 77 AOI221_X2
* cell instance $6277 m0 *1 64.22,107.8
X$6277 5406 8403 8070 3373 8488 8787 109 77 AOI221_X2
* cell instance $6278 m0 *1 66.31,107.8
X$6278 8487 8463 8489 77 8483 109 AOI21_X1
* cell instance $6279 m0 *1 67.07,107.8
X$6279 8411 6290 8489 77 8488 109 AOI21_X1
* cell instance $6281 m0 *1 68.02,107.8
X$6281 8630 7165 6399 109 77 8632 OAI21_X4
* cell instance $6286 r0 *1 57.76,107.8
X$6286 8534 8535 8408 77 109 8624 MUX2_X1
* cell instance $6290 r0 *1 59.09,107.8
X$6290 8536 6902 77 109 8778 NOR2_X1
* cell instance $6292 r0 *1 59.85,107.8
X$6292 8624 7292 77 109 8626 NOR2_X1
* cell instance $6293 r0 *1 60.42,107.8
X$6293 8481 6231 77 109 8625 NOR2_X1
* cell instance $6294 r0 *1 60.99,107.8
X$6294 8337 8666 8335 77 109 8678 MUX2_X1
* cell instance $6295 r0 *1 62.32,107.8
X$6295 8626 8625 3694 77 109 8679 NOR3_X1
* cell instance $6297 r0 *1 63.46,107.8
X$6297 77 8627 8785 8485 8681 109 NOR3_X4
* cell instance $6300 r0 *1 67.26,107.8
X$6300 7194 8629 77 109 8630 NAND2_X1
* cell instance $6301 r0 *1 67.83,107.8
X$6301 7924 8345 77 109 8411 NOR2_X1
* cell instance $6302 r0 *1 68.4,107.8
X$6302 7924 8229 77 109 8487 NOR2_X1
* cell instance $6303 r0 *1 68.97,107.8
X$6303 77 8537 8682 8629 8632 1663 109 DFFR_X1
* cell instance $6305 r0 *1 72.96,107.8
X$6305 77 8537 8538 8638 8412 1663 109 DFFR_X1
* cell instance $6307 m0 *1 73.15,107.8
X$6307 6538 7765 8413 109 8412 77 OAI21_X1
* cell instance $6309 m0 *1 74.29,107.8
X$6309 7878 8638 77 109 8413 NAND2_X1
* cell instance $6310 m0 *1 75.05,107.8
X$6310 8346 7290 8070 3370 8491 8495 109 77 AOI221_X2
* cell instance $6312 m0 *1 77.33,107.8
X$6312 7912 109 7153 77 BUF_X4
* cell instance $6315 r0 *1 76.95,107.8
X$6315 8538 3498 8539 77 109 8540 MUX2_X1
* cell instance $6316 r0 *1 78.28,107.8
X$6316 8797 3498 9024 77 109 8541 MUX2_X1
* cell instance $6318 m0 *1 79.04,107.8
X$6318 77 7776 8238 8969 8506 8495 109 OAI22_X4
* cell instance $6319 r0 *1 79.61,107.8
X$6319 272 77 109 8967 CLKBUF_X3
* cell instance $6321 m0 *1 83.98,107.8
X$6321 7201 8503 77 109 8643 NAND2_X1
* cell instance $6322 m0 *1 82.65,107.8
X$6322 8191 8241 8414 8499 8356 6670 77 109 8415 OAI33_X1
* cell instance $6323 m0 *1 84.55,107.8
X$6323 7878 8242 77 109 8358 NAND2_X1
* cell instance $6326 m0 *1 86.83,107.8
X$6326 8645 109 3041 77 BUF_X4
* cell instance $6327 m0 *1 88.16,107.8
X$6327 6896 109 7912 77 BUF_X4
* cell instance $6328 m0 *1 89.49,107.8
X$6328 8069 109 5415 77 BUF_X4
* cell instance $6332 r0 *1 83.6,107.8
X$6332 5592 6972 8643 109 8642 77 OAI21_X1
* cell instance $6333 r0 *1 84.36,107.8
X$6333 77 7205 8543 8503 8642 4086 109 DFFR_X1
* cell instance $6337 r0 *1 89.49,107.8
X$6337 6593 109 8359 77 BUF_X4
* cell instance $6338 r0 *1 90.82,107.8
X$6338 8543 5318 8646 77 109 8074 MUX2_X1
* cell instance $6340 r0 *1 92.34,107.8
X$6340 8543 7642 8646 77 109 8417 MUX2_X1
* cell instance $6341 r0 *1 93.67,107.8
X$6341 6896 109 8847 77 BUF_X4
* cell instance $6342 r0 *1 95,107.8
X$6342 8375 109 8249 77 BUF_X4
* cell instance $6343 m0 *1 96.33,107.8
X$6343 7936 109 8421 77 BUF_X4
* cell instance $6344 m0 *1 95,107.8
X$6344 6039 6318 8079 77 109 8508 NAND3_X2
* cell instance $6346 m0 *1 97.85,107.8
X$6346 8509 7469 8422 77 109 8511 MUX2_X1
* cell instance $6347 m0 *1 99.18,107.8
X$6347 77 7337 8418 8509 8511 8201 109 DFFR_X1
* cell instance $6348 m0 *1 102.98,107.8
X$6348 8546 8418 6140 77 8653 109 AOI21_X1
* cell instance $6349 m0 *1 103.74,107.8
X$6349 8418 6383 109 77 8654 AND2_X1
* cell instance $6351 m0 *1 104.69,107.8
X$6351 8513 8249 77 109 8419 NOR2_X1
* cell instance $6352 m0 *1 105.26,107.8
X$6352 8513 5960 77 109 8420 OR2_X1
* cell instance $6353 m0 *1 106.02,107.8
X$6353 4643 8420 7597 109 8516 77 OAI21_X1
* cell instance $6355 m0 *1 106.97,107.8
X$6355 8251 77 109 8422 BUF_X2
* cell instance $6356 m0 *1 107.73,107.8
X$6356 8517 8548 8422 77 109 8423 MUX2_X1
* cell instance $6357 m0 *1 109.06,107.8
X$6357 8251 77 109 7647 BUF_X2
* cell instance $6359 r0 *1 96.33,107.8
X$6359 6896 109 8645 77 BUF_X4
* cell instance $6363 r0 *1 98.99,107.8
X$6363 8645 109 8345 77 BUF_X4
* cell instance $6364 r0 *1 100.32,107.8
X$6364 77 8544 18744 8688 8545 8687 109 DFFR_X1
* cell instance $6366 r0 *1 104.31,107.8
X$6366 8654 8652 7627 77 109 8547 NOR3_X1
* cell instance $6367 r0 *1 105.07,107.8
X$6367 8653 8249 7087 6140 8419 8550 109 77 AOI221_X2
* cell instance $6368 r0 *1 107.16,107.8
X$6368 8516 8547 7631 109 8818 77 OAI21_X1
* cell instance $6369 r0 *1 107.92,107.8
X$6369 77 9036 8549 8517 8423 8201 109 DFFR_X1
* cell instance $6370 m0 *1 111.53,107.8
X$6370 7647 8232 8519 77 109 8520 MUX2_X1
* cell instance $6371 m0 *1 110.2,107.8
X$6371 8362 109 7618 77 BUF_X4
* cell instance $6372 m0 *1 112.86,107.8
X$6372 77 6900 8255 8519 8520 4086 109 DFFR_X1
* cell instance $6373 m0 *1 116.66,107.8
X$6373 8255 8421 8424 77 109 8425 MUX2_X1
* cell instance $6374 m0 *1 117.99,107.8
X$6374 8425 8249 8521 77 109 8691 MUX2_X1
* cell instance $6376 m0 *1 119.51,107.8
X$6376 8257 8421 8258 77 109 8521 MUX2_X1
* cell instance $6379 r0 *1 111.72,107.8
X$6379 8253 6125 8551 77 109 8552 MUX2_X1
* cell instance $6385 r0 *1 115.33,107.8
X$6385 8553 8554 6726 109 77 7041 MUX2_X2
* cell instance $6386 r0 *1 117.04,107.8
X$6386 8657 6694 8656 77 8554 109 AOI21_X2
* cell instance $6387 r0 *1 118.37,107.8
X$6387 8550 6866 8658 77 8656 109 AOI21_X1
* cell instance $6389 r0 *1 119.51,107.8
X$6389 8555 6694 77 109 8657 NOR2_X1
* cell instance $6393 r0 *1 121.22,107.8
X$6393 77 8692 8424 8659 8660 4086 109 DFFR_X1
* cell instance $6394 m0 *1 122.17,107.8
X$6394 8261 5434 77 109 8390 NAND2_X1
* cell instance $6396 m0 *1 122.74,107.8
X$6396 7652 77 109 6569 CLKBUF_X3
* cell instance $6397 m0 *1 123.69,107.8
X$6397 5711 109 5990 77 BUF_X4
* cell instance $6398 m0 *1 125.02,107.8
X$6398 4525 5990 9042 77 109 NOR2_X4
* cell instance $6399 m0 *1 126.73,107.8
X$6399 7652 5748 4611 77 109 8426 MUX2_X1
* cell instance $6401 m0 *1 128.25,107.8
X$6401 8266 109 8427 77 BUF_X4
* cell instance $6402 m0 *1 129.58,107.8
X$6402 7652 5748 6698 77 8557 109 AOI21_X2
* cell instance $6403 m0 *1 130.91,107.8
X$6403 8518 8086 109 77 8697 AND2_X1
* cell instance $6404 m0 *1 131.67,107.8
X$6404 7650 77 109 8515 INV_X1
* cell instance $6405 m0 *1 132.05,107.8
X$6405 77 8514 8039 6699 8428 109 AOI21_X4
* cell instance $6406 m0 *1 134.52,107.8
X$6406 8512 5557 5712 77 109 NOR2_X4
* cell instance $6407 m0 *1 136.23,107.8
X$6407 8430 8429 8090 77 109 8431 MUX2_X1
* cell instance $6411 r0 *1 125.4,107.8
X$6411 8512 4525 77 109 4608 NOR2_X2
* cell instance $6412 r0 *1 126.35,107.8
X$6412 77 8877 8039 8427 8086 109 AOI21_X4
* cell instance $6413 r0 *1 128.82,107.8
X$6413 7315 5160 7945 7907 8695 109 77 AOI211_X2
* cell instance $6414 r0 *1 130.53,107.8
X$6414 7790 77 109 8655 INV_X1
* cell instance $6415 r0 *1 130.91,107.8
X$6415 5861 5990 77 109 8428 NOR2_X2
* cell instance $6416 r0 *1 131.86,107.8
X$6416 8829 77 109 8698 BUF_X1
* cell instance $6417 r0 *1 132.43,107.8
X$6417 77 5472 5990 5861 6699 8558 109 NOR4_X4
* cell instance $6418 r0 *1 135.85,107.8
X$6418 8827 109 7232 77 BUF_X4
* cell instance $6420 r0 *1 137.56,107.8
X$6420 8564 8563 8561 77 8562 109 AOI21_X1
* cell instance $6422 r0 *1 138.51,107.8
X$6422 8564 8563 7302 77 109 8651 MUX2_X1
* cell instance $6423 m0 *1 139.27,107.8
X$6423 7302 8510 8271 77 109 8700 MUX2_X1
* cell instance $6424 m0 *1 138.7,107.8
X$6424 8374 7357 77 109 8563 NOR2_X1
* cell instance $6425 m0 *1 140.6,107.8
X$6425 8432 7226 77 109 8510 NAND2_X1
* cell instance $6427 m0 *1 141.36,107.8
X$6427 8507 8374 8433 77 8820 109 AOI21_X2
* cell instance $6429 m0 *1 142.88,107.8
X$6429 8435 7502 7302 77 8501 109 AOI21_X2
* cell instance $6431 m0 *1 144.4,107.8
X$6431 8504 7897 7357 77 8436 109 AOI21_X1
* cell instance $6435 r0 *1 140.98,107.8
X$6435 8205 8560 8093 77 109 8565 MUX2_X1
* cell instance $6436 r0 *1 142.31,107.8
X$6436 8650 8434 8567 8205 109 77 8566 OAI22_X1
* cell instance $6437 r0 *1 143.26,107.8
X$6437 8429 8504 77 109 8567 NAND2_X1
* cell instance $6439 r0 *1 144.59,107.8
X$6439 8569 8436 8437 77 8649 109 AOI21_X2
* cell instance $6441 m0 *1 145.54,107.8
X$6441 7357 8270 77 109 8437 OR2_X1
* cell instance $6443 r0 *1 145.92,107.8
X$6443 8648 8269 8706 77 109 8647 NOR3_X1
* cell instance $6444 r0 *1 146.68,107.8
X$6444 7658 7507 77 109 8648 NOR2_X1
* cell instance $6445 r0 *1 147.25,107.8
X$6445 8647 8560 77 109 8813 NOR2_X2
* cell instance $6446 m0 *1 148.96,107.8
X$6446 7098 7052 77 8378 109 NAND2_X4
* cell instance $6447 m0 *1 148.2,107.8
X$6447 7052 7098 109 77 8377 AND2_X1
* cell instance $6448 m0 *1 150.67,107.8
X$6448 7894 8502 7658 77 109 8500 MUX2_X1
* cell instance $6453 r0 *1 148.58,107.8
X$6453 77 8381 5892 8989 8639 109 AOI21_X4
* cell instance $6454 r0 *1 151.05,107.8
X$6454 8094 8429 8187 77 109 8644 MUX2_X1
* cell instance $6458 r0 *1 153.71,107.8
X$6458 8560 8504 8501 77 8570 109 AOI21_X1
* cell instance $6459 r0 *1 154.47,107.8
X$6459 8570 8504 8274 109 77 8637 OAI21_X2
* cell instance $6460 m0 *1 156.56,107.8
X$6460 8438 8429 8494 77 109 8498 MUX2_X1
* cell instance $6461 m0 *1 154.66,107.8
X$6461 3882 6401 19040 109 77 8497 HA_X1
* cell instance $6465 r0 *1 155.8,107.8
X$6465 8187 8429 8361 77 109 8810 MUX2_X1
* cell instance $6470 r0 *1 159.98,107.8
X$6470 8641 8640 8650 109 9150 77 NOR3_X2
* cell instance $6472 m0 *1 160.55,107.8
X$6472 8493 8496 7357 77 109 8641 NOR3_X1
* cell instance $6473 r0 *1 161.31,107.8
X$6473 8569 8706 8275 77 8571 109 AOI21_X1
* cell instance $6474 m0 *1 161.88,107.8
X$6474 6762 8439 6396 77 109 8440 MUX2_X1
* cell instance $6477 m0 *1 163.4,107.8
X$6477 8440 5552 8441 77 109 8492 MUX2_X1
* cell instance $6479 m0 *1 164.92,107.8
X$6479 6603 7295 8636 109 8441 77 OAI21_X1
* cell instance $6481 m0 *1 165.87,107.8
X$6481 8441 5552 8279 77 109 8348 MUX2_X1
* cell instance $6486 r0 *1 163.4,107.8
X$6486 3470 8572 77 109 8639 NAND2_X1
* cell instance $6488 r0 *1 164.16,107.8
X$6488 8573 7295 77 109 6549 NOR2_X2
* cell instance $6489 r0 *1 165.11,107.8
X$6489 7295 6605 77 109 8636 NAND2_X1
* cell instance $6491 r0 *1 165.87,107.8
X$6491 8574 8637 8576 77 8633 109 AOI21_X1
* cell instance $6493 r0 *1 166.82,107.8
X$6493 8635 8577 109 77 8634 AND2_X1
* cell instance $6495 m0 *1 168.91,107.8
X$6495 7036 8439 6663 77 109 8490 MUX2_X1
* cell instance $6496 m0 *1 167.58,107.8
X$6496 8490 5552 8280 77 109 8276 MUX2_X1
* cell instance $6497 m0 *1 170.24,107.8
X$6497 7805 77 109 8439 CLKBUF_X3
* cell instance $6498 m0 *1 171.19,107.8
X$6498 8282 109 7095 77 BUF_X4
* cell instance $6500 r0 *1 167.96,107.8
X$6500 77 5852 2742 8631 8633 9439 109 OR4_X4
* cell instance $6506 r0 *1 172.33,107.8
X$6506 5688 7809 19078 109 77 8578 HA_X1
* cell instance $6508 m0 *1 172.9,107.8
X$6508 7520 77 109 7963 INV_X1
* cell instance $6511 m0 *1 174.61,107.8
X$6511 8622 8486 8479 109 8484 77 NOR3_X2
* cell instance $6513 m0 *1 175.94,107.8
X$6513 8442 8104 8360 77 8482 109 AOI21_X2
* cell instance $6514 m0 *1 177.27,107.8
X$6514 5895 109 8282 77 BUF_X4
* cell instance $6516 m0 *1 178.79,107.8
X$6516 8104 8443 8479 109 77 8478 OAI21_X2
* cell instance $6518 m0 *1 180.31,107.8
X$6518 8477 77 109 8285 CLKBUF_X3
* cell instance $6519 m0 *1 181.26,107.8
X$6519 5541 77 109 8106 CLKBUF_X3
* cell instance $6520 m0 *1 182.21,107.8
X$6520 7146 77 109 7231 INV_X4
* cell instance $6521 m0 *1 183.16,107.8
X$6521 77 7966 18666 8286 8621 3676 109 DFFR_X1
* cell instance $6525 r0 *1 174.8,107.8
X$6525 77 7966 18826 6119 8628 3676 109 DFFR_X1
* cell instance $6526 r0 *1 178.6,107.8
X$6526 77 8285 18777 6825 8580 3676 109 DFFR_X1
* cell instance $6528 r0 *1 182.59,107.8
X$6528 8286 7965 8623 77 109 8621 MUX2_X1
* cell instance $6529 r0 *1 183.92,107.8
X$6529 8445 8104 109 77 8622 AND2_X1
* cell instance $6532 m0 *1 189.05,107.8
X$6532 8617 8474 109 77 8167 XNOR2_X1
* cell instance $6534 m0 *1 190.19,107.8
X$6534 3637 8443 8445 7709 77 109 8474 NAND4_X1
* cell instance $6535 m0 *1 191.14,107.8
X$6535 3637 8445 7709 77 109 8721 NAND3_X1
* cell instance $6536 m0 *1 191.9,107.8
X$6536 8469 8581 109 77 8164 XNOR2_X1
* cell instance $6537 m0 *1 193.04,107.8
X$6537 8288 8582 77 109 7374 NAND2_X1
* cell instance $6541 m0 *1 196.08,107.8
X$6541 77 8615 8320 8321 8445 109 DFF_X2
* cell instance $6542 m0 *1 199.69,107.8
X$6542 77 8320 18610 8316 8467 3676 109 DFFR_X1
* cell instance $6545 r0 *1 189.62,107.8
X$6545 8890 8620 77 109 6818 XOR2_X1
* cell instance $6547 r0 *1 191.14,107.8
X$6547 8287 3637 8618 8443 77 109 8620 NAND4_X1
* cell instance $6549 r0 *1 192.28,107.8
X$6549 8722 8287 3637 77 109 8581 NAND3_X1
* cell instance $6551 r0 *1 193.23,107.8
X$6551 8287 3637 77 109 8583 NAND2_X1
* cell instance $6552 r0 *1 193.8,107.8
X$6552 8613 8583 109 77 8471 XNOR2_X1
* cell instance $6554 r0 *1 195.32,107.8
X$6554 5971 109 8725 77 BUF_X4
* cell instance $6557 r0 *1 197.22,107.8
X$6557 5971 109 8616 77 BUF_X4
* cell instance $6560 r0 *1 199.69,107.8
X$6560 8445 8614 8609 77 109 8615 MUX2_X1
* cell instance $6561 r0 *1 201.02,107.8
X$6561 77 8613 8612 8585 7971 109 DFF_X1
* cell instance $6562 m0 *1 207.67,107.8
X$6562 7971 77 109 19231 CLKBUF_X1
* cell instance $6563 m0 *1 203.87,107.8
X$6563 77 7971 18658 8118 8466 3676 109 DFFR_X1
* cell instance $6565 m0 *1 209,107.8
X$6565 7387 8608 6097 77 109 8464 OR3_X1
* cell instance $6568 m0 *1 212.23,107.8
X$6568 77 7971 18670 8294 8446 3676 109 DFFR_X1
* cell instance $6572 r0 *1 204.25,107.8
X$6572 8612 77 109 8443 BUF_X2
* cell instance $6576 r0 *1 207.67,107.8
X$6576 6252 6126 77 109 8611 NOR2_X1
* cell instance $6579 r0 *1 209.19,107.8
X$6579 7822 4864 6252 6126 8464 8607 77 109 OAI221_X2
* cell instance $6581 r0 *1 211.66,107.8
X$6581 77 7824 18725 8146 8293 3676 109 DFFR_X1
* cell instance $6584 r0 *1 216.6,107.8
X$6584 6952 77 109 7824 CLKBUF_X3
* cell instance $6585 r0 *1 217.55,107.8
X$6585 7824 77 109 19319 CLKBUF_X1
* cell instance $6587 m0 *1 218.88,107.8
X$6587 6976 5385 8586 5228 77 109 8305 AOI22_X1
* cell instance $6589 m0 *1 219.83,107.8
X$6589 3408 5509 8461 77 109 8447 MUX2_X1
* cell instance $6590 m0 *1 221.16,107.8
X$6590 77 7982 8447 992 18939 3408 109 DFFR_X2
* cell instance $6593 r0 *1 219.83,107.8
X$6593 8604 6614 77 109 8601 NAND2_X1
* cell instance $6594 r0 *1 220.4,107.8
X$6594 3408 6496 8586 77 109 8756 MUX2_X1
* cell instance $6595 r0 *1 221.73,107.8
X$6595 6225 7822 8601 77 109 8598 MUX2_X1
* cell instance $6596 r0 *1 223.06,107.8
X$6596 1236 77 109 6952 CLKBUF_X3
* cell instance $6598 r0 *1 224.2,107.8
X$6598 7982 77 109 19264 CLKBUF_X1
* cell instance $6599 r0 *1 224.77,107.8
X$6599 6121 109 7387 77 BUF_X4
* cell instance $6600 m0 *1 227.05,107.8
X$6600 8151 5385 8295 5228 77 109 8304 AOI22_X1
* cell instance $6601 m0 *1 225.72,107.8
X$6601 3700 5509 8460 77 109 8448 MUX2_X1
* cell instance $6604 r0 *1 226.1,107.8
X$6604 77 7982 8448 992 18987 3700 109 DFFR_X2
* cell instance $6610 r0 *1 230.85,107.8
X$6610 77 7976 8458 992 18977 3972 109 DFFR_X2
* cell instance $6611 m0 *1 232.75,107.8
X$6611 1330 5259 8595 109 8457 77 OAI21_X1
* cell instance $6612 m0 *1 231.42,107.8
X$6612 3972 5509 8457 77 109 8458 MUX2_X1
* cell instance $6614 m0 *1 234.84,107.8
X$6614 6628 5385 8449 5228 77 109 8128 AOI22_X1
* cell instance $6615 m0 *1 233.89,107.8
X$6615 5800 5385 8589 5228 77 109 8595 AOI22_X1
* cell instance $6616 m0 *1 235.79,107.8
X$6616 77 7976 18622 8449 8453 992 109 DFFR_X1
* cell instance $6618 r0 *1 235.03,107.8
X$6618 3972 6496 8589 77 109 8741 MUX2_X1
* cell instance $6619 r0 *1 236.36,107.8
X$6619 5637 6496 8449 77 109 8453 MUX2_X1
* cell instance $6620 r0 *1 237.69,107.8
X$6620 8591 77 109 4855 BUF_X1
* cell instance $6621 r0 *1 238.26,107.8
X$6621 8451 77 109 8296 BUF_X1
* cell instance $6623 r0 *1 239.02,107.8
X$6623 8590 77 109 6350 BUF_X1
* cell instance $6625 m0 *1 1.33,77
X$6625 77 4894 5571 5504 5440 2157 109 DFFR_X1
* cell instance $6628 m0 *1 5.32,77
X$6628 4895 5506 5302 77 109 5572 MUX2_X1
* cell instance $6630 m0 *1 7.41,77
X$6630 77 4894 5441 5442 5508 2157 109 DFFR_X1
* cell instance $6631 m0 *1 11.21,77
X$6631 5442 5301 2540 77 109 5508 MUX2_X1
* cell instance $6639 r0 *1 4.75,77
X$6639 5570 3041 5571 77 109 5644 MUX2_X1
* cell instance $6640 r0 *1 6.08,77
X$6640 5643 3364 5644 77 109 5794 MUX2_X1
* cell instance $6642 r0 *1 7.79,77
X$6642 6011 77 109 4005 BUF_X2
* cell instance $6645 r0 *1 9.5,77
X$6645 5166 5506 5645 77 109 5866 MUX2_X1
* cell instance $6646 r0 *1 10.83,77
X$6646 5166 3603 5645 77 109 5717 MUX2_X1
* cell instance $6648 r0 *1 12.54,77
X$6648 77 5410 109 5446 BUF_X8
* cell instance $6649 m0 *1 13.11,77
X$6649 5103 77 109 19213 CLKBUF_X1
* cell instance $6652 m0 *1 14.25,77
X$6652 3101 77 109 5103 CLKBUF_X3
* cell instance $6654 m0 *1 15.2,77
X$6654 3781 77 109 4193 BUF_X2
* cell instance $6657 r0 *1 15.01,77
X$6657 77 5103 5796 5647 5646 2157 109 DFFR_X1
* cell instance $6659 m0 *1 17.1,77
X$6659 5647 3782 5444 77 109 5646 MUX2_X1
* cell instance $6660 m0 *1 20.14,77
X$6660 5445 4393 5016 77 109 5649 MUX2_X1
* cell instance $6661 m0 *1 18.81,77
X$6661 5443 4065 5444 77 109 5573 MUX2_X1
* cell instance $6664 m0 *1 23.75,77
X$6664 5511 5580 5172 77 109 5574 MUX2_X1
* cell instance $6665 m0 *1 25.08,77
X$6665 5106 5310 5018 77 109 5576 MUX2_X1
* cell instance $6666 m0 *1 26.41,77
X$6666 5172 5513 5018 77 109 5517 MUX2_X1
* cell instance $6667 m0 *1 27.74,77
X$6667 5511 5536 5106 77 109 5516 MUX2_X1
* cell instance $6668 m0 *1 29.07,77
X$6668 77 5449 5516 5803 5451 5517 5455 5304 109 AOI222_X2
* cell instance $6671 m0 *1 33.44,77
X$6671 77 5461 109 4320 BUF_X8
* cell instance $6673 r0 *1 18.81,77
X$6673 77 4389 5720 5443 5573 2157 109 DFFR_X1
* cell instance $6677 r0 *1 25.08,77
X$6677 5574 5575 5576 77 109 5943 MUX2_X1
* cell instance $6680 r0 *1 28.12,77
X$6680 5446 109 5575 77 BUF_X4
* cell instance $6685 r0 *1 32.3,77
X$6685 77 4899 5306 5807 5724 2157 109 DFFR_X1
* cell instance $6687 m0 *1 37.62,77
X$6687 5174 5178 5246 77 109 5308 MUX2_X1
* cell instance $6688 m0 *1 36.29,77
X$6688 5447 3995 5023 77 109 5657 MUX2_X1
* cell instance $6689 m0 *1 38.95,77
X$6689 5450 109 4065 77 BUF_X4
* cell instance $6690 m0 *1 40.28,77
X$6690 77 4773 5660 109 BUF_X32
* cell instance $6691 m0 *1 49.59,77
X$6691 77 5449 5179 5525 5451 4902 5401 4139 109 AOI222_X2
* cell instance $6692 m0 *1 52.25,77
X$6692 5452 5580 5453 77 109 5665 MUX2_X1
* cell instance $6693 m0 *1 53.58,77
X$6693 2795 5175 109 77 5664 AND2_X1
* cell instance $6694 m0 *1 54.34,77
X$6694 5452 5275 5454 77 109 5666 MUX2_X1
* cell instance $6695 m0 *1 55.67,77
X$6695 5454 5310 5032 77 109 5668 MUX2_X1
* cell instance $6696 m0 *1 57,77
X$6696 5453 5729 5032 77 109 5581 MUX2_X1
* cell instance $6699 m0 *1 62.13,77
X$6699 5457 5960 5526 77 109 5669 MUX2_X1
* cell instance $6703 r0 *1 36.67,77
X$6703 5174 5656 5448 77 109 5658 MUX2_X1
* cell instance $6704 r0 *1 38,77
X$6704 5873 109 5726 77 BUF_X4
* cell instance $6705 r0 *1 39.33,77
X$6705 77 4773 5522 109 BUF_X32
* cell instance $6706 r0 *1 48.64,77
X$6706 3489 5661 2367 77 109 5579 MUX2_X1
* cell instance $6707 r0 *1 49.97,77
X$6707 5579 6017 5662 77 109 5813 MUX2_X1
* cell instance $6708 r0 *1 51.3,77
X$6708 3180 5580 2704 77 109 5662 MUX2_X1
* cell instance $6709 r0 *1 52.63,77
X$6709 5664 109 3782 77 BUF_X4
* cell instance $6710 r0 *1 53.96,77
X$6710 5177 77 109 19163 INV_X1
* cell instance $6711 r0 *1 54.34,77
X$6711 5665 5575 5668 77 109 5816 MUX2_X1
* cell instance $6713 r0 *1 55.86,77
X$6713 5175 109 3000 77 BUF_X4
* cell instance $6714 r0 *1 57.19,77
X$6714 77 5449 5666 6295 5451 5581 5455 5669 109 AOI222_X2
* cell instance $6718 r0 *1 59.85,77
X$6718 5456 4393 5312 77 109 5819 MUX2_X1
* cell instance $6723 r0 *1 64.03,77
X$6723 5962 77 109 5034 CLKBUF_X3
* cell instance $6724 r0 *1 64.98,77
X$6724 77 5034 5530 5529 5527 4909 109 DFFR_X1
* cell instance $6725 m0 *1 65.93,77
X$6725 5314 5176 5670 109 5527 77 OAI21_X1
* cell instance $6726 m0 *1 65.36,77
X$6726 4204 5529 77 109 5670 NAND2_X1
* cell instance $6728 m0 *1 67.83,77
X$6728 5733 109 2459 77 BUF_X4
* cell instance $6729 m0 *1 67.07,77
X$6729 5314 5180 5528 109 5264 77 OAI21_X1
* cell instance $6731 r0 *1 68.78,77
X$6731 5034 77 109 19294 CLKBUF_X1
* cell instance $6732 r0 *1 69.35,77
X$6732 5530 4496 5266 77 109 5671 MUX2_X1
* cell instance $6733 m0 *1 69.73,77
X$6733 5532 3482 5531 77 109 6168 MUX2_X1
* cell instance $6735 m0 *1 71.06,77
X$6735 5265 4496 5037 77 109 5583 MUX2_X1
* cell instance $6738 m0 *1 74.67,77
X$6738 77 4324 5585 5317 5458 1663 109 DFFR_X1
* cell instance $6739 m0 *1 78.47,77
X$6739 3995 109 5960 77 BUF_X4
* cell instance $6740 m0 *1 79.8,77
X$6740 5270 3906 4982 77 109 5884 MUX2_X1
* cell instance $6742 m0 *1 81.89,77
X$6742 5537 5536 5459 77 109 5586 MUX2_X1
* cell instance $6744 m0 *1 83.98,77
X$6744 5462 4204 5587 109 5538 77 OAI21_X1
* cell instance $6746 m0 *1 84.93,77
X$6746 4204 5542 77 109 5587 NAND2_X1
* cell instance $6748 m0 *1 87.02,77
X$6748 77 5449 5678 5680 5451 5463 3911 5455 109 AOI222_X2
* cell instance $6751 m0 *1 90.63,77
X$6751 5464 5461 5544 77 109 5590 MUX2_X1
* cell instance $6752 m0 *1 91.96,77
X$6752 5460 77 109 5462 CLKBUF_X3
* cell instance $6755 m0 *1 96.71,77
X$6755 4911 3627 4793 77 109 5467 MUX2_X1
* cell instance $6756 m0 *1 98.04,77
X$6756 5045 3627 5049 77 109 5466 MUX2_X1
* cell instance $6757 m0 *1 99.37,77
X$6757 5465 3302 5466 77 109 5593 MUX2_X1
* cell instance $6758 m0 *1 100.7,77
X$6758 5321 3302 5467 77 109 5546 MUX2_X1
* cell instance $6759 m0 *1 102.03,77
X$6759 5053 5546 5325 77 5468 109 AOI21_X1
* cell instance $6760 m0 *1 102.79,77
X$6760 5468 5547 5594 109 77 3701 MUX2_X2
* cell instance $6761 m0 *1 104.5,77
X$6761 5053 4743 5325 77 5595 109 AOI21_X2
* cell instance $6762 m0 *1 105.83,77
X$6762 5053 4999 5325 77 5890 109 AOI21_X2
* cell instance $6763 m0 *1 107.16,77
X$6763 3587 4451 77 109 5851 NAND2_X1
* cell instance $6766 m0 *1 109.44,77
X$6766 77 3887 5548 6134 5186 109 AOI21_X4
* cell instance $6768 r0 *1 70.68,77
X$6768 5967 5671 5449 77 5582 109 AOI21_X1
* cell instance $6769 r0 *1 71.44,77
X$6769 5825 5582 77 109 5584 NAND2_X1
* cell instance $6770 r0 *1 72.01,77
X$6770 4425 5455 5584 5040 5672 5673 109 77 AOI221_X2
* cell instance $6771 r0 *1 74.1,77
X$6771 4204 5829 77 109 5675 NAND2_X1
* cell instance $6772 r0 *1 74.67,77
X$6772 5674 5313 2548 109 77 5828 OAI21_X4
* cell instance $6773 r0 *1 77.14,77
X$6773 5675 5176 5316 109 77 5830 OAI21_X4
* cell instance $6774 r0 *1 79.61,77
X$6774 5585 3500 4982 77 109 5737 MUX2_X1
* cell instance $6776 r0 *1 82.46,77
X$6776 77 5540 5840 5542 5538 1663 109 DFFR_X1
* cell instance $6777 r0 *1 86.26,77
X$6777 5840 5536 5588 77 109 5678 MUX2_X1
* cell instance $6781 r0 *1 89.68,77
X$6781 3189 5589 3057 77 109 5842 MUX2_X1
* cell instance $6782 r0 *1 91.01,77
X$6782 2418 5589 3385 77 109 5742 MUX2_X1
* cell instance $6783 r0 *1 92.34,77
X$6783 5592 4204 5591 109 5843 77 OAI21_X1
* cell instance $6784 r0 *1 93.1,77
X$6784 4204 5684 77 109 5591 NAND2_X1
* cell instance $6785 r0 *1 93.67,77
X$6785 77 3623 6179 5684 5843 1663 109 DFFR_X1
* cell instance $6786 r0 *1 97.47,77
X$6786 4650 77 109 5592 CLKBUF_X3
* cell instance $6788 r0 *1 98.61,77
X$6788 5324 5325 5593 77 5687 109 AOI21_X2
* cell instance $6789 r0 *1 99.94,77
X$6789 5324 5325 3452 77 5847 109 AOI21_X2
* cell instance $6790 r0 *1 101.27,77
X$6790 77 3781 5687 5690 5186 109 AOI21_X4
* cell instance $6792 r0 *1 103.93,77
X$6792 5567 5594 5595 109 77 3892 OAI21_X4
* cell instance $6794 r0 *1 106.59,77
X$6794 5695 5594 77 109 5694 NOR2_X2
* cell instance $6796 r0 *1 107.92,77
X$6796 5554 109 5323 77 BUF_X4
* cell instance $6798 r0 *1 109.44,77
X$6798 77 5326 18776 5698 5696 4086 109 DFFR_X1
* cell instance $6799 m0 *1 112.48,77
X$6799 5189 77 109 5328 INV_X1
* cell instance $6803 r0 *1 113.24,77
X$6803 5698 109 5189 77 BUF_X4
* cell instance $6804 m0 *1 114.76,77
X$6804 5596 5055 5062 77 109 5469 NAND3_X1
* cell instance $6805 m0 *1 114,77
X$6805 5328 5055 5469 109 5696 77 OAI21_X1
* cell instance $6806 m0 *1 115.52,77
X$6806 5551 5701 4928 77 5700 109 AOI21_X1
* cell instance $6807 m0 *1 116.28,77
X$6807 5328 5327 77 109 5701 NOR2_X1
* cell instance $6808 m0 *1 116.85,77
X$6808 5700 77 109 5703 INV_X1
* cell instance $6809 m0 *1 117.23,77
X$6809 5551 77 109 5293 INV_X1
* cell instance $6811 r0 *1 114.57,77
X$6811 5551 5744 5189 5699 109 77 5596 OAI22_X1
* cell instance $6816 r0 *1 115.71,77
X$6816 5327 5597 5551 77 5699 109 AOI21_X1
* cell instance $6818 r0 *1 116.85,77
X$6818 5327 5597 77 109 5702 OR2_X1
* cell instance $6819 r0 *1 117.61,77
X$6819 5702 4927 5328 109 5857 77 OAI21_X1
* cell instance $6820 m0 *1 118.18,77
X$6820 5293 5470 77 109 5598 NOR2_X1
* cell instance $6822 m0 *1 118.75,77
X$6822 5062 77 109 5470 INV_X1
* cell instance $6825 r0 *1 118.37,77
X$6825 5704 5598 5857 77 5856 109 AOI21_X1
* cell instance $6827 r0 *1 119.32,77
X$6827 5705 5703 171 77 5704 109 AOI21_X1
* cell instance $6830 m0 *1 120.27,77
X$6830 5189 5062 109 77 5555 AND2_X1
* cell instance $6831 m0 *1 121.22,77
X$6831 5188 5330 77 109 5331 NOR2_X1
* cell instance $6832 m0 *1 121.79,77
X$6832 5191 77 109 5471 BUF_X1
* cell instance $6837 r0 *1 121.41,77
X$6837 5990 3630 3314 77 109 5745 MUX2_X1
* cell instance $6838 m0 *1 122.93,77
X$6838 5332 109 5599 77 BUF_X4
* cell instance $6841 m0 *1 124.45,77
X$6841 77 4090 5472 5334 5706 109 NOR3_X4
* cell instance $6843 m0 *1 127.3,77
X$6843 5709 4752 77 109 5859 NOR2_X1
* cell instance $6845 m0 *1 128.06,77
X$6845 5333 5473 5336 109 77 5474 OAI21_X2
* cell instance $6846 m0 *1 129.39,77
X$6846 5557 5711 77 109 5558 NOR2_X1
* cell instance $6847 m0 *1 129.96,77
X$6847 5072 5297 4890 109 5473 77 NOR3_X2
* cell instance $6848 m0 *1 131.29,77
X$6848 4931 4348 77 109 5603 NAND2_X2
* cell instance $6849 m0 *1 132.24,77
X$6849 3918 4090 5065 109 77 5432 AND3_X2
* cell instance $6850 m0 *1 133.38,77
X$6850 4805 5603 5713 3918 4234 4347 77 109 5565 OAI33_X1
* cell instance $6851 m0 *1 134.71,77
X$6851 5071 4090 5068 77 5564 109 AOI21_X2
* cell instance $6852 m0 *1 136.04,77
X$6852 77 5606 4492 4884 5565 109 AOI21_X4
* cell instance $6853 m0 *1 138.51,77
X$6853 4525 4350 4612 77 5195 109 NAND3_X4
* cell instance $6854 m0 *1 140.98,77
X$6854 5479 5569 77 109 5605 OR2_X2
* cell instance $6856 m0 *1 142.12,77
X$6856 5195 4622 5480 5562 5161 5561 77 109 OAI221_X2
* cell instance $6857 m0 *1 144.21,77
X$6857 5350 4809 5568 77 5480 109 AOI21_X2
* cell instance $6858 m0 *1 145.54,77
X$6858 5716 5609 4475 109 5562 77 OAI21_X1
* cell instance $6859 m0 *1 146.3,77
X$6859 5004 5482 5481 77 5340 109 AOI21_X1
* cell instance $6860 m0 *1 147.06,77
X$6860 77 5561 5076 4762 5559 5355 109 NOR4_X4
* cell instance $6861 m0 *1 150.48,77
X$6861 5297 4890 5713 77 109 NOR2_X4
* cell instance $6862 m0 *1 152.19,77
X$6862 5485 4532 5199 77 109 5612 NAND3_X1
* cell instance $6866 r0 *1 123.69,77
X$6866 3815 5707 5566 77 5600 109 AOI21_X1
* cell instance $6867 r0 *1 124.45,77
X$6867 5601 5472 77 109 5707 NOR2_X1
* cell instance $6868 r0 *1 125.02,77
X$6868 5601 3748 3919 109 77 5708 MUX2_X2
* cell instance $6869 r0 *1 126.73,77
X$6869 5334 5472 5336 5473 5333 5897 77 109 OAI221_X2
* cell instance $6871 r0 *1 129.2,77
X$6871 5337 4348 5338 109 77 5999 OAI21_X2
* cell instance $6872 r0 *1 130.53,77
X$6872 5475 4611 5476 77 109 5602 OR3_X1
* cell instance $6873 r0 *1 131.48,77
X$6873 77 5157 5477 3918 4234 5604 109 NAND4_X4
* cell instance $6874 r0 *1 134.9,77
X$6874 3918 4234 5157 5477 109 77 5750 AND4_X2
* cell instance $6876 r0 *1 136.42,77
X$6876 5435 5603 5298 5475 5604 5752 77 109 OAI221_X2
* cell instance $6877 r0 *1 138.51,77
X$6877 4612 4350 5568 77 4927 109 NAND3_X4
* cell instance $6878 r0 *1 140.98,77
X$6878 4350 5199 4306 77 109 5754 NAND3_X1
* cell instance $6879 r0 *1 141.74,77
X$6879 5436 5755 5715 109 77 3073 OAI21_X2
* cell instance $6881 r0 *1 143.45,77
X$6881 4474 4529 5341 77 109 NOR2_X4
* cell instance $6883 r0 *1 145.35,77
X$6883 4477 5199 5077 77 4474 109 NAND3_X4
* cell instance $6884 r0 *1 147.82,77
X$6884 77 5484 5345 1146 5610 5757 109 DFFR_X2
* cell instance $6885 r0 *1 152,77
X$6885 5714 5611 5612 109 4765 77 OAI21_X1
* cell instance $6886 r0 *1 152.76,77
X$6886 5608 5712 5613 77 109 5611 NAND3_X1
* cell instance $6887 m0 *1 154.09,77
X$6887 4988 5615 5759 109 5343 77 OAI21_X1
* cell instance $6888 m0 *1 153.33,77
X$6888 5685 5150 4994 77 5439 109 AOI21_X1
* cell instance $6889 m0 *1 154.85,77
X$6889 77 5554 5854 5352 5486 109 AOI21_X4
* cell instance $6891 m0 *1 157.51,77
X$6891 5616 5613 5200 77 5710 109 AOI21_X1
* cell instance $6892 m0 *1 158.27,77
X$6892 3647 5552 77 109 3823 NOR2_X2
* cell instance $6895 r0 *1 153.71,77
X$6895 5151 5614 4670 77 4937 109 AOI21_X2
* cell instance $6897 r0 *1 155.23,77
X$6897 77 5763 5487 5350 5606 5486 109 NOR4_X4
* cell instance $6898 r0 *1 158.65,77
X$6898 5484 77 109 19110 INV_X2
* cell instance $6899 r0 *1 159.22,77
X$6899 4612 4540 77 5763 109 NAND2_X4
* cell instance $6901 m0 *1 159.6,77
X$6901 5550 5488 77 109 5764 NOR2_X2
* cell instance $6902 m0 *1 160.74,77
X$6902 4613 3931 5550 5488 77 109 4180 NOR4_X1
* cell instance $6903 m0 *1 161.69,77
X$6903 5771 5549 4486 109 5150 77 OAI21_X1
* cell instance $6905 m0 *1 162.64,77
X$6905 4750 5356 4940 5686 109 1704 77 OR4_X2
* cell instance $6906 m0 *1 163.97,77
X$6906 4750 4542 77 109 5357 OR2_X1
* cell instance $6907 m0 *1 164.73,77
X$6907 4994 4988 77 109 5347 NAND2_X1
* cell instance $6908 m0 *1 165.3,77
X$6908 5489 3938 5202 109 77 5356 OAI21_X2
* cell instance $6909 m0 *1 166.63,77
X$6909 5909 5556 5849 77 109 5697 NAND3_X1
* cell instance $6911 m0 *1 167.58,77
X$6911 77 5489 5683 5202 5487 3660 109 OAI211_X4
* cell instance $6912 m0 *1 170.81,77
X$6912 5141 5361 5359 109 77 5691 HA_X1
* cell instance $6913 m0 *1 172.71,77
X$6913 4612 4044 77 109 5686 NAND2_X1
* cell instance $6914 m0 *1 173.28,77
X$6914 77 3160 5681 5539 5543 1146 109 DFFR_X1
* cell instance $6915 m0 *1 177.08,77
X$6915 5539 77 109 4545 CLKBUF_X3
* cell instance $6917 m0 *1 178.22,77
X$6917 5361 77 109 4602 BUF_X1
* cell instance $6920 m0 *1 179.74,77
X$6920 5534 4573 4010 77 109 5535 MUX2_X1
* cell instance $6921 m0 *1 181.07,77
X$6921 5535 5237 77 109 5677 NOR2_X1
* cell instance $6922 m0 *1 181.64,77
X$6922 4944 5534 77 109 5533 NAND2_X1
* cell instance $6923 m0 *1 182.21,77
X$6923 4596 5210 77 109 5676 NOR2_X1
* cell instance $6924 m0 *1 182.78,77
X$6924 5620 77 109 4368 INV_X1
* cell instance $6927 m0 *1 184.11,77
X$6927 4545 77 109 5204 INV_X2
* cell instance $6931 m0 *1 187.15,77
X$6931 5625 109 4678 77 BUF_X4
* cell instance $6932 m0 *1 188.48,77
X$6932 5491 77 109 19208 CLKBUF_X1
* cell instance $6933 m0 *1 189.05,77
X$6933 5369 5364 5619 77 109 2913 OR3_X1
* cell instance $6934 m0 *1 190,77
X$6934 4554 4111 77 109 5363 NAND2_X1
* cell instance $6937 r0 *1 161.12,77
X$6937 77 4745 5765 5766 4940 109 NOR3_X4
* cell instance $6938 r0 *1 163.78,77
X$6938 5146 4485 77 4619 109 NAND2_X4
* cell instance $6940 r0 *1 165.68,77
X$6940 5768 109 3938 77 BUF_X4
* cell instance $6942 r0 *1 167.2,77
X$6942 4054 109 3647 77 BUF_X4
* cell instance $6943 r0 *1 168.53,77
X$6943 4096 4875 109 77 5770 AND2_X1
* cell instance $6944 r0 *1 169.29,77
X$6944 5140 5692 5693 109 77 5489 OAI21_X2
* cell instance $6945 r0 *1 170.62,77
X$6945 5689 5839 5428 109 77 5692 HA_X1
* cell instance $6949 r0 *1 172.52,77
X$6949 5691 5360 77 109 5693 NOR2_X1
* cell instance $6950 r0 *1 173.09,77
X$6950 5688 3647 77 109 5689 NOR2_X1
* cell instance $6952 r0 *1 173.85,77
X$6952 4538 5685 77 109 5841 NOR2_X1
* cell instance $6953 r0 *1 174.42,77
X$6953 5523 3320 5614 77 5682 109 AOI21_X1
* cell instance $6954 r0 *1 175.18,77
X$6954 4751 4940 77 109 5683 NAND2_X1
* cell instance $6955 r0 *1 175.75,77
X$6955 5682 5617 77 109 5618 NOR2_X1
* cell instance $6957 r0 *1 176.51,77
X$6957 5681 109 5773 77 BUF_X4
* cell instance $6959 r0 *1 178.03,77
X$6959 4602 5534 77 109 5772 OR2_X1
* cell instance $6960 r0 *1 178.79,77
X$6960 5679 77 109 5534 BUF_X1
* cell instance $6961 r0 *1 179.36,77
X$6961 5772 4981 77 109 5837 NOR2_X1
* cell instance $6963 r0 *1 180.31,77
X$6963 5676 5677 5490 109 5833 77 OAI21_X1
* cell instance $6965 r0 *1 181.45,77
X$6965 4010 4683 5622 77 109 5831 MUX2_X1
* cell instance $6967 r0 *1 182.97,77
X$6967 5534 5621 5622 4548 77 109 5620 AOI22_X1
* cell instance $6969 r0 *1 184.11,77
X$6969 5655 5490 77 109 5624 NOR2_X2
* cell instance $6971 r0 *1 185.25,77
X$6971 5490 5655 77 109 5623 OR2_X2
* cell instance $6973 r0 *1 186.39,77
X$6973 5623 4545 5915 77 109 NOR2_X4
* cell instance $6974 r0 *1 188.1,77
X$6974 5624 5773 77 109 5088 NAND2_X2
* cell instance $6975 r0 *1 189.05,77
X$6975 3348 77 109 5491 CLKBUF_X3
* cell instance $6976 r0 *1 190,77
X$6976 5524 5626 77 109 5364 NAND2_X1
* cell instance $6977 r0 *1 190.57,77
X$6977 5775 2586 5494 77 109 5493 MUX2_X1
* cell instance $6979 m0 *1 190.95,77
X$6979 77 5491 18657 5494 5493 1146 109 DFFR_X1
* cell instance $6981 m0 *1 196.46,77
X$6981 5778 4683 5777 77 109 5667 MUX2_X1
* cell instance $6984 m0 *1 199.5,77
X$6984 6238 5368 2586 413 5369 3854 109 77 AOI221_X2
* cell instance $6986 m0 *1 201.78,77
X$6986 5778 4256 2904 5495 77 109 5219 AOI22_X2
* cell instance $6989 r0 *1 192.09,77
X$6989 969 5625 5969 77 109 2727 MUX2_X1
* cell instance $6990 r0 *1 193.42,77
X$6990 77 5627 18885 5777 5667 992 109 DFFR_X1
* cell instance $6992 r0 *1 197.41,77
X$6992 77 5627 18897 5778 5824 992 109 DFFR_X1
* cell instance $6994 r0 *1 201.4,77
X$6994 5368 5663 2586 1063 5369 2696 109 77 AOI221_X2
* cell instance $6996 r0 *1 203.68,77
X$6996 625 5781 5815 5631 4684 109 77 5817 OAI221_X1
* cell instance $6998 m0 *1 203.87,77
X$6998 5625 5524 77 109 5221 NAND2_X2
* cell instance $7000 m0 *1 77.71,155.4
X$7000 77 11291 13120 12866 12824 8687 109 DFFR_X1
* cell instance $7001 m0 *1 76.38,155.4
X$7001 12974 8689 12971 77 109 12716 MUX2_X1
* cell instance $7002 m0 *1 81.51,155.4
X$7002 12866 6380 12717 77 109 12824 MUX2_X1
* cell instance $7003 m0 *1 82.84,155.4
X$7003 12826 12481 12717 77 109 12718 MUX2_X1
* cell instance $7004 m0 *1 84.17,155.4
X$7004 77 12576 13043 12826 12718 8687 109 DFFR_X1
* cell instance $7007 r0 *1 76.57,155.4
X$7007 12975 6524 12717 77 109 12973 MUX2_X1
* cell instance $7009 r0 *1 83.98,155.4
X$7009 12867 109 6276 77 BUF_X4
* cell instance $7011 r0 *1 86.83,155.4
X$7011 7167 12709 12982 77 109 12984 MUX2_X1
* cell instance $7012 r0 *1 88.16,155.4
X$7012 77 12576 13046 12982 12984 8201 109 DFFR_X1
* cell instance $7013 m0 *1 89.3,155.4
X$7013 12576 77 109 19247 CLKBUF_X1
* cell instance $7014 m0 *1 88.35,155.4
X$7014 9440 77 109 12576 CLKBUF_X3
* cell instance $7015 m0 *1 89.87,155.4
X$7015 6268 8250 77 109 13044 NAND2_X1
* cell instance $7018 m0 *1 91.39,155.4
X$7018 12987 109 12831 77 BUF_X4
* cell instance $7019 m0 *1 92.72,155.4
X$7019 12719 8079 77 5479 109 NAND2_X4
* cell instance $7020 m0 *1 94.43,155.4
X$7020 10716 77 109 12867 INV_X2
* cell instance $7023 r0 *1 92.15,155.4
X$7023 77 10716 13272 109 BUF_X32
* cell instance $7024 m0 *1 95.57,155.4
X$7024 77 12576 12535 13391 13389 8201 109 DFFR_X1
* cell instance $7026 m0 *1 99.37,155.4
X$7026 7168 77 109 11132 INV_X8
* cell instance $7028 m0 *1 101.27,155.4
X$7028 12721 7447 12868 77 109 12837 MUX2_X1
* cell instance $7029 m0 *1 102.6,155.4
X$7029 12720 10952 12721 77 109 12578 MUX2_X1
* cell instance $7031 m0 *1 104.12,155.4
X$7031 77 12870 12721 12871 12997 8201 109 DFFR_X1
* cell instance $7033 m0 *1 108.11,155.4
X$7033 12871 9815 11573 77 109 12997 MUX2_X1
* cell instance $7035 m0 *1 109.63,155.4
X$7035 13000 9985 12722 77 109 12872 MUX2_X1
* cell instance $7037 m0 *1 111.15,155.4
X$7037 7023 77 109 12722 BUF_X2
* cell instance $7039 m0 *1 112.1,155.4
X$7039 9341 77 109 12261 CLKBUF_X3
* cell instance $7041 m0 *1 113.24,155.4
X$7041 13001 13002 12723 77 109 12726 MUX2_X1
* cell instance $7042 m0 *1 114.57,155.4
X$7042 6184 12726 7590 13003 109 77 12725 OAI22_X1
* cell instance $7043 m0 *1 115.52,155.4
X$7043 77 12261 12874 12842 12727 4086 109 DFFR_X1
* cell instance $7048 r0 *1 102.41,155.4
X$7048 12992 8993 12837 77 109 12838 MUX2_X1
* cell instance $7049 r0 *1 103.74,155.4
X$7049 12869 9632 11573 77 109 13050 MUX2_X1
* cell instance $7050 r0 *1 105.07,155.4
X$7050 12720 7447 13131 77 109 12992 MUX2_X1
* cell instance $7054 r0 *1 110.01,155.4
X$7054 77 12870 13001 13000 12872 8201 109 DFFR_X1
* cell instance $7056 r0 *1 114.19,155.4
X$7056 13001 10142 12874 77 109 12873 MUX2_X1
* cell instance $7060 r0 *1 115.52,155.4
X$7060 12874 13002 13004 77 109 13003 MUX2_X1
* cell instance $7061 r0 *1 116.85,155.4
X$7061 77 13053 13004 13005 13139 4086 109 DFFR_X1
* cell instance $7065 m0 *1 125.21,155.4
X$7065 77 12875 11684 12876 12728 13011 12266 7029 109 AOI222_X2
* cell instance $7066 m0 *1 122.74,155.4
X$7066 77 13141 109 11892 BUF_X8
* cell instance $7068 m0 *1 128.06,155.4
X$7068 11691 77 109 12877 CLKBUF_X3
* cell instance $7069 m0 *1 129.01,155.4
X$7069 77 8383 12875 12730 12099 9422 12266 11732 109 AOI222_X2
* cell instance $7070 m0 *1 131.67,155.4
X$7070 8462 77 109 13015 BUF_X1
* cell instance $7071 m0 *1 132.24,155.4
X$7071 13249 11892 77 109 13016 NOR2_X1
* cell instance $7072 m0 *1 132.81,155.4
X$7072 77 9593 18504 12733 13017 12731 109 DFFR_X1
* cell instance $7073 m0 *1 136.61,155.4
X$7073 12732 77 109 10794 BUF_X1
* cell instance $7074 m0 *1 137.18,155.4
X$7074 12734 6474 77 109 13021 NAND2_X1
* cell instance $7076 m0 *1 137.94,155.4
X$7076 7968 8111 14340 11150 77 109 13020 NOR4_X1
* cell instance $7077 m0 *1 138.89,155.4
X$7077 8718 12734 13021 109 12737 77 OAI21_X1
* cell instance $7078 m0 *1 139.65,155.4
X$7078 12738 12737 12739 109 12881 77 OAI21_X1
* cell instance $7079 m0 *1 140.41,155.4
X$7079 8925 77 109 12879 INV_X1
* cell instance $7081 m0 *1 140.98,155.4
X$7081 12429 12686 109 12585 77 XOR2_X2
* cell instance $7082 m0 *1 142.69,155.4
X$7082 11301 12734 11140 77 109 12740 MUX2_X1
* cell instance $7083 m0 *1 144.02,155.4
X$7083 12738 12740 13023 109 12883 77 OAI21_X1
* cell instance $7086 m0 *1 145.73,155.4
X$7086 12741 109 12429 77 BUF_X4
* cell instance $7087 m0 *1 147.06,155.4
X$7087 12738 12884 77 109 13023 NAND2_X1
* cell instance $7089 m0 *1 147.82,155.4
X$7089 12884 12746 13024 109 12586 77 OAI21_X1
* cell instance $7092 m0 *1 149.53,155.4
X$7092 12742 12270 13132 77 109 12986 MUX2_X1
* cell instance $7093 m0 *1 150.86,155.4
X$7093 12836 12270 12885 77 109 12809 MUX2_X1
* cell instance $7096 r0 *1 123.12,155.4
X$7096 9422 12421 77 109 13142 NOR2_X1
* cell instance $7099 r0 *1 124.83,155.4
X$7099 8168 12421 77 109 13010 NOR2_X1
* cell instance $7100 r0 *1 125.4,155.4
X$7100 7996 12421 77 109 13055 NOR2_X1
* cell instance $7101 r0 *1 125.97,155.4
X$7101 77 12926 13010 13141 12729 109 AOI21_X4
* cell instance $7102 r0 *1 128.44,155.4
X$7102 11894 77 109 13011 BUF_X1
* cell instance $7103 r0 *1 129.01,155.4
X$7103 6235 12877 12236 77 109 13140 MUX2_X1
* cell instance $7105 r0 *1 130.53,155.4
X$7105 77 11938 13016 12100 12730 109 AOI21_X4
* cell instance $7107 r0 *1 133.19,155.4
X$7107 8957 12877 6564 77 109 13137 MUX2_X1
* cell instance $7109 r0 *1 135.28,155.4
X$7109 12738 13019 12878 109 13017 77 OAI21_X1
* cell instance $7110 r0 *1 136.04,155.4
X$7110 12738 12733 77 109 12878 NAND2_X1
* cell instance $7112 r0 *1 136.8,155.4
X$7112 12879 12734 6847 77 109 13019 MUX2_X1
* cell instance $7113 r0 *1 138.13,155.4
X$7113 13020 12880 12879 77 109 12735 NAND3_X1
* cell instance $7115 r0 *1 139.08,155.4
X$7115 77 13022 18727 12882 12881 12731 109 DFFR_X1
* cell instance $7117 r0 *1 143.26,155.4
X$7117 77 13022 18714 12884 12883 12731 109 DFFR_X1
* cell instance $7120 r0 *1 148.77,155.4
X$7120 13068 77 109 12746 BUF_X2
* cell instance $7121 r0 *1 149.53,155.4
X$7121 8168 12832 13061 109 13132 77 OAI21_X1
* cell instance $7124 r0 *1 150.86,155.4
X$7124 9422 12832 13063 109 13007 77 OAI21_X1
* cell instance $7125 r0 *1 151.62,155.4
X$7125 11438 12832 13242 109 12434 77 OAI21_X1
* cell instance $7127 m0 *1 152.76,155.4
X$7127 6558 12887 12743 77 109 11743 MUX2_X1
* cell instance $7129 m0 *1 154.09,155.4
X$7129 12887 77 109 12832 BUF_X2
* cell instance $7132 m0 *1 155.8,155.4
X$7132 12882 12746 12889 109 12533 77 OAI21_X1
* cell instance $7133 m0 *1 156.56,155.4
X$7133 6474 12887 12827 109 12889 77 OAI21_X1
* cell instance $7135 r0 *1 153.14,155.4
X$7135 7996 12832 12886 109 13012 77 OAI21_X1
* cell instance $7137 r0 *1 154.09,155.4
X$7137 13018 12887 77 109 12886 NAND2_X1
* cell instance $7138 r0 *1 154.66,155.4
X$7138 8153 12832 13377 109 13008 77 OAI21_X1
* cell instance $7140 r0 *1 155.61,155.4
X$7140 12733 12746 12888 109 12437 77 OAI21_X1
* cell instance $7141 r0 *1 156.37,155.4
X$7141 6847 12887 12890 109 12888 77 OAI21_X1
* cell instance $7144 m0 *1 157.7,155.4
X$7144 13013 12270 13238 77 109 12510 MUX2_X1
* cell instance $7145 m0 *1 159.79,155.4
X$7145 12999 77 109 12433 BUF_X2
* cell instance $7146 m0 *1 160.55,155.4
X$7146 12749 12592 13007 77 109 12799 MUX2_X1
* cell instance $7147 m0 *1 161.88,155.4
X$7147 13009 12270 13008 77 109 12754 MUX2_X1
* cell instance $7148 m0 *1 163.21,155.4
X$7148 12592 77 109 12270 CLKBUF_X3
* cell instance $7150 m0 *1 164.35,155.4
X$7150 12825 12592 13006 77 109 12803 MUX2_X1
* cell instance $7151 m0 *1 165.68,155.4
X$7151 12822 77 109 12592 CLKBUF_X3
* cell instance $7152 m0 *1 166.63,155.4
X$7152 5716 109 12822 77 BUF_X4
* cell instance $7153 m0 *1 167.96,155.4
X$7153 12996 77 109 12895 CLKBUF_X2
* cell instance $7154 m0 *1 168.72,155.4
X$7154 12999 77 109 12596 CLKBUF_X2
* cell instance $7156 m0 *1 169.67,155.4
X$7156 12273 7872 12998 109 12806 77 OAI21_X1
* cell instance $7159 r0 *1 158.84,155.4
X$7159 13014 12592 13012 77 109 13108 MUX2_X1
* cell instance $7160 r0 *1 160.17,155.4
X$7160 12367 12592 13126 77 109 12891 MUX2_X1
* cell instance $7161 r0 *1 161.5,155.4
X$7161 12892 12273 7879 109 77 12991 OAI21_X2
* cell instance $7164 r0 *1 163.97,155.4
X$7164 8264 12893 12822 109 10920 77 OAI21_X1
* cell instance $7166 r0 *1 164.92,155.4
X$7166 13066 12894 12895 77 109 12678 OR3_X1
* cell instance $7167 r0 *1 165.87,155.4
X$7167 12999 77 109 12894 CLKBUF_X2
* cell instance $7168 r0 *1 166.63,155.4
X$7168 12880 77 109 8623 INV_X8
* cell instance $7170 r0 *1 168.53,155.4
X$7170 13119 12999 13068 77 109 12998 OR3_X1
* cell instance $7172 r0 *1 169.86,155.4
X$7172 12995 12433 12746 77 109 12117 OR3_X1
* cell instance $7173 r0 *1 170.81,155.4
X$7173 12996 77 109 12595 CLKBUF_X2
* cell instance $7175 m0 *1 170.81,155.4
X$7175 11829 12896 12822 109 11003 77 OAI21_X1
* cell instance $7176 m0 *1 172.33,155.4
X$7176 12994 12433 12746 77 109 12278 OR3_X1
* cell instance $7177 m0 *1 173.28,155.4
X$7177 12993 12433 12746 77 109 12598 OR3_X1
* cell instance $7179 m0 *1 174.42,155.4
X$7179 12273 6927 13116 109 12800 77 OAI21_X1
* cell instance $7180 m0 *1 175.18,155.4
X$7180 13067 12596 12595 77 109 12353 OR3_X1
* cell instance $7181 m0 *1 176.13,155.4
X$7181 12989 12596 12595 77 109 12443 OR3_X1
* cell instance $7182 m0 *1 177.08,155.4
X$7182 12897 12596 12595 77 109 12441 OR3_X1
* cell instance $7190 r0 *1 172.14,155.4
X$7190 12972 12894 12895 77 109 12210 OR3_X1
* cell instance $7194 r0 *1 175.75,155.4
X$7194 13183 77 109 9765 INV_X1
* cell instance $7196 r0 *1 176.32,155.4
X$7196 12990 77 109 10085 INV_X1
* cell instance $7198 r0 *1 177.08,155.4
X$7198 13112 12894 12895 77 109 12206 OR3_X1
* cell instance $7200 r0 *1 178.79,155.4
X$7200 12988 12894 12895 77 109 12981 OR3_X1
* cell instance $7202 m0 *1 179.17,155.4
X$7202 12755 12433 12746 77 109 12812 OR3_X1
* cell instance $7204 r0 *1 179.93,155.4
X$7204 12985 12894 12895 77 109 12980 OR3_X1
* cell instance $7205 m0 *1 180.69,155.4
X$7205 12275 6932 12898 109 12760 77 OAI21_X1
* cell instance $7209 r0 *1 181.07,155.4
X$7209 12275 7231 12980 109 12970 77 OAI21_X1
* cell instance $7210 m0 *1 182.02,155.4
X$7210 12979 12433 12746 77 109 12756 OR3_X1
* cell instance $7213 m0 *1 183.16,155.4
X$7213 12757 12433 12746 77 109 12447 OR3_X1
* cell instance $7214 m0 *1 184.11,155.4
X$7214 12275 7962 12978 109 12977 77 OAI21_X1
* cell instance $7215 m0 *1 184.87,155.4
X$7215 12510 12806 12759 109 77 12900 HA_X1
* cell instance $7217 r0 *1 181.83,155.4
X$7217 12275 6603 12981 109 12976 77 OAI21_X1
* cell instance $7219 r0 *1 182.78,155.4
X$7219 12983 12433 12746 77 109 12978 OR3_X1
* cell instance $7221 r0 *1 183.92,155.4
X$7221 12757 77 109 12896 INV_X2
* cell instance $7224 r0 *1 186.2,155.4
X$7224 12976 12891 12899 109 77 12901 HA_X1
* cell instance $7225 m0 *1 187.34,155.4
X$7225 12977 12803 12966 109 77 12761 HA_X1
* cell instance $7227 m0 *1 189.24,155.4
X$7227 12900 12759 12605 77 12287 109 AOI21_X1
* cell instance $7228 m0 *1 190,155.4
X$7228 11327 77 109 19203 CLKBUF_X1
* cell instance $7230 m0 *1 190.76,155.4
X$7230 12607 12658 12657 109 12798 77 OAI21_X1
* cell instance $7231 m0 *1 191.52,155.4
X$7231 12754 12800 12960 109 77 12613 HA_X1
* cell instance $7233 m0 *1 194.18,155.4
X$7233 12966 77 109 12289 CLKBUF_X2
* cell instance $7238 r0 *1 189.43,155.4
X$7238 12759 77 109 12607 INV_X1
* cell instance $7240 r0 *1 190,155.4
X$7240 12900 77 109 12657 INV_X1
* cell instance $7241 r0 *1 190.38,155.4
X$7241 12970 13108 12964 109 77 12968 HA_X1
* cell instance $7244 r0 *1 193.42,155.4
X$7244 12968 77 109 12763 BUF_X2
* cell instance $7245 r0 *1 194.18,155.4
X$7245 12901 77 109 13075 INV_X1
* cell instance $7247 r0 *1 195.32,155.4
X$7247 12903 12963 12901 12899 13076 12732 109 77 AOI221_X2
* cell instance $7249 m0 *1 195.32,155.4
X$7249 12760 12799 12965 109 77 12648 HA_X1
* cell instance $7250 r0 *1 197.41,155.4
X$7250 12899 77 109 12902 INV_X2
* cell instance $7251 m0 *1 198.36,155.4
X$7251 12960 77 109 11951 CLKBUF_X3
* cell instance $7252 m0 *1 197.6,155.4
X$7252 12965 77 109 12291 CLKBUF_X2
* cell instance $7254 r0 *1 197.98,155.4
X$7254 12964 77 109 12488 BUF_X2
* cell instance $7257 m0 *1 199.88,155.4
X$7257 12612 12293 11769 77 109 12794 NAND3_X2
* cell instance $7260 m0 *1 201.4,155.4
X$7260 12611 13079 12762 11952 12904 77 109 OAI211_X2
* cell instance $7262 r0 *1 199.88,155.4
X$7262 12902 13105 109 77 12959 AND2_X1
* cell instance $7263 r0 *1 200.64,155.4
X$7263 13104 12332 13103 12959 12904 11534 77 109 OAI221_X2
* cell instance $7264 r0 *1 202.73,155.4
X$7264 12903 12639 77 109 9393 XNOR2_X2
* cell instance $7266 m0 *1 203.49,155.4
X$7266 12613 11951 12648 77 12953 109 AOI21_X1
* cell instance $7267 r0 *1 204.63,155.4
X$7267 12906 12290 12612 77 12957 109 AOI21_X2
* cell instance $7269 m0 *1 204.63,155.4
X$7269 12763 12488 12764 77 12905 109 AOI21_X2
* cell instance $7270 r0 *1 205.96,155.4
X$7270 12946 12614 12639 109 13081 77 NOR3_X2
* cell instance $7271 m0 *1 206.53,155.4
X$7271 12639 12953 12615 109 12951 77 OAI21_X1
* cell instance $7273 m0 *1 207.29,155.4
X$7273 12614 12639 12615 77 12907 109 AOI21_X1
* cell instance $7275 r0 *1 207.29,155.4
X$7275 12290 77 109 13100 BUF_X2
* cell instance $7276 r0 *1 208.05,155.4
X$7276 12907 12763 13077 109 12952 77 NOR3_X2
* cell instance $7278 m0 *1 208.43,155.4
X$7278 12763 12488 12951 77 12908 109 AOI21_X1
* cell instance $7280 m0 *1 210.14,155.4
X$7280 77 18326 12638 12943 12134 109 DFF_X1
* cell instance $7282 r0 *1 209.38,155.4
X$7282 12908 12946 77 109 12947 NOR2_X1
* cell instance $7285 r0 *1 211.66,155.4
X$7285 9243 109 12691 77 BUF_X4
* cell instance $7288 m0 *1 215.08,155.4
X$7288 12466 12161 109 77 12766 XNOR2_X1
* cell instance $7289 m0 *1 213.75,155.4
X$7289 12638 11508 12766 77 109 12943 MUX2_X1
* cell instance $7292 r0 *1 214.32,155.4
X$7292 77 18482 12909 12940 13191 109 DFF_X1
* cell instance $7293 m0 *1 216.79,155.4
X$7293 12942 9378 109 77 12767 XNOR2_X1
* cell instance $7295 m0 *1 217.93,155.4
X$7295 12767 12789 10204 12910 77 109 12940 AOI22_X1
* cell instance $7296 m0 *1 218.88,155.4
X$7296 12789 9401 77 109 12776 NAND2_X2
* cell instance $7300 r0 *1 217.93,155.4
X$7300 3884 12909 12939 77 109 12910 MUX2_X1
* cell instance $7303 r0 *1 219.83,155.4
X$7303 12912 12911 77 109 12942 NOR2_X1
* cell instance $7304 r0 *1 220.4,155.4
X$7304 12912 12911 3884 77 109 12939 NOR3_X1
* cell instance $7306 m0 *1 220.97,155.4
X$7306 77 18353 12937 12935 12302 109 DFF_X1
* cell instance $7309 r0 *1 223.44,155.4
X$7309 11200 12937 8749 109 77 12914 OAI21_X4
* cell instance $7310 m0 *1 224.77,155.4
X$7310 12937 11508 12913 77 109 12935 MUX2_X1
* cell instance $7312 m0 *1 226.1,155.4
X$7312 12769 12161 77 109 12933 NOR2_X1
* cell instance $7314 m0 *1 226.86,155.4
X$7314 12769 12914 12783 77 109 12782 NOR3_X1
* cell instance $7315 m0 *1 227.62,155.4
X$7315 12297 11783 77 109 12783 NAND2_X1
* cell instance $7316 m0 *1 228.19,155.4
X$7316 12770 12782 109 77 12771 XNOR2_X1
* cell instance $7317 m0 *1 229.33,155.4
X$7317 12302 77 109 19131 INV_X1
* cell instance $7319 m0 *1 230.47,155.4
X$7319 12916 12304 12466 77 109 12917 MUX2_X1
* cell instance $7320 m0 *1 231.8,155.4
X$7320 12916 12305 12917 77 109 12925 MUX2_X1
* cell instance $7322 r0 *1 225.91,155.4
X$7322 12914 12933 109 77 12913 XNOR2_X1
* cell instance $7326 r0 *1 227.05,155.4
X$7326 12304 12915 77 109 13092 NOR2_X1
* cell instance $7328 r0 *1 227.81,155.4
X$7328 77 18424 12916 12925 12302 109 DFF_X1
* cell instance $7330 r0 *1 231.8,155.4
X$7330 3884 3512 77 109 13086 NOR2_X1
* cell instance $7331 r0 *1 232.37,155.4
X$7331 77 18391 12918 12781 12621 109 DFF_X1
* cell instance $7332 m0 *1 233.7,155.4
X$7332 12918 12305 12772 77 109 12781 MUX2_X1
* cell instance $7334 m0 *1 235.03,155.4
X$7334 11186 77 109 18284 INV_X8
* cell instance $7335 m0 *1 236.74,155.4
X$7335 12621 77 109 19245 CLKBUF_X1
* cell instance $7336 m0 *1 237.31,155.4
X$7336 12924 10498 12776 77 109 12919 MUX2_X1
* cell instance $7337 m0 *1 238.64,155.4
X$7337 1236 77 109 11186 CLKBUF_X3
* cell instance $7339 r0 *1 235.6,155.4
X$7339 77 18410 12924 13089 12621 109 DFF_X1
* cell instance $7341 r0 *1 239.02,155.4
X$7341 12473 77 109 12624 BUF_X1
* cell instance $7343 m0 *1 2.66,133
X$7343 77 9790 10659 10750 10660 4909 109 DFFR_X1
* cell instance $7345 m0 *1 6.46,133
X$7345 10750 5167 10425 77 109 10660 MUX2_X1
* cell instance $7348 m0 *1 11.02,133
X$7348 77 9956 10574 10666 10427 4909 109 DFFR_X1
* cell instance $7350 m0 *1 15.58,133
X$7350 77 9956 10753 10844 10845 4909 109 DFFR_X1
* cell instance $7353 m0 *1 21.66,133
X$7353 10511 6158 10575 77 109 10754 MUX2_X1
* cell instance $7355 m0 *1 23.75,133
X$7355 77 10951 10849 10577 10848 4909 109 DFFR_X1
* cell instance $7357 m0 *1 27.74,133
X$7357 10673 5020 10425 77 109 10672 MUX2_X1
* cell instance $7358 m0 *1 29.07,133
X$7358 77 9968 10676 10673 10672 4909 109 DFFR_X1
* cell instance $7360 m0 *1 33.63,133
X$7360 10686 7469 10131 77 109 10756 MUX2_X1
* cell instance $7361 m0 *1 34.96,133
X$7361 77 9968 10578 10686 10756 4909 109 DFFR_X1
* cell instance $7362 m0 *1 38.76,133
X$7362 10685 5169 10578 77 10858 109 AOI21_X1
* cell instance $7363 m0 *1 39.52,133
X$7363 10857 8463 10578 77 10692 109 AOI21_X1
* cell instance $7370 r0 *1 1.71,133
X$7370 77 9790 10838 10837 11022 4909 109 DFFR_X1
* cell instance $7375 r0 *1 6.27,133
X$7375 10838 8005 10659 77 109 10841 MUX2_X1
* cell instance $7377 r0 *1 7.98,133
X$7377 10841 7760 10839 77 109 10751 MUX2_X1
* cell instance $7379 r0 *1 10.07,133
X$7379 77 9956 10947 11024 10842 4909 109 DFFR_X1
* cell instance $7382 r0 *1 17.1,133
X$7382 10752 3043 10844 77 109 10845 MUX2_X1
* cell instance $7384 r0 *1 19.95,133
X$7384 10849 4138 10753 77 109 10846 MUX2_X1
* cell instance $7387 r0 *1 21.85,133
X$7387 10671 6017 10576 77 109 10755 MUX2_X1
* cell instance $7391 r0 *1 25.65,133
X$7391 10258 77 109 10752 BUF_X2
* cell instance $7392 r0 *1 26.41,133
X$7392 10258 6816 10577 77 109 10848 MUX2_X1
* cell instance $7393 r0 *1 27.74,133
X$7393 10850 5110 10425 77 109 10851 MUX2_X1
* cell instance $7394 r0 *1 29.07,133
X$7394 77 9968 10852 10850 10851 4909 109 DFFR_X1
* cell instance $7395 r0 *1 32.87,133
X$7395 10852 5951 10676 77 109 10856 MUX2_X1
* cell instance $7399 r0 *1 35.53,133
X$7399 10757 6885 10131 77 109 11038 MUX2_X1
* cell instance $7400 r0 *1 36.86,133
X$7400 10757 4309 77 109 10685 NOR2_X1
* cell instance $7404 r0 *1 39.9,133
X$7404 10757 10957 77 109 10857 NOR2_X1
* cell instance $7407 m0 *1 40.66,133
X$7407 10436 8403 8858 10860 10858 10215 109 77 AOI221_X2
* cell instance $7408 m0 *1 44.27,133
X$7408 10132 7765 10758 109 10695 77 OAI21_X1
* cell instance $7411 m0 *1 45.98,133
X$7411 6007 109 11278 77 BUF_X4
* cell instance $7416 r0 *1 41.42,133
X$7416 77 10279 11218 10759 10695 9814 109 DFFR_X1
* cell instance $7418 r0 *1 45.41,133
X$7418 77 10279 10762 10761 10861 9814 109 DFFR_X1
* cell instance $7421 r0 *1 51.49,133
X$7421 77 9974 10868 10866 10862 9814 109 DFFR_X1
* cell instance $7422 m0 *1 52.44,133
X$7422 3619 10583 10865 109 10862 77 OAI21_X1
* cell instance $7425 m0 *1 53.77,133
X$7425 3613 10866 77 109 10865 NAND2_X1
* cell instance $7428 m0 *1 54.53,133
X$7428 77 9974 10968 10582 10581 9814 109 DFFR_X1
* cell instance $7430 m0 *1 59.09,133
X$7430 3903 10583 10585 109 10584 77 OAI21_X1
* cell instance $7431 m0 *1 59.85,133
X$7431 4072 10871 77 109 10585 NAND2_X1
* cell instance $7434 m0 *1 61.37,133
X$7434 3903 10763 10586 109 10873 77 OAI21_X1
* cell instance $7436 m0 *1 62.32,133
X$7436 3619 10763 10875 109 10874 77 OAI21_X1
* cell instance $7437 m0 *1 63.08,133
X$7437 10674 77 109 10442 CLKBUF_X3
* cell instance $7438 m0 *1 64.03,133
X$7438 77 10442 10765 10877 10874 9814 109 DFFR_X1
* cell instance $7440 m0 *1 68.02,133
X$7440 10876 3364 10765 77 109 10712 MUX2_X1
* cell instance $7442 m0 *1 70.11,133
X$7442 10712 7928 8024 10766 109 77 10973 OAI22_X1
* cell instance $7445 m0 *1 72.77,133
X$7445 10767 9492 10590 77 10881 109 AOI21_X1
* cell instance $7446 m0 *1 73.53,133
X$7446 10590 10883 77 109 10767 NOR2_X1
* cell instance $7449 m0 *1 77.33,133
X$7449 3565 7767 10593 109 10714 77 OAI21_X1
* cell instance $7451 m0 *1 78.85,133
X$7451 3565 7765 10595 109 10592 77 OAI21_X1
* cell instance $7452 m0 *1 79.61,133
X$7452 10591 10449 10772 77 109 10719 MUX2_X1
* cell instance $7453 m0 *1 80.94,133
X$7453 10594 10449 9493 77 109 10888 MUX2_X1
* cell instance $7454 m0 *1 82.27,133
X$7454 10771 7877 10888 77 109 10718 MUX2_X1
* cell instance $7455 m0 *1 83.6,133
X$7455 10719 10451 10541 77 109 10720 MUX2_X1
* cell instance $7456 m0 *1 84.93,133
X$7456 10772 3896 10598 77 109 9822 MUX2_X1
* cell instance $7458 m0 *1 87.02,133
X$7458 10890 9492 9834 77 10599 109 AOI21_X1
* cell instance $7461 m0 *1 88.73,133
X$7461 9834 10600 77 109 10890 NOR2_X1
* cell instance $7464 m0 *1 93.86,133
X$7464 10601 9895 10602 77 109 10603 MUX2_X1
* cell instance $7465 m0 *1 95.19,133
X$7465 10601 6308 10293 77 109 10730 MUX2_X1
* cell instance $7466 m0 *1 96.52,133
X$7466 10602 6308 10450 77 109 10604 MUX2_X1
* cell instance $7468 m0 *1 98.61,133
X$7468 10779 6983 10781 77 109 10897 MUX2_X1
* cell instance $7474 r0 *1 56.62,133
X$7474 77 10442 10870 10871 10584 9814 109 DFFR_X1
* cell instance $7478 r0 *1 60.42,133
X$7478 77 10442 10764 10588 10873 9814 109 DFFR_X1
* cell instance $7481 r0 *1 64.79,133
X$7481 3613 10877 77 109 10875 NAND2_X1
* cell instance $7484 r0 *1 66.31,133
X$7484 10876 10957 10764 77 109 11054 MUX2_X1
* cell instance $7486 r0 *1 68.02,133
X$7486 10765 8229 10443 77 109 10972 MUX2_X1
* cell instance $7488 r0 *1 69.54,133
X$7488 10764 3978 10443 77 109 10766 MUX2_X1
* cell instance $7490 r0 *1 71.25,133
X$7490 77 9763 10885 10883 10881 9814 109 DFFR_X1
* cell instance $7493 r0 *1 76,133
X$7493 10768 7469 9492 77 10884 109 AOI21_X1
* cell instance $7495 r0 *1 76.95,133
X$7495 7469 10769 77 109 10768 NOR2_X1
* cell instance $7498 r0 *1 78.09,133
X$7498 77 9924 10447 10597 10592 4086 109 DFFR_X1
* cell instance $7501 r0 *1 82.46,133
X$7501 77 9924 10772 10773 10887 8687 109 DFFR_X1
* cell instance $7502 r0 *1 86.26,133
X$7502 10774 9029 9830 77 10887 109 AOI21_X1
* cell instance $7506 r0 *1 88.35,133
X$7506 10775 9029 6983 77 10891 109 AOI21_X1
* cell instance $7507 r0 *1 89.11,133
X$7507 6983 11073 77 109 10775 NOR2_X1
* cell instance $7508 r0 *1 89.68,133
X$7508 10776 77 109 10777 INV_X1
* cell instance $7511 r0 *1 91.2,133
X$7511 77 11078 10602 10778 10895 8687 109 DFFR_X1
* cell instance $7512 r0 *1 95,133
X$7512 10778 6975 10157 77 109 10895 MUX2_X1
* cell instance $7513 r0 *1 96.33,133
X$7513 4789 77 109 8079 INV_X4
* cell instance $7516 r0 *1 98.23,133
X$7516 77 10605 10780 10779 10897 8201 109 DFFR_X1
* cell instance $7517 m0 *1 101.27,133
X$7517 7618 10780 6726 6902 10782 109 77 10734 OAI221_X1
* cell instance $7519 m0 *1 102.41,133
X$7519 6140 10783 10907 109 10782 77 OAI21_X1
* cell instance $7520 m0 *1 103.17,133
X$7520 10737 6372 77 109 10905 NAND2_X1
* cell instance $7521 m0 *1 103.74,133
X$7521 10737 6140 77 109 10907 NAND2_X1
* cell instance $7524 r0 *1 102.79,133
X$7524 6372 10783 10905 109 10906 77 OAI21_X1
* cell instance $7526 r0 *1 103.93,133
X$7526 77 10605 10976 10606 10739 8201 109 DFFR_X1
* cell instance $7528 m0 *1 104.69,133
X$7528 10606 9824 10781 77 109 10739 MUX2_X1
* cell instance $7529 m0 *1 106.59,133
X$7529 10908 9830 10157 77 109 10607 MUX2_X1
* cell instance $7531 m0 *1 107.92,133
X$7531 77 9833 10609 10908 10607 8201 109 DFFR_X1
* cell instance $7535 r0 *1 108.11,133
X$7535 6554 77 109 10781 BUF_X2
* cell instance $7538 r0 *1 109.44,133
X$7538 77 9833 10608 10910 10909 8201 109 DFFR_X1
* cell instance $7540 m0 *1 114.19,133
X$7540 10609 10299 10785 77 109 10747 MUX2_X1
* cell instance $7541 m0 *1 113.62,133
X$7541 10609 7627 77 109 10460 NAND2_X1
* cell instance $7542 m0 *1 115.52,133
X$7542 10785 7627 77 109 10746 NAND2_X1
* cell instance $7544 m0 *1 116.28,133
X$7544 10747 8984 10300 77 109 10745 MUX2_X1
* cell instance $7546 m0 *1 118.37,133
X$7546 10745 6130 11096 77 109 10612 MUX2_X1
* cell instance $7547 m0 *1 119.7,133
X$7547 10612 6007 77 109 10743 NOR2_X1
* cell instance $7554 r0 *1 119.7,133
X$7554 9989 8008 10915 77 109 10786 MUX2_X1
* cell instance $7557 m0 *1 122.93,133
X$7557 10787 5330 10918 109 77 10788 HA_X1
* cell instance $7558 m0 *1 122.17,133
X$7558 10466 10613 77 109 11257 OR2_X1
* cell instance $7559 m0 *1 124.83,133
X$7559 10614 6569 10788 77 10917 109 AOI21_X1
* cell instance $7560 m0 *1 125.59,133
X$7560 10789 6569 77 109 10614 NOR2_X1
* cell instance $7562 m0 *1 126.35,133
X$7562 10922 10789 9042 109 77 5597 OAI21_X2
* cell instance $7565 r0 *1 123.12,133
X$7565 10918 10917 9042 109 77 10919 MUX2_X2
* cell instance $7568 r0 *1 125.78,133
X$7568 9042 10733 6569 77 109 10922 NAND3_X1
* cell instance $7569 r0 *1 126.54,133
X$7569 11472 9042 5705 109 10923 77 OAI21_X1
* cell instance $7570 r0 *1 127.3,133
X$7570 5705 10924 10923 109 10926 77 OAI21_X1
* cell instance $7571 m0 *1 128.25,133
X$7571 10925 9042 10615 109 10924 77 OAI21_X1
* cell instance $7576 r0 *1 128.25,133
X$7576 10926 11097 77 109 10662 NAND2_X2
* cell instance $7579 m0 *1 131.48,133
X$7579 10792 10468 10423 10793 10616 10928 109 77 AOI221_X2
* cell instance $7580 m0 *1 130.15,133
X$7580 10616 10467 10617 77 109 10792 MUX2_X1
* cell instance $7581 m0 *1 133.57,133
X$7581 10617 10467 10616 77 109 10796 MUX2_X1
* cell instance $7582 m0 *1 134.9,133
X$7582 10467 10729 10931 10929 10989 109 77 10727 OAI221_X1
* cell instance $7585 m0 *1 136.99,133
X$7585 10728 10799 10995 77 109 10619 OR3_X1
* cell instance $7586 m0 *1 137.94,133
X$7586 77 10665 9862 8733 10621 6747 109 NOR4_X4
* cell instance $7588 m0 *1 141.55,133
X$7588 10556 9552 77 109 10621 OR2_X1
* cell instance $7591 m0 *1 144.02,133
X$7591 10622 77 109 10722 INV_X1
* cell instance $7592 m0 *1 144.4,133
X$7592 7879 10722 19047 109 77 10801 HA_X1
* cell instance $7593 m0 *1 146.3,133
X$7593 10801 10166 10941 77 109 10625 MUX2_X1
* cell instance $7596 r0 *1 130.53,133
X$7596 10987 10791 10790 10927 77 10929 109 NAND4_X2
* cell instance $7597 r0 *1 132.24,133
X$7597 10794 10468 77 109 10927 NOR2_X1
* cell instance $7598 r0 *1 132.81,133
X$7598 10790 10791 109 77 10798 AND2_X1
* cell instance $7599 r0 *1 133.57,133
X$7599 10616 10794 10569 77 109 10795 MUX2_X1
* cell instance $7600 r0 *1 134.9,133
X$7600 10469 77 109 10932 INV_X1
* cell instance $7601 r0 *1 135.28,133
X$7601 10469 10930 10569 77 109 10933 OR3_X1
* cell instance $7602 r0 *1 136.23,133
X$7602 10798 10991 10933 77 10936 109 AOI21_X1
* cell instance $7604 r0 *1 137.37,133
X$7604 11090 10936 10935 77 109 5481 OR3_X4
* cell instance $7606 r0 *1 139.84,133
X$7606 10665 9862 8733 10621 109 10725 77 OR4_X2
* cell instance $7607 r0 *1 141.17,133
X$7607 10800 10167 77 109 10807 NOR2_X2
* cell instance $7608 r0 *1 142.12,133
X$7608 9805 10470 10311 109 10800 77 OAI21_X1
* cell instance $7610 r0 *1 143.64,133
X$7610 8000 10470 10311 109 11088 77 OAI21_X1
* cell instance $7613 r0 *1 147.82,133
X$7613 11086 9287 10944 77 109 11085 MUX2_X1
* cell instance $7614 m0 *1 148.2,133
X$7614 10626 9287 10475 9360 77 109 10941 AOI22_X1
* cell instance $7616 m0 *1 149.15,133
X$7616 10803 6930 10943 109 77 10627 HA_X1
* cell instance $7617 m0 *1 151.05,133
X$7617 10803 77 109 10804 INV_X1
* cell instance $7619 r0 *1 149.15,133
X$7619 10166 11082 77 109 10802 NOR2_X1
* cell instance $7621 r0 *1 149.91,133
X$7621 6855 109 9219 77 BUF_X4
* cell instance $7623 m0 *1 153.71,133
X$7623 10942 9355 10943 9360 77 109 10717 AOI22_X1
* cell instance $7624 m0 *1 151.81,133
X$7624 10804 7113 19038 109 77 10942 HA_X1
* cell instance $7627 m0 *1 155.61,133
X$7627 9853 9556 77 109 10629 NAND2_X1
* cell instance $7628 m0 *1 156.18,133
X$7628 10629 11072 9678 8500 10937 77 109 OAI211_X2
* cell instance $7629 m0 *1 157.89,133
X$7629 10631 6359 10628 77 10808 109 AOI21_X1
* cell instance $7630 m0 *1 158.65,133
X$7630 7804 4189 19035 109 77 10809 HA_X1
* cell instance $7632 m0 *1 160.74,133
X$7632 10809 10166 9446 77 109 10810 MUX2_X1
* cell instance $7633 m0 *1 162.07,133
X$7633 10628 8111 77 109 10811 NAND2_X1
* cell instance $7635 m0 *1 162.83,133
X$7635 6855 10635 11485 10920 10171 9145 77 109 OAI221_X2
* cell instance $7636 m0 *1 164.92,133
X$7636 10628 77 109 9524 CLKBUF_X3
* cell instance $7637 m0 *1 165.87,133
X$7637 10913 10916 10424 77 11157 109 AOI21_X1
* cell instance $7638 m0 *1 166.63,133
X$7638 4491 7233 19051 109 77 10911 HA_X1
* cell instance $7641 m0 *1 170.24,133
X$7641 10636 77 109 10904 INV_X1
* cell instance $7643 r0 *1 152,133
X$7643 10628 109 9853 77 BUF_X4
* cell instance $7645 r0 *1 153.52,133
X$7645 10805 9355 11081 9447 77 109 10940 AOI22_X1
* cell instance $7646 r0 *1 154.47,133
X$7646 9858 10940 10939 109 9849 77 OAI21_X1
* cell instance $7647 r0 *1 155.23,133
X$7647 8754 10628 10806 10424 77 109 10939 AOI22_X1
* cell instance $7649 r0 *1 156.56,133
X$7649 77 10934 10938 8982 10937 8712 109 AOI22_X4
* cell instance $7652 r0 *1 162.07,133
X$7652 10811 10810 77 109 10914 NAND2_X1
* cell instance $7655 r0 *1 163.21,133
X$7655 9853 9245 10812 10322 10921 9521 109 77 AOI221_X2
* cell instance $7656 r0 *1 165.3,133
X$7656 10912 11067 8572 8712 10914 9292 109 77 AOI221_X2
* cell instance $7657 r0 *1 167.39,133
X$7657 10166 77 109 9361 CLKBUF_X3
* cell instance $7658 r0 *1 168.34,133
X$7658 9607 10911 10322 77 10813 109 AOI21_X1
* cell instance $7661 r0 *1 170.24,133
X$7661 9856 109 9360 77 BUF_X4
* cell instance $7662 m0 *1 171.19,133
X$7662 10903 9360 9362 10898 9355 77 109 10711 AOI221_X1
* cell instance $7668 r0 *1 171.57,133
X$7668 10709 9101 9524 77 10902 109 AOI21_X1
* cell instance $7669 r0 *1 172.33,133
X$7669 6855 10902 10901 109 9286 77 OAI21_X1
* cell instance $7670 m0 *1 174.61,133
X$7670 10900 9056 77 109 10814 NAND2_X1
* cell instance $7671 m0 *1 172.71,133
X$7671 7810 10904 10903 109 77 10898 HA_X1
* cell instance $7673 m0 *1 175.37,133
X$7673 10393 10814 77 109 7810 NAND2_X2
* cell instance $7675 m0 *1 176.51,133
X$7675 10699 11053 77 7113 109 NAND2_X4
* cell instance $7677 m0 *1 178.41,133
X$7677 77 10638 18626 10701 10637 3676 109 DFFR_X1
* cell instance $7679 m0 *1 182.4,133
X$7679 77 9694 10886 7370 10228 9056 10639 8789 109 AOI222_X2
* cell instance $7681 m0 *1 185.25,133
X$7681 10639 8106 9399 77 109 10816 MUX2_X1
* cell instance $7684 r0 *1 173.09,133
X$7684 7237 10899 10896 109 77 10894 HA_X1
* cell instance $7685 r0 *1 174.99,133
X$7685 10896 9447 10424 10894 9597 77 109 10893 AOI221_X1
* cell instance $7689 r0 *1 181.07,133
X$7689 77 9694 10882 10889 10892 9056 7238 8282 109 AOI222_X2
* cell instance $7692 r0 *1 184.87,133
X$7692 77 10638 18880 10639 10816 3676 109 DFFR_X1
* cell instance $7693 m0 *1 188.67,133
X$7693 77 10696 9694 10699 8789 10640 109 AOI22_X4
* cell instance $7695 m0 *1 191.9,133
X$7695 10488 9696 109 77 10886 AND2_X1
* cell instance $7696 m0 *1 192.66,133
X$7696 10647 9696 109 77 10696 AND2_X1
* cell instance $7701 r0 *1 189.81,133
X$7701 77 10010 11045 3676 18993 10640 109 DFFR_X2
* cell instance $7702 r0 *1 193.99,133
X$7702 10013 9696 109 77 10882 AND2_X1
* cell instance $7703 m0 *1 197.03,133
X$7703 9864 77 109 10879 INV_X1
* cell instance $7704 m0 *1 194.56,133
X$7704 10647 10390 10880 77 10382 109 NAND3_X4
* cell instance $7705 m0 *1 197.41,133
X$7705 10382 9864 77 109 10644 NOR2_X1
* cell instance $7706 m0 *1 197.98,133
X$7706 10644 10520 10488 77 109 10818 NAND3_X1
* cell instance $7709 r0 *1 194.94,133
X$7709 10880 10879 77 109 10641 NAND2_X1
* cell instance $7711 r0 *1 195.7,133
X$7711 10880 10817 10390 77 109 10878 NAND3_X1
* cell instance $7712 r0 *1 196.46,133
X$7712 10863 10878 109 77 10643 XNOR2_X1
* cell instance $7714 r0 *1 197.79,133
X$7714 10867 10818 109 77 10690 XNOR2_X1
* cell instance $7715 r0 *1 198.93,133
X$7715 77 10872 10869 10645 10010 109 DFF_X1
* cell instance $7717 m0 *1 199.12,133
X$7717 10872 10644 77 109 10689 XOR2_X1
* cell instance $7718 m0 *1 201.78,133
X$7718 10488 10336 10334 77 109 10645 MUX2_X1
* cell instance $7721 m0 *1 204.06,133
X$7721 10520 8616 10819 77 109 8151 MUX2_X1
* cell instance $7723 m0 *1 206.91,133
X$7723 77 10820 10018 10863 10647 109 DFF_X2
* cell instance $7726 r0 *1 202.16,133
X$7726 10869 77 109 10488 BUF_X2
* cell instance $7729 r0 *1 204.06,133
X$7729 77 10864 10375 10867 10489 109 DFF_X2
* cell instance $7730 r0 *1 207.67,133
X$7730 10489 10336 10821 77 109 10864 MUX2_X1
* cell instance $7733 r0 *1 212.23,133
X$7733 10822 10334 10682 77 109 10680 NAND3_X1
* cell instance $7736 m0 *1 214.13,133
X$7736 10648 10209 10859 109 10677 77 OAI21_X1
* cell instance $7738 m0 *1 214.89,133
X$7738 10648 10859 77 109 10649 NOR2_X1
* cell instance $7739 m0 *1 215.46,133
X$7739 10649 10821 10819 77 109 10363 NAND3_X2
* cell instance $7740 m0 *1 216.79,133
X$7740 10821 10824 109 77 10826 XNOR2_X1
* cell instance $7743 r0 *1 213.94,133
X$7743 10822 10682 77 109 10648 NAND2_X1
* cell instance $7744 r0 *1 214.51,133
X$7744 10334 77 109 10859 INV_X1
* cell instance $7746 r0 *1 215.27,133
X$7746 10649 10819 77 109 10823 NAND2_X1
* cell instance $7747 r0 *1 215.84,133
X$7747 10823 10209 8907 9079 77 109 10824 NOR4_X1
* cell instance $7748 r0 *1 216.79,133
X$7748 2526 10826 10828 109 10825 77 OAI21_X1
* cell instance $7751 m0 *1 219.07,133
X$7751 10338 10651 109 77 10827 XNOR2_X1
* cell instance $7754 r0 *1 220.02,133
X$7754 11037 10204 10827 77 10854 109 AOI21_X1
* cell instance $7755 m0 *1 220.78,133
X$7755 10853 77 109 10338 BUF_X1
* cell instance $7758 r0 *1 220.78,133
X$7758 77 18465 10853 10854 10186 109 DFF_X1
* cell instance $7759 m0 *1 222.68,133
X$7759 10186 77 109 19127 INV_X1
* cell instance $7760 m0 *1 221.73,133
X$7760 10855 77 109 10186 CLKBUF_X3
* cell instance $7762 m0 *1 226.67,133
X$7762 3884 4036 77 109 10194 NAND2_X2
* cell instance $7763 m0 *1 223.44,133
X$7763 77 18334 10655 10653 10186 109 DFF_X1
* cell instance $7764 m0 *1 227.62,133
X$7764 8753 10034 77 109 10828 NAND2_X2
* cell instance $7768 r0 *1 224.58,133
X$7768 8755 10034 77 109 11035 NAND2_X1
* cell instance $7770 r0 *1 225.34,133
X$7770 10034 109 8749 77 BUF_X4
* cell instance $7777 r0 *1 228,133
X$7777 11020 77 109 10829 INV_X1
* cell instance $7778 r0 *1 228.38,133
X$7778 10829 8923 8124 109 77 11026 MUX2_X2
* cell instance $7780 m0 *1 228.95,133
X$7780 4036 8923 77 109 9880 OR2_X1
* cell instance $7781 m0 *1 231.23,133
X$7781 10505 11021 10830 77 109 10664 NAND3_X1
* cell instance $7782 m0 *1 231.99,133
X$7782 10663 10664 109 77 10831 XNOR2_X1
* cell instance $7784 m0 *1 233.32,133
X$7784 8743 10656 8124 109 77 10663 OAI21_X2
* cell instance $7789 r0 *1 231.61,133
X$7789 10832 10194 10831 77 109 10843 MUX2_X1
* cell instance $7790 r0 *1 232.94,133
X$7790 77 18471 10832 10843 10196 109 DFF_X1
* cell instance $7791 r0 *1 236.17,133
X$7791 10833 10498 10830 77 109 10834 MUX2_X1
* cell instance $7792 r0 *1 237.5,133
X$7792 10833 10500 10834 77 109 10840 MUX2_X1
* cell instance $7794 r0 *1 239.02,133
X$7794 10834 77 109 10836 BUF_X1
* cell instance $7797 m0 *1 54.72,79.8
X$7797 77 5177 5876 5877 5731 4909 109 DFFR_X1
* cell instance $7798 m0 *1 53.39,79.8
X$7798 5813 5818 5816 77 109 5958 MUX2_X1
* cell instance $7801 r0 *1 53.39,79.8
X$7801 5656 77 109 4903 CLKBUF_X3
* cell instance $7802 r0 *1 54.34,79.8
X$7802 5118 5249 2795 109 77 5955 AND3_X1
* cell instance $7803 r0 *1 55.29,79.8
X$7803 3619 5875 5956 109 5954 77 OAI21_X1
* cell instance $7805 r0 *1 56.24,79.8
X$7805 5875 3794 5957 109 5731 77 OAI21_X1
* cell instance $7806 r0 *1 57,79.8
X$7806 6030 5175 109 77 5953 AND2_X1
* cell instance $7807 r0 *1 57.76,79.8
X$7807 3709 5877 77 109 5957 NAND2_X1
* cell instance $7813 m0 *1 59.66,79.8
X$7813 5878 5818 5819 77 109 5732 MUX2_X1
* cell instance $7814 r0 *1 59.85,79.8
X$7814 5958 5959 5732 77 109 5961 MUX2_X1
* cell instance $7817 m0 *1 61.37,79.8
X$7817 77 5034 5822 5821 5879 4909 109 DFFR_X1
* cell instance $7819 r0 *1 62.32,79.8
X$7819 2158 5313 5964 109 5879 77 OAI21_X1
* cell instance $7821 r0 *1 63.46,79.8
X$7821 4780 5821 77 109 5964 NAND2_X1
* cell instance $7822 r0 *1 64.03,79.8
X$7822 77 5875 109 5880 BUF_X8
* cell instance $7823 m0 *1 68.02,79.8
X$7823 5118 2797 3380 109 77 5733 AND3_X1
* cell instance $7824 m0 *1 65.55,79.8
X$7824 77 5029 109 5880 BUF_X8
* cell instance $7826 m0 *1 69.16,79.8
X$7826 77 2797 109 5249 BUF_X8
* cell instance $7828 m0 *1 71.82,79.8
X$7828 5583 5827 5039 77 109 5825 NAND3_X1
* cell instance $7830 m0 *1 72.77,79.8
X$7830 5882 3631 77 109 5881 NAND2_X2
* cell instance $7831 m0 *1 73.72,79.8
X$7831 77 4324 5735 5829 5830 1663 109 DFFR_X1
* cell instance $7832 m0 *1 77.52,79.8
X$7832 5735 5734 5585 77 109 5736 MUX2_X1
* cell instance $7834 m0 *1 79.04,79.8
X$7834 5834 3622 5737 77 109 5883 MUX2_X1
* cell instance $7835 m0 *1 80.37,79.8
X$7835 5735 3500 5270 77 109 5834 MUX2_X1
* cell instance $7836 m0 *1 81.7,79.8
X$7836 4327 5738 5739 109 5970 77 OAI21_X1
* cell instance $7837 m0 *1 82.46,79.8
X$7837 5738 5838 77 109 5739 NAND2_X1
* cell instance $7841 m0 *1 85.5,79.8
X$7841 5840 5740 4916 77 109 5886 MUX2_X1
* cell instance $7842 m0 *1 86.83,79.8
X$7842 5588 5740 4078 77 109 5974 MUX2_X1
* cell instance $7845 r0 *1 66.5,79.8
X$7845 77 2158 109 5880 BUF_X8
* cell instance $7847 r0 *1 69.16,79.8
X$7847 6037 3631 77 109 6035 NAND2_X2
* cell instance $7848 r0 *1 70.11,79.8
X$7848 5881 6169 2794 77 109 NOR2_X4
* cell instance $7849 r0 *1 71.82,79.8
X$7849 77 3631 5882 6169 3380 109 NOR3_X4
* cell instance $7851 r0 *1 76,79.8
X$7851 4780 6038 77 109 5674 NAND2_X1
* cell instance $7852 r0 *1 76.57,79.8
X$7852 77 2548 109 3621 BUF_X8
* cell instance $7855 r0 *1 80.18,79.8
X$7855 77 5540 5888 5838 5970 1663 109 DFFR_X1
* cell instance $7856 r0 *1 83.98,79.8
X$7856 77 5540 5977 5973 5885 1663 109 DFFR_X1
* cell instance $7857 r0 *1 87.78,79.8
X$7857 5886 5887 5974 77 109 5975 MUX2_X1
* cell instance $7859 r0 *1 89.3,79.8
X$7859 5888 5589 5977 77 109 5978 MUX2_X1
* cell instance $7862 m0 *1 91.77,79.8
X$7862 5842 6174 5742 77 109 5743 MUX2_X1
* cell instance $7866 m0 *1 94.81,79.8
X$7866 5592 4903 5844 109 5889 77 OAI21_X1
* cell instance $7867 m0 *1 95.57,79.8
X$7867 4903 5845 77 109 5844 NAND2_X1
* cell instance $7870 m0 *1 97.85,79.8
X$7870 3290 77 109 5846 INV_X1
* cell instance $7871 m0 *1 98.23,79.8
X$7871 77 5848 5324 5325 5846 109 AOI21_X4
* cell instance $7874 r0 *1 91.96,79.8
X$7874 5978 3622 6044 77 109 5979 MUX2_X1
* cell instance $7875 r0 *1 93.29,79.8
X$7875 77 4774 109 5734 BUF_X8
* cell instance $7876 r0 *1 95.76,79.8
X$7876 77 3623 6181 5845 5889 1663 109 DFFR_X1
* cell instance $7878 r0 *1 99.94,79.8
X$7878 77 5980 5324 5325 5418 109 AOI21_X4
* cell instance $7879 m0 *1 101.27,79.8
X$7879 5052 5607 5594 109 77 4650 MUX2_X2
* cell instance $7881 m0 *1 102.98,79.8
X$7881 5118 3811 5323 5008 5850 109 77 AOI211_X2
* cell instance $7885 r0 *1 102.98,79.8
X$7885 77 5249 3811 5323 5008 109 AOI21_X4
* cell instance $7886 m0 *1 105.26,79.8
X$7886 5118 5891 5554 5008 5175 109 77 AOI211_X2
* cell instance $7889 m0 *1 107.16,79.8
X$7889 3811 77 109 5891 INV_X1
* cell instance $7890 m0 *1 107.54,79.8
X$7890 5851 5323 77 109 6420 NAND2_X1
* cell instance $7891 m0 *1 108.11,79.8
X$7891 77 5892 5852 3809 4779 5324 109 OAI22_X4
* cell instance $7892 m0 *1 111.34,79.8
X$7892 4346 109 5118 77 BUF_X4
* cell instance $7894 m0 *1 113.43,79.8
X$7894 5741 77 109 4928 CLKBUF_X3
* cell instance $7895 m0 *1 114.38,79.8
X$7895 5855 4928 5701 77 5744 109 AOI21_X1
* cell instance $7896 m0 *1 115.14,79.8
X$7896 3998 77 109 5326 CLKBUF_X3
* cell instance $7897 m0 *1 116.09,79.8
X$7897 5597 5189 77 109 5855 NOR2_X1
* cell instance $7898 m0 *1 116.66,79.8
X$7898 5882 3813 3155 77 109 5988 MUX2_X1
* cell instance $7899 m0 *1 117.99,79.8
X$7899 77 5326 5856 4086 5330 5705 109 DFFR_X2
* cell instance $7900 m0 *1 122.17,79.8
X$7900 77 5601 5993 5745 5326 109 DFF_X1
* cell instance $7901 m0 *1 125.4,79.8
X$7901 5072 4090 77 109 5900 NOR2_X2
* cell instance $7902 m0 *1 126.35,79.8
X$7902 5599 5159 5746 77 109 5747 OR3_X1
* cell instance $7903 m0 *1 127.3,79.8
X$7903 5159 5746 5599 3918 5335 4752 77 109 5898 OAI33_X1
* cell instance $7904 m0 *1 128.63,79.8
X$7904 77 5996 5474 5748 5158 109 AOI21_X4
* cell instance $7906 m0 *1 131.29,79.8
X$7906 5557 5861 5711 109 5862 77 NOR3_X2
* cell instance $7908 m0 *1 132.81,79.8
X$7908 5900 5862 5432 77 5753 109 AOI21_X2
* cell instance $7910 m0 *1 134.33,79.8
X$7910 77 5557 5193 6002 5750 5751 109 AOI22_X4
* cell instance $7911 m0 *1 137.56,79.8
X$7911 5749 3919 3068 77 109 5760 MUX2_X1
* cell instance $7912 m0 *1 138.89,79.8
X$7912 5753 4752 5430 109 5609 77 OAI21_X1
* cell instance $7913 m0 *1 139.65,79.8
X$7913 4350 5199 77 6191 109 NAND2_X4
* cell instance $7916 r0 *1 105.83,79.8
X$7916 77 2945 109 5118 BUF_X8
* cell instance $7917 r0 *1 108.3,79.8
X$7917 6042 5984 5891 5896 77 109 5985 NAND4_X1
* cell instance $7918 r0 *1 109.25,79.8
X$7918 5986 5987 77 5880 109 OR2_X4
* cell instance $7919 r0 *1 110.96,79.8
X$7919 5324 5325 3459 77 5986 109 AOI21_X1
* cell instance $7921 r0 *1 111.91,79.8
X$7921 6137 109 6036 77 BUF_X4
* cell instance $7927 r0 *1 115.14,79.8
X$7927 5326 77 109 19179 INV_X1
* cell instance $7930 r0 *1 116.09,79.8
X$7930 77 5991 5893 4172 5326 109 DFF_X1
* cell instance $7932 r0 *1 120.08,79.8
X$7932 5893 5859 109 77 5989 AND2_X1
* cell instance $7935 r0 *1 121.22,79.8
X$7935 5859 5895 5991 109 6186 77 OAI21_X1
* cell instance $7936 r0 *1 121.98,79.8
X$7936 5859 3919 77 109 6046 NAND2_X1
* cell instance $7938 r0 *1 122.74,79.8
X$7938 5157 5992 77 109 6048 NAND2_X1
* cell instance $7939 r0 *1 123.31,79.8
X$7939 5599 109 5895 77 BUF_X4
* cell instance $7940 r0 *1 124.64,79.8
X$7940 5711 6142 4348 5557 77 109 5995 AOI22_X1
* cell instance $7941 r0 *1 125.59,79.8
X$7941 4525 5995 5478 6270 5600 5902 77 109 OAI221_X2
* cell instance $7942 r0 *1 127.68,79.8
X$7942 5747 109 5997 77 BUF_X4
* cell instance $7943 r0 *1 129.01,79.8
X$7943 5338 5713 5430 109 77 5899 OAI21_X2
* cell instance $7944 r0 *1 130.34,79.8
X$7944 5900 5754 5862 5432 77 109 5709 AOI22_X2
* cell instance $7945 r0 *1 132.05,79.8
X$7945 5430 77 109 6000 BUF_X1
* cell instance $7946 r0 *1 132.62,79.8
X$7946 3918 5563 5896 77 5901 109 AOI21_X1
* cell instance $7947 r0 *1 133.38,79.8
X$7947 5160 5751 5750 77 6001 109 AOI21_X2
* cell instance $7949 r0 *1 135.09,79.8
X$7949 77 5553 6002 5752 6005 5999 109 OAI211_X4
* cell instance $7950 r0 *1 138.32,79.8
X$7950 5753 4752 77 109 5346 NOR2_X2
* cell instance $7951 r0 *1 139.27,79.8
X$7951 77 5903 5902 5904 6006 4540 109 NOR4_X4
* cell instance $7953 m0 *1 141.74,79.8
X$7953 77 5297 5158 4474 5436 109 NOR3_X4
* cell instance $7954 m0 *1 144.59,79.8
X$7954 77 6008 18599 5342 5483 1146 109 DFFR_X1
* cell instance $7955 m0 *1 148.39,79.8
X$7955 5605 6010 5860 109 5559 77 NOR3_X2
* cell instance $7956 m0 *1 149.72,79.8
X$7956 5077 109 5756 77 BUF_X4
* cell instance $7957 m0 *1 151.05,79.8
X$7957 5858 5758 5446 77 109 5549 NAND3_X2
* cell instance $7958 m0 *1 152.38,79.8
X$7958 5757 109 5199 77 BUF_X4
* cell instance $7959 m0 *1 153.71,79.8
X$7959 5485 5076 4754 5614 77 109 5759 NOR4_X1
* cell instance $7960 m0 *1 154.66,79.8
X$7960 5906 6003 109 77 5523 AND2_X2
* cell instance $7961 m0 *1 155.61,79.8
X$7961 5610 5761 5907 109 77 5615 AND3_X1
* cell instance $7962 m0 *1 156.56,79.8
X$7962 5761 5907 5759 109 77 5762 AND3_X1
* cell instance $7963 m0 *1 157.51,79.8
X$7963 5350 5763 4044 5606 109 5854 77 NOR4_X2
* cell instance $7964 m0 *1 159.22,79.8
X$7964 5550 77 109 5998 BUF_X1
* cell instance $7965 m0 *1 159.79,79.8
X$7965 5994 5488 5550 109 77 5908 OAI21_X2
* cell instance $7966 m0 *1 161.12,79.8
X$7966 77 4055 5081 5765 4489 5766 109 OAI211_X4
* cell instance $7967 m0 *1 164.35,79.8
X$7967 5767 77 109 5849 BUF_X2
* cell instance $7968 m0 *1 165.11,79.8
X$7968 77 4745 4489 5769 5908 4740 109 NOR4_X4
* cell instance $7970 m0 *1 168.72,79.8
X$7970 5618 5204 5659 77 5761 109 AOI21_X2
* cell instance $7972 m0 *1 170.24,79.8
X$7972 4096 4355 5771 5078 109 5269 77 OR4_X2
* cell instance $7973 m0 *1 171.57,79.8
X$7973 4875 4485 4538 109 77 5983 OAI21_X2
* cell instance $7974 m0 *1 172.9,79.8
X$7974 77 5839 5679 5833 5484 1146 109 DFFS_X1
* cell instance $7976 m0 *1 176.89,79.8
X$7976 5837 2980 5617 77 5771 109 AOI21_X2
* cell instance $7978 m0 *1 178.41,79.8
X$7978 4981 5772 5835 5836 5773 5909 77 109 OAI221_X2
* cell instance $7979 m0 *1 180.5,79.8
X$7979 5534 4602 77 109 5835 NAND2_X1
* cell instance $7980 m0 *1 181.07,79.8
X$7980 5779 5832 77 109 5774 NOR2_X1
* cell instance $7981 m0 *1 181.64,79.8
X$7981 2980 77 109 5836 INV_X1
* cell instance $7982 m0 *1 182.02,79.8
X$7982 77 6245 18617 5622 5831 1146 109 DFFR_X1
* cell instance $7984 m0 *1 186.58,79.8
X$7984 5624 5204 77 5776 109 NAND2_X4
* cell instance $7986 m0 *1 188.48,79.8
X$7986 788 5625 5916 77 109 5775 MUX2_X1
* cell instance $7987 m0 *1 189.81,79.8
X$7987 5369 77 109 5090 CLKBUF_X3
* cell instance $7990 m0 *1 194.56,79.8
X$7990 5366 5826 77 109 5917 NOR2_X1
* cell instance $7991 m0 *1 195.13,79.8
X$7991 4022 5095 5826 77 109 5968 MUX2_X1
* cell instance $7993 r0 *1 142.69,79.8
X$7993 77 4758 5903 5902 5904 4055 109 NOR4_X4
* cell instance $7994 r0 *1 146.11,79.8
X$7994 77 5610 5860 6009 6010 5614 109 NOR4_X4
* cell instance $7995 r0 *1 149.53,79.8
X$7995 4235 5199 77 109 5556 NAND2_X2
* cell instance $7996 r0 *1 150.48,79.8
X$7996 5858 6007 77 109 6257 NAND2_X1
* cell instance $7997 r0 *1 151.05,79.8
X$7997 5193 6056 6003 109 77 5659 AND3_X2
* cell instance $7998 r0 *1 152.19,79.8
X$7998 4477 4890 5832 77 109 NOR2_X4
* cell instance $7999 r0 *1 153.9,79.8
X$7999 6004 5714 77 109 5906 NOR2_X2
* cell instance $8000 r0 *1 154.85,79.8
X$8000 6057 6059 5697 6195 109 4994 77 OR4_X2
* cell instance $8002 r0 *1 156.37,79.8
X$8002 4875 4096 77 109 5685 NAND2_X2
* cell instance $8003 r0 *1 157.32,79.8
X$8003 5761 77 109 5616 INV_X1
* cell instance $8004 r0 *1 157.7,79.8
X$8004 5606 5350 77 109 6322 NOR2_X2
* cell instance $8005 r0 *1 158.65,79.8
X$8005 6061 5006 77 109 4538 OR2_X2
* cell instance $8006 r0 *1 159.6,79.8
X$8006 2430 77 109 5484 CLKBUF_X3
* cell instance $8007 r0 *1 160.55,79.8
X$8007 77 5488 5998 5994 4050 109 NOR3_X4
* cell instance $8009 r0 *1 163.4,79.8
X$8009 5556 109 5626 77 BUF_X4
* cell instance $8011 r0 *1 164.92,79.8
X$8011 4745 4489 5769 5908 77 109 5768 OR4_X1
* cell instance $8013 r0 *1 166.25,79.8
X$8013 4613 4491 4055 77 109 5769 NAND3_X2
* cell instance $8014 r0 *1 167.58,79.8
X$8014 4382 5351 4986 5296 109 77 6064 AND4_X2
* cell instance $8015 r0 *1 168.91,79.8
X$8015 5770 109 4988 77 BUF_X4
* cell instance $8016 r0 *1 170.24,79.8
X$8016 4096 6059 4355 109 77 6124 OAI21_X2
* cell instance $8021 r0 *1 171.95,79.8
X$8021 5983 5078 77 6067 109 NAND2_X4
* cell instance $8022 r0 *1 173.66,79.8
X$8022 4538 4988 77 109 5779 NAND2_X2
* cell instance $8023 r0 *1 174.61,79.8
X$8023 5910 4988 77 109 5982 NAND2_X2
* cell instance $8024 r0 *1 175.56,79.8
X$8024 5981 5758 5617 4477 77 109 5911 NAND4_X1
* cell instance $8026 r0 *1 176.7,79.8
X$8026 5758 5981 5774 109 77 5914 AND3_X1
* cell instance $8028 r0 *1 178.03,79.8
X$8028 4602 5534 109 77 5617 AND2_X1
* cell instance $8030 r0 *1 179.17,79.8
X$8030 5697 5549 5524 109 5976 77 OAI21_X1
* cell instance $8031 r0 *1 179.93,79.8
X$8031 5773 77 109 4355 INV_X2
* cell instance $8032 r0 *1 180.5,79.8
X$8032 5976 5269 5913 109 77 5490 AND3_X1
* cell instance $8036 r0 *1 184.11,79.8
X$8036 4945 5269 77 109 5655 NAND2_X2
* cell instance $8038 r0 *1 185.25,79.8
X$8038 4382 4945 109 77 5913 AND2_X2
* cell instance $8042 r0 *1 187.53,79.8
X$8042 5915 109 5625 77 BUF_X4
* cell instance $8043 r0 *1 188.86,79.8
X$8043 5972 5779 77 109 5916 NOR2_X1
* cell instance $8046 r0 *1 190.38,79.8
X$8046 4945 4382 77 109 5971 NAND2_X2
* cell instance $8050 r0 *1 192.66,79.8
X$8050 77 5627 18890 5826 5968 1146 109 DFFR_X1
* cell instance $8051 r0 *1 196.46,79.8
X$8051 5914 5776 4415 77 109 5918 NOR3_X1
* cell instance $8052 m0 *1 198.17,79.8
X$8052 5629 77 109 5366 INV_X1
* cell instance $8053 m0 *1 196.84,79.8
X$8053 5823 4554 5778 77 109 5824 MUX2_X1
* cell instance $8054 m0 *1 198.55,79.8
X$8054 5776 5779 77 109 5368 NOR2_X2
* cell instance $8055 m0 *1 199.5,79.8
X$8055 5966 5090 5779 77 109 5215 NOR3_X1
* cell instance $8058 r0 *1 197.22,79.8
X$8058 5777 77 109 6105 INV_X1
* cell instance $8059 r0 *1 197.6,79.8
X$8059 6072 5090 5779 77 109 5127 NOR3_X1
* cell instance $8060 r0 *1 198.36,79.8
X$8060 77 5627 5820 5963 5965 992 109 DFFR_X1
* cell instance $8062 m0 *1 202.16,79.8
X$8062 4831 5820 77 109 3137 NOR2_X1
* cell instance $8063 m0 *1 202.92,79.8
X$8063 5780 4944 77 109 5815 NAND2_X1
* cell instance $8065 m0 *1 203.68,79.8
X$8065 77 6075 18678 5630 5817 992 109 DFFR_X1
* cell instance $8066 m0 *1 207.48,79.8
X$8066 5814 4944 77 109 5782 NAND2_X1
* cell instance $8068 r0 *1 202.16,79.8
X$8068 5820 5437 5853 5220 109 77 5919 OAI22_X2
* cell instance $8069 r0 *1 203.87,79.8
X$8069 77 4271 5853 5912 5629 109 NOR3_X4
* cell instance $8073 r0 *1 207.86,79.8
X$8073 4583 5659 5523 4264 77 109 6074 AOI22_X2
* cell instance $8074 m0 *1 209.57,79.8
X$8074 77 6075 18649 4583 5812 3676 109 DFFR_X1
* cell instance $8075 m0 *1 208.43,79.8
X$8075 1658 5781 5782 5631 5783 109 77 5812 OAI221_X1
* cell instance $8078 m0 *1 215.08,79.8
X$8078 5920 5242 77 109 5922 NOR2_X1
* cell instance $8080 r0 *1 209.57,79.8
X$8080 5912 5632 5920 5371 109 77 5952 OAI22_X2
* cell instance $8083 r0 *1 211.85,79.8
X$8083 4008 77 109 5921 INV_X1
* cell instance $8087 r0 *1 214.7,79.8
X$8087 5376 77 109 5781 CLKBUF_X3
* cell instance $8089 m0 *1 216.22,79.8
X$8089 1084 4867 5784 77 109 5811 MUX2_X1
* cell instance $8093 m0 *1 218.5,79.8
X$8093 5785 5498 77 109 5786 NAND2_X1
* cell instance $8094 m0 *1 219.07,79.8
X$8094 788 4867 5787 77 109 5788 MUX2_X1
* cell instance $8095 m0 *1 220.4,79.8
X$8095 4577 5947 4834 109 77 3004 OAI21_X2
* cell instance $8096 m0 *1 221.73,79.8
X$8096 4986 77 109 4951 CLKBUF_X3
* cell instance $8098 m0 *1 222.87,79.8
X$8098 5802 4951 5789 77 109 5945 MUX2_X1
* cell instance $8099 m0 *1 224.2,79.8
X$8099 625 5233 5801 109 5789 77 OAI21_X1
* cell instance $8100 m0 *1 224.96,79.8
X$8100 4960 5944 77 109 5801 NAND2_X1
* cell instance $8104 r0 *1 216.79,79.8
X$8104 77 5923 5947 5787 5946 3676 109 DFFR_X1
* cell instance $8105 r0 *1 220.59,79.8
X$8105 77 5923 5371 5944 5945 3676 109 DFFR_X1
* cell instance $8106 r0 *1 224.39,79.8
X$8106 2844 6082 6090 2904 6207 2705 109 77 AOI221_X2
* cell instance $8112 m0 *1 227.62,79.8
X$8112 5800 5498 77 109 5799 NAND2_X1
* cell instance $8114 m0 *1 228.19,79.8
X$8114 1330 5781 5799 5374 5798 109 77 5648 OAI221_X1
* cell instance $8115 m0 *1 229.33,79.8
X$8115 4694 5920 4596 5798 109 77 5790 OAI22_X2
* cell instance $8117 r0 *1 227.43,79.8
X$8117 5924 5498 77 109 5941 NAND2_X1
* cell instance $8118 r0 *1 228,79.8
X$8118 978 5372 5941 5374 5939 109 77 5925 OAI221_X1
* cell instance $8121 r0 *1 230.85,79.8
X$8121 3270 77 109 5939 INV_X1
* cell instance $8123 m0 *1 231.61,79.8
X$8123 5635 77 109 19140 INV_X1
* cell instance $8125 m0 *1 231.99,79.8
X$8125 2894 77 109 5635 CLKBUF_X3
* cell instance $8126 m0 *1 232.94,79.8
X$8126 5936 4685 4553 109 5937 77 OAI21_X1
* cell instance $8127 m0 *1 233.7,79.8
X$8127 5926 4685 4553 109 5795 77 OAI21_X1
* cell instance $8130 r0 *1 232.18,79.8
X$8130 2844 5930 5937 2904 6078 2692 109 77 AOI221_X2
* cell instance $8132 r0 *1 234.46,79.8
X$8132 5501 5509 5792 77 109 5927 MUX2_X1
* cell instance $8133 m0 *1 235.03,79.8
X$8133 5924 5385 5502 5228 77 109 5793 AOI22_X1
* cell instance $8135 m0 *1 235.98,79.8
X$8135 978 5384 5793 109 5792 77 OAI21_X1
* cell instance $8136 m0 *1 236.74,79.8
X$8136 5639 77 109 5641 BUF_X1
* cell instance $8140 r0 *1 235.79,79.8
X$8140 77 5635 18831 5501 5927 992 109 DFFR_X1
* cell instance $8151 m0 *1 2.28,68.6
X$8151 4766 77 109 4068 BUF_X2
* cell instance $8160 r0 *1 3.04,68.6
X$8160 4841 77 109 4215 BUF_X2
* cell instance $8162 r0 *1 4.18,68.6
X$8162 4844 4843 4767 77 109 4954 MUX2_X1
* cell instance $8164 r0 *1 5.89,68.6
X$8164 4893 77 109 3571 BUF_X2
* cell instance $8165 r0 *1 6.65,68.6
X$8165 5010 77 109 3132 BUF_X2
* cell instance $8168 m0 *1 9.5,68.6
X$8168 77 4894 4625 4847 4698 2157 109 DFFR_X1
* cell instance $8169 m0 *1 14.82,68.6
X$8169 4699 4708 2779 77 109 4493 MUX2_X1
* cell instance $8174 r0 *1 12.16,68.6
X$8174 4847 4768 4767 77 109 4698 MUX2_X1
* cell instance $8176 r0 *1 14.25,68.6
X$8176 77 4309 109 3041 BUF_X8
* cell instance $8177 r0 *1 16.72,68.6
X$8177 77 4389 4958 4959 4850 2157 109 DFFR_X1
* cell instance $8179 m0 *1 17.29,68.6
X$8179 4625 4309 4626 77 109 4705 MUX2_X1
* cell instance $8180 m0 *1 18.81,68.6
X$8180 4625 3479 4626 77 109 4495 MUX2_X1
* cell instance $8181 m0 *1 20.14,68.6
X$8181 4705 4627 4629 77 109 4769 MUX2_X1
* cell instance $8183 m0 *1 24.51,68.6
X$8183 4852 4631 2779 77 109 4853 MUX2_X1
* cell instance $8187 r0 *1 20.52,68.6
X$8187 4628 4769 5017 109 77 4851 MUX2_X2
* cell instance $8191 r0 *1 23.56,68.6
X$8191 77 3968 4965 4852 4853 2157 109 DFFR_X1
* cell instance $8192 r0 *1 27.36,68.6
X$8192 4854 4768 4770 77 109 4771 MUX2_X1
* cell instance $8193 m0 *1 28.69,68.6
X$8193 4711 4708 2539 77 109 4630 MUX2_X1
* cell instance $8195 m0 *1 30.02,68.6
X$8195 77 3894 4712 4711 4630 2157 109 DFFR_X1
* cell instance $8196 m0 *1 33.82,68.6
X$8196 4856 4205 4712 77 109 4713 MUX2_X1
* cell instance $8197 m0 *1 35.15,68.6
X$8197 4716 4631 2539 77 109 4772 MUX2_X1
* cell instance $8199 m0 *1 36.67,68.6
X$8199 77 4320 109 4496 BUF_X8
* cell instance $8200 m0 *1 39.14,68.6
X$8200 77 4497 3970 109 BUF_X16
* cell instance $8201 m0 *1 43.89,68.6
X$8201 4575 4136 4210 109 77 4717 MUX2_X2
* cell instance $8204 r0 *1 28.69,68.6
X$8204 77 3968 4856 4854 4771 2157 109 DFFR_X1
* cell instance $8208 r0 *1 35.15,68.6
X$8208 77 4899 4967 4716 4772 2157 109 DFFR_X1
* cell instance $8209 r0 *1 38.95,68.6
X$8209 2541 77 109 3894 CLKBUF_X3
* cell instance $8212 r0 *1 40.85,68.6
X$8212 77 4773 3479 109 BUF_X16
* cell instance $8213 r0 *1 45.6,68.6
X$8213 77 3894 4719 4414 4860 2157 109 DFFR_X1
* cell instance $8214 m0 *1 49.21,68.6
X$8214 77 3698 4866 4776 4721 2157 109 DFFR_X1
* cell instance $8215 m0 *1 46.74,68.6
X$8215 4317 4204 4319 109 77 4860 OAI21_X4
* cell instance $8217 r0 *1 49.4,68.6
X$8217 4634 4774 4069 77 109 4902 MUX2_X1
* cell instance $8219 r0 *1 51.49,68.6
X$8219 4318 4776 77 109 4972 NAND2_X1
* cell instance $8222 r0 *1 52.63,68.6
X$8222 4775 3970 4866 77 109 4777 MUX2_X1
* cell instance $8223 m0 *1 53.58,68.6
X$8223 4778 3479 4635 77 109 4498 MUX2_X1
* cell instance $8225 m0 *1 54.91,68.6
X$8225 4778 4205 4635 77 109 4500 MUX2_X1
* cell instance $8227 m0 *1 56.43,68.6
X$8227 77 4504 4635 4502 4976 2157 109 DFFR_X1
* cell instance $8229 m0 *1 60.42,68.6
X$8229 4779 4639 4638 109 4501 77 OAI21_X1
* cell instance $8230 m0 *1 61.18,68.6
X$8230 3701 4639 4727 109 4725 77 OAI21_X1
* cell instance $8231 m0 *1 61.94,68.6
X$8231 77 2226 109 3701 BUF_X8
* cell instance $8232 m0 *1 64.41,68.6
X$8232 4779 77 109 3788 CLKBUF_X3
* cell instance $8233 m0 *1 65.36,68.6
X$8233 4780 4640 77 109 4869 NAND2_X1
* cell instance $8235 m0 *1 66.69,68.6
X$8235 4781 4639 4641 109 4506 77 OAI21_X1
* cell instance $8237 m0 *1 67.64,68.6
X$8237 4505 4728 77 109 4641 NAND2_X1
* cell instance $8242 r0 *1 55.1,68.6
X$8242 4499 4632 4636 77 109 5130 MUX2_X1
* cell instance $8245 r0 *1 58.33,68.6
X$8245 2222 4642 4637 109 4976 77 OAI21_X1
* cell instance $8251 r0 *1 60.04,68.6
X$8251 77 4907 109 3701 BUF_X8
* cell instance $8252 r0 *1 62.51,68.6
X$8252 2543 77 109 4504 CLKBUF_X3
* cell instance $8253 r0 *1 63.46,68.6
X$8253 4869 4780 2700 109 77 4908 OAI21_X4
* cell instance $8254 r0 *1 65.93,68.6
X$8254 3701 109 3793 77 BUF_X4
* cell instance $8257 r0 *1 67.83,68.6
X$8257 4781 77 109 2161 CLKBUF_X3
* cell instance $8259 r0 *1 68.97,68.6
X$8259 77 4324 5037 4732 4783 1663 109 DFFR_X1
* cell instance $8260 m0 *1 70.87,68.6
X$8260 3495 4784 2228 77 109 4785 MUX2_X1
* cell instance $8261 m0 *1 70.11,68.6
X$8261 2161 4642 4730 109 4783 77 OAI21_X1
* cell instance $8263 m0 *1 72.39,68.6
X$8263 4781 77 109 3710 CLKBUF_X3
* cell instance $8264 m0 *1 73.34,68.6
X$8264 4644 4643 4733 77 109 4787 MUX2_X1
* cell instance $8265 m0 *1 74.67,68.6
X$8265 77 4324 4871 4646 4645 1663 109 DFFR_X1
* cell instance $8266 m0 *1 78.47,68.6
X$8266 77 3908 4788 4648 4649 1663 109 DFFR_X1
* cell instance $8267 m0 *1 82.27,68.6
X$8267 4505 4648 77 109 4872 NAND2_X1
* cell instance $8268 m0 *1 82.84,68.6
X$8268 4650 4639 4872 109 4649 77 OAI21_X1
* cell instance $8269 m0 *1 83.6,68.6
X$8269 4650 77 109 4327 CLKBUF_X3
* cell instance $8270 m0 *1 84.55,68.6
X$8270 2232 4318 4651 109 4737 77 OAI21_X1
* cell instance $8272 m0 *1 85.5,68.6
X$8272 4318 4738 77 109 4651 NAND2_X1
* cell instance $8276 r0 *1 73.15,68.6
X$8276 5038 4643 4786 77 109 4910 MUX2_X1
* cell instance $8278 r0 *1 75.24,68.6
X$8278 77 4324 4982 4912 4870 1663 109 DFFR_X1
* cell instance $8280 r0 *1 79.8,68.6
X$8280 4213 4789 4788 77 109 4913 MUX2_X1
* cell instance $8282 r0 *1 81.89,68.6
X$8282 3384 4789 4434 77 109 4915 MUX2_X1
* cell instance $8285 r0 *1 83.79,68.6
X$8285 77 3908 4916 4738 4737 1663 109 DFFR_X1
* cell instance $8287 m0 *1 88.92,68.6
X$8287 3623 77 109 19146 INV_X1
* cell instance $8288 m0 *1 87.97,68.6
X$8288 166 77 109 3623 CLKBUF_X3
* cell instance $8291 m0 *1 90.25,68.6
X$8291 3998 77 109 4216 CLKBUF_X3
* cell instance $8292 m0 *1 91.2,68.6
X$8292 4216 77 109 19129 INV_X1
* cell instance $8295 m0 *1 93.86,68.6
X$8295 4652 3627 4516 77 109 4792 MUX2_X1
* cell instance $8298 r0 *1 88.35,68.6
X$8298 4782 2235 4790 77 109 4989 MUX2_X1
* cell instance $8301 r0 *1 90.25,68.6
X$8301 77 4216 18748 4791 4990 1663 109 DFFR_X1
* cell instance $8302 r0 *1 94.05,68.6
X$8302 4791 3627 4793 77 109 4917 MUX2_X1
* cell instance $8305 r0 *1 95.95,68.6
X$8305 4515 2649 4791 77 109 4992 MUX2_X1
* cell instance $8306 m0 *1 97.28,68.6
X$8306 3016 4874 4654 109 4653 77 OAI21_X1
* cell instance $8308 m0 *1 98.04,68.6
X$8308 2647 4655 4656 109 4919 77 OAI21_X1
* cell instance $8310 m0 *1 98.99,68.6
X$8310 4217 3626 4333 77 109 4658 MUX2_X1
* cell instance $8312 r0 *1 97.28,68.6
X$8312 4652 3387 77 109 4874 NAND2_X1
* cell instance $8314 r0 *1 98.04,68.6
X$8314 4793 2952 77 109 4918 NAND2_X1
* cell instance $8316 r0 *1 98.8,68.6
X$8316 4512 3387 77 109 4920 NAND2_X1
* cell instance $8317 r0 *1 99.37,68.6
X$8317 4782 2952 3059 77 109 4794 NAND3_X1
* cell instance $8319 m0 *1 100.89,68.6
X$8319 4742 3456 77 109 4995 NAND2_X1
* cell instance $8321 m0 *1 101.46,68.6
X$8321 4068 3626 4215 77 109 4657 MUX2_X1
* cell instance $8322 m0 *1 102.79,68.6
X$8322 4657 3628 4658 77 109 4876 MUX2_X1
* cell instance $8323 m0 *1 104.12,68.6
X$8323 4081 77 109 3302 CLKBUF_X3
* cell instance $8324 m0 *1 105.07,68.6
X$8324 3804 4518 3914 77 109 4746 MUX2_X1
* cell instance $8327 r0 *1 101.65,68.6
X$8327 3389 4876 3456 4332 77 109 4996 AOI22_X1
* cell instance $8329 r0 *1 102.98,68.6
X$8329 4657 3302 4658 77 109 4999 MUX2_X1
* cell instance $8330 r0 *1 104.31,68.6
X$8330 4518 109 3626 77 BUF_X4
* cell instance $8334 r0 *1 106.97,68.6
X$8334 4795 77 109 4081 INV_X2
* cell instance $8336 r0 *1 107.73,68.6
X$8336 5000 4341 3389 77 109 4924 NAND3_X1
* cell instance $8338 m0 *1 108.3,68.6
X$8338 4795 109 3628 77 BUF_X4
* cell instance $8341 m0 *1 114.95,68.6
X$8341 4881 77 109 4748 INV_X1
* cell instance $8342 m0 *1 115.33,68.6
X$8342 4225 77 109 19226 CLKBUF_X1
* cell instance $8343 m0 *1 115.9,68.6
X$8343 77 4225 18580 4800 4748 4086 109 DFFR_X1
* cell instance $8344 m0 *1 119.7,68.6
X$8344 77 4225 4929 4524 4659 4086 109 DFFR_X1
* cell instance $8345 m0 *1 123.5,68.6
X$8345 4660 4462 3392 77 109 4804 MUX2_X1
* cell instance $8346 m0 *1 124.83,68.6
X$8346 4525 4660 4348 77 109 4747 NOR3_X1
* cell instance $8347 m0 *1 125.59,68.6
X$8347 4805 4306 77 109 4885 NOR2_X1
* cell instance $8348 m0 *1 126.16,68.6
X$8348 4614 3634 3816 109 77 4882 AND3_X1
* cell instance $8349 m0 *1 127.11,68.6
X$8349 4348 77 109 4883 INV_X2
* cell instance $8350 m0 *1 127.68,68.6
X$8350 4465 109 4752 77 BUF_X4
* cell instance $8351 m0 *1 129.01,68.6
X$8351 3816 77 109 4805 INV_X1
* cell instance $8352 m0 *1 129.39,68.6
X$8352 4528 4232 4088 77 109 4806 MUX2_X1
* cell instance $8353 m0 *1 130.72,68.6
X$8353 4088 4091 4931 77 109 NOR2_X4
* cell instance $8354 m0 *1 132.43,68.6
X$8354 77 1146 4086 109 BUF_X32
* cell instance $8355 m0 *1 141.74,68.6
X$8355 4663 4755 77 2395 109 NAND2_X4
* cell instance $8356 m0 *1 143.45,68.6
X$8356 3920 4664 4530 77 109 2347 NAND3_X2
* cell instance $8357 m0 *1 144.78,68.6
X$8357 4482 4097 4759 109 77 4664 OAI21_X2
* cell instance $8358 m0 *1 146.11,68.6
X$8358 2395 4531 4761 109 4810 77 OAI21_X1
* cell instance $8359 m0 *1 146.87,68.6
X$8359 4534 4620 4665 4238 109 77 3590 OAI22_X2
* cell instance $8360 m0 *1 148.58,68.6
X$8360 4665 4667 4096 77 109 4623 NOR3_X1
* cell instance $8361 m0 *1 149.34,68.6
X$8361 4886 4765 4624 4534 4668 4756 109 77 AOI221_X2
* cell instance $8362 m0 *1 151.43,68.6
X$8362 4238 4485 77 109 4534 NOR2_X2
* cell instance $8363 m0 *1 152.38,68.6
X$8363 4533 77 109 4665 INV_X8
* cell instance $8364 m0 *1 154.09,68.6
X$8364 77 4356 4357 4358 4051 4354 109 OAI211_X4
* cell instance $8365 m0 *1 157.32,68.6
X$8365 77 4354 4358 4240 4103 4818 109 NOR4_X4
* cell instance $8366 m0 *1 160.74,68.6
X$8366 4671 4050 4541 77 4753 109 AOI21_X1
* cell instance $8367 m0 *1 161.5,68.6
X$8367 3589 4298 4171 77 109 4816 NOR3_X1
* cell instance $8368 m0 *1 162.26,68.6
X$8368 4542 4750 77 109 4751 NOR2_X1
* cell instance $8371 r0 *1 108.87,68.6
X$8371 77 4225 18715 4795 4878 4086 109 DFFR_X1
* cell instance $8379 r0 *1 115.52,68.6
X$8379 4796 77 109 4798 BUF_X1
* cell instance $8383 r0 *1 118.18,68.6
X$8383 5062 4797 109 77 4926 AND2_X2
* cell instance $8385 r0 *1 119.32,68.6
X$8385 4798 4095 4799 109 5153 77 OAI21_X1
* cell instance $8386 r0 *1 120.08,68.6
X$8386 4800 4801 129 4802 77 109 4881 AOI22_X1
* cell instance $8388 r0 *1 121.22,68.6
X$8388 4799 4926 4927 77 4802 109 AOI21_X1
* cell instance $8389 r0 *1 121.98,68.6
X$8389 4800 129 77 109 4803 NOR2_X2
* cell instance $8391 r0 *1 123.12,68.6
X$8391 4926 4928 77 109 4809 NAND2_X2
* cell instance $8392 r0 *1 124.07,68.6
X$8392 4803 4809 4524 77 109 5074 NOR3_X1
* cell instance $8395 r0 *1 125.4,68.6
X$8395 4614 3634 109 77 4930 AND2_X1
* cell instance $8396 r0 *1 126.16,68.6
X$8396 4882 109 5157 77 BUF_X4
* cell instance $8397 r0 *1 127.49,68.6
X$8397 3634 4614 77 4932 109 NAND2_X4
* cell instance $8398 r0 *1 129.2,68.6
X$8398 4884 4661 4527 4885 5159 77 109 OAI211_X2
* cell instance $8399 r0 *1 130.91,68.6
X$8399 4230 77 109 19173 INV_X1
* cell instance $8400 r0 *1 131.29,68.6
X$8400 77 5009 4303 4528 4932 4807 109 OR4_X4
* cell instance $8401 r0 *1 133.76,68.6
X$8401 77 4306 4662 4752 4806 4887 109 NOR4_X4
* cell instance $8402 r0 *1 137.18,68.6
X$8402 4088 4469 77 5072 109 OR2_X4
* cell instance $8403 r0 *1 138.89,68.6
X$8403 77 4889 4807 109 BUF_X16
* cell instance $8404 r0 *1 143.64,68.6
X$8404 4808 5007 77 109 5006 OR2_X2
* cell instance $8406 r0 *1 144.78,68.6
X$8406 4531 2395 4812 4097 4353 109 77 4757 OAI221_X1
* cell instance $8407 r0 *1 145.92,68.6
X$8407 4350 4809 4811 109 5161 77 OAI21_X1
* cell instance $8408 r0 *1 146.68,68.6
X$8408 77 4891 4810 3921 4764 2395 4238 4620 109 AOI222_X2
* cell instance $8409 r0 *1 149.34,68.6
X$8409 4892 77 109 5004 BUF_X1
* cell instance $8410 r0 *1 149.91,68.6
X$8410 4525 4890 77 109 4811 NOR2_X1
* cell instance $8412 r0 *1 150.86,68.6
X$8412 4623 4096 4888 77 4813 109 AOI21_X1
* cell instance $8413 r0 *1 151.62,68.6
X$8413 4099 4533 4669 109 4936 77 OAI21_X1
* cell instance $8415 r0 *1 152.76,68.6
X$8415 4097 4486 4533 109 4888 77 OAI21_X1
* cell instance $8416 r0 *1 153.52,68.6
X$8416 4665 4667 77 4620 109 NAND2_X4
* cell instance $8418 r0 *1 155.42,68.6
X$8418 4099 4667 4665 77 4986 109 NAND3_X4
* cell instance $8420 r0 *1 158.27,68.6
X$8420 4540 4492 3824 77 109 4103 NAND3_X2
* cell instance $8421 r0 *1 159.6,68.6
X$8421 4671 109 4171 77 BUF_X4
* cell instance $8423 r0 *1 161.12,68.6
X$8423 3831 4816 4051 3646 4939 77 109 OAI211_X2
* cell instance $8424 r0 *1 162.83,68.6
X$8424 4939 4938 4880 4877 109 77 4672 AND4_X1
* cell instance $8425 m0 *1 163.78,68.6
X$8425 4541 4815 4673 4243 109 77 3536 AND4_X2
* cell instance $8426 m0 *1 163.21,68.6
X$8426 4749 4171 77 109 4817 NOR2_X1
* cell instance $8427 m0 *1 165.11,68.6
X$8427 4673 4818 4056 77 109 4605 NAND3_X2
* cell instance $8428 m0 *1 166.44,68.6
X$8428 4675 4985 3775 4357 77 109 4877 NAND4_X1
* cell instance $8429 m0 *1 167.39,68.6
X$8429 4745 4489 4051 4744 77 109 4741 OR4_X1
* cell instance $8431 r0 *1 163.97,68.6
X$8431 4243 4673 4815 4541 77 109 4880 NAND4_X1
* cell instance $8433 r0 *1 165.11,68.6
X$8433 4673 4818 4056 77 109 2872 AND3_X4
* cell instance $8434 r0 *1 167.2,68.6
X$8434 4176 3931 4056 77 109 NOR2_X4
* cell instance $8435 m0 *1 169.86,68.6
X$8435 77 4108 4054 3931 4819 109 NOR3_X4
* cell instance $8436 m0 *1 168.91,68.6
X$8436 4171 4357 77 109 4168 NOR2_X2
* cell instance $8438 m0 *1 172.71,68.6
X$8438 77 3519 4740 3647 4831 3656 109 OAI211_X4
* cell instance $8439 m0 *1 175.94,68.6
X$8439 3160 77 109 19209 CLKBUF_X1
* cell instance $8441 m0 *1 176.7,68.6
X$8441 77 3404 18646 3837 4676 1146 109 DFFR_X1
* cell instance $8443 r0 *1 168.91,68.6
X$8443 4297 4363 77 109 4983 NOR2_X1
* cell instance $8444 r0 *1 169.48,68.6
X$8444 77 4819 4820 4815 4357 2912 109 AND4_X4
* cell instance $8448 r0 *1 171.95,68.6
X$8448 77 163 4537 4485 4875 4382 109 NAND4_X4
* cell instance $8449 r0 *1 175.37,68.6
X$8449 3348 77 109 3160 CLKBUF_X3
* cell instance $8451 r0 *1 177.08,68.6
X$8451 3837 77 109 4943 INV_X1
* cell instance $8455 r0 *1 180.12,68.6
X$8455 4688 77 109 4981 INV_X1
* cell instance $8457 r0 *1 180.69,68.6
X$8457 77 3404 4873 4979 4822 1146 109 DFFR_X1
* cell instance $8459 m0 *1 180.88,68.6
X$8459 77 3404 18639 4546 4677 1146 109 DFFR_X1
* cell instance $8460 m0 *1 186.2,68.6
X$8460 77 4545 4550 4734 4537 109 NOR3_X4
* cell instance $8461 m0 *1 188.86,68.6
X$8461 77 4376 18641 4731 4735 1146 109 DFFR_X1
* cell instance $8463 m0 *1 193.42,68.6
X$8463 4731 4552 4680 77 109 4729 MUX2_X1
* cell instance $8465 m0 *1 194.94,68.6
X$8465 3348 77 109 4376 CLKBUF_X3
* cell instance $8467 m0 *1 197.41,68.6
X$8467 77 4376 18659 4830 4726 992 109 DFFR_X1
* cell instance $8473 r0 *1 188.48,68.6
X$8473 4947 77 109 4946 INV_X1
* cell instance $8476 r0 *1 190.57,68.6
X$8476 4823 77 109 4735 INV_X1
* cell instance $8479 r0 *1 192.09,68.6
X$8479 4824 4256 2904 4731 77 109 2670 AOI22_X2
* cell instance $8480 r0 *1 193.8,68.6
X$8480 4731 4825 4680 4548 77 109 4823 AOI22_X1
* cell instance $8482 r0 *1 195.13,68.6
X$8482 77 4825 4826 3094 1783 109 AOI21_X4
* cell instance $8483 r0 *1 197.6,68.6
X$8483 4825 4827 4828 109 4974 77 OAI21_X1
* cell instance $8484 r0 *1 198.36,68.6
X$8484 4825 4829 77 109 4828 NAND2_X1
* cell instance $8486 r0 *1 199.12,68.6
X$8486 5215 1084 4683 77 3339 109 AOI21_X1
* cell instance $8487 r0 *1 199.88,68.6
X$8487 4831 4948 77 109 2898 NOR2_X1
* cell instance $8490 m0 *1 205.39,68.6
X$8490 4832 4548 1822 77 109 4723 NOR3_X1
* cell instance $8491 m0 *1 204.63,68.6
X$8491 4723 4591 4548 77 4724 109 AOI21_X1
* cell instance $8493 m0 *1 206.34,68.6
X$8493 2894 77 109 4262 CLKBUF_X3
* cell instance $8494 m0 *1 207.29,68.6
X$8494 4684 4831 4693 4605 109 77 4263 OAI22_X1
* cell instance $8496 m0 *1 209,68.6
X$8496 4686 4685 4553 109 4116 77 OAI21_X1
* cell instance $8499 m0 *1 210.71,68.6
X$8499 77 4687 18612 4688 4722 3676 109 DFFR_X1
* cell instance $8503 r0 *1 205.39,68.6
X$8503 77 4262 4949 992 19025 3946 109 DFFR_X2
* cell instance $8505 r0 *1 209.76,68.6
X$8505 4831 5244 77 109 2711 NOR2_X1
* cell instance $8506 r0 *1 210.33,68.6
X$8506 4868 109 1783 77 BUF_X4
* cell instance $8509 r0 *1 213.94,68.6
X$8509 4868 2912 77 109 4867 NAND2_X2
* cell instance $8510 r0 *1 214.89,68.6
X$8510 1783 2681 77 109 5376 NAND2_X2
* cell instance $8511 m0 *1 219.45,68.6
X$8511 4864 4951 4690 77 109 4720 MUX2_X1
* cell instance $8512 m0 *1 215.65,68.6
X$8512 77 3440 4686 4689 4720 3676 109 DFFR_X1
* cell instance $8514 m0 *1 221.54,68.6
X$8514 4952 4685 4553 109 3237 77 OAI21_X1
* cell instance $8516 r0 *1 215.84,68.6
X$8516 903 4867 5117 77 109 4966 MUX2_X1
* cell instance $8518 r0 *1 217.36,68.6
X$8518 5499 2681 2363 4863 77 109 4381 AOI22_X2
* cell instance $8519 r0 *1 219.07,68.6
X$8519 2894 77 109 19116 INV_X2
* cell instance $8521 r0 *1 219.83,68.6
X$8521 77 3675 4952 4859 4858 3676 109 DFFR_X1
* cell instance $8523 m0 *1 222.68,68.6
X$8523 693 4691 4859 77 109 4692 MUX2_X1
* cell instance $8525 r0 *1 224.01,68.6
X$8525 77 3675 3988 4953 5105 3676 109 DFFR_X1
* cell instance $8526 m0 *1 224.58,68.6
X$8526 4709 77 109 4550 CLKBUF_X3
* cell instance $8528 m0 *1 225.53,68.6
X$8528 77 4563 18609 4709 4710 3676 109 DFFR_X1
* cell instance $8533 r0 *1 227.81,68.6
X$8533 4857 2681 2363 4849 77 109 2489 AOI22_X2
* cell instance $8534 r0 *1 229.52,68.6
X$8534 4694 4834 4577 109 2870 77 OAI21_X1
* cell instance $8535 m0 *1 231.04,68.6
X$8535 548 4691 4704 77 109 4707 MUX2_X1
* cell instance $8536 m0 *1 229.71,68.6
X$8536 4855 4837 4707 77 109 4571 MUX2_X1
* cell instance $8538 m0 *1 233.13,68.6
X$8538 772 4691 4701 77 109 4702 MUX2_X1
* cell instance $8539 m0 *1 234.46,68.6
X$8539 4700 77 109 4693 INV_X1
* cell instance $8544 r0 *1 230.85,68.6
X$8544 4685 109 4834 77 BUF_X4
* cell instance $8546 r0 *1 232.37,68.6
X$8546 4835 4834 4577 109 2987 77 OAI21_X1
* cell instance $8547 r0 *1 233.13,68.6
X$8547 5101 4834 4577 109 3243 77 OAI21_X1
* cell instance $8550 r0 *1 234.84,68.6
X$8550 4848 77 109 4581 BUF_X1
* cell instance $8551 r0 *1 235.41,68.6
X$8551 4838 77 109 4849 BUF_X1
* cell instance $8552 m0 *1 237.31,68.6
X$8552 4839 77 109 4700 BUF_X1
* cell instance $8553 m0 *1 235.98,68.6
X$8553 4846 4837 4702 77 109 4703 MUX2_X1
* cell instance $8556 r0 *1 237.5,68.6
X$8556 4845 77 109 4557 BUF_X1
* cell instance $8557 r0 *1 238.07,68.6
X$8557 4840 77 109 3427 BUF_X2
* cell instance $8558 m0 *1 239.02,68.6
X$8558 4387 77 109 4697 BUF_X1
* cell instance $8559 m0 *1 238.26,68.6
X$8559 4695 77 109 3423 CLKBUF_X2
* cell instance $8562 r0 *1 239.02,68.6
X$8562 4842 77 109 4863 BUF_X1
* cell instance $8565 m0 *1 232.18,147
X$8565 77 18357 11788 11970 11785 109 DFF_X1
* cell instance $8566 m0 *1 236.17,147
X$8566 11938 77 109 11962 BUF_X1
* cell instance $8568 m0 *1 236.93,147
X$8568 11969 77 109 11964 BUF_X1
* cell instance $8569 m0 *1 237.5,147
X$8569 11960 10500 11789 77 109 11967 MUX2_X1
* cell instance $8570 m0 *1 238.83,147
X$8570 11789 77 109 11963 BUF_X1
* cell instance $8574 r0 *1 232.37,147
X$8574 12303 12305 12145 77 109 12314 MUX2_X1
* cell instance $8576 r0 *1 233.89,147
X$8576 3822 10025 12146 109 12145 77 OAI21_X1
* cell instance $8578 r0 *1 235.03,147
X$8578 12154 77 109 12150 BUF_X1
* cell instance $8580 r0 *1 235.98,147
X$8580 12147 12305 12309 77 109 12310 MUX2_X1
* cell instance $8581 r0 *1 237.31,147
X$8581 12144 77 109 11961 BUF_X1
* cell instance $8586 m0 *1 13.11,60.2
X$8586 3966 3782 3361 77 109 3885 MUX2_X1
* cell instance $8587 m0 *1 15.2,60.2
X$8587 3886 2633 2779 77 109 3965 MUX2_X1
* cell instance $8589 m0 *1 17.29,60.2
X$8589 3781 3784 3850 77 109 3848 MUX2_X1
* cell instance $8590 m0 *1 18.62,60.2
X$8590 3781 77 109 2779 BUF_X2
* cell instance $8592 m0 *1 19.57,60.2
X$8592 3781 109 3361 77 BUF_X4
* cell instance $8593 m0 *1 20.9,60.2
X$8593 3969 3782 3484 77 109 3783 MUX2_X1
* cell instance $8594 m0 *1 22.23,60.2
X$8594 77 3968 3888 3969 3783 2157 109 DFFR_X1
* cell instance $8597 m0 *1 26.98,60.2
X$8597 77 2932 109 3887 BUF_X8
* cell instance $8598 m0 *1 29.45,60.2
X$8598 3887 3784 3785 77 109 3852 MUX2_X1
* cell instance $8599 m0 *1 30.78,60.2
X$8599 77 3368 3890 3891 3973 2157 109 DFFR_X1
* cell instance $8600 m0 *1 34.58,60.2
X$8600 3891 3786 2539 77 109 3973 MUX2_X1
* cell instance $8603 m0 *1 36.86,60.2
X$8603 3892 3784 3857 77 109 3691 MUX2_X1
* cell instance $8605 r0 *1 13.11,60.2
X$8605 3596 77 109 19288 CLKBUF_X1
* cell instance $8606 r0 *1 13.68,60.2
X$8606 77 3596 4196 3886 3965 2157 109 DFFR_X1
* cell instance $8607 r0 *1 17.48,60.2
X$8607 3101 77 109 3596 CLKBUF_X3
* cell instance $8610 r0 *1 19,60.2
X$8610 77 3596 4125 4063 4124 2157 109 DFFR_X1
* cell instance $8614 r0 *1 29.45,60.2
X$8614 2934 3970 3888 77 109 4130 MUX2_X1
* cell instance $8615 r0 *1 30.78,60.2
X$8615 2934 3106 3888 77 109 4131 MUX2_X1
* cell instance $8616 r0 *1 32.11,60.2
X$8616 3890 3607 3889 77 109 4132 MUX2_X1
* cell instance $8617 r0 *1 33.44,60.2
X$8617 3890 3106 3889 77 109 4064 MUX2_X1
* cell instance $8622 r0 *1 37.62,60.2
X$8622 2541 77 109 19097 INV_X4
* cell instance $8623 m0 *1 38.76,60.2
X$8623 3892 77 109 2540 CLKBUF_X3
* cell instance $8625 m0 *1 39.71,60.2
X$8625 2937 3479 3975 77 109 3893 MUX2_X1
* cell instance $8626 m0 *1 41.04,60.2
X$8626 77 3894 3975 3897 3976 2157 109 DFFR_X1
* cell instance $8627 m0 *1 44.84,60.2
X$8627 3897 3782 2787 77 109 3976 MUX2_X1
* cell instance $8629 m0 *1 46.36,60.2
X$8629 3609 3861 2406 77 109 3898 MUX2_X1
* cell instance $8630 m0 *1 47.69,60.2
X$8630 3609 3479 2406 77 109 3899 MUX2_X1
* cell instance $8631 m0 *1 49.02,60.2
X$8631 3899 3600 3787 77 109 4416 MUX2_X1
* cell instance $8634 r0 *1 38.95,60.2
X$8634 4135 4065 2787 77 109 4405 MUX2_X1
* cell instance $8635 r0 *1 40.28,60.2
X$8635 3892 77 109 2787 BUF_X2
* cell instance $8636 r0 *1 41.04,60.2
X$8636 3893 3600 3895 77 109 4066 MUX2_X1
* cell instance $8637 r0 *1 42.37,60.2
X$8637 2937 3896 3975 77 109 4406 MUX2_X1
* cell instance $8640 r0 *1 47.5,60.2
X$8640 3898 3978 3862 77 109 4139 MUX2_X1
* cell instance $8642 m0 *1 54.53,60.2
X$8642 3613 3979 77 109 3697 NAND2_X1
* cell instance $8643 m0 *1 50.73,60.2
X$8643 77 3698 3900 3979 3864 2157 109 DFFR_X1
* cell instance $8644 m0 *1 55.1,60.2
X$8644 3788 3794 3981 109 3699 77 OAI21_X1
* cell instance $8645 m0 *1 55.86,60.2
X$8645 3900 3106 3789 77 109 3865 MUX2_X1
* cell instance $8646 m0 *1 57.19,60.2
X$8646 3709 3790 77 109 3981 NAND2_X1
* cell instance $8650 r0 *1 55.86,60.2
X$8650 3900 3479 3789 77 109 4070 MUX2_X1
* cell instance $8652 r0 *1 57.57,60.2
X$8652 4071 3106 4144 77 109 3901 MUX2_X1
* cell instance $8653 m0 *1 59.47,60.2
X$8653 3902 3611 3494 77 109 3983 MUX2_X1
* cell instance $8654 m0 *1 58.14,60.2
X$8654 3901 3370 3865 77 109 3902 MUX2_X1
* cell instance $8661 r0 *1 60.42,60.2
X$8661 3788 3903 4148 109 4146 77 OAI21_X1
* cell instance $8665 m0 *1 61.94,60.2
X$8665 3986 3607 3904 77 109 3867 MUX2_X1
* cell instance $8668 r0 *1 62.51,60.2
X$8668 77 3618 3904 4151 3984 2157 109 DFFR_X1
* cell instance $8669 m0 *1 65.74,60.2
X$8669 3905 3791 3792 77 109 3987 MUX2_X1
* cell instance $8670 m0 *1 64.41,60.2
X$8670 3986 3183 3904 77 109 3905 MUX2_X1
* cell instance $8671 m0 *1 67.07,60.2
X$8671 2543 77 109 3618 CLKBUF_X3
* cell instance $8672 m0 *1 68.02,60.2
X$8672 3793 3794 3868 109 3708 77 OAI21_X1
* cell instance $8674 m0 *1 68.97,60.2
X$8674 77 3618 4211 3872 3870 1663 109 DFFR_X1
* cell instance $8677 r0 *1 66.5,60.2
X$8677 3618 77 109 19278 CLKBUF_X1
* cell instance $8680 r0 *1 67.64,60.2
X$8680 2606 3970 2413 77 109 4074 MUX2_X1
* cell instance $8682 r0 *1 69.35,60.2
X$8682 2606 3896 2413 77 109 4075 MUX2_X1
* cell instance $8684 r0 *1 71.44,60.2
X$8684 77 3618 4510 3991 3990 1663 109 DFFR_X1
* cell instance $8685 m0 *1 73.91,60.2
X$8685 3709 3991 77 109 3795 NAND2_X1
* cell instance $8686 m0 *1 73.15,60.2
X$8686 3710 3794 3795 109 3990 77 OAI21_X1
* cell instance $8690 m0 *1 78.09,60.2
X$8690 3796 3906 3499 77 109 3992 MUX2_X1
* cell instance $8691 m0 *1 75.62,60.2
X$8691 77 3370 109 3906 BUF_X8
* cell instance $8694 r0 *1 76.38,60.2
X$8694 3906 109 3791 77 BUF_X4
* cell instance $8695 r0 *1 77.71,60.2
X$8695 77 3908 4213 3994 4155 1663 109 DFFR_X1
* cell instance $8696 m0 *1 79.99,60.2
X$8696 77 3908 3993 3719 3797 1663 109 DFFR_X1
* cell instance $8698 m0 *1 83.79,60.2
X$8698 2232 3799 3798 109 3910 77 OAI21_X1
* cell instance $8700 r0 *1 81.51,60.2
X$8700 2417 3377 3909 109 4155 77 OAI21_X1
* cell instance $8701 r0 *1 82.27,60.2
X$8701 3377 3994 77 109 3909 NAND2_X1
* cell instance $8703 r0 *1 83.6,60.2
X$8703 77 3623 4078 3997 3910 1663 109 DFFR_X1
* cell instance $8705 m0 *1 84.93,60.2
X$8705 3799 3997 77 109 3798 NAND2_X1
* cell instance $8707 m0 *1 86.45,60.2
X$8707 3800 3995 3570 77 109 3911 MUX2_X1
* cell instance $8710 r0 *1 87.4,60.2
X$8710 77 3058 18796 4079 4160 1663 109 DFFR_X1
* cell instance $8712 m0 *1 95,60.2
X$8712 3626 77 109 3627 CLKBUF_X3
* cell instance $8713 m0 *1 91.2,60.2
X$8713 77 3058 18498 4000 3999 1663 109 DFFR_X1
* cell instance $8715 m0 *1 96.14,60.2
X$8715 3132 3626 3386 77 109 4004 MUX2_X1
* cell instance $8716 m0 *1 97.47,60.2
X$8716 3722 2806 3907 77 109 3802 MUX2_X1
* cell instance $8718 m0 *1 98.99,60.2
X$8718 4005 2650 3802 77 109 4013 MUX2_X1
* cell instance $8719 m0 *1 100.32,60.2
X$8719 3914 2090 3803 77 109 3879 MUX2_X1
* cell instance $8720 m0 *1 101.65,60.2
X$8720 77 3058 18521 3803 3879 4086 109 DFFR_X1
* cell instance $8721 m0 *1 105.45,60.2
X$8721 3803 3805 2808 3915 3914 77 109 3806 AOI221_X1
* cell instance $8722 m0 *1 106.59,60.2
X$8722 3807 3302 4013 77 109 4017 MUX2_X1
* cell instance $8723 m0 *1 107.92,60.2
X$8723 3804 2235 3808 77 109 4016 MUX2_X1
* cell instance $8724 m0 *1 109.25,60.2
X$8724 3915 3805 3581 77 109 NOR2_X4
* cell instance $8729 r0 *1 92.53,60.2
X$8729 4068 2552 4000 77 109 3999 MUX2_X1
* cell instance $8733 r0 *1 95.19,60.2
X$8733 4000 2554 2806 4079 2553 77 109 3913 AOI221_X1
* cell instance $8735 r0 *1 96.71,60.2
X$8735 3571 3626 3801 77 109 3912 MUX2_X1
* cell instance $8737 r0 *1 98.23,60.2
X$8737 4004 3628 3912 77 109 4007 MUX2_X1
* cell instance $8738 r0 *1 99.56,60.2
X$8738 3389 4007 3456 3878 77 109 4162 AOI22_X1
* cell instance $8740 r0 *1 100.89,60.2
X$8740 4004 4081 3912 77 109 4080 MUX2_X1
* cell instance $8744 r0 *1 104.69,60.2
X$8744 2808 3803 3581 109 77 4082 AND3_X1
* cell instance $8745 r0 *1 105.64,60.2
X$8745 3805 3915 77 109 2806 OR2_X2
* cell instance $8746 r0 *1 106.59,60.2
X$8746 3804 2650 3803 77 109 4165 MUX2_X1
* cell instance $8747 r0 *1 107.92,60.2
X$8747 3805 77 109 4166 INV_X1
* cell instance $8749 r0 *1 108.49,60.2
X$8749 77 3739 18784 3808 4016 4086 109 DFFR_X1
* cell instance $8751 r0 *1 112.48,60.2
X$8751 4169 77 109 3805 BUF_X2
* cell instance $8752 m0 *1 113.43,60.2
X$8752 77 18307 3810 4019 3739 109 DFF_X1
* cell instance $8753 m0 *1 112.86,60.2
X$8753 3739 77 109 19101 INV_X2
* cell instance $8755 m0 *1 116.85,60.2
X$8755 77 3812 4020 3883 3510 109 DFF_X1
* cell instance $8756 m0 *1 120.08,60.2
X$8756 4020 77 109 3811 CLKBUF_X3
* cell instance $8757 m0 *1 121.03,60.2
X$8757 77 18343 3815 3814 3510 109 DFF_X1
* cell instance $8758 m0 *1 124.26,60.2
X$8758 77 4028 4024 4023 3510 109 DFF_X1
* cell instance $8759 m0 *1 127.49,60.2
X$8759 4024 109 3631 77 BUF_X4
* cell instance $8760 m0 *1 128.82,60.2
X$8760 3816 3813 2658 77 109 4025 MUX2_X1
* cell instance $8762 r0 *1 113.24,60.2
X$8762 3998 77 109 3739 CLKBUF_X3
* cell instance $8764 r0 *1 114.57,60.2
X$8764 3632 3630 3018 77 109 4172 MUX2_X1
* cell instance $8768 r0 *1 115.9,60.2
X$8768 3916 3813 2752 77 109 4019 MUX2_X1
* cell instance $8776 r0 *1 124.07,60.2
X$8776 2430 77 109 3510 CLKBUF_X3
* cell instance $8777 r0 *1 125.02,60.2
X$8777 3510 77 109 19280 CLKBUF_X1
* cell instance $8779 r0 *1 125.97,60.2
X$8779 3917 2428 1124 77 109 4177 MUX2_X1
* cell instance $8780 r0 *1 127.3,60.2
X$8780 3919 109 3632 77 BUF_X4
* cell instance $8783 r0 *1 129.2,60.2
X$8783 3918 3813 2630 77 109 4026 MUX2_X1
* cell instance $8785 m0 *1 130.72,60.2
X$8785 77 3636 3816 4025 2343 109 DFF_X1
* cell instance $8790 r0 *1 131.48,60.2
X$8790 3634 3919 3635 77 109 4164 MUX2_X1
* cell instance $8794 r0 *1 134.14,60.2
X$8794 77 4029 4179 4026 3325 109 DFF_X1
* cell instance $8795 m0 *1 137.56,60.2
X$8795 1236 77 109 2430 CLKBUF_X3
* cell instance $8796 m0 *1 135.85,60.2
X$8796 4028 3209 3919 109 77 4030 MUX2_X2
* cell instance $8797 m0 *1 138.51,60.2
X$8797 77 3819 1698 4181 3818 109 DFF_X1
* cell instance $8798 m0 *1 141.74,60.2
X$8798 3593 3819 1656 77 3920 109 AOI21_X1
* cell instance $8801 r0 *1 137.37,60.2
X$8801 4029 3817 3632 109 77 4033 MUX2_X2
* cell instance $8802 r0 *1 139.08,60.2
X$8802 2430 77 109 19091 INV_X4
* cell instance $8804 r0 *1 141.55,60.2
X$8804 3819 1654 77 109 4186 OR2_X2
* cell instance $8805 r0 *1 142.5,60.2
X$8805 1654 3210 1003 77 109 4093 NOR3_X1
* cell instance $8806 r0 *1 143.26,60.2
X$8806 4035 1656 4092 77 4094 109 AOI21_X1
* cell instance $8807 m0 *1 143.83,60.2
X$8807 77 3818 18650 4038 3820 1146 109 DFFR_X1
* cell instance $8809 m0 *1 147.63,60.2
X$8809 4038 3210 3822 109 3763 77 OAI21_X1
* cell instance $8812 r0 *1 144.4,60.2
X$8812 4036 1003 77 109 4035 NAND2_X1
* cell instance $8815 r0 *1 146.87,60.2
X$8815 77 3818 3921 1146 19017 4098 109 DFFR_X2
* cell instance $8816 m0 *1 148.96,60.2
X$8816 3821 109 3822 77 BUF_X4
* cell instance $8819 m0 *1 151.81,60.2
X$8819 3823 77 109 3922 INV_X1
* cell instance $8820 m0 *1 152.19,60.2
X$8820 3923 77 109 3640 INV_X1
* cell instance $8821 m0 *1 152.57,60.2
X$8821 4040 77 109 3516 CLKBUF_X3
* cell instance $8822 m0 *1 153.52,60.2
X$8822 4237 3824 77 109 4192 NOR2_X1
* cell instance $8823 m0 *1 154.09,60.2
X$8823 4039 109 3824 77 BUF_X4
* cell instance $8824 m0 *1 155.42,60.2
X$8824 3923 3823 3641 109 77 4045 HA_X1
* cell instance $8825 m0 *1 157.32,60.2
X$8825 4045 109 3519 77 BUF_X4
* cell instance $8826 m0 *1 158.65,60.2
X$8826 3825 3775 3826 109 3928 77 OAI21_X1
* cell instance $8827 m0 *1 159.41,60.2
X$8827 3516 3519 3824 77 109 4043 NOR3_X1
* cell instance $8828 m0 *1 160.17,60.2
X$8828 4043 3826 77 109 3652 NAND2_X1
* cell instance $8830 r0 *1 151.05,60.2
X$8830 3923 3922 19065 109 77 4039 HA_X1
* cell instance $8831 r0 *1 152.95,60.2
X$8831 4039 77 109 3925 INV_X4
* cell instance $8832 r0 *1 153.9,60.2
X$8832 3926 4304 3924 3925 77 109 4041 NAND4_X1
* cell instance $8833 r0 *1 154.85,60.2
X$8833 3924 4100 77 109 3923 NAND2_X2
* cell instance $8834 r0 *1 155.8,60.2
X$8834 4041 3925 4190 109 77 3642 OAI21_X2
* cell instance $8836 r0 *1 157.51,60.2
X$8836 3775 4043 3772 4102 3826 77 109 3927 AOI221_X1
* cell instance $8837 r0 *1 158.65,60.2
X$8837 3928 4188 3927 4047 77 109 3401 AOI211_X4
* cell instance $8838 r0 *1 160.74,60.2
X$8838 4052 3929 4044 77 4047 109 AOI21_X1
* cell instance $8840 m0 *1 161.12,60.2
X$8840 4049 3933 77 109 4048 NAND2_X1
* cell instance $8841 m0 *1 161.88,60.2
X$8841 3516 3646 3824 109 3517 77 NOR3_X2
* cell instance $8842 m0 *1 163.21,60.2
X$8842 3647 3775 3517 109 3773 77 OAI21_X1
* cell instance $8843 m0 *1 163.97,60.2
X$8843 3931 4054 77 109 3881 NOR2_X1
* cell instance $8844 m0 *1 164.54,60.2
X$8844 77 606 3827 3929 4057 109 AOI21_X4
* cell instance $8846 m0 *1 167.2,60.2
X$8846 77 3220 4058 3771 3828 109 AOI21_X4
* cell instance $8847 m0 *1 169.67,60.2
X$8847 3936 3827 3829 77 109 3027 NOR3_X1
* cell instance $8848 m0 *1 170.43,60.2
X$8848 4168 3829 3830 77 109 3874 OR3_X1
* cell instance $8849 m0 *1 171.38,60.2
X$8849 4042 3586 3934 3937 109 77 3572 AND4_X1
* cell instance $8853 r0 *1 161.69,60.2
X$8853 4050 4171 3824 3516 109 77 4052 OAI22_X1
* cell instance $8854 r0 *1 162.64,60.2
X$8854 3933 3930 77 3400 109 NAND2_X4
* cell instance $8856 r0 *1 164.54,60.2
X$8856 4053 4104 3932 109 4174 77 OAI21_X1
* cell instance $8857 r0 *1 165.3,60.2
X$8857 4056 3933 3924 77 109 3649 NAND3_X1
* cell instance $8859 r0 *1 166.25,60.2
X$8859 4055 3933 4056 109 77 3653 AND3_X1
* cell instance $8860 r0 *1 167.2,60.2
X$8860 4059 4176 3924 109 4060 77 OAI21_X1
* cell instance $8861 r0 *1 167.96,60.2
X$8861 4060 3932 77 109 3834 NAND2_X2
* cell instance $8863 r0 *1 169.1,60.2
X$8863 3935 4174 77 109 3655 NAND2_X1
* cell instance $8864 r0 *1 169.67,60.2
X$8864 4103 3656 77 109 3936 NOR2_X1
* cell instance $8865 r0 *1 170.24,60.2
X$8865 4295 3937 77 3657 109 NAND2_X4
* cell instance $8869 r0 *1 171.95,60.2
X$8869 3516 77 109 4107 INV_X2
* cell instance $8871 r0 *1 172.71,60.2
X$8871 77 605 4107 4051 3924 109 AOI21_X4
* cell instance $8873 m0 *1 173.66,60.2
X$8873 3831 3648 4050 109 77 3876 OAI21_X2
* cell instance $8874 m0 *1 176.51,60.2
X$8874 3832 3831 109 77 3535 AND2_X2
* cell instance $8875 m0 *1 177.46,60.2
X$8875 3079 4110 3522 77 109 4046 OR3_X2
* cell instance $8876 m0 *1 178.6,60.2
X$8876 1920 109 839 77 BUF_X4
* cell instance $8880 r0 *1 175.56,60.2
X$8880 4105 4051 77 109 3832 NOR2_X1
* cell instance $8882 r0 *1 176.32,60.2
X$8882 3938 3925 3929 4044 4034 109 77 AOI211_X2
* cell instance $8884 r0 *1 178.41,60.2
X$8884 3779 3925 3929 4044 3840 109 77 AOI211_X2
* cell instance $8887 m0 *1 182.78,60.2
X$8887 3833 3654 3834 4037 3938 3830 77 109 3835 OAI33_X1
* cell instance $8888 m0 *1 181.07,60.2
X$8888 3834 3654 3407 77 109 NOR2_X4
* cell instance $8889 m0 *1 184.11,60.2
X$8889 3660 3654 77 109 3755 NOR2_X1
* cell instance $8891 m0 *1 184.87,60.2
X$8891 3657 3654 3531 77 109 NOR2_X4
* cell instance $8893 m0 *1 186.77,60.2
X$8893 4034 109 2981 77 BUF_X4
* cell instance $8894 m0 *1 188.1,60.2
X$8894 3348 77 109 3147 CLKBUF_X3
* cell instance $8895 m0 *1 189.05,60.2
X$8895 4159 3874 4027 109 77 3760 AND3_X1
* cell instance $8897 r0 *1 181.26,60.2
X$8897 77 3147 18705 4042 4292 1146 109 DFFR_X1
* cell instance $8898 r0 *1 185.06,60.2
X$8898 77 3147 3939 1146 19015 4018 109 DFFR_X2
* cell instance $8899 r0 *1 189.24,60.2
X$8899 77 2447 18702 4112 4032 1146 109 DFFR_X1
* cell instance $8900 m0 *1 191.71,60.2
X$8900 3940 2981 2138 3941 77 109 4027 AOI22_X1
* cell instance $8901 m0 *1 190.38,60.2
X$8901 4031 2586 3838 77 109 3754 MUX2_X1
* cell instance $8904 m0 *1 193.04,60.2
X$8904 3941 109 2841 77 BUF_X4
* cell instance $8905 r0 *1 193.04,60.2
X$8905 484 2728 3942 109 4015 77 OAI21_X1
* cell instance $8908 m0 *1 194.94,60.2
X$8908 405 2728 4021 109 3839 77 OAI21_X1
* cell instance $8910 m0 *1 195.7,60.2
X$8910 4022 2904 3226 2593 77 109 3871 AOI22_X1
* cell instance $8914 r0 *1 194.75,60.2
X$8914 4113 2588 3667 77 109 3943 MUX2_X1
* cell instance $8915 r0 *1 196.08,60.2
X$8915 77 3411 18712 3667 3943 1146 109 DFFR_X1
* cell instance $8916 m0 *1 199.5,60.2
X$8916 3348 77 109 3411 CLKBUF_X3
* cell instance $8918 m0 *1 200.45,60.2
X$8918 77 3407 4018 3944 1623 2709 1800 3941 109 AOI222_X2
* cell instance $8919 m0 *1 203.11,60.2
X$8919 3840 109 2847 77 BUF_X4
* cell instance $8923 m0 *1 206.91,60.2
X$8923 3856 3835 4012 4263 109 3467 77 OR4_X2
* cell instance $8928 r0 *1 201.4,60.2
X$8928 77 3411 18710 4115 4014 992 109 DFFR_X1
* cell instance $8929 r0 *1 205.2,60.2
X$8929 399 1630 4011 77 109 3945 MUX2_X1
* cell instance $8931 r0 *1 206.72,60.2
X$8931 77 4262 18708 4011 3945 992 109 DFFR_X1
* cell instance $8932 r0 *1 210.52,60.2
X$8932 77 4010 3407 4006 4008 3233 3530 2843 109 AOI222_X2
* cell instance $8933 m0 *1 211.09,60.2
X$8933 2591 4001 3866 109 77 4009 AND3_X1
* cell instance $8935 m0 *1 212.04,60.2
X$8935 4009 4006 3947 3948 109 77 2508 AND4_X1
* cell instance $8937 m0 *1 213.37,60.2
X$8937 4003 3090 3671 2593 77 109 4001 AOI22_X1
* cell instance $8939 m0 *1 214.51,60.2
X$8939 77 3440 18653 3950 3951 992 109 DFFR_X1
* cell instance $8940 m0 *1 218.31,60.2
X$8940 548 2258 3989 77 109 3863 MUX2_X1
* cell instance $8941 m0 *1 219.64,60.2
X$8941 77 3675 18652 3989 3863 992 109 DFFR_X1
* cell instance $8942 m0 *1 223.44,60.2
X$8942 3952 2261 2453 3841 77 109 3435 AOI22_X2
* cell instance $8943 m0 *1 225.15,60.2
X$8943 3841 1145 77 109 3956 NAND2_X2
* cell instance $8944 m0 *1 226.1,60.2
X$8944 3860 3426 3980 77 3982 109 AOI21_X1
* cell instance $8945 m0 *1 226.86,60.2
X$8945 3426 3424 109 77 3958 AND2_X1
* cell instance $8946 m0 *1 227.62,60.2
X$8946 3674 3424 77 109 3980 NAND2_X1
* cell instance $8948 m0 *1 228.38,60.2
X$8948 3963 77 109 3558 BUF_X1
* cell instance $8949 m0 *1 228.95,60.2
X$8949 3678 77 109 3747 BUF_X1
* cell instance $8950 m0 *1 229.52,60.2
X$8950 3843 77 109 2876 BUF_X1
* cell instance $8952 m0 *1 230.28,60.2
X$8952 3844 3233 3974 2363 77 109 3421 AOI22_X1
* cell instance $8953 m0 *1 231.23,60.2
X$8953 1970 2852 109 77 2868 AND2_X1
* cell instance $8954 m0 *1 231.99,60.2
X$8954 3972 3090 3971 2847 77 109 3542 AOI22_X1
* cell instance $8955 m0 *1 232.94,60.2
X$8955 3853 3244 3849 3845 109 77 2608 AND4_X1
* cell instance $8956 m0 *1 234.08,60.2
X$8956 2856 3960 3846 109 3851 77 OAI21_X1
* cell instance $8957 m0 *1 234.84,60.2
X$8957 3539 77 109 3100 BUF_X1
* cell instance $8958 m0 *1 235.41,60.2
X$8958 1373 2853 109 77 3960 AND2_X1
* cell instance $8960 m0 *1 236.36,60.2
X$8960 77 4122 1372 3955 2853 1373 109 AOI22_X4
* cell instance $8963 r0 *1 213.37,60.2
X$8963 3949 4002 3950 2978 77 109 3948 AOI22_X1
* cell instance $8964 r0 *1 214.32,60.2
X$8964 3670 1630 3950 77 109 3951 MUX2_X1
* cell instance $8967 r0 *1 216.6,60.2
X$8967 2894 77 109 3440 CLKBUF_X3
* cell instance $8968 r0 *1 217.55,60.2
X$8968 3440 77 109 19184 INV_X1
* cell instance $8970 r0 *1 218.12,60.2
X$8970 3090 3996 4143 2978 3414 2883 109 77 AOI221_X2
* cell instance $8971 r0 *1 220.21,60.2
X$8971 3955 77 109 3860 INV_X1
* cell instance $8972 r0 *1 220.59,60.2
X$8972 77 3547 4141 3673 3953 163 109 NAND4_X4
* cell instance $8973 r0 *1 224.01,60.2
X$8973 3988 77 109 3949 INV_X1
* cell instance $8974 r0 *1 224.39,60.2
X$8974 3953 3954 109 77 3985 AND2_X1
* cell instance $8975 r0 *1 225.15,60.2
X$8975 3954 3956 3955 77 109 4137 NAND3_X1
* cell instance $8977 r0 *1 226.1,60.2
X$8977 3426 3424 3955 3956 109 77 3953 AND4_X1
* cell instance $8981 r0 *1 227.24,60.2
X$8981 494 2258 3959 77 109 3977 MUX2_X1
* cell instance $8982 r0 *1 228.57,60.2
X$8982 77 3675 18788 3959 3977 3676 109 DFFR_X1
* cell instance $8983 r0 *1 232.37,60.2
X$8983 2844 4274 4564 2593 3959 3095 109 77 AOI221_X2
* cell instance $8984 r0 *1 234.46,60.2
X$8984 77 3677 18786 3971 3967 992 109 DFFR_X1
* cell instance $8985 r0 *1 238.26,60.2
X$8985 3677 77 109 19304 CLKBUF_X1
* cell instance $8986 r0 *1 238.83,60.2
X$8986 3964 77 109 2853 BUF_X2
* cell instance $8989 m0 *1 127.87,63
X$8989 4347 3813 2519 77 109 4229 MUX2_X1
* cell instance $8991 m0 *1 130.15,63
X$8991 4231 77 109 4088 BUF_X2
* cell instance $8992 m0 *1 130.91,63
X$8992 4089 77 109 4528 BUF_X2
* cell instance $8993 m0 *1 131.67,63
X$8993 3753 4090 4087 77 4301 109 AOI21_X1
* cell instance $8996 m0 *1 133.38,63
X$8996 4232 4091 77 109 4303 NAND2_X2
* cell instance $8997 m0 *1 134.33,63
X$8997 4233 77 109 3918 CLKBUF_X3
* cell instance $8998 m0 *1 135.28,63
X$8998 4091 77 109 4234 INV_X2
* cell instance $8999 m0 *1 135.85,63
X$8999 4088 3919 2629 77 109 4302 MUX2_X1
* cell instance $9000 m0 *1 137.18,63
X$9000 77 4233 109 4179 BUF_X8
* cell instance $9001 m0 *1 139.65,63
X$9001 4087 1909 4183 109 4182 77 OAI21_X1
* cell instance $9002 m0 *1 140.41,63
X$9002 4233 77 109 4306 INV_X2
* cell instance $9003 m0 *1 140.98,63
X$9003 4087 4235 77 109 4183 NAND2_X1
* cell instance $9006 r0 *1 128.06,63
X$9006 77 4231 4089 4229 4230 109 DFF_X1
* cell instance $9008 r0 *1 131.67,63
X$9008 77 4301 4230 4467 4232 109 DFF_X2
* cell instance $9010 r0 *1 135.47,63
X$9010 4232 109 4348 77 BUF_X4
* cell instance $9011 r0 *1 136.8,63
X$9011 4467 3919 3208 77 109 4471 MUX2_X1
* cell instance $9012 r0 *1 138.13,63
X$9012 4349 77 109 4469 BUF_X1
* cell instance $9014 r0 *1 138.89,63
X$9014 77 18430 4473 4182 3818 109 DFF_X1
* cell instance $9015 m0 *1 142.12,63
X$9015 4185 2346 77 109 4092 NOR2_X1
* cell instance $9017 m0 *1 142.69,63
X$9017 4092 4093 4094 4307 4187 77 109 4181 AOI221_X1
* cell instance $9019 r0 *1 142.12,63
X$9019 4473 77 109 4235 CLKBUF_X3
* cell instance $9021 r0 *1 143.26,63
X$9021 2430 77 109 3818 CLKBUF_X3
* cell instance $9022 m0 *1 144.4,63
X$9022 4095 2817 3395 4191 109 4236 77 NOR4_X2
* cell instance $9024 m0 *1 146.11,63
X$9024 4236 4096 4478 109 77 333 OAI21_X2
* cell instance $9025 m0 *1 147.44,63
X$9025 4036 109 2348 77 BUF_X4
* cell instance $9026 m0 *1 148.77,63
X$9026 4191 4096 77 109 4351 NOR2_X1
* cell instance $9027 m0 *1 149.34,63
X$9027 4237 77 109 4189 INV_X2
* cell instance $9028 m0 *1 149.91,63
X$9028 4099 4097 77 109 4305 NAND2_X1
* cell instance $9029 m0 *1 150.48,63
X$9029 4098 77 109 4096 INV_X4
* cell instance $9031 r0 *1 144.21,63
X$9031 4474 4350 77 109 4475 NOR2_X1
* cell instance $9032 r0 *1 144.78,63
X$9032 3818 77 109 19266 CLKBUF_X1
* cell instance $9034 r0 *1 145.73,63
X$9034 4235 77 109 4477 INV_X2
* cell instance $9036 r0 *1 146.68,63
X$9036 3592 109 4036 77 BUF_X4
* cell instance $9037 r0 *1 148.01,63
X$9037 4623 4238 77 109 4482 NOR2_X1
* cell instance $9039 r0 *1 148.77,63
X$9039 77 3775 4240 4304 4480 109 AOI21_X4
* cell instance $9040 r0 *1 151.24,63
X$9040 4620 4305 77 109 4484 NAND2_X1
* cell instance $9041 m0 *1 153.14,63
X$9041 4239 109 3929 77 BUF_X4
* cell instance $9042 m0 *1 151.81,63
X$9042 4098 109 4485 77 BUF_X4
* cell instance $9043 m0 *1 154.47,63
X$9043 4238 77 109 4099 INV_X2
* cell instance $9044 m0 *1 155.04,63
X$9044 3924 4300 3929 109 77 3515 OAI21_X2
* cell instance $9045 m0 *1 156.37,63
X$9045 3648 4189 3926 77 4190 109 AOI21_X1
* cell instance $9047 m0 *1 157.32,63
X$9047 4240 4358 4354 3824 3519 3516 77 109 4102 OAI33_X1
* cell instance $9049 m0 *1 158.84,63
X$9049 4241 4184 4242 4101 109 77 4175 OAI22_X2
* cell instance $9050 m0 *1 160.55,63
X$9050 4103 3931 77 109 4243 NOR2_X1
* cell instance $9051 m0 *1 161.12,63
X$9051 3589 4298 77 109 4244 NOR2_X1
* cell instance $9052 m0 *1 161.69,63
X$9052 4180 3648 3824 109 4178 77 OAI21_X1
* cell instance $9053 m0 *1 162.45,63
X$9053 4178 3929 4044 77 4053 109 AOI21_X1
* cell instance $9054 m0 *1 163.21,63
X$9054 4245 3656 3647 77 109 4104 NOR3_X1
* cell instance $9055 m0 *1 163.97,63
X$9055 4053 4104 3937 109 4246 77 OAI21_X1
* cell instance $9056 m0 *1 164.73,63
X$9056 4247 4248 3937 109 4490 77 OAI21_X1
* cell instance $9057 m0 *1 165.49,63
X$9057 4105 4051 4176 109 4248 77 NOR3_X2
* cell instance $9058 m0 *1 166.82,63
X$9058 4297 4363 77 109 4362 NAND2_X1
* cell instance $9059 m0 *1 167.39,63
X$9059 3652 4168 4056 3776 109 77 4058 AND4_X1
* cell instance $9060 m0 *1 168.53,63
X$9060 3931 4171 77 109 4106 NOR2_X1
* cell instance $9061 m0 *1 169.1,63
X$9061 3881 3926 3519 77 109 4167 NAND3_X1
* cell instance $9062 m0 *1 169.86,63
X$9062 4167 4163 4101 109 4002 77 NOR3_X2
* cell instance $9063 m0 *1 171.19,63
X$9063 4108 3925 4107 77 3650 109 NAND3_X4
* cell instance $9064 m0 *1 173.66,63
X$9064 3519 77 109 4108 INV_X4
* cell instance $9065 m0 *1 174.61,63
X$9065 77 4051 4105 4163 2838 109 NOR3_X4
* cell instance $9066 m0 *1 177.27,63
X$9066 3779 4108 3924 3929 4117 109 77 AOI211_X2
* cell instance $9067 m0 *1 178.98,63
X$9067 3938 4107 4055 3929 3941 109 77 AOI211_X2
* cell instance $9068 m0 *1 180.69,63
X$9068 4042 77 109 4293 INV_X1
* cell instance $9070 m0 *1 181.83,63
X$9070 77 3404 4109 1146 18925 4010 109 DFFR_X2
* cell instance $9071 m0 *1 186.01,63
X$9071 4018 77 109 4254 INV_X1
* cell instance $9073 m0 *1 186.58,63
X$9073 3147 77 109 19240 CLKBUF_X1
* cell instance $9076 m0 *1 188.1,63
X$9076 4873 77 109 3940 INV_X1
* cell instance $9080 r0 *1 152.19,63
X$9080 4356 4480 4304 77 109 4101 NAND3_X2
* cell instance $9081 r0 *1 153.52,63
X$9081 4100 4356 109 77 4487 XNOR2_X1
* cell instance $9083 r0 *1 154.85,63
X$9083 4192 4487 4815 3824 77 109 3766 AOI22_X2
* cell instance $9084 r0 *1 156.56,63
X$9084 77 3646 4356 4354 4251 4358 109 OAI211_X4
* cell instance $9085 r0 *1 159.79,63
X$9085 3516 3519 4171 4356 4359 4184 77 109 OAI221_X2
* cell instance $9086 r0 *1 161.88,63
X$9086 4613 4491 77 109 4359 NOR2_X1
* cell instance $9088 r0 *1 162.83,63
X$9088 4244 3930 3651 77 109 4245 NAND3_X1
* cell instance $9089 r0 *1 163.59,63
X$9089 4490 4296 4246 4672 77 4879 109 NAND4_X2
* cell instance $9090 r0 *1 165.3,63
X$9090 3932 4248 4247 109 77 2591 OAI21_X4
* cell instance $9091 r0 *1 167.77,63
X$9091 4059 4176 4044 109 3934 77 OAI21_X1
* cell instance $9092 r0 *1 168.53,63
X$9092 4175 3932 4050 77 109 3935 NAND3_X1
* cell instance $9093 r0 *1 169.29,63
X$9093 4357 4106 4359 109 77 4295 AND3_X1
* cell instance $9094 r0 *1 170.24,63
X$9094 4479 4250 4364 4175 77 109 4296 AOI22_X2
* cell instance $9102 r0 *1 172.14,63
X$9102 4252 4251 3658 77 109 4479 NAND3_X1
* cell instance $9103 r0 *1 172.9,63
X$9103 77 2709 3938 4252 4251 109 AOI21_X4
* cell instance $9104 r0 *1 175.37,63
X$9104 4050 3647 77 109 4466 NOR2_X1
* cell instance $9105 r0 *1 175.94,63
X$9105 3779 4251 4252 77 4261 109 AOI21_X2
* cell instance $9106 r0 *1 177.27,63
X$9106 3938 4108 3924 3929 3301 109 77 AOI211_X2
* cell instance $9107 r0 *1 178.98,63
X$9107 3779 4107 3929 4044 4256 109 77 AOI211_X2
* cell instance $9108 r0 *1 180.69,63
X$9108 3348 77 109 3404 CLKBUF_X3
* cell instance $9109 r0 *1 181.64,63
X$9109 4293 4253 4366 109 4292 77 OAI21_X1
* cell instance $9110 r0 *1 182.4,63
X$9110 4456 4253 4459 109 4109 77 OAI21_X1
* cell instance $9111 r0 *1 183.16,63
X$9111 3406 1989 484 77 4367 109 AOI21_X1
* cell instance $9112 r0 *1 183.92,63
X$9112 4371 3406 77 109 4253 NAND2_X1
* cell instance $9113 r0 *1 184.49,63
X$9113 4010 77 109 4456 INV_X1
* cell instance $9114 r0 *1 184.87,63
X$9114 4255 4369 77 109 4372 NAND2_X1
* cell instance $9115 r0 *1 185.44,63
X$9115 4254 4369 4454 109 3939 77 OAI21_X1
* cell instance $9116 r0 *1 186.2,63
X$9116 1867 3406 4597 109 4255 77 OAI21_X1
* cell instance $9117 r0 *1 186.96,63
X$9117 3406 1799 77 109 4447 NOR2_X1
* cell instance $9118 r0 *1 187.53,63
X$9118 77 18281 4375 4444 3147 1146 109 DFFS_X1
* cell instance $9119 m0 *1 190.57,63
X$9119 4290 2605 4112 77 109 4032 MUX2_X1
* cell instance $9120 m0 *1 189.62,63
X$9120 4111 4256 4112 2598 77 109 3836 AOI22_X1
* cell instance $9123 m0 *1 194.18,63
X$9123 1989 2728 4161 109 4113 77 OAI21_X1
* cell instance $9125 r0 *1 191.33,63
X$9125 4443 2605 4257 77 109 4442 MUX2_X1
* cell instance $9126 r0 *1 192.66,63
X$9126 77 4376 18888 4257 4442 1146 109 DFFR_X1
* cell instance $9127 m0 *1 195.51,63
X$9127 3233 4258 77 109 4159 NAND2_X1
* cell instance $9131 m0 *1 197.03,63
X$9131 4259 2586 4114 77 109 4157 MUX2_X1
* cell instance $9132 m0 *1 198.36,63
X$9132 77 3411 18621 4114 4157 1146 109 DFFR_X1
* cell instance $9133 m0 *1 202.16,63
X$9133 77 3840 1868 4152 4433 4256 4115 4261 109 AOI222_X2
* cell instance $9136 m0 *1 208.05,63
X$9136 3090 4264 4116 3941 4011 3232 109 77 AOI221_X2
* cell instance $9137 m0 *1 210.14,63
X$9137 4117 109 3090 77 BUF_X4
* cell instance $9140 r0 *1 196.46,63
X$9140 759 2728 4438 109 4432 77 OAI21_X1
* cell instance $9141 r0 *1 197.22,63
X$9141 4832 77 109 2728 CLKBUF_X3
* cell instance $9142 r0 *1 198.17,63
X$9142 77 4377 4256 3410 4829 2904 4257 2598 109 AOI222_X2
* cell instance $9146 r0 *1 202.92,63
X$9146 4260 2605 4115 77 109 4014 MUX2_X1
* cell instance $9147 r0 *1 204.25,63
X$9147 4261 109 2984 77 BUF_X4
* cell instance $9151 r0 *1 208.05,63
X$9151 4432 2588 4265 77 109 4429 MUX2_X1
* cell instance $9152 r0 *1 209.38,63
X$9152 77 4262 18732 4265 4429 992 109 DFFR_X1
* cell instance $9154 m0 *1 213.56,63
X$9154 4117 4154 77 109 4266 NAND2_X1
* cell instance $9156 m0 *1 214.13,63
X$9156 4266 4152 4147 4285 109 77 3354 AND4_X1
* cell instance $9157 m0 *1 215.27,63
X$9157 4149 2912 2838 2283 3941 77 109 4285 AOI221_X1
* cell instance $9158 m0 *1 216.41,63
X$9158 4118 77 109 4149 INV_X1
* cell instance $9160 r0 *1 213.37,63
X$9160 4379 4117 2984 4265 77 109 3533 AOI22_X2
* cell instance $9162 r0 *1 215.27,63
X$9162 77 2872 4384 4147 4558 3301 1975 2709 109 AOI222_X2
* cell instance $9164 m0 *1 217.17,63
X$9164 2912 4283 2838 2872 4120 3298 109 77 AOI221_X2
* cell instance $9165 m0 *1 219.45,63
X$9165 4114 2598 2453 4119 77 109 3529 AOI22_X2
* cell instance $9166 m0 *1 221.16,63
X$9166 4134 4119 1368 77 4141 109 AOI21_X2
* cell instance $9168 m0 *1 222.68,63
X$9168 3675 77 109 19134 INV_X1
* cell instance $9169 m0 *1 223.06,63
X$9169 3547 4270 4137 3958 3842 4281 109 77 AOI221_X2
* cell instance $9170 m0 *1 225.15,63
X$9170 2894 77 109 3675 CLKBUF_X3
* cell instance $9172 m0 *1 226.29,63
X$9172 3956 3955 3958 77 109 4121 NAND3_X2
* cell instance $9173 m0 *1 227.62,63
X$9173 3851 3956 4270 4271 4134 4269 109 77 AOI221_X2
* cell instance $9174 m0 *1 229.71,63
X$9174 3090 109 2904 77 BUF_X4
* cell instance $9175 m0 *1 231.04,63
X$9175 3961 77 109 3841 BUF_X1
* cell instance $9176 m0 *1 231.61,63
X$9176 3962 77 109 3974 BUF_X1
* cell instance $9178 m0 *1 232.37,63
X$9178 772 2258 3971 77 109 3967 MUX2_X1
* cell instance $9179 m0 *1 233.7,63
X$9179 4127 2605 3428 77 109 4275 MUX2_X1
* cell instance $9180 m0 *1 235.03,63
X$9180 4122 1372 77 109 3846 NAND2_X1
* cell instance $9181 m0 *1 235.6,63
X$9181 3090 109 3094 77 BUF_X4
* cell instance $9182 m0 *1 236.93,63
X$9182 4123 77 109 3099 BUF_X2
* cell instance $9183 m0 *1 237.69,63
X$9183 4273 77 109 4122 BUF_X2
* cell instance $9184 m0 *1 238.45,63
X$9184 2894 77 109 3677 CLKBUF_X3
* cell instance $9188 r0 *1 218.69,63
X$9188 77 3440 18756 3952 4267 992 109 DFFR_X1
* cell instance $9189 r0 *1 222.49,63
X$9189 77 4419 4382 4270 3954 109 AOI21_X4
* cell instance $9190 r0 *1 224.96,63
X$9190 77 4415 4382 3985 3957 109 AOI21_X4
* cell instance $9197 r0 *1 227.43,63
X$9197 4121 3545 77 109 4270 NOR2_X2
* cell instance $9198 r0 *1 228.38,63
X$9198 4409 4278 2588 77 4413 109 AOI21_X1
* cell instance $9199 r0 *1 229.14,63
X$9199 4403 77 109 4278 INV_X1
* cell instance $9200 r0 *1 229.52,63
X$9200 77 4410 3094 3109 4403 2261 3423 2453 109 AOI222_X2
* cell instance $9201 r0 *1 232.18,63
X$9201 4272 77 109 4120 BUF_X1
* cell instance $9203 r0 *1 233.13,63
X$9203 77 4836 2904 2986 4394 2598 4122 2453 109 AOI222_X2
* cell instance $9204 r0 *1 235.79,63
X$9204 77 3677 18736 3428 4275 992 109 DFFR_X1
* cell instance $9209 m0 *1 2.28,85.4
X$9209 6342 77 109 5049 BUF_X2
* cell instance $9210 m0 *1 3.04,85.4
X$9210 3361 6280 6503 77 109 6344 MUX2_X1
* cell instance $9212 m0 *1 4.56,85.4
X$9212 6439 3041 6281 77 109 6346 MUX2_X1
* cell instance $9213 m0 *1 5.89,85.4
X$9213 6504 3364 6346 77 109 6154 MUX2_X1
* cell instance $9215 m0 *1 7.98,85.4
X$9215 77 6153 6282 6156 6155 2157 109 DFFR_X1
* cell instance $9220 r0 *1 2.09,85.4
X$9220 77 6153 6439 6503 6344 2157 109 DFFR_X1
* cell instance $9224 r0 *1 5.89,85.4
X$9224 6570 77 109 4793 BUF_X2
* cell instance $9225 r0 *1 6.65,85.4
X$9225 6438 77 109 4911 BUF_X2
* cell instance $9227 r0 *1 7.6,85.4
X$9227 6153 77 109 19165 INV_X1
* cell instance $9228 r0 *1 7.98,85.4
X$9228 5174 6280 6621 77 109 6505 MUX2_X1
* cell instance $9229 r0 *1 9.31,85.4
X$9229 3101 77 109 6153 CLKBUF_X3
* cell instance $9230 r0 *1 10.26,85.4
X$9230 6437 77 109 5045 BUF_X2
* cell instance $9232 r0 *1 11.78,85.4
X$9232 77 6153 6440 6507 6508 2157 109 DFFR_X1
* cell instance $9233 m0 *1 19,85.4
X$9233 6285 2786 6283 77 109 6352 MUX2_X1
* cell instance $9234 m0 *1 15.2,85.4
X$9234 77 6153 6351 6285 6352 2157 109 DFFR_X1
* cell instance $9236 m0 *1 20.52,85.4
X$9236 6440 5951 6157 77 109 6286 MUX2_X1
* cell instance $9238 m0 *1 23.37,85.4
X$9238 4200 6299 6347 77 109 6510 MUX2_X1
* cell instance $9241 m0 *1 25.65,85.4
X$9241 5444 6287 6355 77 109 6356 MUX2_X1
* cell instance $9242 m0 *1 26.98,85.4
X$9242 77 5722 6024 6355 6356 2157 109 DFFR_X1
* cell instance $9245 m0 *1 31.73,85.4
X$9245 6287 109 3594 77 BUF_X4
* cell instance $9246 m0 *1 33.06,85.4
X$9246 6362 5661 6162 77 109 6363 MUX2_X1
* cell instance $9247 m0 *1 34.39,85.4
X$9247 6362 6290 6162 77 109 6289 MUX2_X1
* cell instance $9250 m0 *1 36.67,85.4
X$9250 6441 6290 6026 77 109 6365 MUX2_X1
* cell instance $9251 m0 *1 38,85.4
X$9251 6164 6292 6163 77 109 6361 MUX2_X1
* cell instance $9255 r0 *1 16.15,85.4
X$9255 6507 2400 6283 77 109 6508 MUX2_X1
* cell instance $9258 r0 *1 18.62,85.4
X$9258 6284 6290 6351 77 109 6626 MUX2_X1
* cell instance $9259 r0 *1 19.95,85.4
X$9259 6284 5522 6351 77 109 6509 MUX2_X1
* cell instance $9261 r0 *1 21.66,85.4
X$9261 6509 5575 6286 77 109 6515 MUX2_X1
* cell instance $9265 r0 *1 25.65,85.4
X$9265 6572 6287 6514 77 109 6512 MUX2_X1
* cell instance $9268 r0 *1 28.69,85.4
X$9268 6159 109 3043 77 BUF_X4
* cell instance $9269 r0 *1 30.02,85.4
X$9269 2541 77 109 5722 CLKBUF_X3
* cell instance $9271 r0 *1 31.35,85.4
X$9271 77 5722 6362 6517 6364 2157 109 DFFR_X1
* cell instance $9274 r0 *1 35.72,85.4
X$9274 6289 6231 6365 77 109 6576 MUX2_X1
* cell instance $9277 r0 *1 37.62,85.4
X$9277 4633 6291 77 109 6519 NOR2_X1
* cell instance $9278 r0 *1 38.19,85.4
X$9278 77 6379 6519 6237 6520 109 NOR3_X4
* cell instance $9279 m0 *1 40.28,85.4
X$9279 5850 2794 109 77 5949 AND2_X1
* cell instance $9280 m0 *1 39.71,85.4
X$9280 5803 6369 77 109 6373 NAND2_X1
* cell instance $9281 m0 *1 41.04,85.4
X$9281 6165 6357 6719 6375 6288 6374 109 77 AOI221_X2
* cell instance $9282 m0 *1 43.13,85.4
X$9282 6372 6165 6375 109 77 6442 OAI21_X2
* cell instance $9283 m0 *1 44.46,85.4
X$9283 3859 6294 77 109 6377 NAND2_X1
* cell instance $9284 m0 *1 45.03,85.4
X$9284 77 6381 6379 5402 6377 109 AOI21_X4
* cell instance $9285 m0 *1 47.5,85.4
X$9285 5949 109 6380 77 BUF_X4
* cell instance $9288 r0 *1 41.04,85.4
X$9288 6236 6371 6161 77 6375 109 AOI21_X2
* cell instance $9289 r0 *1 42.37,85.4
X$9289 77 6523 6373 6374 6442 109 AOI21_X4
* cell instance $9291 r0 *1 45.03,85.4
X$9291 5118 3054 5249 109 77 6027 AND3_X1
* cell instance $9292 r0 *1 45.98,85.4
X$9292 77 6443 6893 6444 6643 4909 109 DFFR_X1
* cell instance $9293 m0 *1 50.54,85.4
X$9293 6292 109 6524 77 BUF_X4
* cell instance $9294 m0 *1 49.21,85.4
X$9294 6007 109 6017 77 BUF_X4
* cell instance $9296 r0 *1 49.78,85.4
X$9296 5118 5950 5249 109 77 6166 AND3_X1
* cell instance $9298 r0 *1 51.11,85.4
X$9298 2795 6293 77 6287 109 NAND2_X4
* cell instance $9299 m0 *1 53.58,85.4
X$9299 6256 6247 77 109 6246 NAND2_X1
* cell instance $9300 m0 *1 52.25,85.4
X$9300 6294 6383 6028 77 6386 109 AOI21_X2
* cell instance $9301 m0 *1 54.15,85.4
X$9301 3380 6293 77 5725 109 NAND2_X4
* cell instance $9302 m0 *1 55.86,85.4
X$9302 6385 109 5805 77 BUF_X4
* cell instance $9304 m0 *1 57.38,85.4
X$9304 6032 3995 5876 77 109 6388 MUX2_X1
* cell instance $9305 m0 *1 58.71,85.4
X$9305 6296 6389 6388 77 6445 109 AOI21_X2
* cell instance $9306 m0 *1 60.04,85.4
X$9306 5130 6291 77 109 6297 NOR2_X1
* cell instance $9307 m0 *1 60.61,85.4
X$9307 3983 6296 77 109 6393 NOR2_X1
* cell instance $9308 m0 *1 61.18,85.4
X$9308 5725 109 4639 77 BUF_X4
* cell instance $9309 m0 *1 62.51,85.4
X$9309 6298 5181 77 109 5313 NAND2_X2
* cell instance $9310 m0 *1 63.46,85.4
X$9310 6287 109 4072 77 BUF_X4
* cell instance $9311 m0 *1 64.79,85.4
X$9311 5314 5313 6657 109 6395 77 OAI21_X1
* cell instance $9312 m0 *1 65.55,85.4
X$9312 77 6397 6299 5525 6447 109 AOI21_X4
* cell instance $9313 m0 *1 68.02,85.4
X$9313 77 3631 6037 6169 3054 109 NOR3_X4
* cell instance $9314 m0 *1 70.68,85.4
X$9314 4072 6402 77 109 6400 NAND2_X1
* cell instance $9315 m0 *1 71.25,85.4
X$9315 77 6399 109 3621 BUF_X8
* cell instance $9316 m0 *1 73.72,85.4
X$9316 77 6170 6404 6405 6122 1663 109 DFFR_X1
* cell instance $9318 m0 *1 78.28,85.4
X$9318 77 6585 6300 6301 6407 1663 109 DFFR_X1
* cell instance $9322 r0 *1 53.01,85.4
X$9322 5875 6127 6525 109 6526 77 OAI21_X1
* cell instance $9323 r0 *1 53.77,85.4
X$9323 6256 6650 77 109 6525 NAND2_X1
* cell instance $9324 r0 *1 54.34,85.4
X$9324 6256 6444 77 109 6649 NAND2_X1
* cell instance $9327 r0 *1 55.48,85.4
X$9327 5181 3380 109 77 6234 AND2_X1
* cell instance $9329 r0 *1 56.62,85.4
X$9329 6386 6251 6546 6445 6530 6529 109 77 AOI221_X2
* cell instance $9330 r0 *1 58.71,85.4
X$9330 6372 6386 6445 109 77 6654 OAI21_X2
* cell instance $9334 r0 *1 60.04,85.4
X$9334 6167 77 109 6530 INV_X1
* cell instance $9335 r0 *1 60.42,85.4
X$9335 77 6379 6297 6393 6463 109 NOR3_X4
* cell instance $9336 r0 *1 63.08,85.4
X$9336 77 5034 6533 6534 6395 4909 109 DFFR_X1
* cell instance $9337 r0 *1 66.88,85.4
X$9337 6256 6535 77 109 6446 NAND2_X1
* cell instance $9338 r0 *1 67.45,85.4
X$9338 2795 6034 77 5252 109 NAND2_X4
* cell instance $9339 r0 *1 69.16,85.4
X$9339 6035 6036 6298 77 109 NOR2_X4
* cell instance $9340 r0 *1 70.87,85.4
X$9340 6035 6169 2795 77 109 NOR2_X4
* cell instance $9342 r0 *1 72.77,85.4
X$9342 3709 6448 77 109 6449 NAND2_X1
* cell instance $9343 r0 *1 73.34,85.4
X$9343 77 6170 6539 6402 6450 1663 109 DFFR_X1
* cell instance $9344 r0 *1 77.14,85.4
X$9344 6404 6451 6539 77 109 6540 MUX2_X1
* cell instance $9346 r0 *1 78.66,85.4
X$9346 3276 6452 3126 77 109 6453 MUX2_X1
* cell instance $9348 r0 *1 80.75,85.4
X$9348 3276 6451 3126 77 109 6542 MUX2_X1
* cell instance $9349 r0 *1 82.08,85.4
X$9349 77 5540 6544 6305 6303 1663 109 DFFR_X1
* cell instance $9350 m0 *1 84.74,85.4
X$9350 6127 6305 77 109 6304 NAND2_X1
* cell instance $9351 m0 *1 83.98,85.4
X$9351 6302 6127 6304 109 6303 77 OAI21_X1
* cell instance $9354 m0 *1 87.02,85.4
X$9354 6302 6262 6306 109 6545 77 OAI21_X1
* cell instance $9355 m0 *1 87.78,85.4
X$9355 6262 6307 77 109 6306 NAND2_X1
* cell instance $9359 r0 *1 85.88,85.4
X$9359 77 5540 6454 6307 6545 1663 109 DFFR_X1
* cell instance $9362 m0 *1 91.01,85.4
X$9362 5590 6299 6175 77 109 6411 MUX2_X1
* cell instance $9363 m0 *1 92.53,85.4
X$9363 77 6455 6176 6178 6265 1663 109 DFFR_X1
* cell instance $9365 m0 *1 96.52,85.4
X$9365 6179 6308 4739 77 109 6548 MUX2_X1
* cell instance $9366 m0 *1 97.85,85.4
X$9366 6181 6308 4329 77 109 6309 MUX2_X1
* cell instance $9367 m0 *1 99.18,85.4
X$9367 6412 5960 6413 77 109 6461 MUX2_X1
* cell instance $9369 m0 *1 100.7,85.4
X$9369 6279 77 109 3804 BUF_X1
* cell instance $9370 m0 *1 101.27,85.4
X$9370 5319 4451 77 109 6416 NAND2_X1
* cell instance $9371 m0 *1 101.84,85.4
X$9371 5322 4451 77 109 6417 NAND2_X1
* cell instance $9372 m0 *1 102.41,85.4
X$9372 77 6372 109 6383 BUF_X8
* cell instance $9375 r0 *1 91.39,85.4
X$9375 5586 6299 6674 77 109 6456 MUX2_X1
* cell instance $9376 r0 *1 92.72,85.4
X$9376 6456 6546 6411 77 109 6457 MUX2_X1
* cell instance $9378 r0 *1 95.57,85.4
X$9378 5462 4780 6547 109 6592 77 OAI21_X1
* cell instance $9381 r0 *1 96.9,85.4
X$9381 4780 6458 77 109 6547 NAND2_X1
* cell instance $9385 r0 *1 98.8,85.4
X$9385 6548 6459 6309 77 109 6460 MUX2_X1
* cell instance $9386 r0 *1 100.13,85.4
X$9386 5592 4780 6462 109 6679 77 OAI21_X1
* cell instance $9388 r0 *1 101.27,85.4
X$9388 4445 5323 77 109 6734 NAND2_X1
* cell instance $9390 r0 *1 102.03,85.4
X$9390 5894 4451 4996 109 77 6683 AND3_X1
* cell instance $9391 r0 *1 102.98,85.4
X$9391 77 5892 109 5894 BUF_X8
* cell instance $9392 m0 *1 106.59,85.4
X$9392 77 7212 6424 5148 3621 5324 109 OAI22_X4
* cell instance $9393 m0 *1 105.26,85.4
X$9393 6182 4085 4451 77 6419 109 AOI21_X2
* cell instance $9394 m0 *1 109.82,85.4
X$9394 3631 77 109 6310 INV_X1
* cell instance $9396 m0 *1 110.39,85.4
X$9396 77 5992 6426 6311 6135 109 DFF_X1
* cell instance $9397 m0 *1 113.62,85.4
X$9397 4523 77 109 6428 INV_X1
* cell instance $9398 m0 *1 114,85.4
X$9398 4523 4170 77 109 6194 NAND2_X2
* cell instance $9399 m0 *1 114.95,85.4
X$9399 6430 4462 1986 77 109 6429 MUX2_X1
* cell instance $9400 m0 *1 116.28,85.4
X$9400 6194 6276 6174 77 109 6054 OR3_X4
* cell instance $9401 m0 *1 118.37,85.4
X$9401 6036 6464 6433 6312 6422 77 109 OAI211_X2
* cell instance $9402 m0 *1 120.08,85.4
X$9402 6464 6433 6312 109 77 6435 OAI21_X2
* cell instance $9403 m0 *1 121.41,85.4
X$9403 6310 6435 6148 6313 6436 6434 77 109 OAI221_X2
* cell instance $9405 m0 *1 123.69,85.4
X$9405 5897 109 6436 77 BUF_X4
* cell instance $9406 m0 *1 125.02,85.4
X$9406 6278 77 109 6465 BUF_X1
* cell instance $9408 r0 *1 105.45,85.4
X$9408 6420 5892 6418 109 77 6686 OAI21_X4
* cell instance $9411 r0 *1 108.49,85.4
X$9411 77 6408 6553 6554 3457 5323 109 AOI22_X4
* cell instance $9412 r0 *1 111.72,85.4
X$9412 5894 6555 77 109 6424 OR2_X1
* cell instance $9414 r0 *1 112.86,85.4
X$9414 77 6593 109 6426 BUF_X8
* cell instance $9418 r0 *1 115.33,85.4
X$9418 6169 3738 3632 109 77 6556 MUX2_X2
* cell instance $9419 r0 *1 117.04,85.4
X$9419 6466 3813 1988 77 109 6865 MUX2_X1
* cell instance $9420 r0 *1 118.37,85.4
X$9420 3811 6464 6433 6312 6559 77 109 OAI211_X2
* cell instance $9421 r0 *1 120.08,85.4
X$9421 6560 6559 109 77 4483 AND2_X2
* cell instance $9424 r0 *1 121.6,85.4
X$9424 6435 5984 6562 6148 6146 6561 77 109 OAI221_X2
* cell instance $9425 r0 *1 123.69,85.4
X$9425 77 6277 5706 6465 6433 109 NOR3_X4
* cell instance $9426 m0 *1 128.06,85.4
X$9426 6048 5709 6315 109 6314 77 OAI21_X1
* cell instance $9427 m0 *1 125.97,85.4
X$9427 6277 6143 5996 3631 6189 6912 109 77 AOI221_X2
* cell instance $9428 m0 *1 128.82,85.4
X$9428 6314 6566 6315 6037 109 77 6316 OAI22_X2
* cell instance $9429 m0 *1 130.53,85.4
X$9429 6317 5157 77 6188 109 NAND2_X4
* cell instance $9430 m0 *1 132.24,85.4
X$9430 5297 4890 3918 109 6567 77 NOR3_X2
* cell instance $9431 m0 *1 133.57,85.4
X$9431 5896 6698 77 109 5751 NAND2_X2
* cell instance $9432 m0 *1 134.52,85.4
X$9432 6053 6051 6054 6318 6430 6468 77 109 6271 OAI33_X1
* cell instance $9433 m0 *1 135.85,85.4
X$9433 5479 5569 6054 77 6432 109 AOI21_X1
* cell instance $9435 m0 *1 136.8,85.4
X$9435 77 6427 6431 5560 5564 109 AOI21_X4
* cell instance $9436 m0 *1 139.27,85.4
X$9436 6425 6421 5075 77 4755 109 NAND3_X4
* cell instance $9437 m0 *1 141.74,85.4
X$9437 4298 6422 6423 77 109 4059 NAND3_X2
* cell instance $9439 r0 *1 126.35,85.4
X$9439 5897 5599 6319 77 109 NOR2_X4
* cell instance $9440 r0 *1 128.06,85.4
X$9440 77 6464 5599 6317 5157 109 AOI21_X4
* cell instance $9441 r0 *1 130.53,85.4
X$9441 6466 6317 5157 77 6566 109 AOI21_X1
* cell instance $9442 r0 *1 131.29,85.4
X$9442 77 5603 6567 6467 6317 5433 109 OAI22_X4
* cell instance $9443 r0 *1 134.52,85.4
X$9443 6568 5193 6569 77 109 6478 NAND3_X2
* cell instance $9445 r0 *1 136.04,85.4
X$9445 5896 5194 5558 5604 5553 6431 77 109 OAI221_X2
* cell instance $9446 r0 *1 138.13,85.4
X$9446 77 6470 6469 5194 5604 109 AOI21_X4
* cell instance $9447 r0 *1 140.6,85.4
X$9447 6564 6319 77 109 6563 NAND2_X1
* cell instance $9448 r0 *1 141.17,85.4
X$9448 6561 109 4304 77 BUF_X4
* cell instance $9449 r0 *1 142.5,85.4
X$9449 77 4354 109 6565 BUF_X8
* cell instance $9450 m0 *1 145.16,85.4
X$9450 77 6007 5446 109 BUF_X16
* cell instance $9451 m0 *1 143.45,85.4
X$9451 4240 6320 4304 4480 6321 109 77 AOI211_X2
* cell instance $9452 m0 *1 149.91,85.4
X$9452 3926 5713 6321 109 77 6414 OAI21_X4
* cell instance $9453 m0 *1 152.38,85.4
X$9453 77 4356 109 4483 BUF_X8
* cell instance $9454 m0 *1 154.85,85.4
X$9454 6410 109 5081 77 BUF_X4
* cell instance $9455 m0 *1 156.18,85.4
X$9455 4357 109 3926 77 BUF_X4
* cell instance $9456 m0 *1 157.51,85.4
X$9456 5758 5832 77 109 5907 NOR2_X2
* cell instance $9457 m0 *1 158.46,85.4
X$9457 5341 6322 5354 109 77 6409 AND3_X1
* cell instance $9458 m0 *1 159.41,85.4
X$9458 6409 109 6182 77 BUF_X4
* cell instance $9459 m0 *1 160.74,85.4
X$9459 5710 4988 77 109 6062 NOR2_X1
* cell instance $9460 m0 *1 161.31,85.4
X$9460 5994 109 3931 77 BUF_X4
* cell instance $9462 m0 *1 162.83,85.4
X$9462 6478 6326 19058 109 77 4750 HA_X1
* cell instance $9463 m0 *1 164.73,85.4
X$9463 6406 109 5080 77 BUF_X4
* cell instance $9465 m0 *1 166.25,85.4
X$9465 6323 5758 77 109 6403 NOR2_X1
* cell instance $9466 m0 *1 166.82,85.4
X$9466 6403 5758 6324 77 6065 109 AOI21_X1
* cell instance $9468 m0 *1 167.77,85.4
X$9468 6326 6398 6197 77 109 6327 MUX2_X1
* cell instance $9469 m0 *1 169.1,85.4
X$9469 6197 6401 6326 77 109 6328 MUX2_X1
* cell instance $9470 m0 *1 170.43,85.4
X$9470 4613 77 109 4297 INV_X4
* cell instance $9471 m0 *1 171.38,85.4
X$9471 6481 6329 6482 109 77 1034 OAI21_X4
* cell instance $9472 m0 *1 173.85,85.4
X$9472 77 6329 6199 2525 1920 6396 109 OAI22_X4
* cell instance $9473 m0 *1 177.08,85.4
X$9473 77 969 6249 6392 2749 109 AOI21_X4
* cell instance $9474 m0 *1 179.55,85.4
X$9474 6390 109 6391 77 BUF_X4
* cell instance $9476 m0 *1 181.64,85.4
X$9476 77 6245 6658 1146 5244 6536 109 DFFR_X2
* cell instance $9477 m0 *1 185.82,85.4
X$9477 6384 6330 77 109 6387 NOR2_X1
* cell instance $9478 m0 *1 186.39,85.4
X$9478 6069 5492 6485 77 109 6334 NAND3_X1
* cell instance $9479 m0 *1 187.15,85.4
X$9479 5655 77 109 4944 CLKBUF_X3
* cell instance $9480 m0 *1 188.1,85.4
X$9480 4824 4683 6486 77 109 6331 MUX2_X1
* cell instance $9481 m0 *1 189.43,85.4
X$9481 1156 5384 6332 6333 5090 109 77 6241 OAI221_X1
* cell instance $9482 m0 *1 190.57,85.4
X$9482 4576 6334 6382 77 6333 109 AOI21_X1
* cell instance $9484 r0 *1 144.97,85.4
X$9484 77 4480 4304 6472 6191 6320 109 AOI22_X4
* cell instance $9485 r0 *1 148.2,85.4
X$9485 77 6055 5713 4354 4358 6751 109 NOR4_X4
* cell instance $9487 r0 *1 151.81,85.4
X$9487 6473 6476 6474 6194 6557 6475 77 109 6410 OAI33_X1
* cell instance $9488 r0 *1 153.14,85.4
X$9488 77 6473 6558 6477 5994 6475 109 OAI22_X4
* cell instance $9489 r0 *1 156.37,85.4
X$9489 6552 6473 6476 109 77 6543 OAI21_X4
* cell instance $9490 r0 *1 158.84,85.4
X$9490 6322 5341 5354 77 5894 109 NAND3_X4
* cell instance $9491 r0 *1 161.31,85.4
X$9491 77 5894 6551 2924 6408 109 NOR3_X4
* cell instance $9492 r0 *1 163.97,85.4
X$9492 77 6602 3357 6549 5547 6550 109 OAI22_X4
* cell instance $9493 r0 *1 167.2,85.4
X$9493 6480 6329 6327 109 77 1925 OAI21_X2
* cell instance $9494 r0 *1 168.53,85.4
X$9494 6479 77 109 4984 INV_X1
* cell instance $9495 r0 *1 168.91,85.4
X$9495 77 6329 6328 2924 1156 6401 109 OAI22_X4
* cell instance $9499 r0 *1 172.14,85.4
X$9499 6543 77 109 5688 INV_X1
* cell instance $9500 r0 *1 172.52,85.4
X$9500 77 6200 6665 3353 1822 6483 109 OAI22_X4
* cell instance $9502 r0 *1 176.13,85.4
X$9502 77 6200 6484 2183 2044 6541 109 OAI22_X4
* cell instance $9503 r0 *1 179.36,85.4
X$9503 6066 4030 6325 6607 5626 6531 77 109 OAI221_X2
* cell instance $9506 r0 *1 182.4,85.4
X$9506 6245 77 109 19273 CLKBUF_X1
* cell instance $9507 r0 *1 182.97,85.4
X$9507 5376 6536 77 109 6537 NAND2_X1
* cell instance $9508 r0 *1 183.54,85.4
X$9508 6817 77 109 6245 CLKBUF_X3
* cell instance $9509 r0 *1 184.49,85.4
X$9509 1059 5376 6537 109 6609 77 OAI21_X1
* cell instance $9511 r0 *1 185.63,85.4
X$9511 77 6245 18815 6486 6331 1146 109 DFFR_X1
* cell instance $9513 r0 *1 189.81,85.4
X$9513 4548 6486 77 109 6332 NAND2_X1
* cell instance $9514 r0 *1 190.38,85.4
X$9514 5776 5086 77 109 6611 NAND2_X1
* cell instance $9515 r0 *1 190.95,85.4
X$9515 77 5491 6487 1146 18991 4258 109 DFFR_X2
* cell instance $9517 m0 *1 191.71,85.4
X$9517 6532 77 109 6487 INV_X1
* cell instance $9519 m0 *1 194.37,85.4
X$9519 4573 4022 4576 4258 5237 6376 109 77 AOI221_X2
* cell instance $9520 m0 *1 196.46,85.4
X$9520 77 5627 4948 6335 6528 992 109 DFFR_X1
* cell instance $9521 m0 *1 200.26,85.4
X$9521 6336 5129 969 6239 77 109 6370 AOI22_X1
* cell instance $9524 r0 *1 195.13,85.4
X$9524 5083 6378 1665 5376 109 77 6651 OAI22_X1
* cell instance $9525 r0 *1 196.08,85.4
X$9525 6651 4258 6368 77 6532 109 AOI21_X1
* cell instance $9528 r0 *1 197.41,85.4
X$9528 5416 6336 77 109 6488 NAND2_X1
* cell instance $9529 r0 *1 197.98,85.4
X$9529 1924 5372 6488 6521 6527 109 77 6528 OAI221_X1
* cell instance $9531 r0 *1 199.5,85.4
X$9531 6335 77 109 6527 INV_X1
* cell instance $9532 r0 *1 199.88,85.4
X$9532 77 5627 18894 5495 6367 992 109 DFFR_X1
* cell instance $9534 m0 *1 202.35,85.4
X$9534 5495 5212 6366 77 109 6367 MUX2_X1
* cell instance $9536 m0 *1 204.63,85.4
X$9536 6239 5655 77 109 6368 NOR2_X2
* cell instance $9539 m0 *1 206.53,85.4
X$9539 2894 77 109 6075 CLKBUF_X3
* cell instance $9540 m0 *1 207.48,85.4
X$9540 5814 4832 6204 6492 77 109 6203 AOI22_X1
* cell instance $9541 m0 *1 208.43,85.4
X$9541 4264 4552 6204 77 109 6205 MUX2_X1
* cell instance $9542 m0 *1 209.76,85.4
X$9542 5655 77 109 6336 CLKBUF_X3
* cell instance $9544 m0 *1 211.47,85.4
X$9544 6337 77 109 4380 INV_X1
* cell instance $9549 r0 *1 204.82,85.4
X$9549 6489 1799 5216 77 6366 109 AOI21_X1
* cell instance $9550 r0 *1 205.58,85.4
X$9550 6490 5369 6640 5086 109 77 6489 OAI22_X1
* cell instance $9551 r0 *1 206.53,85.4
X$9551 6490 6336 77 109 6491 NAND2_X1
* cell instance $9552 r0 *1 207.1,85.4
X$9552 1799 5372 6491 6521 6522 109 77 6637 OAI221_X1
* cell instance $9556 r0 *1 209.57,85.4
X$9556 6636 77 109 6522 INV_X1
* cell instance $9557 r0 *1 209.95,85.4
X$9557 5376 5083 77 109 6521 NAND2_X2
* cell instance $9558 r0 *1 210.9,85.4
X$9558 6360 4832 6493 6492 77 109 6518 AOI22_X1
* cell instance $9559 r0 *1 211.85,85.4
X$9559 484 5259 6518 109 6516 77 OAI21_X1
* cell instance $9560 r0 *1 212.61,85.4
X$9560 77 5923 6634 3676 18969 4003 109 DFFR_X2
* cell instance $9561 m0 *1 213.18,85.4
X$9561 4380 6102 5756 6359 77 109 6358 AOI22_X1
* cell instance $9565 m0 *1 216.22,85.4
X$9565 6073 5417 6227 6102 2886 6614 109 77 AOI221_X2
* cell instance $9567 m0 *1 218.31,85.4
X$9567 631 5259 6494 109 6353 77 OAI21_X1
* cell instance $9569 m0 *1 219.26,85.4
X$9569 3117 6354 6353 77 109 6338 MUX2_X1
* cell instance $9570 m0 *1 220.59,85.4
X$9570 2894 77 109 5923 CLKBUF_X3
* cell instance $9571 m0 *1 221.54,85.4
X$9571 5923 77 109 19238 CLKBUF_X1
* cell instance $9574 m0 *1 223.06,85.4
X$9574 77 5923 4718 6339 6349 3676 109 DFFR_X1
* cell instance $9575 m0 *1 226.86,85.4
X$9575 6350 4951 6208 77 109 6349 MUX2_X1
* cell instance $9578 m0 *1 229.14,85.4
X$9578 3695 77 109 6348 INV_X1
* cell instance $9584 r0 *1 218.12,85.4
X$9584 5785 4832 6495 6492 77 109 6494 AOI22_X1
* cell instance $9586 r0 *1 219.26,85.4
X$9586 3117 6496 6495 77 109 6513 MUX2_X1
* cell instance $9587 r0 *1 220.59,85.4
X$9587 77 5923 18794 6495 6513 3676 109 DFFR_X1
* cell instance $9590 r0 *1 225.34,85.4
X$9590 6202 5773 4718 77 109 6497 NAND3_X1
* cell instance $9591 r0 *1 226.1,85.4
X$9591 6339 5271 6202 77 109 6498 OR3_X1
* cell instance $9596 r0 *1 227.24,85.4
X$9596 1381 5781 6499 5374 6348 109 77 6506 OAI221_X1
* cell instance $9597 r0 *1 228.38,85.4
X$9597 77 6500 18835 3695 6506 992 109 DFFR_X1
* cell instance $9598 m0 *1 230.85,85.4
X$9598 6340 109 4573 77 BUF_X4
* cell instance $9602 m0 *1 232.75,85.4
X$9602 3695 6209 5637 6340 77 109 6345 AOI22_X1
* cell instance $9604 m0 *1 233.7,85.4
X$9604 5926 5392 6345 109 6501 77 OAI21_X1
* cell instance $9607 m0 *1 235.41,85.4
X$9607 77 6210 5926 6343 6341 992 109 DFFR_X1
* cell instance $9611 r0 *1 235.79,85.4
X$9611 413 4691 6343 77 109 6502 MUX2_X1
* cell instance $9619 m0 *1 2.09,110.6
X$9619 8593 5726 5514 77 109 8592 MUX2_X1
* cell instance $9622 m0 *1 5.7,110.6
X$9622 8739 5506 8662 77 109 8523 MUX2_X1
* cell instance $9623 m0 *1 7.03,110.6
X$9623 8739 7912 8662 77 109 8740 MUX2_X1
* cell instance $9624 m0 *1 8.36,110.6
X$9624 8392 8349 8740 77 109 8742 MUX2_X1
* cell instance $9628 r0 *1 2.85,110.6
X$9628 8911 5301 5514 77 109 8913 MUX2_X1
* cell instance $9632 r0 *1 4.18,110.6
X$9632 77 8661 8662 8911 8913 4909 109 DFFR_X1
* cell instance $9634 r0 *1 8.74,110.6
X$9634 8914 5726 8051 77 109 8915 MUX2_X1
* cell instance $9635 r0 *1 10.07,110.6
X$9635 77 8661 8835 8914 8915 4909 109 DFFR_X1
* cell instance $9637 m0 *1 10.07,110.6
X$9637 8217 3611 8742 77 109 8745 MUX2_X1
* cell instance $9639 m0 *1 15.2,110.6
X$9639 8748 7760 8746 77 109 8751 MUX2_X1
* cell instance $9640 m0 *1 16.53,110.6
X$9640 8137 3599 8524 77 109 8920 MUX2_X1
* cell instance $9644 m0 *1 22.61,110.6
X$9644 77 8664 8667 8596 8597 4909 109 DFFR_X1
* cell instance $9645 m0 *1 26.41,110.6
X$9645 77 8664 8668 8665 8600 4909 109 DFFR_X1
* cell instance $9646 m0 *1 30.21,110.6
X$9646 8665 5805 5514 77 109 8600 MUX2_X1
* cell instance $9649 r0 *1 13.87,110.6
X$9649 8835 7477 8836 77 109 8746 MUX2_X1
* cell instance $9652 r0 *1 16.34,110.6
X$9652 8220 9175 8751 77 109 9392 MUX2_X1
* cell instance $9654 r0 *1 18.43,110.6
X$9654 77 9005 8669 8663 8922 4909 109 DFFR_X1
* cell instance $9655 r0 *1 22.23,110.6
X$9655 8663 5577 2540 77 109 8922 MUX2_X1
* cell instance $9657 r0 *1 26.6,110.6
X$9657 9003 5252 8839 77 109 8927 MUX2_X1
* cell instance $9659 r0 *1 28.12,110.6
X$9659 8841 5110 2540 77 109 8840 MUX2_X1
* cell instance $9661 r0 *1 29.83,110.6
X$9661 8928 5805 2540 77 109 8929 MUX2_X1
* cell instance $9662 r0 *1 31.16,110.6
X$9662 77 8525 8843 8928 8929 4909 109 DFFR_X1
* cell instance $9664 m0 *1 36.29,110.6
X$9664 8667 3861 8668 77 109 8762 MUX2_X1
* cell instance $9665 m0 *1 34.96,110.6
X$9665 8667 8666 8668 77 109 8758 MUX2_X1
* cell instance $9667 m0 *1 38.38,110.6
X$9667 8758 8670 77 109 8760 NOR2_X1
* cell instance $9668 m0 *1 38.95,110.6
X$9668 8528 8760 8671 77 109 8757 NOR3_X1
* cell instance $9669 m0 *1 39.71,110.6
X$9669 8762 6231 77 109 8766 NOR2_X1
* cell instance $9671 m0 *1 41.8,110.6
X$9671 8745 6236 77 109 8770 NOR2_X1
* cell instance $9672 m0 *1 42.37,110.6
X$9672 8765 8766 3694 77 109 8767 NOR3_X1
* cell instance $9673 m0 *1 43.13,110.6
X$9673 8673 8767 8672 109 8769 77 NOR3_X2
* cell instance $9678 r0 *1 35.53,110.6
X$9678 8669 8666 8843 77 109 8759 MUX2_X1
* cell instance $9679 r0 *1 36.86,110.6
X$9679 8669 3861 8843 77 109 8937 MUX2_X1
* cell instance $9681 r0 *1 38.38,110.6
X$9681 8937 6231 77 109 8938 NOR2_X1
* cell instance $9682 r0 *1 38.95,110.6
X$9682 8759 8670 77 109 8761 NOR2_X1
* cell instance $9684 r0 *1 39.71,110.6
X$9684 8844 8761 8671 77 109 8764 NOR3_X1
* cell instance $9686 r0 *1 40.66,110.6
X$9686 8465 8403 8858 4774 8531 8942 109 77 AOI221_X2
* cell instance $9688 r0 *1 42.94,110.6
X$9688 77 8627 8769 8770 8946 109 NOR3_X4
* cell instance $9690 r0 *1 45.98,110.6
X$9690 77 8674 8949 8950 8772 4909 109 DFFR_X1
* cell instance $9691 m0 *1 47.31,110.6
X$9691 5135 109 8672 77 BUF_X4
* cell instance $9695 r0 *1 49.78,110.6
X$9695 8949 5506 6244 77 109 8848 MUX2_X1
* cell instance $9697 m0 *1 50.54,110.6
X$9697 3793 5738 8675 109 8772 77 OAI21_X1
* cell instance $9700 r0 *1 51.11,110.6
X$9700 6833 8950 77 109 8675 NAND2_X1
* cell instance $9701 r0 *1 51.68,110.6
X$9701 77 8676 9015 8776 8774 4909 109 DFFR_X1
* cell instance $9702 m0 *1 54.15,110.6
X$9702 3793 6177 8677 109 8774 77 OAI21_X1
* cell instance $9704 m0 *1 54.91,110.6
X$9704 6723 8776 77 109 8677 NAND2_X1
* cell instance $9707 m0 *1 58.71,110.6
X$9707 7327 8783 77 109 8781 NAND2_X1
* cell instance $9708 m0 *1 59.28,110.6
X$9708 8778 8955 8671 77 109 8409 NOR3_X1
* cell instance $9709 m0 *1 60.04,110.6
X$9709 8781 7331 4319 109 77 8780 OAI21_X4
* cell instance $9711 m0 *1 62.7,110.6
X$9711 8787 8679 8672 109 8785 77 NOR3_X2
* cell instance $9712 m0 *1 64.03,110.6
X$9712 77 8855 9020 8790 8959 1663 109 DFFR_X1
* cell instance $9714 r0 *1 55.48,110.6
X$9714 8777 6823 4319 109 77 8953 OAI21_X2
* cell instance $9715 r0 *1 56.81,110.6
X$9715 6725 8850 77 109 8777 NAND2_X1
* cell instance $9717 r0 *1 57.76,110.6
X$9717 77 8676 8853 8783 8780 1663 109 DFFR_X1
* cell instance $9721 r0 *1 61.56,110.6
X$9721 8678 8670 77 109 8955 NOR2_X1
* cell instance $9722 r0 *1 62.13,110.6
X$9722 3793 7165 8958 109 8956 77 OAI21_X1
* cell instance $9725 r0 *1 63.46,110.6
X$9725 7194 8854 77 109 8958 NAND2_X1
* cell instance $9727 r0 *1 65.55,110.6
X$9727 7196 3710 8788 109 8959 77 OAI21_X1
* cell instance $9729 r0 *1 66.5,110.6
X$9729 7084 8790 77 109 8788 NAND2_X1
* cell instance $9731 r0 *1 67.83,110.6
X$9731 6725 8963 77 109 8680 NAND2_X1
* cell instance $9732 m0 *1 68.4,110.6
X$9732 8680 6823 6399 109 77 8962 OAI21_X4
* cell instance $9735 m0 *1 71.06,110.6
X$9735 7327 8792 77 109 8793 NAND2_X1
* cell instance $9736 m0 *1 71.63,110.6
X$9736 8537 77 109 19241 CLKBUF_X1
* cell instance $9737 m0 *1 72.2,110.6
X$9737 8798 77 109 8347 CLKBUF_X3
* cell instance $9738 m0 *1 73.15,110.6
X$9738 8794 7767 6538 109 77 8795 OAI21_X4
* cell instance $9739 m0 *1 75.62,110.6
X$9739 77 8537 8539 8799 8795 4086 109 DFFR_X1
* cell instance $9740 m0 *1 79.42,110.6
X$9740 8683 7335 8539 77 109 8803 MUX2_X1
* cell instance $9741 m0 *1 80.75,110.6
X$9741 8682 7335 8538 77 109 8804 MUX2_X1
* cell instance $9743 r0 *1 68.4,110.6
X$9743 77 8537 8861 8963 8962 4086 109 DFFR_X1
* cell instance $9744 r0 *1 72.2,110.6
X$9744 8793 7331 6538 109 77 8859 OAI21_X4
* cell instance $9746 r0 *1 74.86,110.6
X$9746 7922 8799 77 109 8794 NAND2_X1
* cell instance $9747 r0 *1 75.43,110.6
X$9747 8796 6972 5316 109 77 8860 OAI21_X4
* cell instance $9748 r0 *1 77.9,110.6
X$9748 7201 8965 77 109 8796 NAND2_X1
* cell instance $9749 r0 *1 78.47,110.6
X$9749 8682 8864 8683 77 109 8862 MUX2_X1
* cell instance $9752 r0 *1 80.37,110.6
X$9752 5135 77 109 8868 INV_X4
* cell instance $9754 r0 *1 81.7,110.6
X$9754 8684 109 3565 77 BUF_X4
* cell instance $9756 m0 *1 82.46,110.6
X$9756 8803 6276 3622 77 109 8808 NOR3_X1
* cell instance $9757 m0 *1 83.41,110.6
X$9757 8357 6742 8415 8806 8807 8693 109 77 AOI221_X2
* cell instance $9759 m0 *1 85.69,110.6
X$9759 8808 8367 77 109 8806 NOR2_X1
* cell instance $9762 r0 *1 83.41,110.6
X$9762 8804 6745 77 109 8865 NOR2_X1
* cell instance $9765 r0 *1 85.88,110.6
X$9765 3569 3048 8975 77 109 8867 MUX2_X1
* cell instance $9766 m0 *1 86.83,110.6
X$9766 5592 6890 8809 109 8542 77 OAI21_X1
* cell instance $9769 m0 *1 87.78,110.6
X$9769 7160 8812 77 109 8809 NAND2_X1
* cell instance $9770 m0 *1 88.35,110.6
X$9770 77 9028 8646 8812 8542 4086 109 DFFR_X1
* cell instance $9772 m0 *1 92.34,110.6
X$9772 5887 109 8375 77 BUF_X4
* cell instance $9773 m0 *1 93.67,110.6
X$9773 7495 109 4789 77 BUF_X4
* cell instance $9774 m0 *1 95,110.6
X$9774 7342 7168 109 77 8080 AND2_X2
* cell instance $9776 m0 *1 96.14,110.6
X$9776 8980 6524 8422 77 109 8685 MUX2_X1
* cell instance $9777 m0 *1 97.47,110.6
X$9777 7844 109 6371 77 BUF_X4
* cell instance $9779 m0 *1 100.32,110.6
X$9779 8688 6885 8686 77 109 8545 MUX2_X1
* cell instance $9781 m0 *1 101.84,110.6
X$9781 6389 8688 77 109 8652 NOR2_X1
* cell instance $9782 m0 *1 102.41,110.6
X$9782 77 8201 8687 109 BUF_X32
* cell instance $9785 r0 *1 87.4,110.6
X$9785 7844 7020 77 8157 109 NAND2_X4
* cell instance $9786 r0 *1 89.11,110.6
X$9786 6593 77 109 8239 INV_X2
* cell instance $9788 r0 *1 91.2,110.6
X$9788 9031 8250 77 109 8416 NOR2_X1
* cell instance $9790 r0 *1 92.15,110.6
X$9790 7936 5887 77 7590 109 NAND2_X4
* cell instance $9791 r0 *1 93.86,110.6
X$9791 77 8627 109 6901 BUF_X8
* cell instance $9792 r0 *1 96.33,110.6
X$9792 77 8544 8869 8980 8685 8687 109 DFFR_X1
* cell instance $9795 r0 *1 102.03,110.6
X$9795 8984 8688 77 109 8546 NOR2_X1
* cell instance $9798 r0 *1 103.17,110.6
X$9798 77 8684 6419 5186 8800 109 AOI21_X4
* cell instance $9799 r0 *1 105.64,110.6
X$9799 77 8986 5694 5186 8985 109 AOI21_X4
* cell instance $9800 r0 *1 108.11,110.6
X$9800 77 8870 6594 5594 8559 109 AOI21_X4
* cell instance $9801 r0 *1 110.58,110.6
X$9801 8871 7642 8549 77 109 8991 MUX2_X1
* cell instance $9802 r0 *1 111.91,110.6
X$9802 9154 8689 8991 77 109 8551 MUX2_X1
* cell instance $9803 m0 *1 112.29,110.6
X$9803 9457 6742 8552 77 109 8553 MUX2_X1
* cell instance $9807 m0 *1 114.57,110.6
X$9807 7022 8553 109 77 8823 AND2_X1
* cell instance $9808 m0 *1 115.33,110.6
X$9808 77 8383 8823 6726 8554 109 AOI21_X4
* cell instance $9811 m0 *1 118.75,110.6
X$9811 8691 6125 8826 77 109 8555 MUX2_X1
* cell instance $9812 m0 *1 120.08,110.6
X$9812 7647 8008 8659 77 109 8660 MUX2_X1
* cell instance $9813 m0 *1 121.41,110.6
X$9813 8681 6463 8828 77 109 NOR2_X4
* cell instance $9815 m0 *1 123.31,110.6
X$9815 6463 8681 77 109 8831 OR2_X2
* cell instance $9817 m0 *1 124.45,110.6
X$9817 77 6872 109 5553 BUF_X8
* cell instance $9818 m0 *1 126.92,110.6
X$9818 6436 8693 8508 77 8694 109 AOI21_X1
* cell instance $9820 r0 *1 113.24,110.6
X$9820 77 8254 7006 8971 8872 5401 109 AOI22_X4
* cell instance $9826 r0 *1 117.04,110.6
X$9826 9040 8421 8873 77 109 8690 MUX2_X1
* cell instance $9827 r0 *1 118.37,110.6
X$9827 8690 8249 8874 77 109 8826 MUX2_X1
* cell instance $9828 r0 *1 119.7,110.6
X$9828 8993 4170 4523 77 109 5569 OR3_X2
* cell instance $9831 r0 *1 121.22,110.6
X$9831 77 8692 8873 8876 9161 4086 109 DFFR_X1
* cell instance $9832 r0 *1 125.02,110.6
X$9832 8693 8508 77 8996 109 NAND2_X4
* cell instance $9834 r0 *1 126.92,110.6
X$9834 77 5160 7315 8832 8877 8696 109 NOR4_X4
* cell instance $9835 m0 *1 128.82,110.6
X$9835 77 8695 7790 8697 8829 8039 109 OAI211_X4
* cell instance $9836 m0 *1 128.06,110.6
X$9836 7945 7907 109 77 8832 AND2_X1
* cell instance $9837 m0 *1 132.05,110.6
X$9837 5716 8557 8558 109 77 8830 OAI21_X4
* cell instance $9840 m0 *1 136.23,110.6
X$9840 6699 77 109 8824 INV_X2
* cell instance $9842 m0 *1 136.99,110.6
X$9842 8822 8651 8825 8821 8568 8998 109 77 AOI221_X2
* cell instance $9844 r0 *1 130.34,110.6
X$9844 8878 8698 7516 77 109 NOR2_X4
* cell instance $9845 r0 *1 132.05,110.6
X$9845 8698 8878 77 109 8827 OR2_X1
* cell instance $9846 r0 *1 132.81,110.6
X$9846 77 3916 8824 8250 6430 6053 109 NAND4_X4
* cell instance $9847 r0 *1 136.23,110.6
X$9847 77 8572 2387 8985 8998 8880 109 AOI22_X4
* cell instance $9848 r0 *1 139.46,110.6
X$9848 8706 8574 77 109 8822 NOR2_X1
* cell instance $9850 m0 *1 139.46,110.6
X$9850 8699 8700 3353 8997 8712 77 109 8881 AOI221_X1
* cell instance $9851 m0 *1 140.79,110.6
X$9851 8704 8701 8703 109 8702 77 OAI21_X1
* cell instance $9853 r0 *1 140.03,110.6
X$9853 5714 5712 8995 8702 8712 6553 77 109 OAI221_X2
* cell instance $9854 m0 *1 142.88,110.6
X$9854 8093 8811 77 109 8819 NOR2_X1
* cell instance $9855 m0 *1 141.93,110.6
X$9855 8566 8819 8817 77 109 8701 OR3_X1
* cell instance $9856 m0 *1 143.45,110.6
X$9856 8504 8569 8430 109 77 8817 AND3_X1
* cell instance $9857 m0 *1 144.4,110.6
X$9857 8706 7452 77 109 8815 OR2_X1
* cell instance $9858 m0 *1 145.16,110.6
X$9858 77 8649 8815 8573 8813 8707 109 AOI22_X4
* cell instance $9859 m0 *1 148.39,110.6
X$9859 8569 7507 8564 109 8990 77 OAI21_X1
* cell instance $9860 m0 *1 149.15,110.6
X$9860 8569 7507 7658 77 109 8987 OR3_X1
* cell instance $9864 r0 *1 143.07,110.6
X$9864 9047 8705 8565 77 8802 109 AOI21_X2
* cell instance $9866 r0 *1 144.59,110.6
X$9866 7452 8560 77 109 8992 OR2_X1
* cell instance $9868 r0 *1 145.54,110.6
X$9868 8882 7799 8560 77 8814 109 AOI21_X1
* cell instance $9869 r0 *1 146.3,110.6
X$9869 7799 8705 77 109 8707 NAND2_X1
* cell instance $9870 r0 *1 146.87,110.6
X$9870 8708 8992 8814 77 8884 109 AOI21_X2
* cell instance $9872 r0 *1 148.58,110.6
X$9872 8706 8990 8987 77 8708 109 AOI21_X1
* cell instance $9875 r0 *1 149.91,110.6
X$9875 5712 5714 8710 7295 8982 8989 77 109 OAI221_X2
* cell instance $9876 m0 *1 152.19,110.6
X$9876 7452 8569 7955 77 109 8885 MUX2_X1
* cell instance $9877 m0 *1 150.48,110.6
X$9877 8373 8094 8378 109 77 8709 MUX2_X2
* cell instance $9880 r0 *1 152.19,110.6
X$9880 8983 8705 8498 77 8710 109 AOI21_X2
* cell instance $9881 r0 *1 153.52,110.6
X$9881 8710 8704 77 109 8977 NOR2_X1
* cell instance $9882 m0 *1 155.23,110.6
X$9882 8501 8811 77 109 8805 NOR2_X2
* cell instance $9883 m0 *1 153.9,110.6
X$9883 7299 8560 8274 77 109 8568 MUX2_X1
* cell instance $9884 m0 *1 156.18,110.6
X$9884 8709 8706 8810 77 109 8577 MUX2_X1
* cell instance $9887 m0 *1 160.74,110.6
X$9887 8650 8574 77 109 8711 NOR2_X1
* cell instance $9888 m0 *1 161.31,110.6
X$9888 8706 7299 8571 109 8576 77 OAI21_X1
* cell instance $9889 m0 *1 162.07,110.6
X$9889 77 8572 3358 8800 8713 8801 109 AOI22_X4
* cell instance $9890 m0 *1 165.3,110.6
X$9890 8704 8637 8576 77 8575 109 AOI21_X2
* cell instance $9892 m0 *1 166.82,110.6
X$9892 77 9053 8714 8634 2523 5690 109 NOR4_X4
* cell instance $9893 m0 *1 170.24,110.6
X$9893 77 8575 3574 9134 8791 8559 109 NOR4_X4
* cell instance $9897 r0 *1 154.66,110.6
X$9897 7299 8432 8805 8564 8504 8976 109 77 AOI221_X2
* cell instance $9899 r0 *1 157.13,110.6
X$9899 77 2182 6755 9049 8977 8712 8979 8368 109 OAI222_X2
* cell instance $9902 r0 *1 160.93,110.6
X$9902 8711 7299 9145 8805 8635 8801 109 77 AOI221_X2
* cell instance $9905 r0 *1 164.16,110.6
X$9905 8704 8802 77 109 8713 OR2_X1
* cell instance $9908 r0 *1 166.63,110.6
X$9908 8577 8699 77 109 8972 NAND2_X1
* cell instance $9910 r0 *1 167.39,110.6
X$9910 77 6602 3577 8968 6134 8970 109 OAI22_X4
* cell instance $9911 r0 *1 170.62,110.6
X$9911 7112 77 109 8103 INV_X1
* cell instance $9912 r0 *1 171,110.6
X$9912 7963 5278 9055 109 77 8886 HA_X1
* cell instance $9917 r0 *1 173.09,110.6
X$9917 6427 5553 8771 6471 77 8964 109 NAND4_X2
* cell instance $9918 m0 *1 174.99,110.6
X$9918 8579 6119 8479 77 8715 109 AOI21_X2
* cell instance $9919 m0 *1 174.04,110.6
X$9919 4758 6696 8789 6903 77 109 8579 NOR4_X1
* cell instance $9921 m0 *1 176.51,110.6
X$9921 6119 8716 5149 77 109 8628 MUX2_X1
* cell instance $9923 r0 *1 174.8,110.6
X$9923 5895 8286 77 109 8887 NAND2_X1
* cell instance $9925 r0 *1 175.75,110.6
X$9925 8479 8782 8961 8889 8960 7719 77 109 OAI221_X2
* cell instance $9926 r0 *1 177.84,110.6
X$9926 77 8285 18770 6826 8786 3676 109 DFFR_X1
* cell instance $9928 m0 *1 178.22,110.6
X$9928 6825 5541 8717 77 109 8580 MUX2_X1
* cell instance $9929 m0 *1 179.74,110.6
X$9929 6826 5541 8718 77 109 8786 MUX2_X1
* cell instance $9930 m0 *1 181.07,110.6
X$9930 8285 77 109 19135 INV_X1
* cell instance $9931 m0 *1 181.45,110.6
X$9931 7425 7965 8719 77 109 8720 MUX2_X1
* cell instance $9934 r0 *1 181.64,110.6
X$9934 77 8285 18864 7425 8720 3676 109 DFFR_X1
* cell instance $9935 m0 *1 186.01,110.6
X$9935 7966 77 109 19227 CLKBUF_X1
* cell instance $9936 m0 *1 184.68,110.6
X$9936 7528 8716 8584 77 109 8784 MUX2_X1
* cell instance $9939 m0 *1 190.38,110.6
X$9939 8891 8618 8443 77 109 8779 NAND3_X1
* cell instance $9940 m0 *1 191.14,110.6
X$9940 8779 8721 77 109 8954 NOR2_X1
* cell instance $9943 r0 *1 185.82,110.6
X$9943 77 7966 18863 7528 8784 3676 109 DFFR_X1
* cell instance $9947 r0 *1 190.95,110.6
X$9947 8952 8954 77 109 8165 XOR2_X1
* cell instance $9948 r0 *1 192.09,110.6
X$9948 8723 77 109 8892 INV_X1
* cell instance $9949 m0 *1 192.28,110.6
X$9949 77 8617 8618 8724 8320 109 DFF_X1
* cell instance $9952 r0 *1 192.47,110.6
X$9952 77 8952 8723 8951 8320 109 DFF_X1
* cell instance $9953 r0 *1 195.7,110.6
X$9953 8723 8893 8775 77 109 8951 MUX2_X1
* cell instance $9954 m0 *1 196.08,110.6
X$9954 8723 8725 8775 77 109 6943 MUX2_X1
* cell instance $9956 m0 *1 197.41,110.6
X$9956 6817 77 109 19099 INV_X2
* cell instance $9958 m0 *1 198.17,110.6
X$9958 77 8469 8773 8944 8320 109 DFF_X1
* cell instance $9959 m0 *1 201.4,110.6
X$9959 8443 8614 8726 77 109 8585 MUX2_X1
* cell instance $9962 r0 *1 197.03,110.6
X$9962 1236 77 109 6817 CLKBUF_X3
* cell instance $9963 r0 *1 197.98,110.6
X$9963 6817 77 109 8320 CLKBUF_X3
* cell instance $9965 r0 *1 199.12,110.6
X$9965 8773 8893 8896 77 109 8944 MUX2_X1
* cell instance $9969 r0 *1 201.78,110.6
X$9969 8773 8725 8896 77 109 6991 MUX2_X1
* cell instance $9973 m0 *1 204.63,110.6
X$9973 8443 8616 8726 77 109 6490 MUX2_X1
* cell instance $9974 m0 *1 206.72,110.6
X$9974 8111 4812 77 109 8727 NAND2_X1
* cell instance $9975 m0 *1 207.29,110.6
X$9975 8727 6376 77 109 8897 NAND2_X1
* cell instance $9976 m0 *1 207.86,110.6
X$9976 6121 8611 77 109 8898 NOR2_X1
* cell instance $9977 m0 *1 208.43,110.6
X$9977 8611 5405 77 109 8603 OR2_X1
* cell instance $9978 m0 *1 209.19,110.6
X$9978 6206 6233 109 77 8932 AND2_X2
* cell instance $9981 r0 *1 205.58,110.6
X$9981 8771 8616 9063 77 109 5370 MUX2_X1
* cell instance $9982 r0 *1 206.91,110.6
X$9982 8719 5756 77 109 8941 NAND2_X1
* cell instance $9983 r0 *1 207.48,110.6
X$9983 8897 8898 77 109 8899 NAND2_X1
* cell instance $9984 r0 *1 208.05,110.6
X$9984 8898 8941 7404 109 77 8904 AND3_X2
* cell instance $9985 r0 *1 209.19,110.6
X$9985 8611 109 8933 77 BUF_X4
* cell instance $9986 r0 *1 210.52,110.6
X$9986 8609 3327 8768 109 77 8729 HA_X1
* cell instance $9987 m0 *1 210.9,110.6
X$9987 4186 8728 77 109 8763 NOR2_X1
* cell instance $9988 m0 *1 210.52,110.6
X$9988 8768 77 109 8728 INV_X1
* cell instance $9990 m0 *1 212.04,110.6
X$9990 8726 8763 8729 109 77 9071 OAI21_X2
* cell instance $9995 r0 *1 212.99,110.6
X$9995 77 18396 8730 8900 7824 109 DFF_X1
* cell instance $9996 m0 *1 214.51,110.6
X$9996 8730 77 109 8726 CLKBUF_X2
* cell instance $9997 m0 *1 213.75,110.6
X$9997 6229 2394 8935 77 8900 109 AOI21_X1
* cell instance $10000 m0 *1 217.55,110.6
X$10000 4812 8733 5519 8587 5241 8732 109 77 AOI221_X2
* cell instance $10001 m0 *1 219.64,110.6
X$10001 8717 5756 77 109 8604 NAND2_X1
* cell instance $10003 m0 *1 220.4,110.6
X$10003 6638 6206 77 109 8921 NAND2_X1
* cell instance $10004 m0 *1 220.97,110.6
X$10004 77 7982 18681 8586 8756 992 109 DFFR_X1
* cell instance $10005 m0 *1 224.77,110.6
X$10005 6511 4855 8587 77 8755 109 AOI21_X1
* cell instance $10006 m0 *1 225.53,110.6
X$10006 8584 5756 7119 6121 6350 8924 109 77 AOI221_X2
* cell instance $10007 m0 *1 227.62,110.6
X$10007 6952 77 109 7982 CLKBUF_X3
* cell instance $10008 m0 *1 228.57,110.6
X$10008 8598 8124 77 109 8743 NAND2_X1
* cell instance $10010 m0 *1 229.33,110.6
X$10010 8747 8752 77 109 8753 NAND2_X1
* cell instance $10011 m0 *1 229.9,110.6
X$10011 8734 8754 5790 6340 3972 77 109 8752 AOI221_X1
* cell instance $10013 m0 *1 231.23,110.6
X$10013 8744 6961 7975 8749 77 109 8750 NAND4_X1
* cell instance $10014 m0 *1 232.18,110.6
X$10014 8587 4846 77 109 8747 NAND2_X1
* cell instance $10018 r0 *1 216.79,110.6
X$10018 8932 2394 8934 77 8731 109 AOI21_X1
* cell instance $10020 r0 *1 217.74,110.6
X$10020 4036 8732 77 109 9378 NOR2_X2
* cell instance $10022 r0 *1 218.88,110.6
X$10022 77 8903 8603 8734 7968 109 AOI21_X4
* cell instance $10024 r0 *1 221.54,110.6
X$10024 5806 5651 8587 77 9252 109 AOI21_X1
* cell instance $10028 r0 *1 224.77,110.6
X$10028 5756 109 8734 77 BUF_X4
* cell instance $10029 r0 *1 226.1,110.6
X$10029 8925 8734 7132 6121 7246 8923 109 77 AOI221_X2
* cell instance $10035 r0 *1 229.14,110.6
X$10035 77 9087 6223 8734 8718 109 AOI21_X4
* cell instance $10038 r0 *1 232.56,110.6
X$10038 7251 7688 8587 77 8918 109 AOI21_X1
* cell instance $10039 m0 *1 233.7,110.6
X$10039 77 8735 18693 8589 8741 992 109 DFFR_X1
* cell instance $10040 m0 *1 233.13,110.6
X$10040 8587 8296 77 109 8744 NAND2_X1
* cell instance $10042 r0 *1 233.32,110.6
X$10042 6501 6619 8587 77 8917 109 AOI21_X1
* cell instance $10045 r0 *1 235.98,110.6
X$10045 8910 77 109 5651 BUF_X1
* cell instance $10047 m0 *1 238.07,110.6
X$10047 8736 77 109 5241 BUF_X1
* cell instance $10049 m0 *1 238.64,110.6
X$10049 8738 77 109 4846 BUF_X1
* cell instance $10051 r0 *1 238.07,110.6
X$10051 8737 77 109 6619 BUF_X1
* cell instance $10057 m0 *1 3.23,161
X$10057 11858 6876 13198 77 109 13318 MUX2_X1
* cell instance $10059 m0 *1 5.51,161
X$10059 11858 7054 13255 77 109 13256 MUX2_X1
* cell instance $10062 m0 *1 11.4,161
X$10062 77 12555 13144 13258 13319 9814 109 DFFR_X1
* cell instance $10063 m0 *1 15.2,161
X$10063 13258 3782 11858 77 109 13319 MUX2_X1
* cell instance $10065 m0 *1 16.72,161
X$10065 13321 7059 13401 77 109 13478 MUX2_X1
* cell instance $10076 r0 *1 3.23,161
X$10076 77 12552 12846 13255 13256 4909 109 DFFR_X1
* cell instance $10079 r0 *1 7.98,161
X$10079 77 6158 109 3370 BUF_X8
* cell instance $10081 r0 *1 10.64,161
X$10081 77 12552 13400 13618 13543 9814 109 DFFR_X1
* cell instance $10082 r0 *1 14.44,161
X$10082 13399 7059 13400 77 109 13477 MUX2_X1
* cell instance $10083 r0 *1 15.77,161
X$10083 13400 3370 13401 77 109 13480 MUX2_X1
* cell instance $10084 r0 *1 17.1,161
X$10084 13477 11278 13478 77 109 13481 MUX2_X1
* cell instance $10086 m0 *1 18.43,161
X$10086 77 12069 13321 13324 13323 9814 109 DFFR_X1
* cell instance $10087 m0 *1 22.42,161
X$10087 9142 12709 13324 77 109 13323 MUX2_X1
* cell instance $10089 r0 *1 18.43,161
X$10089 13399 3370 13321 77 109 13479 MUX2_X1
* cell instance $10093 r0 *1 21.09,161
X$10093 13479 10952 13480 77 109 13148 MUX2_X1
* cell instance $10096 r0 *1 23.56,161
X$10096 13481 5818 13402 77 109 13495 MUX2_X1
* cell instance $10097 m0 *1 25.46,161
X$10097 77 12069 13260 13325 13259 9814 109 DFFR_X1
* cell instance $10098 m0 *1 24.13,161
X$10098 13325 4128 13096 77 109 13259 MUX2_X1
* cell instance $10099 m0 *1 29.26,161
X$10099 13029 4627 13260 77 109 13405 MUX2_X1
* cell instance $10100 m0 *1 30.59,161
X$10100 13261 2938 13260 77 109 13211 MUX2_X1
* cell instance $10103 r0 *1 24.89,161
X$10103 77 12069 13261 13404 13484 9814 109 DFFR_X1
* cell instance $10104 r0 *1 28.69,161
X$10104 13404 4126 13096 77 109 13484 MUX2_X1
* cell instance $10107 r0 *1 31.16,161
X$10107 13405 5451 77 109 13406 NAND2_X1
* cell instance $10108 r0 *1 31.73,161
X$10108 77 12856 13407 13625 13488 9814 109 DFFR_X1
* cell instance $10109 m0 *1 33.25,161
X$10109 77 12856 13030 13326 13327 9814 109 DFFR_X1
* cell instance $10111 m0 *1 37.05,161
X$10111 13150 2938 13407 77 109 13262 MUX2_X1
* cell instance $10114 m0 *1 39.33,161
X$10114 13331 6291 9337 77 109 13334 NOR3_X1
* cell instance $10118 r0 *1 35.53,161
X$10118 13326 13408 13544 77 109 13327 MUX2_X1
* cell instance $10120 r0 *1 37.24,161
X$10120 13407 12240 13030 77 109 13493 MUX2_X1
* cell instance $10124 r0 *1 39.9,161
X$10124 6236 13148 8858 109 13409 77 OAI21_X1
* cell instance $10125 r0 *1 40.66,161
X$10125 13409 13491 13334 77 109 13546 NOR3_X1
* cell instance $10127 r0 *1 41.61,161
X$10127 13493 8672 4643 77 109 13491 NOR3_X1
* cell instance $10130 m0 *1 103.93,124.6
X$10130 77 8067 6140 109 BUF_X16
* cell instance $10133 r0 *1 104.12,124.6
X$10133 9987 9831 9988 77 109 10257 MUX2_X1
* cell instance $10134 r0 *1 105.45,124.6
X$10134 9940 9027 10157 77 109 10115 MUX2_X1
* cell instance $10135 r0 *1 106.78,124.6
X$10135 77 10258 5420 5594 10112 109 AOI21_X4
* cell instance $10136 r0 *1 109.25,124.6
X$10136 6554 77 109 9989 BUF_X2
* cell instance $10138 m0 *1 109.82,124.6
X$10138 9942 9985 7647 77 109 9941 MUX2_X1
* cell instance $10139 m0 *1 114.19,124.6
X$10139 9989 6993 10120 77 109 10119 MUX2_X1
* cell instance $10145 r0 *1 112.48,124.6
X$10145 77 9833 10262 10120 10119 4086 109 DFFR_X1
* cell instance $10149 r0 *1 116.28,124.6
X$10149 10122 9667 9989 77 109 10264 MUX2_X1
* cell instance $10151 m0 *1 116.66,124.6
X$10151 77 8692 9669 9948 10123 4086 109 DFFR_X1
* cell instance $10152 m0 *1 123.5,124.6
X$10152 5163 5330 19037 109 77 9990 HA_X1
* cell instance $10159 r0 *1 121.98,124.6
X$10159 5163 5149 19073 109 77 10124 HA_X1
* cell instance $10160 r0 *1 123.88,124.6
X$10160 10124 6569 9990 77 109 10160 MUX2_X1
* cell instance $10162 m0 *1 126.92,124.6
X$10162 9991 9835 8829 109 77 10125 MUX2_X2
* cell instance $10163 m0 *1 126.54,124.6
X$10163 9203 77 109 9996 INV_X1
* cell instance $10164 m0 *1 128.63,124.6
X$10164 9993 9203 9837 77 9995 109 AOI21_X2
* cell instance $10165 m0 *1 129.96,124.6
X$10165 9671 77 109 9838 BUF_X1
* cell instance $10167 m0 *1 130.72,124.6
X$10167 9996 9992 77 109 9952 NAND2_X2
* cell instance $10169 m0 *1 131.86,124.6
X$10169 9952 9511 77 109 9997 NOR2_X1
* cell instance $10171 m0 *1 132.62,124.6
X$10171 9045 9510 77 109 9840 NOR2_X2
* cell instance $10172 m0 *1 133.57,124.6
X$10172 9843 9841 9673 77 9947 109 NAND3_X4
* cell instance $10173 m0 *1 136.04,124.6
X$10173 10121 9045 9203 77 109 9949 NAND3_X2
* cell instance $10174 m0 *1 137.37,124.6
X$10174 77 9839 9947 10121 10168 109 NOR3_X4
* cell instance $10177 r0 *1 126.92,124.6
X$10177 9509 9508 9992 77 109 9991 NAND3_X1
* cell instance $10178 r0 *1 127.68,124.6
X$10178 9508 109 9841 77 BUF_X4
* cell instance $10179 r0 *1 129.01,124.6
X$10179 8829 9673 9992 77 109 9993 NOR3_X1
* cell instance $10181 r0 *1 129.96,124.6
X$10181 9992 9841 9996 109 10268 77 OAI21_X1
* cell instance $10183 r0 *1 130.91,124.6
X$10183 10260 9675 9994 10263 9998 9999 109 77 AOI221_X2
* cell instance $10185 r0 *1 133.19,124.6
X$10185 9841 77 109 9512 INV_X4
* cell instance $10187 r0 *1 134.33,124.6
X$10187 9203 9951 77 109 10255 NOR2_X2
* cell instance $10188 r0 *1 135.28,124.6
X$10188 9951 10161 77 109 10121 NOR2_X2
* cell instance $10190 r0 *1 136.42,124.6
X$10190 77 9045 9947 10255 10165 109 NOR3_X4
* cell instance $10193 m0 *1 140.41,124.6
X$10193 9999 5482 5481 77 8995 109 AOI21_X2
* cell instance $10194 m0 *1 144.78,124.6
X$10194 7295 10118 9943 77 10114 109 AOI21_X2
* cell instance $10195 m0 *1 146.11,124.6
X$10195 8644 8705 77 109 10118 NAND2_X1
* cell instance $10197 m0 *1 148.2,124.6
X$10197 10117 8574 10116 109 77 6684 OAI21_X2
* cell instance $10202 r0 *1 140.98,124.6
X$10202 7169 6145 6911 77 10167 109 AOI21_X1
* cell instance $10203 r0 *1 141.74,124.6
X$10203 6911 77 109 10310 BUF_X2
* cell instance $10206 r0 *1 147.06,124.6
X$10206 8644 9171 10624 9844 9516 10117 109 77 AOI221_X2
* cell instance $10207 r0 *1 149.15,124.6
X$10207 9352 8705 9350 77 10116 109 AOI21_X1
* cell instance $10208 r0 *1 149.91,124.6
X$10208 77 10169 10114 10113 2299 9939 109 NOR4_X4
* cell instance $10209 m0 *1 153.14,124.6
X$10209 77 10077 3152 10111 9851 10112 109 NOR4_X4
* cell instance $10210 m0 *1 152.19,124.6
X$10210 9349 77 109 8635 CLKBUF_X3
* cell instance $10213 m0 *1 158.27,124.6
X$10213 8574 8500 10109 109 9049 77 OAI21_X1
* cell instance $10216 m0 *1 159.98,124.6
X$10216 10242 10107 9354 10108 6755 6680 77 109 OAI221_X2
* cell instance $10220 m0 *1 166.06,124.6
X$10220 7036 3651 10002 109 77 10004 HA_X1
* cell instance $10223 r0 *1 153.71,124.6
X$10223 8705 8635 77 109 10170 NAND2_X1
* cell instance $10227 r0 *1 156.37,124.6
X$10227 6605 4100 10245 109 77 10246 HA_X1
* cell instance $10231 r0 *1 161.88,124.6
X$10231 10173 77 109 9777 INV_X1
* cell instance $10233 r0 *1 162.45,124.6
X$10233 10000 9552 9524 77 10173 109 AOI21_X1
* cell instance $10236 r0 *1 165.11,124.6
X$10236 10097 10168 10001 9856 77 109 10238 AOI22_X1
* cell instance $10237 r0 *1 166.06,124.6
X$10237 4360 10176 10001 109 77 10097 HA_X1
* cell instance $10238 r0 *1 167.96,124.6
X$10238 10176 77 109 6398 INV_X2
* cell instance $10239 m0 *1 168.53,124.6
X$10239 9602 10005 9524 9396 77 109 9640 AOI22_X2
* cell instance $10241 m0 *1 170.24,124.6
X$10241 10007 7586 19053 109 77 10093 HA_X1
* cell instance $10248 r0 *1 172.33,124.6
X$10248 10007 77 109 10091 INV_X1
* cell instance $10249 m0 *1 173.66,124.6
X$10249 10089 10088 9858 77 9917 109 AOI21_X1
* cell instance $10250 m0 *1 172.52,124.6
X$10250 10008 9856 9362 10093 9287 77 109 10089 AOI221_X1
* cell instance $10254 m0 *1 176.89,124.6
X$10254 8479 10074 8831 8889 9860 7586 77 109 OAI221_X2
* cell instance $10256 r0 *1 172.71,124.6
X$10256 10091 7962 10008 109 77 10088 HA_X1
* cell instance $10260 r0 *1 175.94,124.6
X$10260 9762 8889 10085 109 77 10176 OAI21_X2
* cell instance $10261 r0 *1 177.27,124.6
X$10261 9910 8889 10083 109 77 6663 OAI21_X4
* cell instance $10263 m0 *1 179.36,124.6
X$10263 77 9593 18625 9861 10082 3676 109 DFFR_X1
* cell instance $10264 r0 *1 179.74,124.6
X$10264 9741 77 109 10081 BUF_X2
* cell instance $10267 r0 *1 181.64,124.6
X$10267 77 6927 10179 8282 10081 9124 10223 9694 109 AOI222_X4
* cell instance $10269 m0 *1 183.54,124.6
X$10269 77 10071 8105 9910 8282 10009 109 AOI22_X4
* cell instance $10271 m0 *1 187.72,124.6
X$10271 6699 8327 10179 6391 77 109 9904 AOI22_X1
* cell instance $10274 r0 *1 184.68,124.6
X$10274 10009 8106 9393 77 109 10079 MUX2_X1
* cell instance $10275 r0 *1 186.01,124.6
X$10275 77 10010 10079 3676 18973 10009 109 DFFR_X2
* cell instance $10277 m0 *1 189.05,124.6
X$10277 3916 8327 10009 6391 77 109 9906 AOI22_X1
* cell instance $10278 r0 *1 190.19,124.6
X$10278 6427 77 109 9058 BUF_X2
* cell instance $10279 m0 *1 190.57,124.6
X$10279 9058 10011 77 109 10074 NAND2_X1
* cell instance $10284 m0 *1 196.46,124.6
X$10284 9864 10070 109 7380 77 XOR2_X2
* cell instance $10289 r0 *1 192.66,124.6
X$10289 10019 9696 109 77 10223 AND2_X1
* cell instance $10293 r0 *1 194.75,124.6
X$10293 77 10070 10067 10181 10010 109 DFF_X1
* cell instance $10294 r0 *1 197.98,124.6
X$10294 10067 77 109 10013 BUF_X1
* cell instance $10297 r0 *1 199.12,124.6
X$10297 9704 10015 77 109 10220 NAND2_X1
* cell instance $10298 m0 *1 199.5,124.6
X$10298 10012 8582 10014 77 6238 109 AOI21_X2
* cell instance $10301 m0 *1 202.35,124.6
X$10301 10013 8616 10016 77 109 7991 MUX2_X1
* cell instance $10303 m0 *1 203.87,124.6
X$10303 10059 9866 109 77 9905 XNOR2_X1
* cell instance $10306 m0 *1 205.96,124.6
X$10306 77 10059 10019 10057 10018 109 DFF_X1
* cell instance $10309 m0 *1 210.14,124.6
X$10309 10019 8614 9706 77 109 10057 MUX2_X1
* cell instance $10312 m0 *1 212.42,124.6
X$10312 10011 8725 10183 77 109 6628 MUX2_X1
* cell instance $10316 m0 *1 216.22,124.6
X$10316 9538 8893 9382 77 109 10050 NAND3_X1
* cell instance $10317 m0 *1 216.98,124.6
X$10317 4307 9870 9710 109 9869 77 OAI21_X1
* cell instance $10319 r0 *1 199.69,124.6
X$10319 10056 10220 109 77 10014 XNOR2_X1
* cell instance $10321 r0 *1 201.59,124.6
X$10321 10015 10011 10182 10019 109 77 9749 AND4_X1
* cell instance $10322 r0 *1 202.73,124.6
X$10322 10218 10335 109 77 10219 XNOR2_X1
* cell instance $10323 r0 *1 203.87,124.6
X$10323 9704 10182 10011 10015 77 109 9866 NAND4_X1
* cell instance $10325 r0 *1 205.58,124.6
X$10325 10182 8616 10017 77 109 7533 MUX2_X1
* cell instance $10329 r0 *1 208.24,124.6
X$10329 77 10056 10054 10053 10018 109 DFF_X1
* cell instance $10331 r0 *1 211.66,124.6
X$10331 10011 8614 10183 77 109 10053 MUX2_X1
* cell instance $10332 r0 *1 212.99,124.6
X$10332 10054 77 109 10011 BUF_X1
* cell instance $10334 r0 *1 214.32,124.6
X$10334 4185 3593 77 109 9867 NOR2_X2
* cell instance $10336 r0 *1 215.65,124.6
X$10336 10017 3210 9867 77 109 10049 OR3_X1
* cell instance $10338 r0 *1 216.79,124.6
X$10338 10050 10049 10020 109 77 10184 AND3_X1
* cell instance $10341 m0 *1 218.12,124.6
X$10341 8893 4307 9698 77 109 10041 NOR3_X1
* cell instance $10342 m0 *1 219.64,124.6
X$10342 9871 9724 9078 77 109 10209 OR3_X4
* cell instance $10343 m0 *1 221.73,124.6
X$10343 10016 9702 9698 77 109 9871 NAND3_X1
* cell instance $10344 m0 *1 222.49,124.6
X$10344 9872 9068 9066 77 109 10021 NOR3_X1
* cell instance $10345 m0 *1 223.25,124.6
X$10345 9874 9702 9698 77 109 9872 NAND3_X1
* cell instance $10346 m0 *1 224.01,124.6
X$10346 9724 9078 77 109 9874 NOR2_X1
* cell instance $10347 m0 *1 224.58,124.6
X$10347 9698 9890 2900 9874 109 77 10040 AND4_X1
* cell instance $10348 m0 *1 225.72,124.6
X$10348 10039 10041 10040 77 109 9731 NOR3_X1
* cell instance $10350 m0 *1 226.67,124.6
X$10350 8924 8933 77 109 10022 NOR2_X1
* cell instance $10351 m0 *1 227.24,124.6
X$10351 9724 9078 9877 109 10023 77 OAI21_X1
* cell instance $10355 r0 *1 221.73,124.6
X$10355 10016 10021 109 77 10187 XNOR2_X1
* cell instance $10359 r0 *1 225.34,124.6
X$10359 9237 109 4812 77 BUF_X4
* cell instance $10360 r0 *1 226.67,124.6
X$10360 10022 2348 10023 77 10039 109 AOI21_X1
* cell instance $10364 r0 *1 227.43,124.6
X$10364 10188 77 109 9706 CLKBUF_X2
* cell instance $10367 m0 *1 228.38,124.6
X$10367 9887 10204 10037 77 9886 109 AOI21_X1
* cell instance $10369 m0 *1 230.09,124.6
X$10369 10027 10024 10034 109 77 10025 MUX2_X2
* cell instance $10371 m0 *1 232.56,124.6
X$10371 9878 77 109 9702 CLKBUF_X2
* cell instance $10372 m0 *1 233.32,124.6
X$10372 10030 3884 77 109 9879 NOR2_X1
* cell instance $10373 m0 *1 233.89,124.6
X$10373 10027 9879 109 77 9883 XNOR2_X1
* cell instance $10377 r0 *1 228.95,124.6
X$10377 10189 4812 77 109 10190 NAND2_X1
* cell instance $10378 r0 *1 229.52,124.6
X$10378 10034 7256 109 77 10191 AND2_X1
* cell instance $10379 r0 *1 230.28,124.6
X$10379 9093 9237 9862 77 10192 109 AOI21_X2
* cell instance $10380 r0 *1 231.61,124.6
X$10380 9554 77 109 19195 CLKBUF_X2
* cell instance $10382 r0 *1 232.56,124.6
X$10382 6206 10026 77 109 10193 NOR2_X2
* cell instance $10383 r0 *1 233.51,124.6
X$10383 10026 10194 10028 77 109 10029 MUX2_X1
* cell instance $10385 r0 *1 236.36,124.6
X$10385 77 18476 10026 10029 9554 109 DFF_X1
* cell instance $10388 m0 *1 165.11,149.8
X$10388 12276 77 109 11609 BUF_X2
* cell instance $10389 m0 *1 166.63,149.8
X$10389 8264 12365 5716 109 11158 77 OAI21_X1
* cell instance $10392 m0 *1 168.34,149.8
X$10392 12030 6398 12594 109 12364 77 OAI21_X1
* cell instance $10394 m0 *1 169.29,149.8
X$10394 12363 12364 12362 109 77 12360 HA_X1
* cell instance $10395 m0 *1 171.19,149.8
X$10395 12360 77 109 11753 CLKBUF_X2
* cell instance $10396 m0 *1 171.95,149.8
X$10396 12361 77 109 11618 BUF_X2
* cell instance $10397 m0 *1 172.71,149.8
X$10397 7235 12116 12278 109 12355 77 OAI21_X1
* cell instance $10400 r0 *1 165.3,149.8
X$10400 12527 12525 12276 109 77 12115 HA_X1
* cell instance $10402 r0 *1 167.58,149.8
X$10402 12030 7869 12523 109 12525 77 OAI21_X1
* cell instance $10405 r0 *1 170.62,149.8
X$10405 12362 77 109 11620 CLKBUF_X2
* cell instance $10409 r0 *1 171.38,149.8
X$10409 12518 12521 12361 109 77 12356 HA_X1
* cell instance $10410 r0 *1 173.28,149.8
X$10410 7520 12116 12598 109 12518 77 OAI21_X1
* cell instance $10412 m0 *1 173.85,149.8
X$10412 12355 12208 11757 109 77 12352 HA_X1
* cell instance $10416 r0 *1 174.61,149.8
X$10416 12030 7518 12669 109 12440 77 OAI21_X1
* cell instance $10417 r0 *1 175.37,149.8
X$10417 12030 7517 12441 109 12442 77 OAI21_X1
* cell instance $10418 r0 *1 176.13,149.8
X$10418 12273 7521 12443 109 12444 77 OAI21_X1
* cell instance $10420 m0 *1 176.89,149.8
X$10420 12352 11756 11757 77 12351 109 AOI21_X1
* cell instance $10421 m0 *1 177.84,149.8
X$10421 11760 77 109 12350 INV_X1
* cell instance $10422 m0 *1 178.22,149.8
X$10422 12350 12120 12351 109 77 12198 OAI21_X2
* cell instance $10423 m0 *1 179.55,149.8
X$10423 11933 77 109 12120 INV_X2
* cell instance $10426 r0 *1 177.27,149.8
X$10426 12274 12440 12279 109 77 12280 HA_X1
* cell instance $10429 r0 *1 180.12,149.8
X$10429 12279 12121 77 109 11762 NAND2_X2
* cell instance $10430 m0 *1 181.26,149.8
X$10430 12446 12198 12280 12279 12445 11764 109 77 AOI221_X2
* cell instance $10431 m0 *1 180.5,149.8
X$10431 12280 12279 12445 77 11819 109 AOI21_X1
* cell instance $10432 m0 *1 183.35,149.8
X$10432 12275 7370 12447 109 12344 77 OAI21_X1
* cell instance $10434 m0 *1 184.3,149.8
X$10434 12344 12192 12343 109 77 12188 HA_X1
* cell instance $10437 m0 *1 188.48,149.8
X$10437 12343 77 109 11943 BUF_X2
* cell instance $10438 m0 *1 189.24,149.8
X$10438 12282 77 109 12284 INV_X1
* cell instance $10439 m0 *1 189.62,149.8
X$10439 12283 11943 77 109 9399 XNOR2_X2
* cell instance $10440 m0 *1 191.52,149.8
X$10440 9399 77 109 12277 BUF_X1
* cell instance $10441 m0 *1 192.09,149.8
X$10441 11942 12187 12284 109 12450 77 OAI21_X1
* cell instance $10442 m0 *1 192.85,149.8
X$10442 11942 11945 12284 109 12285 77 OAI21_X1
* cell instance $10443 m0 *1 193.61,149.8
X$10443 12282 12000 12339 77 12338 109 AOI21_X2
* cell instance $10445 m0 *1 195.13,149.8
X$10445 12286 12000 77 109 12288 NAND2_X1
* cell instance $10446 m0 *1 195.7,149.8
X$10446 12125 12288 12287 109 12334 77 OAI21_X1
* cell instance $10447 m0 *1 196.46,149.8
X$10447 12287 11945 77 109 12337 NAND2_X1
* cell instance $10449 m0 *1 197.22,149.8
X$10449 12292 12337 12334 109 12335 77 OAI21_X1
* cell instance $10451 m0 *1 198.17,149.8
X$10451 12289 11947 12286 109 77 12293 AND3_X1
* cell instance $10452 m0 *1 199.12,149.8
X$10452 12290 12291 77 109 11949 XNOR2_X2
* cell instance $10454 r0 *1 181.07,149.8
X$10454 12445 12121 12198 77 12122 109 AOI21_X2
* cell instance $10455 r0 *1 182.4,149.8
X$10455 11762 77 109 12446 INV_X1
* cell instance $10458 r0 *1 183.35,149.8
X$10458 12346 12442 12663 109 77 11770 HA_X1
* cell instance $10460 r0 *1 185.63,149.8
X$10460 12509 12444 12508 109 77 12282 HA_X1
* cell instance $10461 r0 *1 187.53,149.8
X$10461 12508 77 109 12000 BUF_X2
* cell instance $10462 r0 *1 188.29,149.8
X$10462 12603 12281 12000 11943 77 109 12504 NAND4_X1
* cell instance $10463 r0 *1 189.24,149.8
X$10463 12451 12281 12282 77 12449 109 AOI21_X1
* cell instance $10464 r0 *1 190,149.8
X$10464 12448 12502 12283 12504 12507 12606 77 109 OAI221_X2
* cell instance $10465 r0 *1 192.09,149.8
X$10465 12451 12281 12450 77 12502 109 AOI21_X1
* cell instance $10466 r0 *1 192.85,149.8
X$10466 12451 12281 12285 77 12452 109 AOI21_X2
* cell instance $10467 r0 *1 194.18,149.8
X$10467 11952 12496 12452 109 12453 77 OAI21_X1
* cell instance $10468 r0 *1 194.94,149.8
X$10468 12281 77 109 12454 INV_X1
* cell instance $10469 r0 *1 195.32,149.8
X$10469 12456 12454 77 109 8754 XNOR2_X2
* cell instance $10470 r0 *1 197.22,149.8
X$10470 11947 12281 77 109 12496 NAND2_X1
* cell instance $10471 r0 *1 197.79,149.8
X$10471 11947 11769 77 109 12653 NAND2_X1
* cell instance $10472 r0 *1 198.36,149.8
X$10472 12457 12338 11807 12494 12609 12290 77 109 OAI221_X2
* cell instance $10473 r0 *1 200.45,149.8
X$10473 9393 77 109 12426 BUF_X1
* cell instance $10475 r0 *1 201.21,149.8
X$10475 12289 12291 109 77 12491 AND2_X1
* cell instance $10477 m0 *1 201.4,149.8
X$10477 12331 12292 11989 77 12332 109 AOI21_X1
* cell instance $10478 r0 *1 201.97,149.8
X$10478 12458 12455 12491 77 12128 109 AOI21_X2
* cell instance $10479 m0 *1 202.73,149.8
X$10479 12291 12293 109 77 11989 AND2_X1
* cell instance $10483 m0 *1 204.44,149.8
X$10483 12130 12131 11989 77 109 12294 NOR3_X1
* cell instance $10484 m0 *1 205.2,149.8
X$10484 12329 12294 77 109 12330 NOR2_X1
* cell instance $10488 r0 *1 203.3,149.8
X$10488 12611 77 109 12331 INV_X1
* cell instance $10491 r0 *1 204.82,149.8
X$10491 12488 12459 11951 77 109 12132 NAND3_X2
* cell instance $10492 r0 *1 206.15,149.8
X$10492 12460 12488 12461 77 12133 109 AOI21_X2
* cell instance $10493 r0 *1 207.48,149.8
X$10493 77 18469 12295 12487 12134 109 DFF_X1
* cell instance $10494 m0 *1 210.14,149.8
X$10494 12136 12135 109 77 12486 XNOR2_X1
* cell instance $10497 m0 *1 211.47,149.8
X$10497 12295 77 109 12136 INV_X1
* cell instance $10499 m0 *1 212.04,149.8
X$10499 77 12296 11779 12136 3592 109 AOI21_X4
* cell instance $10501 m0 *1 214.7,149.8
X$10501 12175 8930 109 77 12176 XNOR2_X1
* cell instance $10503 m0 *1 216.6,149.8
X$10503 77 18351 12139 12327 12134 109 DFF_X1
* cell instance $10504 m0 *1 219.83,149.8
X$10504 12139 11508 12325 77 109 12327 MUX2_X1
* cell instance $10505 m0 *1 221.16,149.8
X$10505 3592 8930 12140 109 12143 77 OAI21_X1
* cell instance $10506 m0 *1 221.92,149.8
X$10506 12141 12299 77 109 12325 XOR2_X1
* cell instance $10507 m0 *1 223.06,149.8
X$10507 12298 12141 12157 77 109 11959 NAND3_X1
* cell instance $10508 m0 *1 223.82,149.8
X$10508 11783 12297 12298 109 77 12299 AND3_X1
* cell instance $10510 r0 *1 210.71,149.8
X$10510 12486 4307 12484 77 109 12487 MUX2_X1
* cell instance $10511 r0 *1 212.04,149.8
X$10511 12462 11648 77 109 12484 XOR2_X1
* cell instance $10513 r0 *1 213.56,149.8
X$10513 12482 11629 7983 77 12464 109 AOI21_X2
* cell instance $10516 r0 *1 215.84,149.8
X$10516 12463 12161 77 109 12175 NOR2_X1
* cell instance $10519 r0 *1 218.31,149.8
X$10519 12465 12297 11783 77 109 12462 NAND3_X1
* cell instance $10522 r0 *1 220.02,149.8
X$10522 10828 12480 10034 109 77 12467 OAI21_X4
* cell instance $10524 r0 *1 222.87,149.8
X$10524 12466 12464 12143 109 77 12298 AND3_X1
* cell instance $10526 r0 *1 224.2,149.8
X$10526 12296 12467 12167 12299 77 109 12300 NAND4_X1
* cell instance $10527 m0 *1 225.91,149.8
X$10527 12300 12317 12318 109 12476 77 OAI21_X1
* cell instance $10528 m0 *1 225.15,149.8
X$10528 10342 11784 12304 109 12156 77 OAI21_X1
* cell instance $10529 m0 *1 226.67,149.8
X$10529 12301 11197 77 109 12317 NAND2_X1
* cell instance $10530 m0 *1 227.24,149.8
X$10530 77 18349 12158 12316 12302 109 DFF_X1
* cell instance $10532 m0 *1 230.66,149.8
X$10532 77 18356 12303 12314 12621 109 DFF_X1
* cell instance $10533 m0 *1 233.89,149.8
X$10533 3822 12303 77 109 12146 NAND2_X1
* cell instance $10534 m0 *1 234.46,149.8
X$10534 12145 77 109 12308 BUF_X1
* cell instance $10535 m0 *1 235.03,149.8
X$10535 12147 12304 11180 77 109 12309 MUX2_X1
* cell instance $10536 m0 *1 236.36,149.8
X$10536 77 18354 12147 12310 12621 109 DFF_X1
* cell instance $10540 r0 *1 225.72,149.8
X$10540 10654 12300 12619 77 109 12477 MUX2_X1
* cell instance $10544 r0 *1 227.05,149.8
X$10544 12477 12476 77 109 12316 OR2_X1
* cell instance $10547 r0 *1 228.76,149.8
X$10547 8124 109 10034 77 BUF_X4
* cell instance $10550 r0 *1 233.51,149.8
X$10550 12629 12304 12159 77 109 12622 MUX2_X1
* cell instance $10552 r0 *1 235.22,149.8
X$10552 12313 77 109 12149 BUF_X1
* cell instance $10555 r0 *1 236.36,149.8
X$10555 12468 12305 12473 77 109 12623 MUX2_X1
* cell instance $10556 r0 *1 237.69,149.8
X$10556 12359 77 109 12148 BUF_X1
* cell instance $10557 r0 *1 238.26,149.8
X$10557 12309 77 109 12306 BUF_X1
* cell instance $10559 r0 *1 239.02,149.8
X$10559 12472 77 109 12307 BUF_X1
* cell instance $10561 m0 *1 25.27,79.8
X$10561 5444 2931 5804 77 109 5723 MUX2_X1
* cell instance $10562 m0 *1 23.94,79.8
X$10562 5461 109 5729 77 BUF_X4
* cell instance $10563 m0 *1 26.6,79.8
X$10563 77 5722 6019 5804 5723 2157 109 DFFR_X1
* cell instance $10564 m0 *1 30.4,79.8
X$10564 5870 77 109 4897 BUF_X2
* cell instance $10565 m0 *1 31.16,79.8
X$10565 5807 5805 4767 77 109 5724 MUX2_X1
* cell instance $10566 m0 *1 32.49,79.8
X$10566 5808 4631 4897 77 109 5809 MUX2_X1
* cell instance $10567 m0 *1 33.82,79.8
X$10567 5725 109 3784 77 BUF_X4
* cell instance $10568 m0 *1 35.15,79.8
X$10568 77 4899 5727 5808 5809 2157 109 DFFR_X1
* cell instance $10569 m0 *1 38.95,79.8
X$10569 3892 77 109 5174 BUF_X2
* cell instance $10570 m0 *1 39.71,79.8
X$10570 5309 109 5020 77 BUF_X4
* cell instance $10572 m0 *1 20.71,79.8
X$10572 5719 5661 5796 77 109 5721 MUX2_X1
* cell instance $10576 r0 *1 20.52,79.8
X$10576 5868 5580 5720 77 109 5940 MUX2_X1
* cell instance $10577 r0 *1 21.85,79.8
X$10577 5721 6017 5940 77 109 5942 MUX2_X1
* cell instance $10581 r0 *1 24.51,79.8
X$10581 5942 5818 5943 77 109 5869 MUX2_X1
* cell instance $10584 r0 *1 27.55,79.8
X$10584 5870 77 109 5444 BUF_X2
* cell instance $10587 r0 *1 29.45,79.8
X$10587 77 5722 5871 6025 6096 2157 109 DFFR_X1
* cell instance $10589 r0 *1 33.63,79.8
X$10589 5948 5949 6163 77 109 5872 MUX2_X1
* cell instance $10590 r0 *1 34.96,79.8
X$10590 4773 109 5310 77 BUF_X4
* cell instance $10591 r0 *1 36.29,79.8
X$10591 77 4773 5580 109 BUF_X16
* cell instance $10592 r0 *1 41.04,79.8
X$10592 77 4773 5951 109 BUF_X32
* cell instance $10593 m0 *1 41.61,79.8
X$10593 77 5728 4773 109 BUF_X32
* cell instance $10595 m0 *1 50.92,79.8
X$10595 6042 5175 109 77 5730 AND2_X1
* cell instance $10596 m0 *1 51.68,79.8
X$10596 2367 5536 2704 77 109 6028 MUX2_X1
* cell instance $10598 r0 *1 50.35,79.8
X$10598 3489 3995 3180 77 109 5874 MUX2_X1
* cell instance $10599 r0 *1 51.68,79.8
X$10599 5953 109 5110 77 BUF_X4
* cell instance $10601 m0 *1 2.66,144.2
X$10601 10752 7054 11791 77 109 11792 MUX2_X1
* cell instance $10603 m0 *1 3.99,144.2
X$10603 77 11262 11441 11791 11792 4909 109 DFFR_X1
* cell instance $10605 r0 *1 2.47,144.2
X$10605 9961 77 109 11262 CLKBUF_X3
* cell instance $10609 r0 *1 3.42,144.2
X$10609 77 11262 11853 11966 11965 4909 109 DFFR_X1
* cell instance $10611 r0 *1 7.41,144.2
X$10611 11697 7760 11698 77 109 11855 MUX2_X1
* cell instance $10613 m0 *1 8.17,144.2
X$10613 12062 5446 11795 77 109 11699 MUX2_X1
* cell instance $10615 m0 *1 12.73,144.2
X$10615 11582 2633 10429 77 109 11638 MUX2_X1
* cell instance $10618 r0 *1 8.74,144.2
X$10618 11699 9175 11855 77 109 11806 MUX2_X1
* cell instance $10621 r0 *1 13.49,144.2
X$10621 77 11701 12245 11700 11968 9814 109 DFFR_X1
* cell instance $10622 m0 *1 15.39,144.2
X$10622 11518 3782 10752 77 109 11640 MUX2_X1
* cell instance $10624 m0 *1 16.72,144.2
X$10624 11583 7059 11641 77 109 11642 MUX2_X1
* cell instance $10625 m0 *1 18.05,144.2
X$10625 77 11701 11271 11702 11801 9814 109 DFFR_X1
* cell instance $10626 m0 *1 21.85,144.2
X$10626 11702 4128 10429 77 109 11801 MUX2_X1
* cell instance $10629 m0 *1 24.13,144.2
X$10629 9175 109 3482 77 BUF_X4
* cell instance $10630 m0 *1 25.46,144.2
X$10630 9175 109 4284 77 BUF_X4
* cell instance $10633 m0 *1 30.02,144.2
X$10633 9175 109 10368 77 BUF_X4
* cell instance $10634 m0 *1 31.35,144.2
X$10634 77 5446 3173 109 BUF_X16
* cell instance $10635 m0 *1 36.1,144.2
X$10635 77 7997 109 7022 BUF_X8
* cell instance $10637 r0 *1 17.29,144.2
X$10637 11700 2631 11857 77 109 11968 MUX2_X1
* cell instance $10640 r0 *1 19.19,144.2
X$10640 9961 77 109 11701 CLKBUF_X3
* cell instance $10643 r0 *1 23.94,144.2
X$10643 11703 5959 12163 77 109 11809 MUX2_X1
* cell instance $10645 r0 *1 25.65,144.2
X$10645 10273 109 11858 77 BUF_X4
* cell instance $10646 r0 *1 26.98,144.2
X$10646 10273 109 11857 77 BUF_X4
* cell instance $10648 r0 *1 28.5,144.2
X$10648 77 10951 11862 11981 11860 9814 109 DFFR_X1
* cell instance $10649 r0 *1 32.3,144.2
X$10649 77 11704 11863 11983 11861 9814 109 DFFR_X1
* cell instance $10651 r0 *1 36.48,144.2
X$10651 11806 7617 77 109 11866 NOR2_X1
* cell instance $10652 r0 *1 37.05,144.2
X$10652 11866 11985 7022 109 11987 77 NOR3_X2
* cell instance $10653 r0 *1 38.38,144.2
X$10653 77 11684 11987 8152 11809 109 AOI21_X4
* cell instance $10654 m0 *1 42.75,144.2
X$10654 3445 77 109 10674 CLKBUF_X3
* cell instance $10655 m0 *1 38.95,144.2
X$10655 77 11704 11445 11814 11655 9814 109 DFFR_X1
* cell instance $10656 m0 *1 43.7,144.2
X$10656 11705 10763 9631 77 11655 109 AOI21_X1
* cell instance $10657 m0 *1 44.46,144.2
X$10657 9631 11814 77 109 11705 NOR2_X1
* cell instance $10660 m0 *1 46.74,144.2
X$10660 6140 109 8005 77 BUF_X4
* cell instance $10661 m0 *1 48.07,144.2
X$10661 11585 9972 9667 77 11817 109 AOI21_X1
* cell instance $10662 m0 *1 48.83,144.2
X$10662 9667 11818 77 109 11585 NOR2_X1
* cell instance $10663 m0 *1 49.4,144.2
X$10663 77 9974 11588 11659 11542 9814 109 DFFR_X1
* cell instance $10665 r0 *1 40.85,144.2
X$10665 77 11116 11654 11991 11816 9814 109 DFFR_X1
* cell instance $10666 r0 *1 44.65,144.2
X$10666 10674 77 109 19191 CLKBUF_X3
* cell instance $10667 r0 *1 45.6,144.2
X$10667 11706 10763 9824 77 11816 109 AOI21_X1
* cell instance $10668 r0 *1 46.36,144.2
X$10668 9824 11991 77 109 11706 NOR2_X1
* cell instance $10670 r0 *1 47.31,144.2
X$10670 77 11116 11868 11818 11817 9814 109 DFFR_X1
* cell instance $10674 r0 *1 52.44,144.2
X$10674 11707 9972 9832 77 11993 109 AOI21_X1
* cell instance $10675 r0 *1 53.2,144.2
X$10675 9832 11869 77 109 11707 NOR2_X1
* cell instance $10677 m0 *1 53.58,144.2
X$10677 11587 6627 11588 77 109 11821 MUX2_X1
* cell instance $10679 r0 *1 53.77,144.2
X$10679 11821 6091 11660 77 109 11871 MUX2_X1
* cell instance $10680 r0 *1 55.1,144.2
X$10680 10967 5017 11871 77 109 11872 MUX2_X1
* cell instance $10681 m0 *1 57.38,144.2
X$10681 77 11125 109 5446 BUF_X8
* cell instance $10682 m0 *1 56.05,144.2
X$10682 2633 109 9830 77 BUF_X4
* cell instance $10683 m0 *1 59.85,144.2
X$10683 11823 11448 9829 77 11663 109 AOI21_X1
* cell instance $10684 m0 *1 60.61,144.2
X$10684 11550 6997 77 109 11668 NOR2_X1
* cell instance $10685 m0 *1 61.18,144.2
X$10685 9829 11664 77 109 11823 NOR2_X1
* cell instance $10688 m0 *1 62.7,144.2
X$10688 77 11708 11711 11670 11589 9814 109 DFFR_X1
* cell instance $10690 m0 *1 67.26,144.2
X$10690 11711 4496 11712 77 109 11455 MUX2_X1
* cell instance $10692 m0 *1 69.35,144.2
X$10692 77 7776 11551 11826 11592 11714 9570 9912 109 OAI222_X2
* cell instance $10698 r0 *1 58.71,144.2
X$10698 77 11283 12002 11873 11998 9814 109 DFFR_X1
* cell instance $10702 r0 *1 62.51,144.2
X$10702 6975 11709 77 109 12001 NOR2_X1
* cell instance $10703 r0 *1 63.08,144.2
X$10703 77 8152 11710 11668 11713 109 NOR3_X4
* cell instance $10705 r0 *1 67.26,144.2
X$10705 12003 8229 11712 77 109 12080 MUX2_X1
* cell instance $10708 r0 *1 69.73,144.2
X$10708 12082 7197 11457 77 109 12006 MUX2_X1
* cell instance $10709 r0 *1 71.06,144.2
X$10709 77 11593 11874 11830 12012 4086 109 DFFR_X1
* cell instance $10710 m0 *1 78.47,144.2
X$10710 11715 3896 11595 77 109 11833 MUX2_X1
* cell instance $10711 m0 *1 74.67,144.2
X$10711 77 11593 11715 11674 11828 8687 109 DFFR_X1
* cell instance $10713 m0 *1 81.32,144.2
X$10713 11835 11461 11597 77 109 11718 MUX2_X1
* cell instance $10717 r0 *1 74.86,144.2
X$10717 11830 9830 11289 77 109 12012 MUX2_X1
* cell instance $10721 r0 *1 77.52,144.2
X$10721 11874 7447 11715 77 109 11716 MUX2_X1
* cell instance $10722 r0 *1 78.85,144.2
X$10722 11716 11240 11596 77 109 11717 MUX2_X1
* cell instance $10725 r0 *1 81.32,144.2
X$10725 11833 4320 11718 77 109 12015 MUX2_X1
* cell instance $10727 r0 *1 83.03,144.2
X$10727 77 11291 11876 11841 11842 8687 109 DFFR_X1
* cell instance $10729 m0 *1 85.31,144.2
X$10729 11841 6524 11293 77 109 11842 MUX2_X1
* cell instance $10730 m0 *1 87.4,144.2
X$10730 11719 5513 11720 77 109 11721 MUX2_X1
* cell instance $10733 r0 *1 86.83,144.2
X$10733 11875 3624 11876 77 109 11719 MUX2_X1
* cell instance $10735 r0 *1 88.35,144.2
X$10735 7638 8627 11721 77 12020 109 AOI21_X1
* cell instance $10737 r0 *1 89.3,144.2
X$10737 77 11296 11875 12021 12017 8201 109 DFFR_X1
* cell instance $10738 m0 *1 90.82,144.2
X$10738 11598 11461 11844 77 109 11722 MUX2_X1
* cell instance $10740 m0 *1 92.15,144.2
X$10740 11722 4320 11570 77 109 11878 MUX2_X1
* cell instance $10741 m0 *1 93.48,144.2
X$10741 11598 10149 11844 77 109 11723 MUX2_X1
* cell instance $10742 m0 *1 94.81,144.2
X$10742 11723 8375 11599 77 109 12024 MUX2_X1
* cell instance $10743 m0 *1 96.14,144.2
X$10743 77 11296 11598 11724 11848 8201 109 DFFR_X1
* cell instance $10744 m0 *1 99.94,144.2
X$10744 11724 9829 11573 77 109 11848 MUX2_X1
* cell instance $10753 r0 *1 95.95,144.2
X$10753 12024 8499 77 109 11879 NOR2_X1
* cell instance $10755 r0 *1 96.71,144.2
X$10755 11296 77 109 19259 CLKBUF_X1
* cell instance $10758 r0 *1 98.42,144.2
X$10758 11850 9834 11573 77 109 12027 MUX2_X1
* cell instance $10759 r0 *1 99.75,144.2
X$10759 77 11296 11882 11850 12027 8201 109 DFFR_X1
* cell instance $10760 r0 *1 103.55,144.2
X$10760 77 11416 12094 11725 12032 8201 109 DFFR_X1
* cell instance $10761 m0 *1 108.3,144.2
X$10761 77 11416 11726 11851 11852 8201 109 DFFR_X1
* cell instance $10762 m0 *1 106.97,144.2
X$10762 11851 9027 11293 77 109 11852 MUX2_X1
* cell instance $10763 m0 *1 112.1,144.2
X$10763 11466 8345 11467 77 109 11849 MUX2_X1
* cell instance $10766 m0 *1 115.71,144.2
X$10766 77 8152 109 7022 BUF_X8
* cell instance $10767 m0 *1 118.18,144.2
X$10767 11696 10299 11729 77 109 11468 MUX2_X1
* cell instance $10769 r0 *1 107.35,144.2
X$10769 11725 9503 11573 77 109 12032 MUX2_X1
* cell instance $10772 r0 *1 110.39,144.2
X$10772 11883 8067 11726 77 109 11884 MUX2_X1
* cell instance $10773 r0 *1 111.72,144.2
X$10773 11883 9023 11726 77 109 11727 MUX2_X1
* cell instance $10774 r0 *1 113.05,144.2
X$10774 11727 4774 11849 77 109 11885 MUX2_X1
* cell instance $10775 r0 *1 114.38,144.2
X$10775 9989 8166 12039 77 109 11728 MUX2_X1
* cell instance $10779 r0 *1 115.71,144.2
X$10779 77 10982 11729 12039 11728 4086 109 DFFR_X1
* cell instance $10781 r0 *1 119.7,144.2
X$10781 9989 8235 11847 77 109 11730 MUX2_X1
* cell instance $10782 m0 *1 120.08,144.2
X$10782 77 10982 11469 11847 11730 4086 109 DFFR_X1
* cell instance $10785 m0 *1 125.4,144.2
X$10785 5163 11301 19055 109 77 11845 HA_X1
* cell instance $10786 m0 *1 127.3,144.2
X$10786 11845 109 10789 77 BUF_X4
* cell instance $10792 r0 *1 125.78,144.2
X$10792 10789 77 109 11846 INV_X2
* cell instance $10793 r0 *1 126.35,144.2
X$10793 10733 77 109 11472 INV_X1
* cell instance $10794 r0 *1 126.73,144.2
X$10794 11895 77 109 11889 INV_X1
* cell instance $10796 r0 *1 127.3,144.2
X$10796 11731 11890 11892 109 77 11796 MUX2_X2
* cell instance $10798 r0 *1 129.2,144.2
X$10798 8334 12043 11892 109 77 11637 MUX2_X2
* cell instance $10799 m0 *1 129.96,144.2
X$10799 10125 9465 11690 109 77 11142 OAI21_X4
* cell instance $10802 m0 *1 132.62,144.2
X$10802 9675 5716 77 109 11688 NOR2_X1
* cell instance $10803 m0 *1 133.19,144.2
X$10803 11843 10302 9643 11688 12048 109 77 AOI211_X2
* cell instance $10804 m0 *1 134.9,144.2
X$10804 11896 7793 5434 6430 77 109 11840 NAND4_X1
* cell instance $10805 m0 *1 135.85,144.2
X$10805 7035 7095 7631 77 109 11839 NOR3_X1
* cell instance $10806 m0 *1 136.61,144.2
X$10806 12101 11306 10797 11686 11307 11600 77 109 OAI221_X2
* cell instance $10807 m0 *1 138.7,144.2
X$10807 11306 11732 10797 11839 11307 10636 77 109 OAI221_X2
* cell instance $10808 m0 *1 140.79,144.2
X$10808 11306 11838 10797 11733 11307 11484 77 109 OAI221_X2
* cell instance $10810 r0 *1 130.91,144.2
X$10810 11472 6847 12044 109 12045 77 OAI21_X1
* cell instance $10812 r0 *1 131.86,144.2
X$10812 6599 12045 11892 109 77 11794 MUX2_X2
* cell instance $10813 r0 *1 133.57,144.2
X$10813 11896 11831 77 109 11843 NAND2_X1
* cell instance $10814 r0 *1 134.14,144.2
X$10814 12050 11142 12048 11897 77 109 7968 AOI211_X4
* cell instance $10815 r0 *1 136.23,144.2
X$10815 11142 77 109 11837 INV_X2
* cell instance $10817 r0 *1 136.99,144.2
X$10817 7035 7095 4643 77 109 12052 NOR3_X1
* cell instance $10818 r0 *1 137.75,144.2
X$10818 11306 11731 10797 12052 11307 11152 77 109 OAI221_X2
* cell instance $10819 r0 *1 139.84,144.2
X$10819 11735 11840 11898 77 11832 109 AOI21_X2
* cell instance $10821 r0 *1 141.36,144.2
X$10821 7035 7095 11829 77 109 11733 NOR3_X1
* cell instance $10823 r0 *1 142.5,144.2
X$10823 11734 11900 77 109 11737 NAND2_X1
* cell instance $10824 r0 *1 143.07,144.2
X$10824 11735 11736 77 109 11901 NOR2_X1
* cell instance $10825 m0 *1 143.45,144.2
X$10825 11836 11837 11680 77 109 11834 MUX2_X1
* cell instance $10827 m0 *1 144.78,144.2
X$10827 11834 109 8957 77 BUF_X4
* cell instance $10830 r0 *1 143.64,144.2
X$10830 11902 11737 11901 77 11738 109 AOI21_X1
* cell instance $10831 r0 *1 144.4,144.2
X$10831 12056 77 109 11903 INV_X1
* cell instance $10834 r0 *1 146.49,144.2
X$10834 11739 11831 77 109 11735 NAND2_X1
* cell instance $10835 r0 *1 147.06,144.2
X$10835 11739 77 109 11906 INV_X1
* cell instance $10836 m0 *1 147.44,144.2
X$10836 11482 11600 109 77 12682 XNOR2_X1
* cell instance $10840 m0 *1 150.29,144.2
X$10840 11480 10636 109 77 11741 XNOR2_X1
* cell instance $10842 m0 *1 152.19,144.2
X$10842 4298 11603 109 77 11742 XNOR2_X1
* cell instance $10843 m0 *1 153.33,144.2
X$10843 4356 11603 109 77 11909 XNOR2_X1
* cell instance $10845 r0 *1 147.44,144.2
X$10845 12058 12060 11832 109 77 11748 OAI21_X4
* cell instance $10847 r0 *1 150.1,144.2
X$10847 77 11896 12058 11739 11831 11490 109 AND4_X4
* cell instance $10848 r0 *1 152.57,144.2
X$10848 12054 77 109 11739 BUF_X1
* cell instance $10849 r0 *1 153.14,144.2
X$10849 11742 11908 11743 77 109 12057 MUX2_X1
* cell instance $10850 r0 *1 154.47,144.2
X$10850 11745 11483 109 77 12370 XNOR2_X1
* cell instance $10851 m0 *1 157.32,144.2
X$10851 6479 11480 109 77 12046 XNOR2_X1
* cell instance $10852 m0 *1 154.85,144.2
X$10852 77 11480 109 11603 BUF_X8
* cell instance $10854 m0 *1 158.65,144.2
X$10854 11745 11484 109 77 11919 XNOR2_X1
* cell instance $10857 r0 *1 155.8,144.2
X$10857 11918 11678 11744 77 11913 109 AOI21_X2
* cell instance $10859 r0 *1 157.51,144.2
X$10859 11745 11152 109 77 12049 XNOR2_X1
* cell instance $10860 r0 *1 158.65,144.2
X$10860 12040 77 109 11678 BUF_X2
* cell instance $10862 r0 *1 159.79,144.2
X$10862 11827 11908 12042 77 109 11922 MUX2_X1
* cell instance $10863 m0 *1 160.36,144.2
X$10863 11549 109 11745 77 BUF_X4
* cell instance $10865 m0 *1 161.69,144.2
X$10865 4491 11745 109 77 11827 XNOR2_X1
* cell instance $10869 r0 *1 162.07,144.2
X$10869 11923 11910 11918 77 11749 109 AOI21_X2
* cell instance $10870 m0 *1 164.35,144.2
X$10870 11490 11609 77 109 11608 NAND2_X1
* cell instance $10871 m0 *1 163.21,144.2
X$10871 5080 11745 109 77 11746 XNOR2_X1
* cell instance $10873 m0 *1 165.11,144.2
X$10873 11747 10302 9673 9643 11619 109 77 AOI211_X2
* cell instance $10874 m0 *1 166.82,144.2
X$10874 11749 11748 77 109 11612 NAND2_X2
* cell instance $10875 m0 *1 167.77,144.2
X$10875 11748 11749 109 77 11610 AND2_X1
* cell instance $10876 m0 *1 168.53,144.2
X$10876 11609 11610 11671 77 109 11611 MUX2_X1
* cell instance $10877 m0 *1 169.86,144.2
X$10877 11490 11609 77 109 11671 NOR2_X1
* cell instance $10880 r0 *1 164.92,144.2
X$10880 11490 11924 11609 77 109 11747 NAND3_X1
* cell instance $10882 r0 *1 165.87,144.2
X$10882 11609 77 109 11925 INV_X1
* cell instance $10884 r0 *1 166.44,144.2
X$10884 11925 11749 11927 109 12036 77 OAI21_X1
* cell instance $10886 r0 *1 167.39,144.2
X$10886 11928 11748 11750 109 77 11622 OAI21_X4
* cell instance $10888 r0 *1 170.05,144.2
X$10888 11924 11609 77 109 11750 NAND2_X2
* cell instance $10889 m0 *1 171,144.2
X$10889 11751 11750 11752 77 11825 109 AOI21_X1
* cell instance $10891 m0 *1 171.76,144.2
X$10891 11618 11825 11753 109 77 11754 OAI21_X2
* cell instance $10892 m0 *1 173.09,144.2
X$10892 11822 11752 109 77 11824 AND2_X1
* cell instance $10894 m0 *1 174.04,144.2
X$10894 11753 77 109 11822 INV_X1
* cell instance $10896 r0 *1 171,144.2
X$10896 11620 77 109 11751 INV_X1
* cell instance $10900 r0 *1 171.38,144.2
X$10900 11751 11752 11822 109 12026 77 OAI21_X1
* cell instance $10901 r0 *1 172.14,144.2
X$10901 77 11768 11754 11824 11926 109 AOI21_X4
* cell instance $10902 r0 *1 174.61,144.2
X$10902 11618 12026 109 77 11755 AND2_X1
* cell instance $10904 m0 *1 174.8,144.2
X$10904 11493 11490 11491 77 109 11614 NAND3_X1
* cell instance $10905 m0 *1 175.75,144.2
X$10905 11493 11612 11491 77 109 11615 NAND3_X1
* cell instance $10906 m0 *1 176.51,144.2
X$10906 11616 11493 11490 77 109 11613 NAND3_X1
* cell instance $10908 m0 *1 177.46,144.2
X$10908 11495 11750 77 109 11493 NOR2_X2
* cell instance $10909 m0 *1 178.41,144.2
X$10909 11616 11753 11618 77 109 11815 NAND3_X1
* cell instance $10911 m0 *1 179.36,144.2
X$10911 11610 11617 11820 11762 11819 11625 77 109 OAI221_X2
* cell instance $10912 m0 *1 181.45,144.2
X$10912 11620 11618 11621 109 77 11661 AND3_X1
* cell instance $10914 r0 *1 175.37,144.2
X$10914 11756 11755 77 109 11492 OR2_X1
* cell instance $10915 r0 *1 176.13,144.2
X$10915 11755 11756 77 109 11758 NOR2_X1
* cell instance $10916 r0 *1 176.7,144.2
X$10916 11757 109 11491 77 BUF_X4
* cell instance $10917 r0 *1 178.03,144.2
X$10917 11931 11758 11759 109 11932 77 OAI21_X1
* cell instance $10918 r0 *1 178.79,144.2
X$10918 11757 77 109 11931 INV_X1
* cell instance $10919 r0 *1 179.17,144.2
X$10919 11760 11933 11932 77 11820 109 AOI21_X1
* cell instance $10920 r0 *1 179.93,144.2
X$10920 11933 11757 77 109 11935 NAND2_X2
* cell instance $10921 r0 *1 180.88,144.2
X$10921 11495 11935 11761 109 11937 77 OAI21_X1
* cell instance $10922 r0 *1 181.64,144.2
X$10922 11761 77 109 12016 INV_X1
* cell instance $10923 r0 *1 182.02,144.2
X$10923 11762 11935 77 109 11616 NOR2_X2
* cell instance $10925 m0 *1 182.78,144.2
X$10925 11762 11935 11765 109 11813 77 NOR3_X2
* cell instance $10927 r0 *1 183.35,144.2
X$10927 11661 11622 11619 109 77 11950 OAI21_X2
* cell instance $10928 m0 *1 184.68,144.2
X$10928 11763 11769 11616 109 77 11621 AND3_X1
* cell instance $10930 m0 *1 185.63,144.2
X$10930 11766 77 109 12011 INV_X1
* cell instance $10932 m0 *1 186.2,144.2
X$10932 77 11807 11767 11813 11768 109 AOI21_X4
* cell instance $10933 m0 *1 188.67,144.2
X$10933 11812 12005 77 109 11624 OR2_X2
* cell instance $10937 r0 *1 184.68,144.2
X$10937 11765 11815 11764 77 11811 109 AOI21_X1
* cell instance $10938 r0 *1 185.44,144.2
X$10938 11763 77 109 11765 INV_X1
* cell instance $10939 r0 *1 185.82,144.2
X$10939 12011 11765 11764 109 77 11767 OAI21_X2
* cell instance $10941 r0 *1 187.34,144.2
X$10941 11940 11764 12011 77 109 12007 NAND3_X2
* cell instance $10942 r0 *1 188.67,144.2
X$10942 77 11812 12007 11810 12283 11939 109 OAI22_X4
* cell instance $10943 r0 *1 191.9,144.2
X$10943 11770 77 109 11772 INV_X1
* cell instance $10945 m0 *1 192.28,144.2
X$10945 11763 11766 11769 109 11656 77 OAI21_X1
* cell instance $10948 r0 *1 192.28,144.2
X$10948 11769 11811 11766 109 77 11773 OAI21_X2
* cell instance $10949 r0 *1 193.61,144.2
X$10949 11771 11656 11772 77 11810 109 AOI21_X2
* cell instance $10950 r0 *1 194.94,144.2
X$10950 11772 11773 109 77 11777 AND2_X2
* cell instance $10951 m0 *1 196.84,144.2
X$10951 77 11626 11653 11652 10556 109 NOR3_X4
* cell instance $10952 m0 *1 195.7,144.2
X$10952 11496 11605 11946 109 77 11626 AND3_X2
* cell instance $10953 m0 *1 199.5,144.2
X$10953 9236 11775 11776 11627 109 11499 77 OR4_X2
* cell instance $10955 r0 *1 195.89,144.2
X$10955 11773 11772 77 109 11808 NAND2_X1
* cell instance $10956 r0 *1 196.46,144.2
X$10956 77 11653 11774 11496 11605 109 AOI21_X4
* cell instance $10957 r0 *1 198.93,144.2
X$10957 11769 11807 77 109 9101 XNOR2_X2
* cell instance $10958 r0 *1 200.83,144.2
X$10958 11777 11605 11496 77 109 12292 NAND3_X1
* cell instance $10959 m0 *1 201.78,144.2
X$10959 77 11805 11804 11650 11778 10189 109 NOR4_X4
* cell instance $10960 m0 *1 201.21,144.2
X$10960 11651 11777 77 109 11805 NOR2_X1
* cell instance $10963 m0 *1 209.76,144.2
X$10963 7838 11500 8933 109 11779 77 NOR3_X2
* cell instance $10964 m0 *1 211.09,144.2
X$10964 7838 11500 77 109 11648 NOR2_X1
* cell instance $10966 r0 *1 201.59,144.2
X$10966 11777 11605 11496 77 109 11952 AND3_X4
* cell instance $10968 r0 *1 204.06,144.2
X$10968 12182 11605 11496 77 109 11990 NAND3_X2
* cell instance $10969 r0 *1 205.39,144.2
X$10969 10189 77 109 11775 BUF_X2
* cell instance $10972 r0 *1 210.71,144.2
X$10972 11328 11169 109 77 11988 XNOR2_X1
* cell instance $10973 r0 *1 211.85,144.2
X$10973 77 18474 11802 11780 11172 109 DFF_X1
* cell instance $10975 m0 *1 212.04,144.2
X$10975 11779 10204 11803 77 11780 109 AOI21_X1
* cell instance $10977 m0 *1 214.51,144.2
X$10977 10855 77 109 11172 CLKBUF_X3
* cell instance $10978 m0 *1 215.46,144.2
X$10978 11802 77 109 10819 CLKBUF_X2
* cell instance $10980 m0 *1 216.41,144.2
X$10980 11783 9398 77 109 11799 XOR2_X1
* cell instance $10981 m0 *1 217.55,144.2
X$10981 11799 11955 10204 11781 77 109 11800 AOI22_X1
* cell instance $10983 m0 *1 220.02,144.2
X$10983 77 18355 11630 11645 11785 109 DFF_X1
* cell instance $10987 m0 *1 228.57,144.2
X$10987 11786 11508 11797 77 109 11798 MUX2_X1
* cell instance $10988 m0 *1 229.9,144.2
X$10988 77 10030 11787 10025 11783 109 NOR3_X4
* cell instance $10992 r0 *1 215.27,144.2
X$10992 77 18486 11782 11800 11172 109 DFF_X1
* cell instance $10993 r0 *1 218.5,144.2
X$10993 11782 11197 11984 109 11781 77 OAI21_X1
* cell instance $10995 r0 *1 219.64,144.2
X$10995 11783 11197 11782 77 109 11984 NAND3_X1
* cell instance $10998 r0 *1 222.3,144.2
X$10998 10342 77 109 11957 INV_X1
* cell instance $10999 r0 *1 222.68,144.2
X$10999 11959 11982 11957 77 11958 109 AOI21_X1
* cell instance $11000 r0 *1 223.44,144.2
X$11000 3884 11959 11784 109 12164 77 OAI21_X1
* cell instance $11001 r0 *1 224.2,144.2
X$11001 11784 77 109 11982 INV_X1
* cell instance $11004 r0 *1 226.29,144.2
X$11004 77 18467 11786 11798 11785 109 DFF_X1
* cell instance $11008 r0 *1 229.52,144.2
X$11008 11785 77 109 19296 CLKBUF_X1
* cell instance $11010 r0 *1 230.28,144.2
X$11010 11787 11509 109 77 11797 XNOR2_X1
* cell instance $11011 r0 *1 231.42,144.2
X$11011 11186 77 109 11785 CLKBUF_X3
* cell instance $11012 r0 *1 232.37,144.2
X$11012 11786 77 109 11975 INV_X1
* cell instance $11013 r0 *1 232.75,144.2
X$11013 11796 77 109 11790 BUF_X1
* cell instance $11014 r0 *1 233.32,144.2
X$11014 11788 10498 10663 77 109 11969 MUX2_X1
* cell instance $11016 m0 *1 234.46,144.2
X$11016 11632 10500 11793 77 109 11639 MUX2_X1
* cell instance $11018 m0 *1 236.74,144.2
X$11018 11794 77 109 11635 BUF_X1
* cell instance $11019 m0 *1 237.31,144.2
X$11019 11960 10498 11175 77 109 11789 MUX2_X1
* cell instance $11020 m0 *1 238.64,144.2
X$11020 11793 77 109 11634 BUF_X1
* cell instance $11022 r0 *1 234.65,144.2
X$11022 11788 10500 11969 77 109 11970 MUX2_X1
* cell instance $11024 r0 *1 236.36,144.2
X$11024 77 18406 11960 11967 10196 109 DFF_X1
* cell instance $11027 m0 *1 155.99,172.2
X$11027 11437 14300 14343 77 109 14458 MUX2_X1
* cell instance $11028 m0 *1 154.66,172.2
X$11028 13373 109 14210 77 BUF_X4
* cell instance $11030 m0 *1 157.51,172.2
X$11030 14207 14226 77 109 14455 NAND2_X1
* cell instance $11032 m0 *1 158.27,172.2
X$11032 13706 14124 14457 77 109 14300 NAND3_X1
* cell instance $11033 m0 *1 159.03,172.2
X$11033 14065 77 109 13373 INV_X4
* cell instance $11035 m0 *1 160.17,172.2
X$11035 14065 109 14226 77 BUF_X4
* cell instance $11037 m0 *1 152.95,172.2
X$11037 13292 109 14208 77 BUF_X4
* cell instance $11038 m0 *1 150.29,172.2
X$11038 77 10892 14208 14342 13287 14210 14215 13244 109 OAI222_X2
* cell instance $11041 r0 *1 150.48,172.2
X$11041 77 10228 14208 14489 13287 14210 14348 13241 109 OAI222_X2
* cell instance $11042 r0 *1 153.14,172.2
X$11042 77 14493 18808 14343 14458 12731 109 DFFR_X1
* cell instance $11043 r0 *1 156.94,172.2
X$11043 11829 14561 77 109 10938 NAND2_X2
* cell instance $11044 r0 *1 157.89,172.2
X$11044 14163 14343 8514 77 14456 109 AOI21_X1
* cell instance $11045 r0 *1 158.65,172.2
X$11045 14457 14212 14455 14456 109 77 14454 OAI22_X1
* cell instance $11046 r0 *1 159.6,172.2
X$11046 11309 5763 14344 77 109 14494 OR3_X1
* cell instance $11047 r0 *1 160.55,172.2
X$11047 5472 14454 109 77 14344 AND2_X1
* cell instance $11048 r0 *1 161.31,172.2
X$11048 14344 5763 10242 77 109 14346 NOR3_X1
* cell instance $11049 m0 *1 163.59,172.2
X$11049 14213 14448 14293 13070 14214 77 109 14452 AOI221_X1
* cell instance $11050 m0 *1 161.88,172.2
X$11050 8514 8265 77 14435 109 NAND2_X4
* cell instance $11051 m0 *1 164.73,172.2
X$11051 14018 14153 77 109 14293 NOR2_X1
* cell instance $11052 m0 *1 165.3,172.2
X$11052 14557 77 109 14087 CLKBUF_X3
* cell instance $11053 m0 *1 166.25,172.2
X$11053 14087 14212 77 109 14345 NOR2_X2
* cell instance $11054 m0 *1 167.2,172.2
X$11054 14213 14212 77 109 14351 NAND2_X2
* cell instance $11057 r0 *1 162.26,172.2
X$11057 77 14493 14452 12731 12993 14153 109 DFFR_X2
* cell instance $11058 r0 *1 166.44,172.2
X$11058 14345 14067 77 109 13950 NAND2_X1
* cell instance $11059 r0 *1 167.01,172.2
X$11059 14346 77 109 14018 CLKBUF_X3
* cell instance $11060 r0 *1 167.96,172.2
X$11060 9764 14347 14533 109 14448 77 OAI21_X1
* cell instance $11062 m0 *1 168.53,172.2
X$11062 10242 13447 13119 77 14679 109 AOI21_X1
* cell instance $11063 r0 *1 168.72,172.2
X$11063 12822 13447 77 14550 109 NAND2_X4
* cell instance $11065 m0 *1 169.67,172.2
X$11065 77 14446 14217 13832 14069 12731 109 DFFR_X1
* cell instance $11066 r0 *1 170.43,172.2
X$11066 77 13295 109 5472 BUF_X8
* cell instance $11070 r0 *1 172.9,172.2
X$11070 14296 12815 109 77 14497 AND2_X1
* cell instance $11073 m0 *1 173.85,172.2
X$11073 77 14446 14350 14215 14071 12731 109 DFFR_X1
* cell instance $11074 r0 *1 174.04,172.2
X$11074 13070 14348 13359 10228 14349 14540 77 109 OAI221_X2
* cell instance $11076 r0 *1 176.89,172.2
X$11076 14350 77 109 12755 BUF_X2
* cell instance $11077 r0 *1 177.65,172.2
X$11077 14351 109 13709 77 BUF_X4
* cell instance $11078 m0 *1 178.22,172.2
X$11078 14219 12819 13841 77 14352 109 AOI21_X1
* cell instance $11080 m0 *1 178.98,172.2
X$11080 13959 12199 77 109 14219 NOR2_X1
* cell instance $11081 m0 *1 179.55,172.2
X$11081 14437 13303 77 109 14013 NAND2_X1
* cell instance $11083 m0 *1 180.31,172.2
X$11083 13968 13585 14352 77 109 14437 MUX2_X1
* cell instance $11085 m0 *1 181.83,172.2
X$11085 14258 14435 14220 77 109 14430 MUX2_X1
* cell instance $11087 m0 *1 183.35,172.2
X$11087 77 13844 14355 12731 12757 14348 109 DFFR_X2
* cell instance $11089 r0 *1 178.98,172.2
X$11089 14354 14415 10083 14345 77 109 14439 AOI22_X1
* cell instance $11091 r0 *1 180.31,172.2
X$11091 14352 14081 13709 11165 14079 14542 109 77 AOI221_X2
* cell instance $11092 r0 *1 182.4,172.2
X$11092 14430 14353 77 109 14432 NAND2_X1
* cell instance $11094 r0 *1 183.16,172.2
X$11094 14353 77 109 13303 CLKBUF_X3
* cell instance $11096 r0 *1 184.3,172.2
X$11096 14540 14422 14424 77 14355 109 AOI21_X1
* cell instance $11098 r0 *1 185.44,172.2
X$11098 14537 13454 77 109 14424 NAND2_X1
* cell instance $11100 r0 *1 186.2,172.2
X$11100 14221 14081 13709 9399 14079 14422 109 77 AOI221_X2
* cell instance $11102 m0 *1 187.91,172.2
X$11102 14222 13585 14221 77 109 14356 MUX2_X1
* cell instance $11103 m0 *1 189.43,172.2
X$11103 13842 14408 14087 14225 14354 77 109 OAI211_X2
* cell instance $11104 m0 *1 191.14,172.2
X$11104 77 13883 13842 14226 14211 14357 109 NOR4_X4
* cell instance $11105 m0 *1 194.56,172.2
X$11105 13643 14070 14229 77 109 14267 OR3_X1
* cell instance $11106 m0 *1 195.51,172.2
X$11106 14086 14124 14267 109 14359 77 OAI21_X1
* cell instance $11107 m0 *1 196.27,172.2
X$11107 13844 77 109 19132 INV_X1
* cell instance $11110 r0 *1 188.67,172.2
X$11110 14356 13454 77 109 14418 NAND2_X1
* cell instance $11112 r0 *1 189.62,172.2
X$11112 14084 9393 77 109 14534 NOR2_X1
* cell instance $11114 r0 *1 190.57,172.2
X$11114 14656 13883 14357 9393 14226 14415 109 77 AOI221_X2
* cell instance $11115 r0 *1 192.66,172.2
X$11115 14086 14228 14227 109 14533 77 OAI21_X1
* cell instance $11116 r0 *1 193.42,172.2
X$11116 14410 109 13842 77 BUF_X4
* cell instance $11117 r0 *1 194.75,172.2
X$11117 14231 77 109 14268 INV_X1
* cell instance $11119 r0 *1 195.32,172.2
X$11119 77 14358 18731 14410 14359 3676 109 DFFR_X1
* cell instance $11121 m0 *1 197.03,172.2
X$11121 14230 14087 14266 77 109 14408 NAND3_X1
* cell instance $11122 m0 *1 197.98,172.2
X$11122 13593 14266 14230 77 14264 109 AOI21_X1
* cell instance $11123 m0 *1 198.74,172.2
X$11123 77 13844 14404 3676 13961 14235 109 DFFR_X2
* cell instance $11124 m0 *1 202.92,172.2
X$11124 14236 13961 14084 77 109 14402 OR3_X1
* cell instance $11125 m0 *1 203.87,172.2
X$11125 14402 77 109 14090 BUF_X2
* cell instance $11128 m0 *1 205.58,172.2
X$11128 14238 14361 109 77 13755 AND2_X1
* cell instance $11131 r0 *1 199.12,172.2
X$11131 14263 14624 14233 109 14404 77 OAI21_X1
* cell instance $11132 r0 *1 199.88,172.2
X$11132 14084 77 109 14223 CLKBUF_X3
* cell instance $11134 r0 *1 201.59,172.2
X$11134 13996 14234 77 109 14504 NOR2_X1
* cell instance $11135 r0 *1 202.16,172.2
X$11135 14504 13755 77 109 14229 NAND2_X1
* cell instance $11137 r0 *1 205.77,172.2
X$11137 13633 14397 77 109 14230 OR2_X1
* cell instance $11139 r0 *1 206.72,172.2
X$11139 14396 14238 77 109 13330 NAND2_X2
* cell instance $11140 m0 *1 207.67,172.2
X$11140 14360 14394 109 77 14237 AND2_X1
* cell instance $11143 m0 *1 209.19,172.2
X$11143 14394 14238 77 109 13329 NAND2_X1
* cell instance $11145 r0 *1 207.67,172.2
X$11145 14396 14360 77 109 14397 NAND2_X2
* cell instance $11147 r0 *1 209.38,172.2
X$11147 13464 77 109 14109 CLKBUF_X3
* cell instance $11148 m0 *1 210.52,172.2
X$11148 14090 13330 14255 109 14258 77 OAI21_X1
* cell instance $11149 m0 *1 210.14,172.2
X$11149 14393 77 109 14257 INV_X1
* cell instance $11151 m0 *1 211.47,172.2
X$11151 14390 14109 14258 13967 77 109 14393 AOI22_X1
* cell instance $11155 r0 *1 212.04,172.2
X$11155 14361 14360 77 109 14365 NAND2_X2
* cell instance $11157 m0 *1 212.8,172.2
X$11157 14361 14238 77 109 13467 NAND2_X1
* cell instance $11160 r0 *1 212.99,172.2
X$11160 14362 14238 77 109 13722 NAND2_X1
* cell instance $11163 r0 *1 214.7,172.2
X$11163 14363 77 109 14507 INV_X1
* cell instance $11165 r0 *1 215.46,172.2
X$11165 14525 14109 14508 13967 77 109 14363 AOI22_X1
* cell instance $11166 r0 *1 216.41,172.2
X$11166 14386 14109 14222 13967 77 109 14364 AOI22_X1
* cell instance $11167 r0 *1 217.36,172.2
X$11167 14364 77 109 14388 INV_X1
* cell instance $11168 m0 *1 217.74,172.2
X$11168 14365 13602 14387 109 14092 77 OAI21_X1
* cell instance $11174 r0 *1 217.93,172.2
X$11174 77 13854 14521 14386 14388 3676 109 DFFR_X1
* cell instance $11176 m0 *1 223.63,172.2
X$11176 77 18299 14239 14383 13854 109 DFF_X1
* cell instance $11178 m0 *1 226.86,172.2
X$11178 14239 13201 14240 77 109 14383 MUX2_X1
* cell instance $11182 r0 *1 226.67,172.2
X$11182 14366 13613 12619 77 109 14367 MUX2_X1
* cell instance $11186 r0 *1 228,172.2
X$11186 14366 13201 14367 77 109 14519 MUX2_X1
* cell instance $11188 m0 *1 228.57,172.2
X$11188 77 18375 14241 14251 13476 109 DFF_X1
* cell instance $11189 m0 *1 231.99,172.2
X$11189 6359 77 109 14371 BUF_X1
* cell instance $11190 m0 *1 232.56,172.2
X$11190 14379 13201 14242 77 109 14380 MUX2_X1
* cell instance $11191 m0 *1 233.89,172.2
X$11191 77 18385 14243 14376 13476 109 DFF_X1
* cell instance $11196 r0 *1 230.28,172.2
X$11196 13716 77 109 14633 BUF_X1
* cell instance $11197 r0 *1 230.85,172.2
X$11197 77 18464 14379 14380 13854 109 DFF_X1
* cell instance $11198 r0 *1 234.08,172.2
X$11198 14243 13201 14244 77 109 14376 MUX2_X1
* cell instance $11199 r0 *1 235.41,172.2
X$11199 8111 77 109 14375 BUF_X1
* cell instance $11201 r0 *1 236.17,172.2
X$11201 14242 77 109 14368 BUF_X1
* cell instance $11204 r0 *1 237.31,172.2
X$11204 14240 77 109 14369 BUF_X1
* cell instance $11205 r0 *1 237.88,172.2
X$11205 14367 77 109 14510 BUF_X1
* cell instance $11206 r0 *1 238.45,172.2
X$11206 14375 77 109 14247 BUF_X1
* cell instance $11207 r0 *1 239.02,172.2
X$11207 14244 77 109 14246 BUF_X1
* cell instance $11209 m0 *1 239.02,172.2
X$11209 14371 77 109 14100 BUF_X1
* cell instance $11211 m0 *1 3.42,113.4
X$11211 9003 6280 8833 77 109 8912 MUX2_X1
* cell instance $11214 m0 *1 4.94,113.4
X$11214 7180 77 109 8661 CLKBUF_X3
* cell instance $11217 m0 *1 7.6,113.4
X$11217 77 8661 8836 8834 8916 4909 109 DFFR_X1
* cell instance $11218 m0 *1 11.4,113.4
X$11218 8834 5301 8051 77 109 8916 MUX2_X1
* cell instance $11220 m0 *1 13.49,113.4
X$11220 8835 4138 8836 77 109 8594 MUX2_X1
* cell instance $11222 m0 *1 15.01,113.4
X$11222 8837 3043 8919 77 109 9088 MUX2_X1
* cell instance $11233 r0 *1 2.66,113.4
X$11233 9002 77 109 5551 CLKBUF_X3
* cell instance $11238 r0 *1 3.99,113.4
X$11238 9007 6214 9083 77 109 9084 MUX2_X1
* cell instance $11239 r0 *1 5.32,113.4
X$11239 77 8661 9004 9083 9084 4909 109 DFFR_X1
* cell instance $11243 r0 *1 10.45,113.4
X$11243 9175 109 6704 77 BUF_X4
* cell instance $11246 r0 *1 13.68,113.4
X$11246 77 9005 9244 8919 9088 4909 109 DFFR_X1
* cell instance $11247 r0 *1 17.48,113.4
X$11247 77 9005 9006 9092 9089 4909 109 DFFR_X1
* cell instance $11248 m0 *1 19.19,113.4
X$11248 8837 3594 9092 77 109 9089 MUX2_X1
* cell instance $11252 r0 *1 21.28,113.4
X$11252 77 8664 9250 8926 9008 4909 109 DFFR_X1
* cell instance $11254 m0 *1 21.66,113.4
X$11254 9007 5178 8926 77 109 9008 MUX2_X1
* cell instance $11256 m0 *1 23.94,113.4
X$11256 77 8664 8838 8839 8927 4909 109 DFFR_X1
* cell instance $11260 r0 *1 25.65,113.4
X$11260 7180 77 109 8664 CLKBUF_X3
* cell instance $11261 r0 *1 26.6,113.4
X$11261 8664 77 109 19285 CLKBUF_X1
* cell instance $11265 m0 *1 28.12,113.4
X$11265 77 8664 8842 8841 8840 4909 109 DFFR_X1
* cell instance $11267 m0 *1 35.15,113.4
X$11267 8842 8666 9097 77 109 9098 MUX2_X1
* cell instance $11268 m0 *1 36.48,113.4
X$11268 8920 6296 77 109 8846 NOR2_X1
* cell instance $11269 m0 *1 37.05,113.4
X$11269 8842 3861 9097 77 109 8939 MUX2_X1
* cell instance $11270 m0 *1 38.38,113.4
X$11270 9098 6902 77 109 8844 NOR2_X1
* cell instance $11271 m0 *1 38.95,113.4
X$11271 8939 7292 77 109 8845 NOR2_X1
* cell instance $11272 m0 *1 39.52,113.4
X$11272 8845 8938 3599 77 109 8943 NOR3_X1
* cell instance $11273 m0 *1 40.28,113.4
X$11273 8846 9100 6369 109 9179 77 NOR3_X2
* cell instance $11274 m0 *1 41.61,113.4
X$11274 8942 8943 6291 109 9102 77 NOR3_X2
* cell instance $11275 m0 *1 42.94,113.4
X$11275 77 8627 9102 6971 8875 109 NOR3_X4
* cell instance $11276 m0 *1 45.6,113.4
X$11276 8948 6890 4907 109 77 8945 OAI21_X4
* cell instance $11277 m0 *1 48.07,113.4
X$11277 9010 5506 9011 77 109 9012 MUX2_X1
* cell instance $11278 m0 *1 49.4,113.4
X$11278 7160 9105 77 109 8948 NAND2_X1
* cell instance $11281 r0 *1 28.5,113.4
X$11281 9003 5656 9094 77 109 9253 MUX2_X1
* cell instance $11284 r0 *1 33.06,113.4
X$11284 77 8525 9097 9009 9095 4909 109 DFFR_X1
* cell instance $11285 r0 *1 36.86,113.4
X$11285 9009 5020 2540 77 109 9095 MUX2_X1
* cell instance $11287 r0 *1 38.38,113.4
X$11287 77 9178 109 4205 BUF_X8
* cell instance $11289 r0 *1 41.61,113.4
X$11289 5672 6296 77 7742 109 NAND2_X4
* cell instance $11292 r0 *1 43.89,113.4
X$11292 77 8674 9011 9105 8945 4909 109 DFFR_X1
* cell instance $11294 r0 *1 48.07,113.4
X$11294 9010 8847 9011 77 109 9107 MUX2_X1
* cell instance $11295 r0 *1 49.4,113.4
X$11295 7201 9106 77 109 9013 NAND2_X1
* cell instance $11297 m0 *1 26.03,203
X$11297 16790 15375 16732 77 109 16704 MUX2_X1
* cell instance $11298 m0 *1 24.7,203
X$11298 16790 10138 16732 77 109 16570 MUX2_X1
* cell instance $11299 m0 *1 27.36,203
X$11299 16734 10138 16638 77 109 16637 MUX2_X1
* cell instance $11300 m0 *1 28.69,203
X$11300 16734 15375 16638 77 109 16796 MUX2_X1
* cell instance $11301 m0 *1 30.02,203
X$11301 16704 12240 16796 77 109 16035 MUX2_X1
* cell instance $11304 m0 *1 33.06,203
X$11304 16898 13548 15167 77 109 16795 MUX2_X1
* cell instance $11308 m0 *1 22.99,203
X$11308 16700 10508 16069 77 109 16699 MUX2_X1
* cell instance $11309 r0 *1 22.99,203
X$11309 77 16942 16732 16733 16792 9814 109 DFFR_X1
* cell instance $11310 r0 *1 26.79,203
X$11310 16733 12481 16069 77 109 16792 MUX2_X1
* cell instance $11314 r0 *1 30.21,203
X$11314 77 16573 16423 16898 16795 4086 109 DFFR_X1
* cell instance $11316 r0 *1 34.2,203
X$11316 14461 77 109 16573 CLKBUF_X3
* cell instance $11317 r0 *1 35.15,203
X$11317 16735 8535 16855 77 109 16798 MUX2_X1
* cell instance $11318 m0 *1 36.48,203
X$11318 16856 11278 16903 77 109 15653 MUX2_X1
* cell instance $11324 r0 *1 36.86,203
X$11324 16737 11276 16736 77 109 16903 MUX2_X1
* cell instance $11327 r0 *1 38.76,203
X$11327 16737 7153 16736 77 109 16857 MUX2_X1
* cell instance $11329 r0 *1 40.28,203
X$11329 16798 3978 16857 77 109 16908 MUX2_X1
* cell instance $11330 m0 *1 41.8,203
X$11330 16738 3978 16640 77 109 16740 MUX2_X1
* cell instance $11331 m0 *1 40.47,203
X$11331 16502 8535 16639 77 109 16738 MUX2_X1
* cell instance $11332 m0 *1 43.13,203
X$11332 16740 9652 16908 77 109 15729 MUX2_X1
* cell instance $11335 m0 *1 49.02,203
X$11335 16802 4627 16743 77 109 16744 MUX2_X1
* cell instance $11336 m0 *1 50.35,203
X$11336 16744 6299 16806 77 109 15530 MUX2_X1
* cell instance $11339 m0 *1 52.63,203
X$11339 16745 4627 16642 77 109 16806 MUX2_X1
* cell instance $11343 r0 *1 41.61,203
X$11343 16800 8535 16739 77 109 16640 MUX2_X1
* cell instance $11344 r0 *1 42.94,203
X$11344 16800 10957 16739 77 109 16582 MUX2_X1
* cell instance $11348 r0 *1 46.36,203
X$11348 16948 9812 16741 77 109 16802 MUX2_X1
* cell instance $11349 r0 *1 47.69,203
X$11349 16742 10283 16910 77 109 16641 MUX2_X1
* cell instance $11350 r0 *1 49.02,203
X$11350 16858 9812 17006 77 109 16743 MUX2_X1
* cell instance $11353 r0 *1 52.25,203
X$11353 16859 9812 16746 77 109 16745 MUX2_X1
* cell instance $11354 r0 *1 53.58,203
X$11354 16859 10957 16746 77 109 16808 MUX2_X1
* cell instance $11356 r0 *1 55.1,203
X$11356 14135 77 109 16330 CLKBUF_X3
* cell instance $11357 r0 *1 56.05,203
X$11357 16330 77 109 19257 CLKBUF_X1
* cell instance $11360 r0 *1 58.33,203
X$11360 16809 10440 16747 77 109 16748 MUX2_X1
* cell instance $11361 m0 *1 59.09,203
X$11361 16809 11563 16747 77 109 16811 MUX2_X1
* cell instance $11367 r0 *1 59.66,203
X$11367 16748 10283 16914 77 109 16430 MUX2_X1
* cell instance $11368 m0 *1 60.99,203
X$11368 16811 3373 16643 77 109 16079 MUX2_X1
* cell instance $11373 r0 *1 60.99,203
X$11373 16860 10440 16749 77 109 16914 MUX2_X1
* cell instance $11376 r0 *1 64.22,203
X$11376 77 15861 16815 16917 16916 8687 109 DFFR_X1
* cell instance $11377 m0 *1 65.17,203
X$11377 77 15861 16507 16716 16644 8687 109 DFFR_X1
* cell instance $11380 m0 *1 69.16,203
X$11380 16751 4627 16645 77 109 16193 MUX2_X1
* cell instance $11383 m0 *1 74.29,203
X$11383 77 16752 16509 16718 16819 8687 109 DFFR_X1
* cell instance $11385 r0 *1 68.02,203
X$11385 16750 9812 16815 77 109 16751 MUX2_X1
* cell instance $11387 r0 *1 69.73,203
X$11387 16431 6993 16818 77 109 16918 MUX2_X1
* cell instance $11388 r0 *1 71.06,203
X$11388 77 16752 16861 16818 16918 8687 109 DFFR_X1
* cell instance $11390 r0 *1 75.05,203
X$11390 16750 8993 16815 77 109 16510 MUX2_X1
* cell instance $11393 m0 *1 79.23,203
X$11393 9666 12709 16920 77 109 16822 MUX2_X1
* cell instance $11394 m0 *1 78.47,203
X$11394 9666 77 109 15434 BUF_X2
* cell instance $11396 m0 *1 80.75,203
X$11396 16824 3599 16646 77 109 16601 MUX2_X1
* cell instance $11401 r0 *1 79.04,203
X$11401 77 16336 16862 16920 16822 8687 109 DFFR_X1
* cell instance $11404 r0 *1 83.79,203
X$11404 16863 9030 77 109 16825 NOR2_X1
* cell instance $11405 r0 *1 84.36,203
X$11405 77 16336 16648 17029 16827 8687 109 DFFR_X1
* cell instance $11406 m0 *1 87.21,203
X$11406 16512 8067 16648 77 109 16606 MUX2_X1
* cell instance $11411 r0 *1 88.16,203
X$11411 16829 12312 15671 77 109 16754 MUX2_X1
* cell instance $11412 r0 *1 89.49,203
X$11412 77 16338 16755 16829 16754 8687 109 DFFR_X1
* cell instance $11413 m0 *1 92.91,203
X$11413 16755 8864 16865 77 109 16513 MUX2_X1
* cell instance $11417 r0 *1 93.29,203
X$11417 16755 10149 16865 77 109 16831 MUX2_X1
* cell instance $11418 r0 *1 94.62,203
X$11418 16831 9030 77 109 15954 NOR2_X1
* cell instance $11420 m0 *1 95.57,203
X$11420 16834 9652 16649 77 109 15868 MUX2_X1
* cell instance $11422 m0 *1 96.9,203
X$11422 16723 13926 15737 77 109 16650 MUX2_X1
* cell instance $11426 m0 *1 102.22,203
X$11426 16838 12240 16927 77 109 15824 MUX2_X1
* cell instance $11429 r0 *1 96.33,203
X$11429 16756 4632 17150 77 109 16834 MUX2_X1
* cell instance $11432 r0 *1 99.56,203
X$11432 9622 77 109 15339 BUF_X2
* cell instance $11434 r0 *1 100.51,203
X$11434 9622 77 109 15737 BUF_X2
* cell instance $11437 r0 *1 103.55,203
X$11437 9622 12709 16926 77 109 16867 MUX2_X1
* cell instance $11439 m0 *1 103.93,203
X$11439 16516 12153 16517 77 109 16838 MUX2_X1
* cell instance $11440 r0 *1 104.88,203
X$11440 9622 77 109 16435 BUF_X2
* cell instance $11442 m0 *1 105.64,203
X$11442 8864 109 12153 77 BUF_X4
* cell instance $11443 r0 *1 105.64,203
X$11443 16757 12153 16839 77 109 16927 MUX2_X1
* cell instance $11444 r0 *1 106.97,203
X$11444 16757 7447 16868 77 109 16758 MUX2_X1
* cell instance $11445 m0 *1 108.68,203
X$11445 16758 8993 16840 77 109 15871 MUX2_X1
* cell instance $11446 m0 *1 107.35,203
X$11446 16839 7447 16759 77 109 16840 MUX2_X1
* cell instance $11448 m0 *1 110.2,203
X$11448 77 16343 16728 16844 16843 12731 109 DFFR_X1
* cell instance $11452 m0 *1 126.92,203
X$11452 16654 16655 109 77 16846 XNOR2_X1
* cell instance $11455 r0 *1 108.3,203
X$11455 16868 8864 16759 77 109 16930 MUX2_X1
* cell instance $11456 r0 *1 109.63,203
X$11456 16841 3791 16930 77 109 16756 MUX2_X1
* cell instance $11457 r0 *1 110.96,203
X$11457 16726 8864 16728 77 109 16841 MUX2_X1
* cell instance $11458 r0 *1 112.29,203
X$11458 16343 77 109 19157 INV_X1
* cell instance $11460 r0 *1 113.05,203
X$11460 16435 6993 16844 77 109 16843 MUX2_X1
* cell instance $11461 r0 *1 114.38,203
X$11461 14026 77 109 16343 CLKBUF_X3
* cell instance $11473 r0 *1 128.25,203
X$11473 77 16760 16941 16869 16847 16939 109 FA_X1
* cell instance $11475 m0 *1 129.2,203
X$11475 16846 17227 109 77 16532 XNOR2_X1
* cell instance $11476 m0 *1 131.1,203
X$11476 16657 77 109 16761 INV_X1
* cell instance $11477 m0 *1 131.48,203
X$11477 16658 77 109 16762 INV_X1
* cell instance $11480 m0 *1 134.14,203
X$11480 16659 77 109 16937 INV_X1
* cell instance $11483 r0 *1 131.29,203
X$11483 16761 16762 16939 109 77 17051 HA_X1
* cell instance $11486 r0 *1 133.76,203
X$11486 16660 16937 16938 109 77 16847 HA_X1
* cell instance $11489 m0 *1 136.8,203
X$11489 16763 16661 16529 109 77 16628 HA_X1
* cell instance $11490 m0 *1 136.42,203
X$11490 16871 77 109 16661 INV_X1
* cell instance $11491 m0 *1 138.7,203
X$11491 16662 16663 16765 109 77 16848 HA_X1
* cell instance $11492 m0 *1 140.6,203
X$11492 16933 16934 16670 109 77 16664 HA_X1
* cell instance $11493 m0 *1 142.5,203
X$11493 16665 77 109 16766 INV_X1
* cell instance $11494 m0 *1 142.88,203
X$11494 16666 77 109 16874 INV_X1
* cell instance $11497 m0 *1 144.97,203
X$11497 16929 77 109 16730 INV_X1
* cell instance $11499 m0 *1 145.54,203
X$11499 16731 77 109 16849 INV_X1
* cell instance $11500 m0 *1 145.92,203
X$11500 16850 16730 16767 109 77 16853 HA_X1
* cell instance $11502 m0 *1 148.58,203
X$11502 16877 16768 16769 109 77 16630 HA_X1
* cell instance $11503 m0 *1 150.48,203
X$11503 16670 77 109 16530 INV_X1
* cell instance $11505 r0 *1 136.61,203
X$11505 16870 77 109 16763 INV_X1
* cell instance $11506 r0 *1 136.99,203
X$11506 77 16765 16935 16873 16932 16764 109 FA_X1
* cell instance $11508 r0 *1 140.41,203
X$11508 16872 77 109 16933 INV_X1
* cell instance $11511 r0 *1 141.93,203
X$11511 16766 16874 16931 109 77 16932 HA_X1
* cell instance $11514 r0 *1 148.39,203
X$11514 16925 77 109 16876 INV_X1
* cell instance $11515 r0 *1 148.77,203
X$11515 16852 77 109 16768 INV_X1
* cell instance $11516 r0 *1 149.15,203
X$11516 77 16487 16925 16878 16345 16346 109 FA_X1
* cell instance $11518 m0 *1 151.24,203
X$11518 15746 109 16854 77 BUF_X4
* cell instance $11519 r0 *1 152.19,203
X$11519 16671 16853 16670 109 16534 77 OAI21_X1
* cell instance $11521 m0 *1 154.85,203
X$11521 16769 77 109 16349 INV_X1
* cell instance $11522 m0 *1 152.95,203
X$11522 17070 17069 16674 109 77 16673 HA_X1
* cell instance $11528 r0 *1 155.8,203
X$11528 16879 77 109 16924 INV_X1
* cell instance $11529 r0 *1 156.18,203
X$11529 16880 77 109 16770 INV_X1
* cell instance $11530 m0 *1 156.56,203
X$11530 15386 16351 16349 77 109 16405 NOR3_X1
* cell instance $11532 m0 *1 157.32,203
X$11532 16673 16674 77 109 16771 NOR2_X1
* cell instance $11533 m0 *1 157.89,203
X$11533 16673 16727 16676 77 109 16851 NOR3_X1
* cell instance $11534 m0 *1 158.65,203
X$11534 16769 16443 109 77 15641 XNOR2_X1
* cell instance $11535 m0 *1 159.79,203
X$11535 16675 16727 16673 77 109 16538 OR3_X1
* cell instance $11536 m0 *1 160.74,203
X$11536 16674 16773 77 109 16352 XOR2_X1
* cell instance $11538 m0 *1 162.07,203
X$11538 16541 16542 16725 109 16772 77 OAI21_X1
* cell instance $11540 m0 *1 163.02,203
X$11540 16774 16677 109 77 16725 AND2_X1
* cell instance $11541 m0 *1 163.78,203
X$11541 16539 16678 77 109 16677 OR2_X1
* cell instance $11543 m0 *1 164.73,203
X$11543 16842 77 109 16544 BUF_X1
* cell instance $11545 m0 *1 165.49,203
X$11545 16679 16544 16450 77 16678 109 AOI21_X1
* cell instance $11547 r0 *1 156.56,203
X$11547 16770 16924 16676 109 77 16727 HA_X1
* cell instance $11548 r0 *1 158.46,203
X$11548 16771 16851 77 109 16535 NOR2_X1
* cell instance $11550 r0 *1 159.79,203
X$11550 16536 16535 16769 77 109 16632 NAND3_X1
* cell instance $11552 r0 *1 160.93,203
X$11552 16727 16676 16772 77 16773 109 AOI21_X1
* cell instance $11553 r0 *1 161.69,203
X$11553 16923 77 109 16922 INV_X1
* cell instance $11554 r0 *1 162.07,203
X$11554 16656 77 109 16524 INV_X4
* cell instance $11555 r0 *1 163.02,203
X$11555 16675 77 109 16774 INV_X1
* cell instance $11556 r0 *1 163.4,203
X$11556 16845 16922 16842 109 77 16679 HA_X1
* cell instance $11560 r0 *1 166.63,203
X$11560 77 16775 16883 16885 16218 16346 109 FA_X1
* cell instance $11561 m0 *1 166.82,203
X$11561 16681 16667 16345 77 109 NOR2_X4
* cell instance $11563 m0 *1 168.53,203
X$11563 16681 16667 16775 77 109 NOR2_X4
* cell instance $11564 m0 *1 170.24,203
X$11564 16667 16681 16837 77 109 NOR2_X4
* cell instance $11566 m0 *1 172.71,203
X$11566 15837 15163 109 77 16833 AND2_X1
* cell instance $11569 r0 *1 169.86,203
X$11569 77 16836 16884 16835 16837 16346 109 FA_X1
* cell instance $11573 r0 *1 172.9,203
X$11573 16835 77 109 16886 INV_X1
* cell instance $11576 m0 *1 173.85,203
X$11576 16391 77 109 16721 INV_X1
* cell instance $11577 m0 *1 174.42,203
X$11577 16832 17596 16550 109 77 16551 HA_X1
* cell instance $11578 m0 *1 176.32,203
X$11578 77 16216 16830 16826 16833 16837 109 FA_X1
* cell instance $11579 m0 *1 179.36,203
X$11579 16977 77 109 16682 INV_X1
* cell instance $11584 r0 *1 178.98,203
X$11584 16830 77 109 16887 INV_X1
* cell instance $11586 m0 *1 180.31,203
X$11586 16978 77 109 16555 INV_X1
* cell instance $11589 m0 *1 180.88,203
X$11589 16387 16293 77 109 16776 NOR2_X1
* cell instance $11590 m0 *1 181.45,203
X$11590 16919 16828 16388 109 77 16557 HA_X1
* cell instance $11594 r0 *1 182.02,203
X$11594 16888 77 109 16828 INV_X1
* cell instance $11597 r0 *1 182.97,203
X$11597 16777 77 109 16919 INV_X1
* cell instance $11598 r0 *1 183.35,203
X$11598 77 16780 16777 16686 16779 17324 109 FA_X1
* cell instance $11599 m0 *1 183.92,203
X$11599 16683 16684 77 16455 109 NAND2_X4
* cell instance $11601 m0 *1 185.63,203
X$11601 16778 77 109 16779 INV_X1
* cell instance $11602 m0 *1 186.01,203
X$11602 16686 77 109 16685 INV_X1
* cell instance $11604 r0 *1 186.39,203
X$11604 16826 77 109 17043 INV_X2
* cell instance $11606 m0 *1 186.77,203
X$11606 17092 77 109 16717 INV_X1
* cell instance $11608 m0 *1 188.1,203
X$11608 77 15803 16981 17113 16820 16714 109 FA_X1
* cell instance $11609 m0 *1 187.53,203
X$11609 16823 16359 77 109 16820 NAND2_X1
* cell instance $11611 m0 *1 191.9,203
X$11611 16688 77 109 16604 INV_X1
* cell instance $11615 r0 *1 187.91,203
X$11615 16781 16360 77 109 16714 NAND2_X1
* cell instance $11618 m0 *1 193.42,203
X$11618 77 16690 16816 16817 16015 16689 109 FA_X1
* cell instance $11621 r0 *1 194.75,203
X$11621 16051 16380 77 109 16689 NAND2_X1
* cell instance $11624 r0 *1 196.27,203
X$11624 16549 16380 77 109 17027 NAND2_X1
* cell instance $11626 m0 *1 197.79,203
X$11626 77 16817 16813 16707 16713 16712 109 FA_X1
* cell instance $11628 m0 *1 200.83,203
X$11628 77 16782 16562 16812 16814 16691 109 FA_X1
* cell instance $11629 m0 *1 203.87,203
X$11629 16812 77 109 16710 INV_X1
* cell instance $11630 m0 *1 204.25,203
X$11630 77 16912 16810 16564 16711 16710 109 FA_X1
* cell instance $11631 m0 *1 207.29,203
X$11631 15346 77 109 16783 INV_X1
* cell instance $11632 m0 *1 207.67,203
X$11632 16783 15690 77 109 16705 NOR2_X1
* cell instance $11635 m0 *1 209.95,203
X$11635 16784 77 109 16807 INV_X1
* cell instance $11640 r0 *1 201.02,203
X$11640 16353 16561 77 109 16782 NOR2_X1
* cell instance $11642 r0 *1 202.35,203
X$11642 15528 16125 77 109 16892 NOR2_X2
* cell instance $11643 r0 *1 203.3,203
X$11643 16813 77 109 16906 INV_X1
* cell instance $11646 r0 *1 205.58,203
X$11646 16810 77 109 16907 INV_X1
* cell instance $11649 r0 *1 207.67,203
X$11649 16783 16124 77 109 16893 NOR2_X1
* cell instance $11650 r0 *1 208.24,203
X$11650 16894 16893 16909 109 77 17316 HA_X1
* cell instance $11653 r0 *1 211.28,203
X$11653 16905 16909 16706 109 77 16904 HA_X1
* cell instance $11654 m0 *1 214.51,203
X$11654 16804 77 109 16805 INV_X1
* cell instance $11655 m0 *1 211.47,203
X$11655 77 16692 16799 16804 16807 16895 109 FA_X1
* cell instance $11658 r0 *1 213.18,203
X$11658 77 16805 16803 16234 16904 17004 109 FA_X1
* cell instance $11660 m0 *1 216.03,203
X$11660 16801 16457 77 109 16567 NAND2_X1
* cell instance $11661 r0 *1 216.22,203
X$11661 16803 77 109 16901 INV_X1
* cell instance $11662 r0 *1 216.6,203
X$11662 77 16799 16902 16787 16786 16901 109 FA_X1
* cell instance $11664 m0 *1 216.98,203
X$11664 16693 77 109 16801 INV_X1
* cell instance $11665 m0 *1 218.12,203
X$11665 16703 16797 16693 77 109 16458 NAND3_X2
* cell instance $11666 m0 *1 219.45,203
X$11666 16029 16568 16466 77 109 16703 NAND3_X1
* cell instance $11667 m0 *1 220.21,203
X$11667 16694 16568 77 109 16797 NAND2_X1
* cell instance $11669 r0 *1 219.64,203
X$11669 16791 16793 16697 16695 16896 16785 77 109 OAI221_X2
* cell instance $11670 m0 *1 222.11,203
X$11670 16466 77 109 16468 BUF_X1
* cell instance $11671 m0 *1 221.16,203
X$11671 16698 16696 77 109 16788 NAND2_X2
* cell instance $11672 m0 *1 222.68,203
X$11672 16695 16697 77 109 16794 NOR2_X1
* cell instance $11678 r0 *1 221.73,203
X$11678 16789 16990 16793 77 109 16695 OR3_X4
* cell instance $11679 r0 *1 223.82,203
X$11679 16789 77 109 16698 INV_X1
* cell instance $11689 m0 *1 5.7,102.2
X$11689 7911 5506 7981 77 109 7979 MUX2_X1
* cell instance $11692 m0 *1 7.22,102.2
X$11692 7911 7912 7981 77 109 7913 MUX2_X1
* cell instance $11695 m0 *1 9.5,102.2
X$11695 77 7914 8135 7833 7834 4909 109 DFFR_X1
* cell instance $11699 m0 *1 18.05,102.2
X$11699 7180 77 109 7459 CLKBUF_X3
* cell instance $11704 r0 *1 5.7,102.2
X$11704 7176 6701 7685 77 109 8130 MUX2_X1
* cell instance $11705 r0 *1 7.03,102.2
X$11705 7176 7912 7685 77 109 8050 MUX2_X1
* cell instance $11706 r0 *1 8.36,102.2
X$11706 7180 77 109 7914 CLKBUF_X3
* cell instance $11710 r0 *1 11.97,102.2
X$11710 7318 8005 8135 77 109 7915 MUX2_X1
* cell instance $11711 r0 *1 13.3,102.2
X$11711 7318 4138 8135 77 109 8052 MUX2_X1
* cell instance $11712 r0 *1 14.63,102.2
X$11712 8052 6158 8053 77 109 8137 MUX2_X1
* cell instance $11713 r0 *1 15.96,102.2
X$11713 5444 7178 8138 77 109 8054 MUX2_X1
* cell instance $11715 r0 *1 17.67,102.2
X$11715 5444 7070 7988 77 109 8140 MUX2_X1
* cell instance $11716 r0 *1 19,102.2
X$11716 77 7459 8056 7988 8140 4909 109 DFFR_X1
* cell instance $11717 m0 *1 21.85,102.2
X$11717 7613 7477 7758 77 109 7840 MUX2_X1
* cell instance $11723 m0 *1 24.32,102.2
X$11723 8057 6704 7916 77 109 7993 MUX2_X1
* cell instance $11726 m0 *1 26.98,102.2
X$11726 77 7464 7761 7842 7843 4909 109 DFFR_X1
* cell instance $11732 r0 *1 28.5,102.2
X$11732 7180 77 109 7464 CLKBUF_X3
* cell instance $11736 m0 *1 32.68,102.2
X$11736 7993 7617 77 109 7994 NOR2_X1
* cell instance $11738 m0 *1 34.2,102.2
X$11738 7994 7846 7022 109 7995 77 NOR3_X2
* cell instance $11739 m0 *1 35.53,102.2
X$11739 77 7996 7995 8152 6713 109 AOI21_X4
* cell instance $11740 m0 *1 38,102.2
X$11740 6793 7917 77 109 8154 NOR2_X2
* cell instance $11741 m0 *1 38.95,102.2
X$11741 7918 7876 77 109 7998 NAND2_X1
* cell instance $11742 m0 *1 39.52,102.2
X$11742 7919 7998 7202 77 109 7999 NAND3_X2
* cell instance $11744 m0 *1 41.04,102.2
X$11744 77 8001 6652 7999 7854 109 AOI21_X4
* cell instance $11746 m0 *1 44.27,102.2
X$11746 77 7269 7768 7921 8002 4909 109 DFFR_X1
* cell instance $11747 m0 *1 48.07,102.2
X$11747 77 7269 7858 8009 7766 4909 109 DFFR_X1
* cell instance $11748 m0 *1 51.87,102.2
X$11748 7768 8005 7858 77 109 7770 MUX2_X1
* cell instance $11749 m0 *1 53.2,102.2
X$11749 7070 109 7922 77 BUF_X4
* cell instance $11750 m0 *1 54.53,102.2
X$11750 7410 109 7201 77 BUF_X4
* cell instance $11751 m0 *1 55.86,102.2
X$11751 7070 109 8008 77 BUF_X4
* cell instance $11755 r0 *1 34.58,102.2
X$11755 5174 6716 8149 77 109 8148 MUX2_X1
* cell instance $11756 r0 *1 35.91,102.2
X$11756 77 8153 8058 4572 8152 109 AOI21_X4
* cell instance $11757 r0 *1 38.38,102.2
X$11757 7703 7623 4965 8157 109 77 8156 OAI22_X1
* cell instance $11759 r0 *1 40.85,102.2
X$11759 8154 8228 7997 109 8159 77 NOR3_X2
* cell instance $11761 r0 *1 42.37,102.2
X$11761 77 8000 8159 4717 7026 109 AOI21_X4
* cell instance $11764 r0 *1 45.41,102.2
X$11764 7178 109 7878 77 BUF_X4
* cell instance $11766 r0 *1 47.12,102.2
X$11766 7878 7921 77 109 7920 NAND2_X1
* cell instance $11767 r0 *1 47.69,102.2
X$11767 8061 6014 7325 77 109 8003 MUX2_X1
* cell instance $11768 r0 *1 49.02,102.2
X$11768 8003 6704 7408 77 109 8163 MUX2_X1
* cell instance $11769 r0 *1 50.35,102.2
X$11769 7189 109 6890 77 BUF_X4
* cell instance $11770 r0 *1 51.68,102.2
X$11770 7189 109 7160 77 BUF_X4
* cell instance $11771 r0 *1 53.01,102.2
X$11771 8063 5135 5401 77 109 NOR2_X4
* cell instance $11772 r0 *1 54.72,102.2
X$11772 77 8067 5728 109 BUF_X32
* cell instance $11773 m0 *1 58.14,102.2
X$11773 7922 8009 77 109 7769 NAND2_X1
* cell instance $11774 m0 *1 57.57,102.2
X$11774 7863 7617 77 109 8011 NOR2_X1
* cell instance $11776 m0 *1 58.9,102.2
X$11776 4904 7331 7866 109 8010 77 OAI21_X1
* cell instance $11777 m0 *1 59.66,102.2
X$11777 8011 7774 7022 109 8012 77 NOR3_X2
* cell instance $11778 m0 *1 60.99,102.2
X$11778 77 8168 8012 8152 5961 109 AOI21_X4
* cell instance $11779 m0 *1 63.46,102.2
X$11779 3788 7165 7923 109 8013 77 OAI21_X1
* cell instance $11781 m0 *1 64.41,102.2
X$11781 77 8016 6652 7772 7716 109 AOI21_X4
* cell instance $11786 r0 *1 64.03,102.2
X$11786 7194 8169 77 109 7923 NAND2_X1
* cell instance $11787 r0 *1 64.6,102.2
X$11787 3788 7329 8017 109 8170 77 OAI21_X1
* cell instance $11788 r0 *1 65.36,102.2
X$11788 77 8019 18754 7924 8170 1663 109 DFFR_X1
* cell instance $11790 m0 *1 67.26,102.2
X$11790 7775 7924 77 109 8017 NAND2_X1
* cell instance $11791 m0 *1 68.4,102.2
X$11791 6723 8021 77 109 7925 NAND2_X1
* cell instance $11793 m0 *1 68.97,102.2
X$11793 7925 6177 6661 109 77 7870 OAI21_X2
* cell instance $11794 m0 *1 70.3,102.2
X$11794 77 8019 8175 8021 7870 1663 109 DFFR_X1
* cell instance $11795 m0 *1 74.1,102.2
X$11795 5135 7844 77 109 8024 NAND2_X1
* cell instance $11798 m0 *1 75.62,102.2
X$11798 7777 3498 6664 77 109 7927 MUX2_X1
* cell instance $11804 r0 *1 72.77,102.2
X$11804 7635 3498 8175 77 109 8178 MUX2_X1
* cell instance $11805 r0 *1 74.1,102.2
X$11805 7635 7926 8175 77 109 8176 MUX2_X1
* cell instance $11806 r0 *1 75.43,102.2
X$11806 7777 7926 6664 77 109 8182 MUX2_X1
* cell instance $11807 r0 *1 76.76,102.2
X$11807 7927 3906 8178 77 109 8179 MUX2_X1
* cell instance $11809 r0 *1 78.47,102.2
X$11809 2379 8068 2611 77 109 8351 MUX2_X1
* cell instance $11810 m0 *1 80.18,102.2
X$11810 77 3048 7496 8070 6666 109 NOR3_X4
* cell instance $11811 m0 *1 78.85,102.2
X$11811 7496 109 5135 77 BUF_X4
* cell instance $11813 m0 *1 83.6,102.2
X$11813 5462 7765 8026 109 7778 77 OAI21_X1
* cell instance $11818 r0 *1 80.37,102.2
X$11818 77 8070 109 7932 BUF_X8
* cell instance $11820 r0 *1 83.03,102.2
X$11820 8182 5887 77 109 8071 NOR2_X1
* cell instance $11823 m0 *1 85.69,102.2
X$11823 5462 7767 7929 109 7779 77 OAI21_X1
* cell instance $11825 m0 *1 86.45,102.2
X$11825 7922 7780 77 109 7929 NAND2_X1
* cell instance $11828 m0 *1 89.3,102.2
X$11828 7592 7930 77 109 8188 OR2_X1
* cell instance $11829 m0 *1 90.06,102.2
X$11829 8028 5975 8031 6846 77 109 7931 AOI22_X1
* cell instance $11830 m0 *1 91.01,102.2
X$11830 77 7205 7933 7889 8030 1663 109 DFFR_X1
* cell instance $11831 m0 *1 94.81,102.2
X$11831 7933 6389 77 109 8033 NAND2_X1
* cell instance $11832 m0 *1 95.38,102.2
X$11832 6389 7934 8033 109 7781 77 OAI21_X1
* cell instance $11833 m0 *1 96.14,102.2
X$11833 5462 7775 7935 109 8193 77 OAI21_X1
* cell instance $11834 m0 *1 96.9,102.2
X$11834 7775 7934 77 109 7935 NAND2_X1
* cell instance $11836 r0 *1 85.88,102.2
X$11836 7932 77 109 8063 INV_X8
* cell instance $11837 r0 *1 87.59,102.2
X$11837 6671 77 109 7205 CLKBUF_X3
* cell instance $11838 r0 *1 88.54,102.2
X$11838 7205 77 109 19120 INV_X2
* cell instance $11842 r0 *1 90.44,102.2
X$11842 8188 7931 8073 8190 109 77 8208 AND4_X1
* cell instance $11843 r0 *1 91.58,102.2
X$11843 8416 7594 8075 7640 77 109 8190 AOI22_X1
* cell instance $11846 r0 *1 93.48,102.2
X$11846 8077 8068 7933 77 8076 109 AOI21_X1
* cell instance $11847 r0 *1 94.24,102.2
X$11847 7934 7926 77 109 8077 NOR2_X1
* cell instance $11848 r0 *1 94.81,102.2
X$11848 6678 77 109 8078 INV_X1
* cell instance $11849 r0 *1 95.19,102.2
X$11849 7087 8079 77 109 8081 NOR2_X1
* cell instance $11850 r0 *1 95.76,102.2
X$11850 77 7337 18743 7934 8193 4086 109 DFFR_X1
* cell instance $11851 m0 *1 98.04,102.2
X$11851 5592 7775 7893 109 8035 77 OAI21_X1
* cell instance $11853 m0 *1 98.8,102.2
X$11853 6671 77 109 7337 CLKBUF_X3
* cell instance $11854 m0 *1 99.75,102.2
X$11854 77 7337 18558 7782 8035 4086 109 DFFR_X1
* cell instance $11857 m0 *1 104.5,102.2
X$11857 7445 6389 77 109 7901 NAND2_X1
* cell instance $11861 r0 *1 99.75,102.2
X$11861 8082 6318 6460 77 8197 109 AOI21_X1
* cell instance $11863 r0 *1 100.89,102.2
X$11863 7782 7936 77 109 7937 NOR2_X1
* cell instance $11864 r0 *1 101.46,102.2
X$11864 7937 6308 7445 77 8083 109 AOI21_X1
* cell instance $11866 r0 *1 102.41,102.2
X$11866 6858 77 109 8198 INV_X1
* cell instance $11869 r0 *1 103.36,102.2
X$11869 6523 8001 8037 77 109 NOR2_X4
* cell instance $11870 r0 *1 105.07,102.2
X$11870 6523 8001 77 8047 109 OR2_X4
* cell instance $11872 m0 *1 106.21,102.2
X$11872 77 6900 7938 8040 8200 8201 109 DFFR_X1
* cell instance $11873 m0 *1 110.2,102.2
X$11873 7938 7642 7939 77 109 8252 MUX2_X1
* cell instance $11875 m0 *1 111.72,102.2
X$11875 77 6900 7939 8042 8041 4086 109 DFFR_X1
* cell instance $11877 r0 *1 106.78,102.2
X$11877 77 4086 8201 109 BUF_X32
* cell instance $11882 m0 *1 115.9,102.2
X$11882 7647 7279 8042 77 109 8041 MUX2_X1
* cell instance $11883 m0 *1 117.42,102.2
X$11883 77 5594 109 6182 BUF_X8
* cell instance $11885 m0 *1 120.08,102.2
X$11885 7497 109 6430 77 BUF_X4
* cell instance $11887 m0 *1 121.6,102.2
X$11887 7752 109 6145 77 BUF_X4
* cell instance $11891 r0 *1 116.66,102.2
X$11891 8208 109 7028 77 BUF_X4
* cell instance $11894 r0 *1 118.56,102.2
X$11894 3916 6430 8209 6699 109 8046 77 NOR4_X2
* cell instance $11897 r0 *1 121.22,102.2
X$11897 8046 7940 77 6004 109 NAND2_X4
* cell instance $11898 r0 *1 122.93,102.2
X$11898 7752 6466 77 109 7940 NOR2_X2
* cell instance $11899 m0 *1 123.88,102.2
X$11899 7344 77 109 7941 INV_X1
* cell instance $11900 m0 *1 123.31,102.2
X$11900 7450 7785 77 109 8048 NAND2_X1
* cell instance $11902 m0 *1 124.45,102.2
X$11902 7497 7219 5861 77 7942 109 AOI21_X1
* cell instance $11904 m0 *1 125.4,102.2
X$11904 5748 7652 7344 109 8049 77 OAI21_X1
* cell instance $11906 m0 *1 126.35,102.2
X$11906 7499 7652 4660 109 7786 77 NOR3_X2
* cell instance $11907 m0 *1 127.68,102.2
X$11907 7940 7450 7174 77 109 8045 NAND3_X1
* cell instance $11908 m0 *1 128.44,102.2
X$11908 6145 7650 7909 109 8038 77 OAI21_X1
* cell instance $11910 m0 *1 129.39,102.2
X$11910 7347 7348 4611 7944 109 8043 77 NOR4_X2
* cell instance $11911 m0 *1 131.1,102.2
X$11911 7219 7499 7344 109 7944 77 OAI21_X1
* cell instance $11912 m0 *1 131.86,102.2
X$11912 5472 7652 109 77 7791 XNOR2_X1
* cell instance $11913 m0 *1 133,102.2
X$11913 5861 5711 77 109 7650 NAND2_X1
* cell instance $11914 m0 *1 133.57,102.2
X$11914 7316 77 109 7945 BUF_X1
* cell instance $11915 m0 *1 134.14,102.2
X$11915 7347 77 109 8039 BUF_X1
* cell instance $11916 m0 *1 134.71,102.2
X$11916 7791 7174 77 109 7792 NAND2_X1
* cell instance $11919 r0 *1 123.88,102.2
X$11919 8049 8044 8048 7943 7941 7942 77 109 8087 OAI33_X1
* cell instance $11920 r0 *1 125.21,102.2
X$11920 7940 7450 77 109 7943 NAND2_X2
* cell instance $11921 r0 *1 126.16,102.2
X$11921 7752 5711 77 109 8211 NOR2_X1
* cell instance $11922 r0 *1 126.73,102.2
X$11922 7219 7650 8045 77 109 8086 OR3_X2
* cell instance $11923 r0 *1 127.87,102.2
X$11923 8211 5861 7216 77 109 8044 NOR3_X1
* cell instance $11925 r0 *1 128.82,102.2
X$11925 8213 7348 77 109 8212 OR2_X2
* cell instance $11926 r0 *1 129.77,102.2
X$11926 7653 5990 7316 77 109 8214 MUX2_X1
* cell instance $11927 r0 *1 131.1,102.2
X$11927 7788 7316 7499 77 109 8088 NAND3_X1
* cell instance $11928 r0 *1 131.86,102.2
X$11928 77 7174 8039 7943 5716 109 NOR3_X4
* cell instance $11929 r0 *1 134.52,102.2
X$11929 8038 5434 77 109 8213 NAND2_X1
* cell instance $11930 r0 *1 135.09,102.2
X$11930 5557 6569 77 109 8387 NOR2_X1
* cell instance $11932 m0 *1 136.61,102.2
X$11932 7749 7502 7794 77 109 8205 MUX2_X1
* cell instance $11935 m0 *1 138.13,102.2
X$11935 7796 7795 77 109 8036 NAND2_X1
* cell instance $11937 r0 *1 136.42,102.2
X$11937 8036 7797 7946 77 109 8089 MUX2_X1
* cell instance $11939 r0 *1 138.13,102.2
X$11939 7894 7948 8032 109 77 7302 OAI21_X2
* cell instance $11941 m0 *1 139.08,102.2
X$11941 7796 7795 7221 77 109 7947 NAND3_X1
* cell instance $11942 m0 *1 140.03,102.2
X$11942 6913 6915 7948 109 7950 77 OAI21_X1
* cell instance $11944 r0 *1 139.46,102.2
X$11944 7357 7946 7947 109 8206 77 OAI21_X1
* cell instance $11946 r0 *1 140.6,102.2
X$11946 7357 8195 8092 8204 109 77 8203 OAI22_X1
* cell instance $11947 m0 *1 141.74,102.2
X$11947 7949 7502 77 109 8034 NAND2_X1
* cell instance $11948 m0 *1 141.17,102.2
X$11948 7949 7221 77 109 8204 NAND2_X1
* cell instance $11951 m0 *1 143.26,102.2
X$11951 7305 7504 7662 77 109 8032 NAND3_X1
* cell instance $11952 m0 *1 144.02,102.2
X$11952 7798 7096 7897 77 8029 109 AOI21_X1
* cell instance $11953 m0 *1 144.78,102.2
X$11953 7221 7951 7950 109 77 7895 AND3_X1
* cell instance $11954 m0 *1 145.73,102.2
X$11954 7604 7305 7504 7662 77 109 7951 NAND4_X1
* cell instance $11955 m0 *1 146.68,102.2
X$11955 6913 6915 7952 109 7953 77 OAI21_X1
* cell instance $11956 m0 *1 147.44,102.2
X$11956 3882 7801 7953 109 77 8027 AND3_X1
* cell instance $11957 m0 *1 148.39,102.2
X$11957 7953 7801 3882 77 109 7888 NAND3_X2
* cell instance $11959 m0 *1 149.91,102.2
X$11959 7660 7221 7047 77 109 8094 MUX2_X1
* cell instance $11960 m0 *1 151.24,102.2
X$11960 7884 6920 7296 77 109 7954 MUX2_X1
* cell instance $11961 m0 *1 152.57,102.2
X$11961 7507 7954 77 109 7955 OR2_X1
* cell instance $11963 r0 *1 141.55,102.2
X$11963 7354 7310 77 109 8091 NAND2_X2
* cell instance $11964 r0 *1 142.5,102.2
X$11964 8034 8092 7797 7946 109 77 8093 OAI22_X1
* cell instance $11965 r0 *1 143.45,102.2
X$11965 7802 8015 109 77 8092 AND2_X1
* cell instance $11967 r0 *1 144.4,102.2
X$11967 7950 7951 7096 77 109 8199 NAND3_X2
* cell instance $11968 r0 *1 145.73,102.2
X$11968 77 8199 8027 7894 8373 7096 109 OAI22_X4
* cell instance $11969 r0 *1 148.96,102.2
X$11969 77 7226 7047 8095 7895 7888 109 AOI22_X4
* cell instance $11971 r0 *1 152.38,102.2
X$11971 7954 7294 7310 109 77 8192 MUX2_X2
* cell instance $11972 m0 *1 154.66,102.2
X$11972 7660 7502 7883 77 109 8189 MUX2_X1
* cell instance $11973 m0 *1 153.71,102.2
X$11973 7310 77 109 7802 CLKBUF_X3
* cell instance $11974 m0 *1 155.99,102.2
X$11974 7803 7226 7956 77 109 8025 MUX2_X1
* cell instance $11975 m0 *1 157.32,102.2
X$11975 7880 7310 8023 77 109 8022 MUX2_X1
* cell instance $11976 m0 *1 158.65,102.2
X$11976 7524 7806 8014 77 109 7880 MUX2_X1
* cell instance $11979 m0 *1 160.93,102.2
X$11979 8018 7159 7957 77 109 8020 MUX2_X1
* cell instance $11982 m0 *1 163.97,102.2
X$11982 3882 7958 7873 109 8018 77 OAI21_X1
* cell instance $11983 m0 *1 164.73,102.2
X$11983 7808 5552 7958 77 109 7960 MUX2_X1
* cell instance $11984 m0 *1 166.06,102.2
X$11984 7958 7662 7961 77 109 8015 MUX2_X1
* cell instance $11988 r0 *1 155.23,102.2
X$11988 7883 7226 8022 77 109 8187 MUX2_X1
* cell instance $11992 r0 *1 158.65,102.2
X$11992 7804 7805 7879 77 109 8185 MUX2_X1
* cell instance $11994 r0 *1 160.74,102.2
X$11994 7956 7797 8099 77 109 8275 MUX2_X1
* cell instance $11996 r0 *1 162.83,102.2
X$11996 7959 6920 8100 77 109 8096 MUX2_X1
* cell instance $11997 r0 *1 164.16,102.2
X$11997 7233 7805 6932 77 109 8100 MUX2_X1
* cell instance $11999 r0 *1 165.87,102.2
X$11999 7960 7802 8180 77 109 8099 MUX2_X1
* cell instance $12001 r0 *1 167.39,102.2
X$12001 7961 5552 7959 77 109 8180 MUX2_X1
* cell instance $12003 m0 *1 167.77,102.2
X$12003 7869 7805 7872 77 109 7961 MUX2_X1
* cell instance $12004 m0 *1 169.86,102.2
X$12004 7809 7805 7871 77 109 7958 MUX2_X1
* cell instance $12006 r0 *1 168.72,102.2
X$12006 8103 7232 7962 77 109 7228 MUX2_X1
* cell instance $12007 r0 *1 170.05,102.2
X$12007 8103 7805 7962 77 109 7959 MUX2_X1
* cell instance $12013 m0 *1 171.57,102.2
X$12013 77 6200 8007 3583 1989 7963 109 OAI22_X4
* cell instance $12014 m0 *1 174.99,102.2
X$12014 6198 7521 6604 77 109 8006 MUX2_X1
* cell instance $12016 m0 *1 176.51,102.2
X$12016 77 6200 8006 2300 7814 7964 109 OAI22_X4
* cell instance $12018 m0 *1 179.93,102.2
X$12018 7668 8106 5002 77 109 8004 MUX2_X1
* cell instance $12020 m0 *1 181.45,102.2
X$12020 5541 77 109 7965 CLKBUF_X3
* cell instance $12021 m0 *1 182.4,102.2
X$12021 7815 7965 6359 77 109 7967 MUX2_X1
* cell instance $12023 m0 *1 183.92,102.2
X$12023 7864 7965 7968 77 109 7812 MUX2_X1
* cell instance $12027 r0 *1 172.33,102.2
X$12027 7964 77 109 7521 INV_X2
* cell instance $12030 r0 *1 173.47,102.2
X$12030 7810 77 109 7517 INV_X2
* cell instance $12034 r0 *1 175.37,102.2
X$12034 77 6872 6471 8173 6005 7668 109 AOI22_X4
* cell instance $12035 r0 *1 178.6,102.2
X$12035 77 8285 8004 3676 18967 7668 109 DFFR_X2
* cell instance $12036 r0 *1 182.78,102.2
X$12036 77 7966 18898 7815 7967 3676 109 DFFR_X1
* cell instance $12038 m0 *1 187.34,102.2
X$12038 7424 109 471 77 BUF_X4
* cell instance $12044 r0 *1 189.24,102.2
X$12044 7709 3637 109 77 8109 XNOR2_X1
* cell instance $12045 r0 *1 190.38,102.2
X$12045 8109 8110 77 109 7375 NAND2_X1
* cell instance $12047 r0 *1 191.14,102.2
X$12047 7861 77 109 7709 CLKBUF_X2
* cell instance $12049 m0 *1 196.27,102.2
X$12049 7814 109 621 77 BUF_X4
* cell instance $12050 m0 *1 192.09,102.2
X$12050 77 7816 7859 3676 18916 5417 109 DFFR_X2
* cell instance $12051 m0 *1 197.6,102.2
X$12051 7002 4832 8112 6492 77 109 7817 AOI22_X1
* cell instance $12052 m0 *1 198.55,102.2
X$12052 1989 5259 7817 109 8114 77 OAI21_X1
* cell instance $12053 m0 *1 199.31,102.2
X$12053 6071 109 5216 77 BUF_X4
* cell instance $12055 r0 *1 192.28,102.2
X$12055 7816 77 109 19188 INV_X1
* cell instance $12056 r0 *1 192.66,102.2
X$12056 6817 77 109 7816 CLKBUF_X3
* cell instance $12057 r0 *1 193.61,102.2
X$12057 8164 8110 77 109 7274 NAND2_X1
* cell instance $12058 r0 *1 194.18,102.2
X$12058 8162 8110 77 109 7377 NAND2_X1
* cell instance $12059 r0 *1 194.75,102.2
X$12059 8161 8110 77 109 7241 NAND2_X1
* cell instance $12062 r0 *1 196.27,102.2
X$12062 3562 4552 8112 77 109 7969 MUX2_X1
* cell instance $12063 r0 *1 197.6,102.2
X$12063 3562 6354 8114 77 109 8113 MUX2_X1
* cell instance $12066 r0 *1 200.83,102.2
X$12066 5915 77 109 5385 CLKBUF_X3
* cell instance $12067 m0 *1 201.21,102.2
X$12067 1084 6071 7819 6492 7818 77 109 7821 AOI221_X1
* cell instance $12069 m0 *1 202.35,102.2
X$12069 8317 5083 77 109 7407 NOR2_X1
* cell instance $12070 m0 *1 202.92,102.2
X$12070 405 5259 8291 109 8115 77 OAI21_X1
* cell instance $12075 m0 *1 209.19,102.2
X$12075 8151 5083 77 109 7990 NOR2_X1
* cell instance $12076 m0 *1 209.76,102.2
X$12076 7814 6239 7990 6368 7987 77 109 7989 AOI221_X1
* cell instance $12077 m0 *1 210.9,102.2
X$12077 77 7971 7989 3676 18935 4857 109 DFFR_X2
* cell instance $12078 m0 *1 215.08,102.2
X$12078 4857 77 109 7987 INV_X1
* cell instance $12080 r0 *1 201.78,102.2
X$12080 3666 6354 8115 77 109 8116 MUX2_X1
* cell instance $12084 r0 *1 204.44,102.2
X$12084 5915 77 109 4832 CLKBUF_X3
* cell instance $12085 r0 *1 205.39,102.2
X$12085 7991 5915 109 77 8117 AND2_X1
* cell instance $12086 r0 *1 206.15,102.2
X$12086 7526 5216 8117 4548 8118 77 109 7992 AOI221_X1
* cell instance $12087 r0 *1 207.29,102.2
X$12087 7533 5915 109 77 8144 AND2_X1
* cell instance $12091 r0 *1 209.38,102.2
X$12091 5776 6987 77 109 8150 NOR2_X1
* cell instance $12092 r0 *1 209.95,102.2
X$12092 494 5216 8150 4548 8146 77 109 7970 AOI221_X1
* cell instance $12093 r0 *1 211.09,102.2
X$12093 7242 3315 77 109 8147 NOR2_X1
* cell instance $12094 r0 *1 211.66,102.2
X$12094 5776 8120 77 109 8121 NOR2_X1
* cell instance $12095 r0 *1 212.23,102.2
X$12095 8120 5083 77 109 7851 NOR2_X1
* cell instance $12098 r0 *1 213.94,102.2
X$12098 685 5216 8121 6492 8294 77 109 7972 AOI221_X1
* cell instance $12099 r0 *1 215.08,102.2
X$12099 5216 7424 8144 6492 8125 7986 109 77 AOI221_X2
* cell instance $12100 m0 *1 216.03,102.2
X$12100 77 7824 7698 3676 18938 2707 109 DFFR_X2
* cell instance $12106 r0 *1 218.5,102.2
X$12106 8123 7242 7986 77 8122 109 AOI21_X1
* cell instance $12108 r0 *1 219.45,102.2
X$12108 6354 4410 77 109 8123 NOR2_X1
* cell instance $12110 m0 *1 220.78,102.2
X$12110 8124 7841 7985 7984 109 77 7983 AND4_X2
* cell instance $12112 m0 *1 222.11,102.2
X$12112 685 4691 7693 77 109 7825 MUX2_X1
* cell instance $12115 m0 *1 226.67,102.2
X$12115 77 7982 5393 7980 7973 992 109 DFFR_X1
* cell instance $12119 r0 *1 222.68,102.2
X$12119 4410 6496 8125 77 109 8139 MUX2_X1
* cell instance $12123 r0 *1 226.48,102.2
X$12123 8129 4951 8136 77 109 7973 MUX2_X1
* cell instance $12127 r0 *1 227.81,102.2
X$12127 494 4691 7980 77 109 8136 MUX2_X1
* cell instance $12130 r0 *1 230.28,102.2
X$12130 77 7976 5101 7679 8134 992 109 DFFR_X1
* cell instance $12131 m0 *1 232.18,102.2
X$12131 7829 7830 6067 77 109 7975 NAND3_X1
* cell instance $12132 m0 *1 230.85,102.2
X$12132 471 4691 7679 77 109 7974 MUX2_X1
* cell instance $12135 m0 *1 233.32,102.2
X$12135 77 7976 5936 7831 7977 992 109 DFFR_X1
* cell instance $12139 r0 *1 234.08,102.2
X$12139 8296 4837 7832 77 109 7977 MUX2_X1
* cell instance $12140 r0 *1 235.41,102.2
X$12140 8126 77 109 7544 BUF_X1
* cell instance $12145 m0 *1 24.89,119
X$12145 9481 5575 9562 77 109 9480 MUX2_X1
* cell instance $12149 m0 *1 29.45,119
X$12149 9321 5310 9322 77 109 9562 MUX2_X1
* cell instance $12152 m0 *1 33.06,119
X$12152 8525 77 109 19137 INV_X1
* cell instance $12156 r0 *1 24.89,119
X$12156 77 8664 9320 9563 9733 4909 109 DFFR_X1
* cell instance $12157 r0 *1 28.69,119
X$12157 9482 3784 9563 77 109 9733 MUX2_X1
* cell instance $12160 r0 *1 32.3,119
X$12160 9392 7617 77 109 9735 NOR2_X1
* cell instance $12161 r0 *1 32.87,119
X$12161 9564 7917 77 109 9736 NOR2_X1
* cell instance $12162 r0 *1 33.44,119
X$12162 9482 109 9003 77 BUF_X4
* cell instance $12163 m0 *1 35.91,119
X$12163 77 8525 18506 9403 9324 4909 109 DFFR_X1
* cell instance $12164 m0 *1 34.58,119
X$12164 9007 6716 9739 77 109 9484 MUX2_X1
* cell instance $12165 m0 *1 39.71,119
X$12165 9483 6383 77 109 9572 NAND2_X1
* cell instance $12169 r0 *1 34.96,119
X$12169 77 8525 9485 9739 9484 4909 109 DFFR_X1
* cell instance $12170 r0 *1 38.76,119
X$12170 7618 9485 7619 7620 9655 109 77 9743 OAI221_X1
* cell instance $12171 r0 *1 39.9,119
X$12171 9483 7321 77 109 9802 NAND2_X1
* cell instance $12172 r0 *1 40.47,119
X$12172 6389 9403 9572 109 9744 77 OAI21_X1
* cell instance $12173 r0 *1 41.23,119
X$12173 7643 9485 7597 7627 9744 109 77 9657 OAI221_X1
* cell instance $12174 m0 *1 43.89,119
X$12174 77 8674 9181 9266 9575 4909 109 DFFR_X1
* cell instance $12175 m0 *1 41.42,119
X$12175 77 5318 109 9178 BUF_X8
* cell instance $12176 m0 *1 47.69,119
X$12176 4907 7765 9180 109 9575 77 OAI21_X1
* cell instance $12178 m0 *1 48.64,119
X$12178 8847 109 8535 77 BUF_X4
* cell instance $12180 m0 *1 50.16,119
X$12180 9408 8349 9107 77 109 9411 MUX2_X1
* cell instance $12182 m0 *1 54.53,119
X$12182 77 8676 9486 9419 9415 1663 109 DFFR_X1
* cell instance $12185 r0 *1 42.37,119
X$12185 4843 109 9631 77 BUF_X4
* cell instance $12187 r0 *1 44.46,119
X$12187 6701 109 8666 77 BUF_X4
* cell instance $12190 r0 *1 46.93,119
X$12190 9577 7767 4907 109 77 9745 OAI21_X4
* cell instance $12191 r0 *1 49.4,119
X$12191 7922 9748 77 109 9577 NAND2_X1
* cell instance $12192 r0 *1 49.97,119
X$12192 2631 109 8548 77 BUF_X4
* cell instance $12197 r0 *1 57,119
X$12197 77 8676 9659 9753 9579 1663 109 DFFR_X1
* cell instance $12202 m0 *1 59.47,119
X$12202 5314 7331 9580 109 9579 77 OAI21_X1
* cell instance $12203 m0 *1 64.41,119
X$12203 6833 9328 77 109 9584 NAND2_X1
* cell instance $12204 m0 *1 60.61,119
X$12204 77 8855 9582 9328 9487 1663 109 DFFR_X1
* cell instance $12206 r0 *1 60.8,119
X$12206 7331 9753 77 109 9580 NAND2_X1
* cell instance $12210 r0 *1 62.7,119
X$12210 3710 7165 9583 109 9754 77 OAI21_X1
* cell instance $12211 r0 *1 63.46,119
X$12211 7165 9757 77 109 9583 NAND2_X1
* cell instance $12212 r0 *1 64.03,119
X$12212 3710 5738 9584 109 9487 77 OAI21_X1
* cell instance $12214 r0 *1 65.17,119
X$12214 3710 6262 9488 109 9756 77 OAI21_X1
* cell instance $12216 m0 *1 65.36,119
X$12216 77 8627 9489 9428 9585 109 NOR3_X4
* cell instance $12217 r0 *1 65.93,119
X$12217 6262 9660 77 109 9488 NAND2_X1
* cell instance $12220 r0 *1 68.21,119
X$12220 3710 6177 9586 109 9760 77 OAI21_X1
* cell instance $12221 m0 *1 68.59,119
X$12221 77 9491 18537 9490 9431 4086 109 DFFR_X1
* cell instance $12224 r0 *1 68.97,119
X$12224 6177 9761 77 109 9586 NAND2_X1
* cell instance $12226 r0 *1 72.58,119
X$12226 77 9491 9774 9591 9589 4086 109 DFFR_X1
* cell instance $12227 m0 *1 72.96,119
X$12227 3565 5738 9435 109 9589 77 OAI21_X1
* cell instance $12230 m0 *1 74.29,119
X$12230 6833 9591 77 109 9435 NAND2_X1
* cell instance $12234 m0 *1 75.81,119
X$12234 9440 77 109 9491 CLKBUF_X3
* cell instance $12235 m0 *1 76.76,119
X$12235 9491 77 109 19202 CLKBUF_X1
* cell instance $12238 m0 *1 80.56,119
X$12238 8684 4639 9599 109 9330 77 OAI21_X1
* cell instance $12241 r0 *1 76.57,119
X$12241 3903 9492 9595 109 9661 77 OAI21_X1
* cell instance $12243 r0 *1 77.52,119
X$12243 4072 9594 77 109 9595 NAND2_X1
* cell instance $12246 r0 *1 79.99,119
X$12246 3565 3794 9598 109 9767 77 OAI21_X1
* cell instance $12248 r0 *1 80.94,119
X$12248 3709 9768 77 109 9598 NAND2_X1
* cell instance $12250 m0 *1 81.89,119
X$12250 4505 9331 77 109 9599 NAND2_X1
* cell instance $12255 m0 *1 86.45,119
X$12255 9333 3048 9193 77 109 9334 MUX2_X1
* cell instance $12258 m0 *1 88.73,119
X$12258 9496 8069 77 109 9192 NOR2_X1
* cell instance $12261 m0 *1 90.25,119
X$12261 9608 9029 6820 77 9606 109 AOI21_X1
* cell instance $12265 r0 *1 82.46,119
X$12265 8684 77 109 9492 CLKBUF_X3
* cell instance $12266 r0 *1 83.41,119
X$12266 9437 3048 9493 77 109 9494 MUX2_X1
* cell instance $12267 r0 *1 84.74,119
X$12267 9494 3373 9495 77 109 9772 MUX2_X1
* cell instance $12270 r0 *1 86.64,119
X$12270 9772 3694 9191 77 109 9605 MUX2_X1
* cell instance $12272 r0 *1 88.73,119
X$12272 9605 6294 77 109 9613 NAND2_X1
* cell instance $12273 r0 *1 89.3,119
X$12273 77 9028 9775 9497 9606 8687 109 DFFR_X1
* cell instance $12275 m0 *1 92.15,119
X$12275 6820 9497 77 109 9608 NOR2_X1
* cell instance $12276 m0 *1 92.91,119
X$12276 8548 9335 77 109 9444 NOR2_X1
* cell instance $12280 r0 *1 93.48,119
X$12280 9498 3364 9663 77 109 9664 MUX2_X1
* cell instance $12281 r0 *1 94.81,119
X$12281 77 9499 6379 9612 9613 109 AOI21_X4
* cell instance $12282 m0 *1 97.09,119
X$12282 9611 6380 8422 77 109 9614 MUX2_X1
* cell instance $12284 m0 *1 98.42,119
X$12284 77 8544 9336 9611 9614 8201 109 DFFR_X1
* cell instance $12286 r0 *1 97.28,119
X$12286 6380 9616 77 109 9665 NOR2_X1
* cell instance $12290 m0 *1 102.79,119
X$12290 77 8544 9338 9500 9623 8201 109 DFFR_X1
* cell instance $12292 m0 *1 106.59,119
X$12292 9338 9831 9339 77 109 9625 MUX2_X1
* cell instance $12295 r0 *1 103.55,119
X$12295 77 9622 6267 5186 9621 109 AOI21_X4
* cell instance $12296 r0 *1 106.02,119
X$12296 9500 9830 8422 77 109 9623 MUX2_X1
* cell instance $12298 m0 *1 109.63,119
X$12298 9629 7642 9633 77 109 9627 MUX2_X1
* cell instance $12299 m0 *1 108.3,119
X$12299 9625 8689 9627 77 109 9340 MUX2_X1
* cell instance $12300 m0 *1 110.96,119
X$12300 9629 6180 9633 77 109 9342 MUX2_X1
* cell instance $12307 r0 *1 112.48,119
X$12307 9786 9632 8686 77 109 9634 MUX2_X1
* cell instance $12308 r0 *1 113.81,119
X$12308 77 9036 9501 9786 9634 4086 109 DFFR_X1
* cell instance $12312 m0 *1 117.42,119
X$12312 9501 6180 9502 77 109 9344 MUX2_X1
* cell instance $12316 m0 *1 121.03,119
X$12316 77 8692 9502 9636 9635 4086 109 DFFR_X1
* cell instance $12317 m0 *1 124.83,119
X$12317 9345 8556 19050 109 77 9505 HA_X1
* cell instance $12318 m0 *1 126.73,119
X$12318 9202 109 9506 77 BUF_X4
* cell instance $12319 m0 *1 128.06,119
X$12319 9462 109 9203 77 BUF_X4
* cell instance $12320 m0 *1 129.39,119
X$12320 9638 77 109 9511 CLKBUF_X3
* cell instance $12321 m0 *1 130.34,119
X$12321 9508 9346 77 109 9641 NAND2_X1
* cell instance $12322 m0 *1 130.91,119
X$12322 7651 9508 9203 77 109 9466 NAND3_X2
* cell instance $12323 m0 *1 132.24,119
X$12323 9510 9508 9509 77 109 8878 OR3_X2
* cell instance $12324 m0 *1 133.38,119
X$12324 9512 9506 77 109 9001 NAND2_X2
* cell instance $12325 m0 *1 134.33,119
X$12325 9511 77 109 9510 INV_X1
* cell instance $12328 m0 *1 138.51,119
X$12328 8699 8882 77 109 9515 NAND2_X1
* cell instance $12329 m0 *1 139.08,119
X$12329 8429 77 109 8560 CLKBUF_X3
* cell instance $12332 r0 *1 117.61,119
X$12332 9501 6140 9502 77 109 9788 MUX2_X1
* cell instance $12334 r0 *1 119.7,119
X$12334 9504 6007 9788 77 109 8658 MUX2_X1
* cell instance $12338 r0 *1 121.79,119
X$12338 9636 9815 8686 77 109 9635 MUX2_X1
* cell instance $12339 r0 *1 123.12,119
X$12339 8692 77 109 19316 CLKBUF_X1
* cell instance $12343 r0 *1 127.68,119
X$12343 8696 77 109 9671 BUF_X1
* cell instance $12344 r0 *1 128.25,119
X$12344 8877 9507 9672 9512 8696 9674 77 109 9639 OAI33_X1
* cell instance $12345 r0 *1 129.58,119
X$12345 77 8877 9675 9507 9513 109 NOR3_X4
* cell instance $12346 r0 *1 132.24,119
X$12346 9641 9466 8696 109 77 9643 MUX2_X2
* cell instance $12347 r0 *1 133.95,119
X$12347 9512 9511 9513 77 7229 109 NAND3_X4
* cell instance $12348 r0 *1 136.42,119
X$12348 9511 9512 9513 109 77 9349 AND3_X2
* cell instance $12350 r0 *1 139.08,119
X$12350 9171 77 109 9642 INV_X1
* cell instance $12351 r0 *1 139.46,119
X$12351 9642 8267 9640 9515 9347 109 77 9679 OAI221_X1
* cell instance $12353 r0 *1 140.79,119
X$12353 7229 109 8574 77 BUF_X4
* cell instance $12354 m0 *1 142.12,119
X$12354 9348 9210 8429 8430 9047 109 77 AOI211_X2
* cell instance $12359 m0 *1 144.21,119
X$12359 8271 8378 77 109 9348 NOR2_X2
* cell instance $12361 m0 *1 146.11,119
X$12361 9351 9460 9637 109 9850 77 OAI21_X1
* cell instance $12362 m0 *1 146.87,119
X$12362 8564 8373 8378 109 77 9516 MUX2_X2
* cell instance $12363 m0 *1 148.58,119
X$12363 8430 8432 77 109 9688 NAND2_X1
* cell instance $12364 m0 *1 149.15,119
X$12364 9348 8560 7225 77 9680 109 AOI21_X1
* cell instance $12370 r0 *1 147.25,119
X$12370 8820 9210 8380 77 109 9684 MUX2_X1
* cell instance $12374 r0 *1 151.24,119
X$12374 8705 9455 109 77 9848 AND2_X1
* cell instance $12375 m0 *1 152.38,119
X$12375 9348 9351 77 109 9517 NAND2_X1
* cell instance $12376 m0 *1 151.81,119
X$12376 7225 8432 77 109 9686 NAND2_X1
* cell instance $12377 m0 *1 152.95,119
X$12377 9348 8560 8433 77 9518 109 AOI21_X1
* cell instance $12378 m0 *1 153.71,119
X$12378 9518 9454 9630 8699 9624 6687 109 77 AOI221_X2
* cell instance $12380 m0 *1 157.32,119
X$12380 9517 8699 77 109 9628 NAND2_X1
* cell instance $12384 r0 *1 152.57,119
X$12384 9351 7295 77 109 9454 NOR2_X2
* cell instance $12388 r0 *1 158.27,119
X$12388 9626 9519 77 109 9630 OR2_X1
* cell instance $12390 m0 *1 158.27,119
X$12390 9354 9628 77 109 9217 OR2_X1
* cell instance $12392 m0 *1 159.98,119
X$12392 9357 8432 8433 77 9619 109 AOI21_X1
* cell instance $12397 r0 *1 160.36,119
X$12397 77 6602 6322 5341 9615 9620 109 AND4_X4
* cell instance $12398 m0 *1 161.69,119
X$12398 9520 9618 2740 9617 109 77 7016 AND4_X2
* cell instance $12399 m0 *1 161.12,119
X$12399 9624 8635 77 109 9520 NAND2_X1
* cell instance $12401 m0 *1 163.21,119
X$12401 9356 8699 77 109 9357 NAND2_X1
* cell instance $12402 m0 *1 163.78,119
X$12402 9521 9219 9052 9357 9610 6550 77 109 OAI221_X2
* cell instance $12405 r0 *1 162.83,119
X$12405 9777 9619 8712 109 9618 77 OAI21_X1
* cell instance $12408 r0 *1 166.82,119
X$12408 8439 9356 109 77 9689 AND2_X1
* cell instance $12410 m0 *1 167.01,119
X$12410 9357 9441 10003 109 9054 77 OAI21_X1
* cell instance $12412 r0 *1 167.77,119
X$12412 9609 8712 9522 77 9220 109 AOI21_X2
* cell instance $12414 m0 *1 168.15,119
X$12414 9441 9358 9523 109 9522 77 OAI21_X1
* cell instance $12417 m0 *1 169.29,119
X$12417 4298 6392 19033 109 77 9604 HA_X1
* cell instance $12418 m0 *1 171.38,119
X$12418 9604 9361 9601 109 9603 77 OAI21_X1
* cell instance $12420 r0 *1 169.29,119
X$12420 9602 9603 6235 9524 77 109 9523 AOI22_X1
* cell instance $12421 r0 *1 170.24,119
X$12421 4297 8103 19067 109 77 9600 HA_X1
* cell instance $12425 r0 *1 172.14,119
X$12425 9602 9692 8719 9524 77 109 9769 AOI22_X1
* cell instance $12427 m0 *1 172.52,119
X$12427 9363 9361 77 109 9601 NAND2_X1
* cell instance $12428 r0 *1 173.09,119
X$12428 9600 9361 9596 109 9692 77 OAI21_X1
* cell instance $12430 m0 *1 173.47,119
X$12430 9364 9597 9224 77 109 9525 MUX2_X1
* cell instance $12433 r0 *1 174.23,119
X$12433 9525 9361 77 109 9596 NAND2_X1
* cell instance $12435 m0 *1 176.7,119
X$12435 9285 6427 77 8889 109 NAND2_X4
* cell instance $12436 m0 *1 175.94,119
X$12436 9056 10086 109 77 9226 AND2_X1
* cell instance $12438 r0 *1 176.32,119
X$12438 77 9593 18802 9592 9590 3676 109 DFFR_X1
* cell instance $12439 m0 *1 179.36,119
X$12439 6390 9592 5832 4170 6255 9413 109 77 AOI221_X2
* cell instance $12440 m0 *1 178.79,119
X$12440 8282 9592 77 109 9365 NAND2_X1
* cell instance $12442 m0 *1 181.64,119
X$12442 9588 109 6603 77 BUF_X4
* cell instance $12445 r0 *1 180.12,119
X$12445 9592 7965 9552 77 109 9590 MUX2_X1
* cell instance $12447 r0 *1 181.64,119
X$12447 9263 9124 9529 8282 9526 9588 109 77 AOI221_X2
* cell instance $12449 m0 *1 205.96,77
X$12449 3946 4552 5497 77 109 5521 MUX2_X1
* cell instance $12450 m0 *1 205.2,77
X$12450 625 5384 5628 109 5496 77 OAI21_X1
* cell instance $12451 m0 *1 207.29,77
X$12451 77 4687 18644 5497 5521 3676 109 DFFR_X1
* cell instance $12452 m0 *1 211.09,77
X$12452 77 4687 5520 3676 18930 4558 109 DFFR_X2
* cell instance $12456 m0 *1 217.74,77
X$12456 77 4687 18662 4833 5810 3676 109 DFFR_X1
* cell instance $12457 m0 *1 221.54,77
X$12457 5093 5392 5515 109 5806 77 OAI21_X1
* cell instance $12458 m0 *1 222.3,77
X$12458 4833 77 109 5634 INV_X1
* cell instance $12459 m0 *1 222.68,77
X$12459 4952 5392 5634 4596 109 77 5652 OAI22_X1
* cell instance $12461 m0 *1 223.82,77
X$12461 77 5635 5093 5512 5650 3676 109 DFFR_X1
* cell instance $12464 m0 *1 229.33,77
X$12464 77 5635 4835 5503 5505 992 109 DFFR_X1
* cell instance $12465 m0 *1 233.13,77
X$12465 2872 5641 5636 3090 5501 3430 109 77 AOI221_X2
* cell instance $12467 m0 *1 235.41,77
X$12467 5501 5095 5502 77 109 5638 MUX2_X1
* cell instance $12468 m0 *1 236.74,77
X$12468 4960 5503 77 109 5507 NAND2_X1
* cell instance $12472 r0 *1 205.2,77
X$12472 5780 5625 5497 5629 77 109 5628 AOI22_X1
* cell instance $12474 r0 *1 206.91,77
X$12474 5630 77 109 4684 INV_X1
* cell instance $12476 r0 *1 207.48,77
X$12476 5630 5659 5523 3946 77 109 5632 AOI22_X2
* cell instance $12477 r0 *1 209.19,77
X$12477 4583 77 109 5783 INV_X1
* cell instance $12479 r0 *1 209.95,77
X$12479 5655 77 109 5498 CLKBUF_X3
* cell instance $12482 r0 *1 212.8,77
X$12482 77 4687 5242 5784 5654 3676 109 DFFR_X1
* cell instance $12483 r0 *1 216.6,77
X$12483 5633 4986 5811 77 109 5654 MUX2_X1
* cell instance $12486 r0 *1 218.5,77
X$12486 631 5781 5786 5374 5634 109 77 5810 OAI221_X1
* cell instance $12489 r0 *1 220.59,77
X$12489 5652 3117 4373 77 5653 109 AOI21_X2
* cell instance $12492 r0 *1 223.63,77
X$12492 5651 4986 5500 77 109 5650 MUX2_X1
* cell instance $12494 r0 *1 225.34,77
X$12494 4867 77 109 5233 CLKBUF_X3
* cell instance $12499 r0 *1 227.05,77
X$12499 77 5635 18833 3844 5648 992 109 DFFR_X1
* cell instance $12500 r0 *1 230.85,77
X$12500 3844 77 109 5798 INV_X1
* cell instance $12503 r0 *1 232.18,77
X$12503 5791 4685 4553 109 5636 77 OAI21_X1
* cell instance $12505 r0 *1 233.13,77
X$12505 2872 5642 5795 3090 5637 3845 109 77 AOI221_X2
* cell instance $12506 r0 *1 235.22,77
X$12506 5640 77 109 5642 BUF_X1
* cell instance $12507 r0 *1 235.79,77
X$12507 77 5635 18844 5502 5638 992 109 DFFR_X1
* cell instance $12509 m0 *1 160.17,93.8
X$12509 7154 6920 7155 77 109 7294 MUX2_X1
* cell instance $12513 r0 *1 159.98,93.8
X$12513 6763 7229 7146 77 109 7155 MUX2_X1
* cell instance $12516 r0 *1 162.26,93.8
X$12516 6926 109 7295 77 BUF_X4
* cell instance $12517 m0 *1 163.97,93.8
X$12517 7109 6602 3344 109 77 7152 OAI21_X2
* cell instance $12518 m0 *1 162.64,93.8
X$12518 6920 109 5552 77 BUF_X4
* cell instance $12520 m0 *1 165.49,93.8
X$12520 77 6329 7110 3344 1893 7149 109 OAI22_X4
* cell instance $12521 m0 *1 168.72,93.8
X$12521 7233 77 109 7149 INV_X1
* cell instance $12523 r0 *1 163.59,93.8
X$12523 7233 7232 6932 77 109 7107 MUX2_X1
* cell instance $12526 r0 *1 165.87,93.8
X$12526 2620 6602 77 109 7293 NOR2_X2
* cell instance $12529 r0 *1 167.96,93.8
X$12529 7113 77 109 6930 INV_X2
* cell instance $12531 m0 *1 169.67,93.8
X$12531 6326 6927 6197 77 109 7111 MUX2_X1
* cell instance $12542 r0 *1 171.19,93.8
X$12542 6927 77 109 7234 INV_X2
* cell instance $12543 m0 *1 172.71,93.8
X$12543 6764 77 109 6326 BUF_X2
* cell instance $12544 m0 *1 171.38,93.8
X$12544 6197 7112 6326 77 109 7033 MUX2_X1
* cell instance $12546 r0 *1 171.76,93.8
X$12546 6198 7235 6604 77 109 7236 MUX2_X1
* cell instance $12547 r0 *1 173.09,93.8
X$12547 77 6200 7236 2620 484 7371 109 OAI22_X4
* cell instance $12548 m0 *1 175.18,93.8
X$12548 6840 6696 6872 7115 109 77 7287 OAI22_X2
* cell instance $12549 m0 *1 173.85,93.8
X$12549 6198 7370 6197 77 109 7289 MUX2_X1
* cell instance $12550 m0 *1 176.89,93.8
X$12550 6749 7285 6931 77 109 7147 MUX2_X1
* cell instance $12551 m0 *1 178.22,93.8
X$12551 77 6831 7147 3152 1330 7114 109 OAI22_X4
* cell instance $12552 m0 *1 181.45,93.8
X$12552 6761 7146 6749 77 109 7144 MUX2_X1
* cell instance $12553 m0 *1 182.78,93.8
X$12553 7144 6659 77 109 7145 NOR2_X1
* cell instance $12554 m0 *1 183.35,93.8
X$12554 7116 109 1063 77 BUF_X4
* cell instance $12555 m0 *1 184.68,93.8
X$12555 7425 77 109 6934 INV_X1
* cell instance $12556 m0 *1 185.06,93.8
X$12556 6066 109 6937 77 BUF_X4
* cell instance $12558 m0 *1 186.58,93.8
X$12558 5626 109 6485 77 BUF_X4
* cell instance $12560 m0 *1 188.1,93.8
X$12560 6937 6928 5492 7280 6936 7140 77 109 OAI221_X2
* cell instance $12562 m0 *1 190.38,93.8
X$12562 7141 77 109 7280 INV_X1
* cell instance $12564 r0 *1 176.32,93.8
X$12564 77 6329 7289 3523 7372 7237 109 OAI22_X4
* cell instance $12565 r0 *1 179.55,93.8
X$12565 7238 77 109 6765 INV_X1
* cell instance $12566 r0 *1 179.93,93.8
X$12566 77 7116 7145 7231 2740 109 AOI21_X4
* cell instance $12567 r0 *1 182.4,93.8
X$12567 77 7424 7018 6932 3356 109 AOI21_X4
* cell instance $12568 r0 *1 184.87,93.8
X$12568 7373 5492 6485 6937 4599 109 77 7278 OAI221_X1
* cell instance $12569 r0 *1 186.01,93.8
X$12569 6937 7175 5492 7282 6485 7239 77 109 OAI221_X2
* cell instance $12570 r0 *1 188.1,93.8
X$12570 6937 6149 5492 7420 6936 7276 77 109 OAI221_X2
* cell instance $12572 r0 *1 190.38,93.8
X$12572 7375 7278 6941 6382 77 109 6773 NAND4_X1
* cell instance $12573 m0 *1 191.33,93.8
X$12573 6935 7277 6941 6382 77 109 6772 NAND4_X1
* cell instance $12576 r0 *1 191.33,93.8
X$12576 5524 77 109 6382 CLKBUF_X3
* cell instance $12578 m0 *1 2.66,172.2
X$12578 14038 7054 14309 77 109 14308 MUX2_X1
* cell instance $12581 m0 *1 4.18,172.2
X$12581 9961 77 109 13800 CLKBUF_X3
* cell instance $12582 m0 *1 5.13,172.2
X$12582 77 13800 14310 14312 14373 9814 109 DFFR_X1
* cell instance $12583 m0 *1 8.93,172.2
X$12583 14118 6876 14312 77 109 14373 MUX2_X1
* cell instance $12585 m0 *1 10.45,172.2
X$12585 77 13672 14253 14166 14249 9814 109 DFFR_X1
* cell instance $12586 m0 *1 14.25,172.2
X$12586 77 14168 14381 14169 14167 9814 109 DFFR_X1
* cell instance $12598 r0 *1 3.04,172.2
X$12598 77 13800 14311 14309 14308 9814 109 DFFR_X1
* cell instance $12599 r0 *1 6.84,172.2
X$12599 14038 6214 14372 77 109 14515 MUX2_X1
* cell instance $12600 r0 *1 8.17,172.2
X$12600 14310 6083 14311 77 109 14459 MUX2_X1
* cell instance $12601 r0 *1 9.5,172.2
X$12601 14310 4309 14311 77 109 14374 MUX2_X1
* cell instance $12603 r0 *1 11.59,172.2
X$12603 14374 10860 14520 77 109 14377 MUX2_X1
* cell instance $12605 r0 *1 15.96,172.2
X$12605 14377 5017 14378 77 109 14122 MUX2_X1
* cell instance $12609 r0 *1 18.62,172.2
X$12609 77 5169 109 3048 BUF_X8
* cell instance $12610 m0 *1 20.14,172.2
X$12610 14313 4496 14170 77 109 14382 MUX2_X1
* cell instance $12612 m0 *1 21.47,172.2
X$12612 14253 4496 14381 77 109 14384 MUX2_X1
* cell instance $12616 r0 *1 21.28,172.2
X$12616 14170 13257 14381 77 109 14526 MUX2_X1
* cell instance $12619 m0 *1 23.94,172.2
X$12619 14382 5039 14384 77 109 14174 MUX2_X1
* cell instance $12623 r0 *1 25.08,172.2
X$12623 77 13984 14315 14385 14314 9814 109 DFFR_X1
* cell instance $12624 m0 *1 26.6,172.2
X$12624 14038 5252 14385 77 109 14314 MUX2_X1
* cell instance $12628 r0 *1 28.88,172.2
X$12628 14171 13257 14316 77 109 14532 MUX2_X1
* cell instance $12630 m0 *1 29.07,172.2
X$12630 14463 4627 14171 77 109 14172 MUX2_X1
* cell instance $12631 m0 *1 33.44,172.2
X$12631 14038 4905 14173 77 109 14317 MUX2_X1
* cell instance $12635 r0 *1 30.21,172.2
X$12635 14315 5461 14316 77 109 14254 MUX2_X1
* cell instance $12636 r0 *1 31.54,172.2
X$12636 77 14318 14316 14173 14317 9814 109 DFFR_X1
* cell instance $12637 r0 *1 35.34,172.2
X$12637 77 14318 14389 14643 14465 9814 109 DFFR_X1
* cell instance $12638 r0 *1 39.14,172.2
X$12638 14389 77 109 14042 INV_X1
* cell instance $12640 m0 *1 39.9,172.2
X$12640 6236 14174 8858 109 14176 77 OAI21_X1
* cell instance $12643 m0 *1 40.85,172.2
X$12643 14176 14260 14648 77 109 14177 NOR3_X1
* cell instance $12645 r0 *1 40.28,172.2
X$12645 14175 14391 4210 77 109 14466 NOR3_X1
* cell instance $12648 r0 *1 41.61,172.2
X$12648 14392 4627 14650 77 109 13631 MUX2_X1
* cell instance $12649 m0 *1 43.32,172.2
X$12649 77 14318 14320 14395 14262 4086 109 DFFR_X1
* cell instance $12650 m0 *1 41.99,172.2
X$12650 14395 13926 14043 77 109 14262 MUX2_X1
* cell instance $12654 m0 *1 47.69,172.2
X$12654 14320 10435 14399 77 109 14398 MUX2_X1
* cell instance $12657 m0 *1 49.21,172.2
X$12657 14320 13355 14399 77 109 14321 MUX2_X1
* cell instance $12659 m0 *1 51.3,172.2
X$12659 77 13551 14325 14324 14270 4086 109 DFFR_X1
* cell instance $12660 m0 *1 55.1,172.2
X$12660 14048 5178 14324 77 109 14270 MUX2_X1
* cell instance $12662 m0 *1 57.95,172.2
X$12662 14325 10200 14179 77 109 14326 MUX2_X1
* cell instance $12663 m0 *1 59.28,172.2
X$12663 14326 7156 14405 77 109 14474 MUX2_X1
* cell instance $12665 m0 *1 61.37,172.2
X$12665 14180 4784 14181 77 109 14407 MUX2_X1
* cell instance $12666 m0 *1 62.7,172.2
X$12666 14180 10200 14181 77 109 14405 MUX2_X1
* cell instance $12669 m0 *1 66.31,172.2
X$12669 8063 109 3694 77 BUF_X4
* cell instance $12671 m0 *1 67.83,172.2
X$12671 14140 5178 14411 77 109 14327 MUX2_X1
* cell instance $12672 m0 *1 69.16,172.2
X$12672 77 13555 14185 14273 14182 8687 109 DFFR_X1
* cell instance $12673 m0 *1 72.96,172.2
X$12673 14328 6584 14185 77 109 14329 MUX2_X1
* cell instance $12674 m0 *1 74.29,172.2
X$12674 14328 13040 14185 77 109 14280 MUX2_X1
* cell instance $12678 m0 *1 80.37,172.2
X$12678 14277 7290 8070 9429 14665 14423 109 77 AOI221_X2
* cell instance $12679 m0 *1 82.46,172.2
X$12679 10449 8369 14277 77 14420 109 AOI21_X1
* cell instance $12680 m0 *1 83.22,172.2
X$12680 14331 14187 13164 77 109 14417 MUX2_X1
* cell instance $12681 m0 *1 84.55,172.2
X$12681 77 13559 14189 14331 14417 8687 109 DFFR_X1
* cell instance $12685 r0 *1 48.07,172.2
X$12685 14398 5536 14469 77 109 14121 MUX2_X1
* cell instance $12686 r0 *1 49.4,172.2
X$12686 14471 14400 8671 77 109 14391 NOR3_X1
* cell instance $12687 r0 *1 50.16,172.2
X$12687 14321 8670 77 109 14400 NOR2_X1
* cell instance $12691 r0 *1 52.82,172.2
X$12691 14401 13149 14712 77 109 14403 MUX2_X1
* cell instance $12694 r0 *1 54.72,172.2
X$12694 14322 3048 14323 77 109 14545 MUX2_X1
* cell instance $12695 r0 *1 56.05,172.2
X$12695 14472 3048 14546 77 109 14473 MUX2_X1
* cell instance $12697 r0 *1 58.14,172.2
X$12697 14325 4784 14179 77 109 14406 MUX2_X1
* cell instance $12702 r0 *1 59.85,172.2
X$12702 14406 5410 14407 77 109 14598 MUX2_X1
* cell instance $12703 r0 *1 61.18,172.2
X$12703 77 13553 14181 14549 14409 4086 109 DFFR_X1
* cell instance $12705 r0 *1 68.02,172.2
X$12705 77 13555 14328 14411 14327 8687 109 DFFR_X1
* cell instance $12708 r0 *1 72.39,172.2
X$12708 14414 6584 14413 77 109 14330 MUX2_X1
* cell instance $12709 r0 *1 73.72,172.2
X$12709 14329 3978 14330 77 109 14554 MUX2_X1
* cell instance $12710 r0 *1 75.05,172.2
X$12710 14414 13040 14413 77 109 14412 MUX2_X1
* cell instance $12714 r0 *1 79.04,172.2
X$12714 77 5740 109 13040 BUF_X8
* cell instance $12715 r0 *1 81.51,172.2
X$12715 14440 6888 14333 77 109 14558 MUX2_X1
* cell instance $12718 r0 *1 83.41,172.2
X$12718 14332 5589 14476 77 14416 109 AOI21_X1
* cell instance $12719 r0 *1 84.17,172.2
X$12719 14333 6451 77 109 14332 NOR2_X1
* cell instance $12722 r0 *1 85.31,172.2
X$12722 14416 5887 77 109 14421 NAND2_X1
* cell instance $12725 r0 *1 86.45,172.2
X$12725 14419 14187 14193 77 109 14559 MUX2_X1
* cell instance $12727 r0 *1 88.54,172.2
X$12727 14421 14420 5479 8250 14334 14335 109 77 AOI221_X2
* cell instance $12729 m0 *1 88.73,172.2
X$12729 14280 6593 14412 77 109 14334 MUX2_X1
* cell instance $12730 m0 *1 90.82,172.2
X$12730 14478 6236 77 109 14284 NOR2_X1
* cell instance $12731 m0 *1 91.39,172.2
X$12731 14423 14191 8672 77 109 14426 NOR3_X1
* cell instance $12732 m0 *1 92.15,172.2
X$12732 14284 14426 8627 109 14425 77 NOR3_X2
* cell instance $12733 m0 *1 93.48,172.2
X$12733 77 14428 14429 14192 14433 8201 109 DFFR_X1
* cell instance $12734 m0 *1 97.28,172.2
X$12734 14192 13767 14193 77 109 14433 MUX2_X1
* cell instance $12737 r0 *1 91.39,172.2
X$12737 77 14428 14565 14567 14427 8201 109 DFFR_X1
* cell instance $12740 r0 *1 95.76,172.2
X$12740 14431 8672 14568 77 109 14434 MUX2_X1
* cell instance $12741 r0 *1 97.09,172.2
X$12741 77 13183 14425 6369 14434 109 AOI21_X4
* cell instance $12743 m0 *1 98.99,172.2
X$12743 8250 6125 77 109 14194 NOR2_X2
* cell instance $12745 r0 *1 99.56,172.2
X$12745 14569 3611 14554 77 109 14431 MUX2_X1
* cell instance $12747 m0 *1 101.46,172.2
X$12747 14436 14046 14193 77 109 14438 MUX2_X1
* cell instance $12748 m0 *1 101.08,172.2
X$12748 13687 77 109 19130 INV_X1
* cell instance $12750 m0 *1 106.97,172.2
X$12750 14442 13548 14440 77 109 14336 MUX2_X1
* cell instance $12751 m0 *1 103.17,172.2
X$12751 77 13819 14196 14436 14438 8201 109 DFFR_X1
* cell instance $12755 r0 *1 104.31,172.2
X$12755 14195 8209 14479 77 109 14575 MUX2_X1
* cell instance $12757 r0 *1 105.83,172.2
X$12757 14196 10449 14441 77 109 14480 MUX2_X1
* cell instance $12758 r0 *1 107.16,172.2
X$12758 77 14198 14441 14442 14336 8201 109 DFFR_X1
* cell instance $12759 r0 *1 110.96,172.2
X$12759 10451 109 13002 77 BUF_X4
* cell instance $12762 r0 *1 112.86,172.2
X$12762 77 14198 14197 14577 14578 12731 109 DFFR_X1
* cell instance $12763 m0 *1 114.95,172.2
X$12763 13788 13002 14197 77 109 14056 MUX2_X1
* cell instance $12771 r0 *1 116.85,172.2
X$12771 77 14198 14057 14582 14444 12731 109 DFFR_X1
* cell instance $12773 m0 *1 117.42,172.2
X$12773 12722 8008 14445 77 109 14295 MUX2_X1
* cell instance $12775 m0 *1 121.03,172.2
X$12775 77 13171 14298 14199 14297 12731 109 DFFR_X1
* cell instance $12777 m0 *1 125.02,172.2
X$12777 14298 14200 14201 77 109 14447 MUX2_X1
* cell instance $12780 m0 *1 127.3,172.2
X$12780 14202 14200 13936 77 109 14337 MUX2_X1
* cell instance $12782 m0 *1 128.82,172.2
X$12782 77 13430 14339 14204 14302 12731 109 DFFR_X1
* cell instance $12783 m0 *1 132.62,172.2
X$12783 14204 14206 14449 77 109 14302 MUX2_X1
* cell instance $12784 m0 *1 133.95,172.2
X$12784 9764 14338 8584 77 109 14449 MUX2_X1
* cell instance $12794 r0 *1 126.73,172.2
X$12794 13795 13823 8111 77 109 14484 MUX2_X1
* cell instance $12795 r0 *1 128.06,172.2
X$12795 14337 14485 14447 77 109 14689 MUX2_X1
* cell instance $12799 r0 *1 132.05,172.2
X$12799 14339 14200 13938 77 109 14610 MUX2_X1
* cell instance $12800 r0 *1 133.38,172.2
X$12800 9912 14338 9396 77 109 14486 MUX2_X1
* cell instance $12803 r0 *1 136.61,172.2
X$12803 12990 14338 8925 77 109 14488 MUX2_X1
* cell instance $12804 m0 *1 139.27,172.2
X$12804 14341 13432 14342 77 109 14451 MUX2_X1
* cell instance $12805 m0 *1 137.94,172.2
X$12805 11201 12734 14450 77 109 14341 MUX2_X1
* cell instance $12806 m0 *1 140.6,172.2
X$12806 77 14205 18494 14342 14451 12731 109 DFFR_X1
* cell instance $12808 m0 *1 145.16,172.2
X$12808 9396 12734 11894 77 109 14453 MUX2_X1
* cell instance $12813 r0 *1 139.27,172.2
X$12813 12539 13797 11438 77 109 14574 MUX2_X1
* cell instance $12815 r0 *1 142.12,172.2
X$12815 1236 77 109 13437 CLKBUF_X3
* cell instance $12817 r0 *1 143.45,172.2
X$12817 77 14205 18867 14489 14490 12731 109 DFFR_X1
* cell instance $12818 m0 *1 147.06,172.2
X$12818 14453 13432 14209 77 109 14305 MUX2_X1
* cell instance $12822 r0 *1 147.25,172.2
X$12822 14491 13432 14566 77 109 14492 MUX2_X1
* cell instance $12823 r0 *1 148.58,172.2
X$12823 13060 77 109 14450 BUF_X1
* cell instance $12826 m0 *1 23.94,166.6
X$12826 13804 10435 13674 77 109 13862 MUX2_X1
* cell instance $12828 m0 *1 25.27,166.6
X$12828 13861 5536 13862 77 109 13746 MUX2_X1
* cell instance $12829 m0 *1 26.6,166.6
X$12829 77 12856 13403 13985 13921 9814 109 DFFR_X1
* cell instance $12831 m0 *1 22.04,166.6
X$12831 13860 10435 13673 77 109 13861 MUX2_X1
* cell instance $12835 r0 *1 22.04,166.6
X$12835 77 13984 13674 13920 14108 9814 109 DFFR_X1
* cell instance $12838 r0 *1 26.41,166.6
X$12838 13985 4768 13675 77 109 13921 MUX2_X1
* cell instance $12840 m0 *1 32.11,166.6
X$12840 77 12856 13870 13864 13866 9814 109 DFFR_X1
* cell instance $12841 m0 *1 30.78,166.6
X$12841 13864 4631 13096 77 109 13866 MUX2_X1
* cell instance $12842 m0 *1 35.91,166.6
X$12842 13870 77 109 13809 INV_X1
* cell instance $12845 r0 *1 30.78,166.6
X$12845 13987 5017 13923 77 109 13751 MUX2_X1
* cell instance $12847 r0 *1 32.3,166.6
X$12847 77 12856 13924 13991 13990 9814 109 DFFR_X1
* cell instance $12850 r0 *1 38,166.6
X$12850 13806 7844 13924 77 13992 109 AOI21_X1
* cell instance $12852 m0 *1 38.19,166.6
X$12852 13805 10129 77 109 13806 NOR2_X1
* cell instance $12853 m0 *1 38.95,166.6
X$12853 13805 8666 77 109 13807 NOR2_X1
* cell instance $12856 r0 *1 38.76,166.6
X$12856 13807 8463 13924 77 13994 109 AOI21_X1
* cell instance $12857 r0 *1 39.52,166.6
X$12857 14042 8529 6866 11125 13994 14175 109 77 AOI221_X2
* cell instance $12858 m0 *1 41.61,166.6
X$12858 13925 6591 13808 77 13875 109 AOI21_X1
* cell instance $12860 m0 *1 42.37,166.6
X$12860 13809 8529 7764 8670 13877 13876 109 77 AOI221_X2
* cell instance $12861 m0 *1 44.46,166.6
X$12861 13878 9810 13808 77 13877 109 AOI21_X1
* cell instance $12863 m0 *1 45.41,166.6
X$12863 13757 8463 77 109 13878 NOR2_X1
* cell instance $12866 m0 *1 46.93,166.6
X$12866 77 7844 109 3624 BUF_X8
* cell instance $12867 m0 *1 49.4,166.6
X$12867 14129 10583 9632 77 13998 109 AOI21_X1
* cell instance $12872 r0 *1 42.94,166.6
X$12872 13757 5169 77 109 13925 NOR2_X1
* cell instance $12874 r0 *1 43.7,166.6
X$12874 13876 7338 14045 77 14044 109 AOI21_X1
* cell instance $12877 r0 *1 46.36,166.6
X$12877 5110 109 14047 77 BUF_X4
* cell instance $12878 r0 *1 47.69,166.6
X$12878 77 13551 13678 14131 13998 4086 109 DFFR_X1
* cell instance $12880 m0 *1 50.54,166.6
X$12880 5577 109 13926 77 BUF_X4
* cell instance $12882 r0 *1 51.49,166.6
X$12882 77 13551 13549 14001 14002 4086 109 DFFR_X1
* cell instance $12884 m0 *1 53.01,166.6
X$12884 5577 109 9945 77 BUF_X4
* cell instance $12886 r0 *1 55.29,166.6
X$12886 9945 14001 77 109 14132 NOR2_X1
* cell instance $12888 m0 *1 56.43,166.6
X$12888 77 13551 13811 13810 14003 4086 109 DFFR_X1
* cell instance $12890 m0 *1 60.23,166.6
X$12890 13811 13355 13679 77 109 13882 MUX2_X1
* cell instance $12894 r0 *1 58.33,166.6
X$12894 13927 10763 9632 77 14003 109 AOI21_X1
* cell instance $12898 r0 *1 59.09,166.6
X$12898 9632 13810 77 109 13927 NOR2_X1
* cell instance $12900 r0 *1 60.42,166.6
X$12900 13811 10200 13679 77 109 14004 MUX2_X1
* cell instance $12902 m0 *1 62.13,166.6
X$12902 13882 7620 77 109 13680 NOR2_X1
* cell instance $12904 m0 *1 62.7,166.6
X$12904 77 13553 13765 13813 13812 4086 109 DFFR_X1
* cell instance $12908 m0 *1 70.49,166.6
X$12908 77 13555 13887 13768 13885 8687 109 DFFR_X1
* cell instance $12909 m0 *1 74.29,166.6
X$12909 13814 7926 13887 77 109 13892 MUX2_X1
* cell instance $12913 r0 *1 62.7,166.6
X$12913 14005 10763 9945 77 13812 109 AOI21_X1
* cell instance $12914 r0 *1 63.46,166.6
X$12914 13884 10860 14004 77 109 13266 MUX2_X1
* cell instance $12917 r0 *1 66.5,166.6
X$12917 9945 13813 77 109 14005 NOR2_X1
* cell instance $12921 r0 *1 69.16,166.6
X$12921 77 9429 109 5734 BUF_X8
* cell instance $12923 r0 *1 71.82,166.6
X$12923 77 13555 13890 14009 14007 8687 109 DFFR_X1
* cell instance $12925 m0 *1 78.09,166.6
X$12925 13888 13928 4632 77 109 13557 NOR3_X1
* cell instance $12926 m0 *1 76.76,166.6
X$12926 13890 9023 13891 77 109 13815 MUX2_X1
* cell instance $12930 r0 *1 77.71,166.6
X$12930 13815 3978 77 109 13928 NOR2_X1
* cell instance $12932 r0 *1 79.04,166.6
X$12932 14010 12312 13164 77 109 14011 MUX2_X1
* cell instance $12933 m0 *1 79.42,166.6
X$12933 13890 5740 13891 77 109 13655 MUX2_X1
* cell instance $12938 m0 *1 84.74,166.6
X$12938 7926 109 3500 77 BUF_X4
* cell instance $12941 m0 *1 88.35,166.6
X$12941 13892 8209 8069 109 13776 77 NOR3_X2
* cell instance $12943 m0 *1 89.87,166.6
X$12943 13561 7926 13818 77 109 13564 MUX2_X1
* cell instance $12945 m0 *1 91.39,166.6
X$12945 13816 8359 77 109 13894 NOR2_X1
* cell instance $12946 m0 *1 91.96,166.6
X$12946 13561 8847 13818 77 109 13896 MUX2_X1
* cell instance $12948 r0 *1 80.37,166.6
X$12948 77 13559 14014 14010 14011 8687 109 DFFR_X1
* cell instance $12950 r0 *1 84.55,166.6
X$12950 77 13559 14016 14015 14143 8687 109 DFFR_X1
* cell instance $12951 r0 *1 88.35,166.6
X$12951 14014 13040 14016 77 109 13562 MUX2_X1
* cell instance $12953 r0 *1 90.06,166.6
X$12953 8080 7877 77 109 13929 NAND2_X2
* cell instance $12955 r0 *1 91.39,166.6
X$12955 8080 8079 77 109 14019 NAND2_X1
* cell instance $12957 r0 *1 92.34,166.6
X$12957 13271 13894 13929 14021 13897 13566 77 109 13565 OAI33_X1
* cell instance $12958 r0 *1 93.67,166.6
X$12958 14146 5887 77 109 14021 NOR2_X1
* cell instance $12960 m0 *1 93.67,166.6
X$12960 13900 8069 77 109 13897 NOR2_X1
* cell instance $12961 m0 *1 94.43,166.6
X$12961 9831 8069 77 8362 109 NAND2_X4
* cell instance $12962 m0 *1 96.14,166.6
X$12962 13899 7926 13931 77 109 13900 MUX2_X1
* cell instance $12965 m0 *1 99.75,166.6
X$12965 77 13687 13686 13817 13902 8201 109 DFFR_X1
* cell instance $12966 m0 *1 103.55,166.6
X$12966 13817 13408 13276 77 109 13902 MUX2_X1
* cell instance $12972 r0 *1 95.19,166.6
X$12972 13930 5734 14023 77 109 14022 MUX2_X1
* cell instance $12973 r0 *1 96.52,166.6
X$12973 13899 8645 13931 77 109 14023 MUX2_X1
* cell instance $12975 r0 *1 98.04,166.6
X$12975 77 13687 13931 13932 14024 8201 109 DFFR_X1
* cell instance $12976 r0 *1 101.84,166.6
X$12976 13276 8235 13932 77 109 14024 MUX2_X1
* cell instance $12979 r0 *1 105.07,166.6
X$12979 13276 8166 14027 77 109 13933 MUX2_X1
* cell instance $12980 r0 *1 106.4,166.6
X$12980 77 13819 13899 14027 13933 8201 109 DFFR_X1
* cell instance $12981 m0 *1 109.25,166.6
X$12981 13819 77 109 19149 INV_X1
* cell instance $12984 m0 *1 110.39,166.6
X$12984 77 13819 13934 13906 13786 8201 109 DFFR_X1
* cell instance $12985 m0 *1 114.19,166.6
X$12985 7618 13909 6184 13821 109 77 13820 OAI22_X1
* cell instance $12987 r0 *1 110.2,166.6
X$12987 14026 77 109 13819 CLKBUF_X3
* cell instance $12991 r0 *1 113.81,166.6
X$12991 13934 13002 14029 77 109 13821 MUX2_X1
* cell instance $12995 r0 *1 115.14,166.6
X$12995 13934 10142 13935 77 109 13428 MUX2_X1
* cell instance $12996 m0 *1 115.71,166.6
X$12996 13691 13002 14292 77 109 13909 MUX2_X1
* cell instance $13003 r0 *1 117.04,166.6
X$13003 14161 9945 12095 77 109 14162 MUX2_X1
* cell instance $13009 m0 *1 122.17,166.6
X$13009 77 13171 14201 13913 13912 12731 109 DFFR_X1
* cell instance $13011 m0 *1 125.97,166.6
X$13011 13913 13822 13914 77 109 13912 MUX2_X1
* cell instance $13014 r0 *1 124.64,166.6
X$13014 77 13171 13936 13937 14031 12731 109 DFFR_X1
* cell instance $13015 m0 *1 127.87,166.6
X$13015 9272 13823 6235 77 109 13824 MUX2_X1
* cell instance $13017 m0 *1 129.2,166.6
X$13017 13297 13823 8719 77 109 13825 MUX2_X1
* cell instance $13019 m0 *1 131.29,166.6
X$13019 77 13430 18586 13826 13915 12731 109 DFFR_X1
* cell instance $13021 r0 *1 128.44,166.6
X$13021 13937 13822 13824 77 109 14031 MUX2_X1
* cell instance $13022 r0 *1 129.77,166.6
X$13022 77 13430 13938 13940 14032 12731 109 DFFR_X1
* cell instance $13023 r0 *1 133.57,166.6
X$13023 13940 13939 14033 77 109 14032 MUX2_X1
* cell instance $13024 r0 *1 134.9,166.6
X$13024 13183 14061 8717 77 109 14033 MUX2_X1
* cell instance $13026 m0 *1 135.47,166.6
X$13026 8584 12734 6869 77 109 14034 MUX2_X1
* cell instance $13030 r0 *1 136.42,166.6
X$13030 14034 12738 13941 77 109 14164 MUX2_X1
* cell instance $13034 r0 *1 139.08,166.6
X$13034 12877 77 109 13797 CLKBUF_X3
* cell instance $13035 m0 *1 139.65,166.6
X$13035 77 13022 18493 13799 13911 12731 109 DFFR_X1
* cell instance $13038 m0 *1 143.64,166.6
X$13038 11150 13797 11731 77 109 13910 MUX2_X1
* cell instance $13042 r0 *1 141.17,166.6
X$13042 8111 13281 6599 77 109 13942 MUX2_X1
* cell instance $13043 r0 *1 142.5,166.6
X$13043 13942 14063 13798 77 109 13943 MUX2_X1
* cell instance $13047 m0 *1 145.35,166.6
X$13047 13910 13432 13697 77 109 13827 MUX2_X1
* cell instance $13050 m0 *1 149.15,166.6
X$13050 77 9263 13176 13826 13287 13178 13908 13571 109 OAI222_X2
* cell instance $13052 m0 *1 152,166.6
X$13052 13828 13439 77 109 13699 NAND2_X1
* cell instance $13054 m0 *1 152.76,166.6
X$13054 14064 13439 77 109 13905 NAND2_X1
* cell instance $13055 m0 *1 153.33,166.6
X$13055 14030 13439 77 109 13904 NAND2_X1
* cell instance $13056 m0 *1 153.9,166.6
X$13056 13829 13439 77 109 13903 NAND2_X1
* cell instance $13058 m0 *1 154.66,166.6
X$13058 14564 13181 13830 77 109 12528 MUX2_X1
* cell instance $13061 r0 *1 145.92,166.6
X$13061 9101 13797 13429 77 109 13944 MUX2_X1
* cell instance $13062 r0 *1 147.25,166.6
X$13062 13944 13432 13945 77 109 14159 MUX2_X1
* cell instance $13065 r0 *1 149.53,166.6
X$13065 14560 77 109 13901 CLKBUF_X3
* cell instance $13066 r0 *1 150.48,166.6
X$13066 13292 77 109 13374 CLKBUF_X3
* cell instance $13067 r0 *1 151.43,166.6
X$13067 77 10900 13374 13945 12996 13700 13840 14030 109 OAI222_X2
* cell instance $13069 r0 *1 154.28,166.6
X$13069 77 9764 13176 13941 13182 13178 14153 13830 109 OAI222_X2
* cell instance $13070 m0 *1 156.56,166.6
X$13070 13374 11541 13700 14028 109 77 13701 OAI22_X1
* cell instance $13075 r0 *1 157.51,166.6
X$13075 14152 77 109 10316 INV_X1
* cell instance $13076 m0 *1 158.84,166.6
X$13076 13374 11406 13700 13832 109 77 13831 OAI22_X1
* cell instance $13077 m0 *1 157.89,166.6
X$13077 13374 11409 13700 13833 109 77 13443 OAI22_X1
* cell instance $13081 r0 *1 158.46,166.6
X$13081 14157 77 109 13444 BUF_X2
* cell instance $13082 r0 *1 159.22,166.6
X$13082 77 13947 13643 13946 14066 13444 11301 14025 109 OAI222_X2
* cell instance $13083 m0 *1 160.36,166.6
X$13083 77 13901 13066 13367 13898 12731 109 DFFR_X1
* cell instance $13085 m0 *1 164.16,166.6
X$13085 13790 13949 13704 77 13898 109 AOI21_X1
* cell instance $13089 r0 *1 162.45,166.6
X$13089 12822 13232 13948 109 77 10248 OAI21_X2
* cell instance $13090 r0 *1 163.78,166.6
X$13090 14025 13451 77 109 13949 NOR2_X1
* cell instance $13093 r0 *1 164.92,166.6
X$13093 9170 13950 13951 4660 12751 109 77 13834 OAI221_X1
* cell instance $13094 m0 *1 165.49,166.6
X$13094 13834 13781 13895 109 13787 77 OAI21_X1
* cell instance $13098 m0 *1 169.48,166.6
X$13098 11409 13359 13893 13070 13833 109 77 13835 OAI221_X1
* cell instance $13103 r0 *1 167.01,166.6
X$13103 77 13118 14020 13833 14017 12731 109 DFFR_X1
* cell instance $13108 r0 *1 171.19,166.6
X$13108 14020 77 109 12819 BUF_X2
* cell instance $13110 m0 *1 171.76,166.6
X$13110 12646 77 109 10528 INV_X2
* cell instance $13111 m0 *1 173.09,166.6
X$13111 13444 5163 13836 13703 13643 109 77 13889 OAI221_X1
* cell instance $13112 m0 *1 174.23,166.6
X$13112 13889 13454 13837 77 13781 109 AOI21_X1
* cell instance $13114 m0 *1 175.18,166.6
X$13114 13708 13706 13598 77 13837 109 AOI21_X1
* cell instance $13115 m0 *1 175.94,166.6
X$13115 13886 13236 13769 77 13579 109 AOI21_X2
* cell instance $13116 m0 *1 177.27,166.6
X$13116 13712 12585 77 109 13886 NOR2_X1
* cell instance $13117 m0 *1 177.84,166.6
X$13117 13953 12753 13769 77 13710 109 AOI21_X2
* cell instance $13118 m0 *1 179.17,166.6
X$13118 13842 13883 13285 77 109 NOR2_X4
* cell instance $13119 m0 *1 180.88,166.6
X$13119 13838 12755 13584 77 13956 109 AOI21_X1
* cell instance $13120 m0 *1 181.64,166.6
X$13120 13712 11201 77 109 13838 NOR2_X1
* cell instance $13122 m0 *1 182.4,166.6
X$13122 14006 13303 77 109 13839 NAND2_X1
* cell instance $13125 r0 *1 172.14,166.6
X$13125 13840 14018 77 109 13952 OR2_X1
* cell instance $13128 r0 *1 173.85,166.6
X$13128 13835 14012 14013 77 14017 109 AOI21_X1
* cell instance $13131 r0 *1 175.56,166.6
X$13131 13841 11150 77 109 14145 NOR2_X1
* cell instance $13132 r0 *1 176.13,166.6
X$13132 13956 13580 13709 12199 13452 14012 109 77 AOI221_X2
* cell instance $13133 r0 *1 178.22,166.6
X$13133 13841 8717 77 109 13953 NOR2_X1
* cell instance $13134 r0 *1 178.79,166.6
X$13134 13712 9396 77 109 13955 NOR2_X1
* cell instance $13136 r0 *1 179.55,166.6
X$13136 13955 12994 13584 77 14008 109 AOI21_X2
* cell instance $13138 r0 *1 181.07,166.6
X$13138 13871 13585 13956 77 109 13954 MUX2_X1
* cell instance $13139 r0 *1 182.4,166.6
X$13139 13957 13585 14008 77 109 14006 MUX2_X1
* cell instance $13140 m0 *1 183.54,166.6
X$13140 13880 13303 77 109 13707 NAND2_X1
* cell instance $13143 r0 *1 183.73,166.6
X$13143 77 13118 13958 12731 14137 13840 109 DFFR_X2
* cell instance $13144 m0 *1 184.68,166.6
X$13144 13841 77 109 13584 CLKBUF_X3
* cell instance $13146 m0 *1 185.63,166.6
X$13146 13695 13794 109 13881 77 XOR2_X2
* cell instance $13148 m0 *1 189.05,166.6
X$13148 13718 77 109 18282 INV_X8
* cell instance $13149 m0 *1 187.72,166.6
X$13149 13709 109 13451 77 BUF_X4
* cell instance $13150 m0 *1 190.76,166.6
X$13150 13868 13585 13843 77 109 13880 MUX2_X1
* cell instance $13151 m0 *1 192.09,166.6
X$13151 13960 12738 77 109 13879 NAND2_X1
* cell instance $13152 m0 *1 192.66,166.6
X$13152 77 13844 18533 13845 13879 3676 109 DFFR_X1
* cell instance $13155 m0 *1 198.74,166.6
X$13155 13769 13961 13996 109 13721 77 NOR3_X2
* cell instance $13158 r0 *1 187.91,166.6
X$13158 14000 12897 13584 77 14082 109 AOI21_X1
* cell instance $13160 r0 *1 189.05,166.6
X$13160 13345 77 109 13585 CLKBUF_X3
* cell instance $13161 r0 *1 190,166.6
X$13161 13959 77 109 13712 CLKBUF_X3
* cell instance $13162 r0 *1 190.95,166.6
X$13162 13881 13286 77 109 13999 NAND2_X2
* cell instance $13163 r0 *1 191.9,166.6
X$13163 13712 9101 77 109 14000 NOR2_X1
* cell instance $13164 r0 *1 192.47,166.6
X$13164 77 13999 13997 13881 13633 12880 109 OAI211_X4
* cell instance $13166 r0 *1 195.89,166.6
X$13166 13845 109 13883 77 BUF_X4
* cell instance $13170 r0 *1 198.55,166.6
X$13170 13961 13996 77 109 13997 NOR2_X2
* cell instance $13173 r0 *1 200.07,166.6
X$13173 77 13844 13962 13963 13995 3676 109 DFFR_X1
* cell instance $13175 m0 *1 201.21,166.6
X$13175 13873 13846 13755 77 13598 109 AOI21_X2
* cell instance $13176 m0 *1 203.11,166.6
X$13176 13595 13963 77 109 13874 NAND2_X1
* cell instance $13180 r0 *1 203.87,166.6
X$13180 77 13847 13965 13993 13964 3676 109 DFFR_X1
* cell instance $13182 m0 *1 205.58,166.6
X$13182 13872 13603 109 77 13720 AND2_X1
* cell instance $13184 r0 *1 207.67,166.6
X$13184 77 13847 14093 13966 14115 3676 109 DFFR_X1
* cell instance $13186 m0 *1 208.24,166.6
X$13186 13847 77 109 19210 CLKBUF_X1
* cell instance $13187 m0 *1 209,166.6
X$13187 77 13847 13869 13850 13848 3676 109 DFFR_X1
* cell instance $13188 m0 *1 212.8,166.6
X$13188 13849 77 109 13848 INV_X1
* cell instance $13189 m0 *1 213.18,166.6
X$13189 13850 13595 13871 13967 77 109 13849 AOI22_X1
* cell instance $13190 m0 *1 214.13,166.6
X$13190 14090 13467 13869 109 13871 77 OAI21_X1
* cell instance $13191 m0 *1 214.89,166.6
X$13191 13867 13595 13868 13967 77 109 13851 AOI22_X1
* cell instance $13192 m0 *1 215.84,166.6
X$13192 13851 77 109 13989 INV_X1
* cell instance $13197 r0 *1 211.66,166.6
X$13197 13966 13595 13957 13967 77 109 14112 AOI22_X1
* cell instance $13201 r0 *1 214.7,166.6
X$13201 13633 13722 13988 109 13868 77 OAI21_X1
* cell instance $13202 r0 *1 215.46,166.6
X$13202 77 13191 13988 13867 13989 3676 109 DFFR_X1
* cell instance $13204 r0 *1 219.45,166.6
X$13204 77 18441 13865 13986 12302 109 DFF_X1
* cell instance $13205 r0 *1 222.68,166.6
X$13205 13865 11506 13863 77 109 13986 MUX2_X1
* cell instance $13206 m0 *1 223.82,166.6
X$13206 13609 13322 109 77 13863 XNOR2_X1
* cell instance $13207 m0 *1 223.44,166.6
X$13207 13865 77 109 13608 INV_X1
* cell instance $13209 m0 *1 225.15,166.6
X$13209 10847 13725 109 77 13853 XNOR2_X1
* cell instance $13211 m0 *1 226.48,166.6
X$13211 77 18374 13611 13741 13854 109 DFF_X1
* cell instance $13213 m0 *1 229.9,166.6
X$13213 13980 13613 12467 77 109 13976 MUX2_X1
* cell instance $13217 r0 *1 224.2,166.6
X$13217 8717 77 109 13852 BUF_X1
* cell instance $13218 r0 *1 224.77,166.6
X$13218 13610 11506 13853 77 109 13983 MUX2_X1
* cell instance $13219 r0 *1 226.1,166.6
X$13219 77 18457 13610 13983 13854 109 DFF_X1
* cell instance $13225 r0 *1 229.9,166.6
X$13225 13980 13201 13976 77 109 13982 MUX2_X1
* cell instance $13228 r0 *1 231.8,166.6
X$13228 6235 77 109 14103 BUF_X1
* cell instance $13229 r0 *1 232.37,166.6
X$13229 14105 77 109 13979 BUF_X1
* cell instance $13230 m0 *1 235.6,166.6
X$13230 13728 77 109 13616 BUF_X1
* cell instance $13231 m0 *1 232.37,166.6
X$13231 77 18372 13729 13737 13476 109 DFF_X1
* cell instance $13232 m0 *1 236.17,166.6
X$13232 13734 12305 13855 77 109 13730 MUX2_X1
* cell instance $13233 m0 *1 237.5,166.6
X$13233 13736 77 109 13733 BUF_X1
* cell instance $13234 m0 *1 238.07,166.6
X$13234 13726 77 109 13732 BUF_X1
* cell instance $13236 r0 *1 232.94,166.6
X$13236 13476 77 109 19312 CLKBUF_X1
* cell instance $13237 r0 *1 233.51,166.6
X$13237 11186 77 109 13476 CLKBUF_X3
* cell instance $13238 r0 *1 234.46,166.6
X$13238 13969 13613 13310 77 109 13970 MUX2_X1
* cell instance $13240 r0 *1 235.98,166.6
X$13240 8719 77 109 13978 BUF_X1
* cell instance $13242 r0 *1 237.31,166.6
X$13242 13852 77 109 13731 BUF_X1
* cell instance $13243 r0 *1 237.88,166.6
X$13243 13978 77 109 13857 BUF_X1
* cell instance $13244 r0 *1 238.45,166.6
X$13244 13976 77 109 13856 BUF_X1
* cell instance $13245 r0 *1 239.02,166.6
X$13245 13975 77 109 13972 BUF_X1
* cell instance $13247 m0 *1 239.02,166.6
X$13247 13855 77 109 13615 BUF_X1
* cell instance $13249 m0 *1 68.4,63
X$13249 3184 4287 2718 77 109 4288 MUX2_X1
* cell instance $13252 m0 *1 69.92,63
X$13252 3184 3896 2718 77 109 4424 MUX2_X1
* cell instance $13254 m0 *1 72.77,63
X$13254 3903 3710 4076 109 4212 77 OAI21_X1
* cell instance $13255 m0 *1 73.53,63
X$13255 4072 4289 77 109 4076 NAND2_X1
* cell instance $13257 r0 *1 68.21,63
X$13257 4288 4322 4074 77 109 4323 MUX2_X1
* cell instance $13258 r0 *1 69.54,63
X$13258 4424 4320 4075 77 109 4425 MUX2_X1
* cell instance $13261 r0 *1 71.82,63
X$13261 77 4324 4325 4289 4212 1663 109 DFFR_X1
* cell instance $13263 m0 *1 74.48,63
X$13263 77 4205 109 3498 BUF_X8
* cell instance $13264 m0 *1 79.99,63
X$13264 4327 3794 4156 109 4430 77 OAI21_X1
* cell instance $13269 r0 *1 76.76,63
X$13269 3613 4427 77 109 4428 NAND2_X1
* cell instance $13270 r0 *1 77.33,63
X$13270 3619 4327 4428 109 4326 77 OAI21_X1
* cell instance $13272 r0 *1 79.61,63
X$13272 77 3908 4328 4291 4430 1663 109 DFFR_X1
* cell instance $13274 m0 *1 81.89,63
X$13274 3709 4291 77 109 4156 NAND2_X1
* cell instance $13276 m0 *1 84.17,63
X$13276 2417 3799 4077 109 4214 77 OAI21_X1
* cell instance $13278 m0 *1 85.12,63
X$13278 3799 4158 77 109 4077 NAND2_X1
* cell instance $13283 r0 *1 83.6,63
X$13283 77 3623 4329 4158 4214 1663 109 DFFR_X1
* cell instance $13285 r0 *1 88.16,63
X$13285 77 4216 18747 4331 4437 1663 109 DFFR_X1
* cell instance $13287 m0 *1 88.35,63
X$13287 4215 2235 4079 77 109 4160 MUX2_X1
* cell instance $13288 m0 *1 92.72,63
X$13288 4217 2090 4219 77 109 4218 MUX2_X1
* cell instance $13293 r0 *1 92.91,63
X$13293 77 4216 18737 4219 4218 1663 109 DFFR_X1
* cell instance $13294 m0 *1 95.38,63
X$13294 4068 3626 4079 77 109 4220 MUX2_X1
* cell instance $13300 r0 *1 97.09,63
X$13300 4220 3628 4440 77 109 4332 MUX2_X1
* cell instance $13302 r0 *1 98.61,63
X$13302 4219 3060 3062 4217 77 109 4441 AOI22_X1
* cell instance $13304 m0 *1 99.37,63
X$13304 4294 3913 77 109 4221 OR2_X1
* cell instance $13306 m0 *1 101.08,63
X$13306 3628 4222 3581 4068 2554 77 109 4294 AOI221_X1
* cell instance $13307 m0 *1 102.22,63
X$13307 3626 4081 2553 77 109 NOR2_X4
* cell instance $13309 m0 *1 104.69,63
X$13309 3804 2649 4081 77 109 4083 NAND3_X1
* cell instance $13310 m0 *1 105.45,63
X$13310 3914 2808 2804 77 109 4084 NAND3_X1
* cell instance $13311 m0 *1 106.21,63
X$13311 4166 4083 4084 77 4223 109 AOI21_X1
* cell instance $13312 m0 *1 106.97,63
X$13312 4081 3808 3581 109 77 4453 AND3_X1
* cell instance $13313 m0 *1 107.92,63
X$13313 3915 4166 77 3060 109 NAND2_X4
* cell instance $13316 m0 *1 110.58,63
X$13316 77 3739 18583 4169 4224 4086 109 DFFR_X1
* cell instance $13318 m0 *1 114.57,63
X$13318 4170 3813 2293 77 109 4173 MUX2_X1
* cell instance $13319 m0 *1 115.9,63
X$13319 77 18330 4226 4173 4225 109 DFF_X1
* cell instance $13322 m0 *1 121.41,63
X$13322 3306 2945 77 109 4299 NAND2_X1
* cell instance $13324 r0 *1 99.56,63
X$13324 2952 4441 4221 109 4335 77 OAI21_X1
* cell instance $13326 r0 *1 100.51,63
X$13326 4222 3387 4219 77 4336 109 AOI21_X1
* cell instance $13327 r0 *1 101.27,63
X$13327 4068 2808 77 109 4446 NOR2_X1
* cell instance $13329 r0 *1 102.03,63
X$13329 4337 4215 109 77 4222 AND2_X1
* cell instance $13330 r0 *1 102.79,63
X$13330 4337 77 109 2808 CLKBUF_X3
* cell instance $13331 r0 *1 103.74,63
X$13331 4081 2808 3907 109 77 4338 AND3_X1
* cell instance $13334 r0 *1 105.64,63
X$13334 4082 4223 3059 109 4450 77 OAI21_X1
* cell instance $13336 r0 *1 106.59,63
X$13336 4453 4223 3387 109 4340 77 OAI21_X1
* cell instance $13338 r0 *1 107.54,63
X$13338 3915 109 3062 77 BUF_X4
* cell instance $13340 r0 *1 109.63,63
X$13340 77 3739 18720 4457 4522 4086 109 DFFR_X1
* cell instance $13341 r0 *1 113.43,63
X$13341 4457 109 3915 77 BUF_X4
* cell instance $13350 r0 *1 115.71,63
X$13350 4087 2208 4344 109 4342 77 OAI21_X1
* cell instance $13352 r0 *1 117.99,63
X$13352 4226 77 109 4345 BUF_X1
* cell instance $13353 r0 *1 118.56,63
X$13353 77 4460 109 4226 BUF_X8
* cell instance $13356 r0 *1 121.6,63
X$13356 77 4227 4225 4463 4346 109 DFF_X2
* cell instance $13357 m0 *1 122.55,63
X$13357 4087 2771 4299 109 4227 77 OAI21_X1
* cell instance $13359 m0 *1 123.31,63
X$13359 77 4228 3917 4177 3510 109 DFF_X1
* cell instance $13360 m0 *1 126.54,63
X$13360 2900 77 109 3813 CLKBUF_X3
* cell instance $13364 r0 *1 125.78,63
X$13364 4463 4228 3919 109 77 4249 MUX2_X2
* cell instance $13366 m0 *1 84.17,147
X$13366 12207 7468 11293 77 109 12205 MUX2_X1
* cell instance $13369 m0 *1 87.02,147
X$13369 11875 8984 11876 77 109 11877 MUX2_X1
* cell instance $13370 m0 *1 88.35,147
X$13370 11877 8249 12019 77 109 12212 MUX2_X1
* cell instance $13372 r0 *1 83.98,147
X$13372 77 11291 12088 12207 12205 8687 109 DFFR_X1
* cell instance $13373 r0 *1 87.78,147
X$13373 12088 6180 77 109 12089 NAND2_X1
* cell instance $13377 r0 *1 89.68,147
X$13377 77 12259 12371 8028 12212 109 AOI21_X4
* cell instance $13378 m0 *1 90.25,147
X$13378 12021 6820 12095 77 109 12017 MUX2_X1
* cell instance $13381 m0 *1 91.77,147
X$13381 12015 7063 11878 77 109 12090 MUX2_X1
* cell instance $13386 r0 *1 93.48,147
X$13386 11289 8232 12025 77 109 12022 MUX2_X1
* cell instance $13388 m0 *1 93.48,147
X$13388 77 11296 11880 12025 12022 8201 109 DFFR_X1
* cell instance $13389 m0 *1 97.47,147
X$13389 11717 6130 8249 77 109 11881 NOR3_X1
* cell instance $13392 m0 *1 99.94,147
X$13392 12222 9631 11573 77 109 12220 MUX2_X1
* cell instance $13395 m0 *1 105.83,147
X$13395 12029 9829 11293 77 109 12031 MUX2_X1
* cell instance $13396 m0 *1 107.16,147
X$13396 77 12261 11883 12029 12031 8201 109 DFFR_X1
* cell instance $13399 m0 *1 111.91,147
X$13399 11884 6459 12035 77 109 12227 MUX2_X1
* cell instance $13401 m0 *1 113.43,147
X$13401 12037 9834 12095 77 109 11886 MUX2_X1
* cell instance $13402 m0 *1 114.76,147
X$13402 77 11416 11887 12037 11886 4086 109 DFFR_X1
* cell instance $13403 m0 *1 118.56,147
X$13403 11887 8421 12097 77 109 12230 MUX2_X1
* cell instance $13405 m0 *1 122.93,147
X$13405 5002 5149 19057 109 77 11888 HA_X1
* cell instance $13409 r0 *1 95.76,147
X$13409 12218 12216 77 109 12219 NOR2_X1
* cell instance $13410 r0 *1 96.33,147
X$13410 11879 12219 77 109 12225 NOR2_X2
* cell instance $13411 r0 *1 97.28,147
X$13411 77 11296 12091 12222 12220 8201 109 DFFR_X1
* cell instance $13412 r0 *1 101.08,147
X$13412 12091 11461 12092 77 109 12093 MUX2_X1
* cell instance $13415 r0 *1 102.98,147
X$13415 11882 7936 12094 77 109 12384 MUX2_X1
* cell instance $13416 r0 *1 104.31,147
X$13416 11882 12153 12094 77 109 12224 MUX2_X1
* cell instance $13419 r0 *1 108.87,147
X$13419 7023 77 109 11293 BUF_X2
* cell instance $13422 r0 *1 111.91,147
X$13422 77 8363 12227 12096 12229 8031 109 AOI22_X4
* cell instance $13428 r0 *1 117.04,147
X$13428 12544 8249 12230 77 109 12229 MUX2_X1
* cell instance $13429 r0 *1 118.37,147
X$13429 11887 8345 12097 77 109 12098 MUX2_X1
* cell instance $13430 r0 *1 119.7,147
X$13430 12231 9503 12095 77 109 12391 MUX2_X1
* cell instance $13435 r0 *1 123.69,147
X$13435 7029 11892 77 109 12233 NOR2_X1
* cell instance $13436 r0 *1 124.26,147
X$13436 11888 77 109 10733 CLKBUF_X2
* cell instance $13437 r0 *1 125.02,147
X$13437 11212 109 12420 77 BUF_X4
* cell instance $13438 m0 *1 126.16,147
X$13438 12099 77 109 11891 INV_X1
* cell instance $13439 m0 *1 125.21,147
X$13439 12265 8334 10733 11731 77 109 12041 AOI22_X1
* cell instance $13440 m0 *1 126.54,147
X$13440 11889 11140 12041 109 11471 77 OAI21_X1
* cell instance $13441 m0 *1 127.3,147
X$13441 11889 6474 12234 11140 11891 109 77 11890 OAI221_X1
* cell instance $13442 m0 *1 128.44,147
X$13442 11571 109 11894 77 BUF_X4
* cell instance $13443 m0 *1 129.77,147
X$13443 11891 6474 12235 11140 11472 109 77 12043 OAI221_X1
* cell instance $13444 m0 *1 130.91,147
X$13444 11895 8153 12099 11474 77 109 12044 AOI22_X1
* cell instance $13446 m0 *1 132.05,147
X$13446 11846 6235 6359 77 109 12051 OR3_X1
* cell instance $13448 r0 *1 126.35,147
X$13448 8334 12264 77 109 12234 NAND2_X1
* cell instance $13449 r0 *1 126.92,147
X$13449 77 12144 12233 12100 12392 109 AOI21_X4
* cell instance $13450 r0 *1 129.39,147
X$13450 8334 109 12424 77 BUF_X4
* cell instance $13451 r0 *1 130.72,147
X$13451 11731 11895 77 109 12235 NAND2_X1
* cell instance $13453 r0 *1 131.48,147
X$13453 77 11895 8168 12237 12099 11212 12266 12101 109 AOI222_X2
* cell instance $13454 m0 *1 133.57,147
X$13454 11896 11831 77 109 12047 NOR2_X1
* cell instance $13456 m0 *1 134.14,147
X$13456 11831 11898 12047 77 109 11897 MUX2_X1
* cell instance $13457 m0 *1 135.47,147
X$13457 11899 11898 109 77 12050 AND2_X1
* cell instance $13461 r0 *1 134.33,147
X$13461 12236 11892 77 109 12385 NOR2_X1
* cell instance $13464 r0 *1 135.47,147
X$13464 8719 8717 8584 12051 77 109 12102 OR4_X1
* cell instance $13466 m0 *1 137.56,147
X$13466 11831 77 109 11899 INV_X1
* cell instance $13469 m0 *1 139.46,147
X$13469 11201 11165 12102 77 109 12053 OR3_X1
* cell instance $13470 m0 *1 140.41,147
X$13470 8957 8718 12053 77 109 11543 OR3_X1
* cell instance $13471 m0 *1 141.36,147
X$13471 11734 11736 11896 77 109 NOR2_X4
* cell instance $13472 m0 *1 143.07,147
X$13472 11900 11735 11736 77 109 12055 NOR3_X1
* cell instance $13473 m0 *1 143.83,147
X$13473 12055 11902 77 109 11683 NOR2_X1
* cell instance $13475 m0 *1 144.59,147
X$13475 11905 11831 11903 77 11904 109 AOI21_X1
* cell instance $13476 m0 *1 145.35,147
X$13476 11906 11904 12059 109 11902 77 OAI21_X1
* cell instance $13478 m0 *1 146.87,147
X$13478 11911 77 109 12059 INV_X1
* cell instance $13479 m0 *1 147.25,147
X$13479 12059 11906 12109 109 77 12060 OAI21_X2
* cell instance $13480 m0 *1 148.58,147
X$13480 12061 77 109 11831 BUF_X2
* cell instance $13481 m0 *1 149.34,147
X$13481 12228 11912 12061 109 77 11905 HA_X1
* cell instance $13482 m0 *1 151.24,147
X$13482 11601 11908 12373 77 109 12009 MUX2_X1
* cell instance $13483 m0 *1 152.57,147
X$13483 11910 11678 109 77 12058 AND2_X1
* cell instance $13484 m0 *1 153.33,147
X$13484 12057 11915 12054 109 77 11911 HA_X1
* cell instance $13485 m0 *1 155.23,147
X$13485 11910 11913 77 109 8719 XNOR2_X2
* cell instance $13486 m0 *1 157.13,147
X$13486 11910 11739 11678 109 77 11916 AND3_X1
* cell instance $13487 m0 *1 158.08,147
X$13487 12049 11908 77 109 11917 NOR2_X1
* cell instance $13488 m0 *1 158.65,147
X$13488 11918 11678 11911 77 11920 109 AOI21_X1
* cell instance $13489 m0 *1 159.41,147
X$13489 11920 77 109 11921 INV_X1
* cell instance $13494 r0 *1 140.98,147
X$13494 12103 77 109 12105 INV_X1
* cell instance $13495 r0 *1 141.36,147
X$13495 12104 12103 77 109 11736 NAND2_X1
* cell instance $13496 r0 *1 141.93,147
X$13496 12105 12106 12107 109 12380 77 OAI21_X1
* cell instance $13497 r0 *1 142.69,147
X$13497 12105 11900 12107 109 12232 77 OAI21_X1
* cell instance $13498 r0 *1 143.45,147
X$13498 11899 12056 12108 12106 12109 12110 77 109 OAI221_X2
* cell instance $13499 r0 *1 145.54,147
X$13499 11831 12104 12103 77 109 12108 NAND3_X1
* cell instance $13500 r0 *1 146.3,147
X$13500 11905 77 109 12109 INV_X1
* cell instance $13502 r0 *1 146.87,147
X$13502 11906 12110 77 109 6235 XNOR2_X2
* cell instance $13504 r0 *1 149.15,147
X$13504 11907 11908 12112 77 109 12228 MUX2_X1
* cell instance $13508 r0 *1 155.8,147
X$13508 11911 11739 12110 77 12226 109 AOI21_X1
* cell instance $13509 r0 *1 156.56,147
X$13509 12226 77 109 11744 INV_X1
* cell instance $13512 r0 *1 158.08,147
X$13512 11917 12116 12748 77 12014 109 AOI21_X2
* cell instance $13513 r0 *1 159.41,147
X$13513 12110 11916 11923 11910 11921 11926 109 77 AOI221_X2
* cell instance $13514 m0 *1 160.36,147
X$13514 11922 12033 12040 109 77 11918 HA_X1
* cell instance $13516 m0 *1 162.26,147
X$13516 12221 77 109 11910 BUF_X2
* cell instance $13519 m0 *1 163.97,147
X$13519 12038 11924 109 8717 77 XOR2_X2
* cell instance $13520 m0 *1 165.68,147
X$13520 12215 77 109 11924 BUF_X2
* cell instance $13521 m0 *1 166.44,147
X$13521 11925 11926 11927 109 12038 77 OAI21_X1
* cell instance $13522 m0 *1 167.2,147
X$13522 12034 11924 12036 77 11928 109 AOI21_X2
* cell instance $13523 m0 *1 168.53,147
X$13523 12034 11924 12115 77 11752 109 AOI21_X2
* cell instance $13524 m0 *1 169.86,147
X$13524 12030 7233 12023 109 12033 77 OAI21_X1
* cell instance $13525 m0 *1 170.62,147
X$13525 12030 6392 12206 109 11915 77 OAI21_X1
* cell instance $13527 m0 *1 171.57,147
X$13527 11926 11750 11752 109 12028 77 OAI21_X1
* cell instance $13529 m0 *1 172.52,147
X$13529 12028 11620 77 109 12211 NAND2_X1
* cell instance $13530 m0 *1 173.09,147
X$13530 11753 11618 77 109 11929 NOR2_X1
* cell instance $13533 m0 *1 175.37,147
X$13533 12030 6930 12119 109 12010 77 OAI21_X1
* cell instance $13534 m0 *1 176.13,147
X$13534 11768 11756 11757 109 11930 77 OAI21_X1
* cell instance $13536 m0 *1 177.08,147
X$13536 11756 11618 11753 77 12201 109 AOI21_X1
* cell instance $13537 m0 *1 177.84,147
X$13537 11931 12201 11759 109 12018 77 OAI21_X1
* cell instance $13538 m0 *1 178.6,147
X$13538 11758 11931 77 109 11666 NOR2_X1
* cell instance $13542 r0 *1 162.07,147
X$13542 12214 12114 12221 109 77 11923 HA_X1
* cell instance $13544 r0 *1 164.73,147
X$13544 12275 6758 12210 109 11912 77 OAI21_X1
* cell instance $13545 r0 *1 165.49,147
X$13545 12217 12213 12215 109 77 12034 HA_X1
* cell instance $13546 r0 *1 167.39,147
X$13546 12115 77 109 11927 INV_X1
* cell instance $13549 r0 *1 168.72,147
X$13549 12116 8103 12117 109 12214 77 OAI21_X1
* cell instance $13550 r0 *1 169.48,147
X$13550 12030 7809 12118 109 12213 77 OAI21_X1
* cell instance $13557 r0 *1 171.57,147
X$13557 77 8584 11768 12211 11929 109 AOI21_X4
* cell instance $13558 r0 *1 174.04,147
X$13558 12356 77 109 11756 BUF_X1
* cell instance $13560 r0 *1 175.37,147
X$13560 12030 7519 12353 109 12197 77 OAI21_X1
* cell instance $13562 r0 *1 176.51,147
X$13562 11930 11759 77 109 12204 NAND2_X1
* cell instance $13563 r0 *1 177.08,147
X$13563 12352 77 109 11759 INV_X1
* cell instance $13564 r0 *1 177.46,147
X$13564 12120 12204 77 109 11201 XNOR2_X2
* cell instance $13565 r0 *1 179.36,147
X$13565 9236 77 109 12199 BUF_X2
* cell instance $13567 m0 *1 179.55,147
X$13567 11760 11933 12018 77 11761 109 AOI21_X1
* cell instance $13568 r0 *1 180.12,147
X$13568 12121 11933 11757 77 109 12196 NAND3_X1
* cell instance $13569 m0 *1 180.88,147
X$13569 11619 11936 11937 109 11934 77 OAI21_X1
* cell instance $13571 m0 *1 181.64,147
X$13571 11622 12016 77 109 11936 OR2_X1
* cell instance $13572 m0 *1 182.4,147
X$13572 12014 12197 12013 109 77 11766 HA_X1
* cell instance $13573 m0 *1 184.3,147
X$13573 12013 77 109 11763 BUF_X1
* cell instance $13576 m0 *1 185.82,147
X$13576 12191 11768 77 109 12005 NOR2_X1
* cell instance $13577 m0 *1 186.39,147
X$13577 1236 77 109 8477 CLKBUF_X3
* cell instance $13578 m0 *1 187.34,147
X$13578 12009 12010 12008 109 77 11939 HA_X1
* cell instance $13579 m0 *1 189.24,147
X$13579 8477 77 109 18283 INV_X8
* cell instance $13580 m0 *1 190.95,147
X$13580 11939 11941 11770 77 11940 109 AOI21_X2
* cell instance $13581 m0 *1 192.28,147
X$13581 12000 77 109 11942 INV_X1
* cell instance $13582 m0 *1 192.66,147
X$13582 11775 77 109 10180 BUF_X1
* cell instance $13584 m0 *1 193.42,147
X$13584 11942 12124 11771 109 11947 77 NOR3_X2
* cell instance $13585 m0 *1 194.75,147
X$13585 12000 11941 11943 77 11944 109 AOI21_X1
* cell instance $13586 m0 *1 195.51,147
X$13586 11944 11945 77 109 11994 NAND2_X1
* cell instance $13587 m0 *1 196.08,147
X$13587 11941 77 109 11771 INV_X1
* cell instance $13588 m0 *1 196.46,147
X$13588 11945 11942 11774 11777 11994 11652 77 109 OAI221_X2
* cell instance $13589 m0 *1 198.55,147
X$13589 11945 77 109 12126 INV_X1
* cell instance $13590 m0 *1 198.93,147
X$13590 11949 11941 77 109 12127 NAND2_X1
* cell instance $13591 m0 *1 199.5,147
X$13591 11949 11771 77 109 11948 NAND2_X1
* cell instance $13592 m0 *1 200.07,147
X$13592 11947 77 109 11774 INV_X1
* cell instance $13595 m0 *1 202.16,147
X$13595 11989 11951 77 109 12183 NOR2_X1
* cell instance $13596 m0 *1 202.73,147
X$13596 11496 11605 11777 12129 109 77 11804 AND4_X1
* cell instance $13597 m0 *1 203.87,147
X$13597 11989 11951 77 109 11651 NAND2_X1
* cell instance $13598 m0 *1 204.44,147
X$13598 77 11990 12330 11950 9552 11953 109 OAI211_X4
* cell instance $13601 m0 *1 208.62,147
X$13601 2526 11988 8607 109 11954 77 OAI21_X1
* cell instance $13605 m0 *1 211.85,147
X$13605 12179 77 109 11328 BUF_X1
* cell instance $13608 m0 *1 214.7,147
X$13608 12174 2526 12176 77 109 12177 MUX2_X1
* cell instance $13609 m0 *1 216.03,147
X$13609 8933 109 3592 77 BUF_X4
* cell instance $13611 r0 *1 180.88,147
X$13611 11934 12121 77 109 9236 XNOR2_X2
* cell instance $13613 r0 *1 182.97,147
X$13613 12279 77 109 12123 INV_X1
* cell instance $13614 r0 *1 183.35,147
X$13614 12196 12122 12123 77 109 12195 NAND3_X1
* cell instance $13615 r0 *1 184.11,147
X$13615 12195 12123 12122 109 77 11623 OAI21_X2
* cell instance $13616 r0 *1 185.44,147
X$13616 12122 12123 77 109 12191 NAND2_X1
* cell instance $13620 r0 *1 189.62,147
X$13620 12188 77 109 12187 INV_X1
* cell instance $13621 r0 *1 190,147
X$13621 12008 77 109 11941 BUF_X2
* cell instance $13623 r0 *1 190.95,147
X$13623 77 11945 12188 11943 11939 109 AOI21_X4
* cell instance $13624 r0 *1 193.42,147
X$13624 11943 77 109 12124 INV_X1
* cell instance $13626 r0 *1 193.99,147
X$13626 12124 11940 12187 109 12339 77 OAI21_X1
* cell instance $13629 r0 *1 195.32,147
X$13629 12126 11941 11943 77 12125 109 AOI21_X1
* cell instance $13630 r0 *1 196.08,147
X$13630 12126 11808 12000 77 109 11946 NOR3_X1
* cell instance $13631 r0 *1 196.84,147
X$13631 11952 11941 77 109 11012 XNOR2_X2
* cell instance $13632 r0 *1 198.74,147
X$13632 12127 11952 11948 77 109 11776 MUX2_X1
* cell instance $13633 r0 *1 200.07,147
X$13633 11949 77 109 9245 INV_X4
* cell instance $13635 r0 *1 201.78,147
X$13635 11951 77 109 12184 INV_X1
* cell instance $13636 r0 *1 202.16,147
X$13636 12184 12128 109 77 12129 AND2_X1
* cell instance $13637 r0 *1 202.92,147
X$13637 11951 12128 12183 77 109 11778 MUX2_X1
* cell instance $13640 r0 *1 204.82,147
X$13640 12130 12131 11808 77 109 12182 NOR3_X1
* cell instance $13641 r0 *1 205.58,147
X$13641 12128 12132 12133 109 12131 77 OAI21_X1
* cell instance $13642 r0 *1 206.34,147
X$13642 11808 11989 12133 12132 109 77 12329 AND4_X1
* cell instance $13643 r0 *1 207.48,147
X$13643 12132 12133 11989 77 109 11953 NAND3_X2
* cell instance $13644 r0 *1 208.81,147
X$13644 77 18468 12179 11954 12134 109 DFF_X1
* cell instance $13645 r0 *1 212.04,147
X$13645 2348 77 109 10204 CLKBUF_X3
* cell instance $13647 r0 *1 213.37,147
X$13647 77 18473 12137 12177 11172 109 DFF_X1
* cell instance $13648 r0 *1 216.6,147
X$13648 12137 12138 109 77 12174 XNOR2_X1
* cell instance $13649 r0 *1 217.74,147
X$13649 12175 11197 77 109 12138 NAND2_X1
* cell instance $13651 m0 *1 217.74,147
X$13651 3592 11782 77 109 11955 NAND2_X1
* cell instance $13652 m0 *1 218.5,147
X$13652 9398 11955 77 109 12297 NAND2_X2
* cell instance $13655 m0 *1 220.4,147
X$13655 77 11018 11956 11982 12167 12171 109 OAI22_X4
* cell instance $13657 m0 *1 223.82,147
X$13657 77 18366 11977 12166 11785 109 DFF_X1
* cell instance $13658 m0 *1 227.05,147
X$13658 11977 8933 109 77 11784 AND2_X1
* cell instance $13660 m0 *1 228,147
X$13660 10361 11975 4036 77 12159 109 AOI21_X2
* cell instance $13661 m0 *1 229.33,147
X$13661 10361 77 109 11976 INV_X1
* cell instance $13662 m0 *1 229.71,147
X$13662 11976 11786 8749 109 77 11787 OAI21_X2
* cell instance $13668 r0 *1 219.64,147
X$13668 3884 77 109 11197 INV_X2
* cell instance $13669 r0 *1 220.21,147
X$13669 12139 77 109 12171 INV_X1
* cell instance $13670 r0 *1 220.59,147
X$13670 8933 12137 77 109 12140 NAND2_X1
* cell instance $13672 r0 *1 221.35,147
X$13672 11336 12171 8749 109 77 12141 OAI21_X2
* cell instance $13673 r0 *1 222.68,147
X$13673 11957 11959 77 109 12168 NAND2_X1
* cell instance $13674 r0 *1 223.25,147
X$13674 11958 12142 12164 109 12166 77 OAI21_X1
* cell instance $13675 r0 *1 224.01,147
X$13675 12168 11508 77 109 12142 NAND2_X1
* cell instance $13679 r0 *1 225.91,147
X$13679 3884 2348 12158 77 109 12318 NAND3_X1
* cell instance $13684 r0 *1 227.05,147
X$13684 10034 12158 77 109 12301 NOR2_X1
* cell instance $13687 r0 *1 228.19,147
X$13687 12297 11509 12159 77 109 12161 NAND3_X2
* cell instance $13690 r0 *1 230.09,147
X$13690 12159 11631 12297 109 77 12157 AND3_X1
* cell instance $13693 m0 *1 54.34,135.8
X$13693 11047 6091 11049 77 109 10967 MUX2_X1
* cell instance $13695 m0 *1 55.67,135.8
X$13695 10703 6627 10870 77 109 11047 MUX2_X1
* cell instance $13696 m0 *1 57,135.8
X$13696 10868 6627 10968 77 109 11049 MUX2_X1
* cell instance $13700 r0 *1 54.34,135.8
X$13700 8548 11121 77 109 11226 NOR2_X1
* cell instance $13703 r0 *1 55.48,135.8
X$13703 10703 10966 10870 77 109 11122 MUX2_X1
* cell instance $13704 r0 *1 56.81,135.8
X$13704 10868 10966 10968 77 109 11229 MUX2_X1
* cell instance $13706 r0 *1 58.9,135.8
X$13706 77 11283 11123 10970 11231 9814 109 DFFR_X1
* cell instance $13710 m0 *1 60.42,135.8
X$13710 11050 10969 9027 77 11231 109 AOI21_X1
* cell instance $13713 m0 *1 61.94,135.8
X$13713 9027 10970 77 109 11050 NOR2_X1
* cell instance $13718 r0 *1 63.27,135.8
X$13718 77 10974 11126 11234 11232 9814 109 DFFR_X1
* cell instance $13719 m0 *1 64.6,135.8
X$13719 9813 77 109 10969 CLKBUF_X3
* cell instance $13720 m0 *1 63.65,135.8
X$13720 9813 77 109 10763 CLKBUF_X3
* cell instance $13723 m0 *1 67.26,135.8
X$13723 11054 11125 10972 77 109 10971 MUX2_X1
* cell instance $13728 m0 *1 74.1,135.8
X$13728 77 10974 10975 10769 10884 4086 109 DFFR_X1
* cell instance $13729 m0 *1 77.9,135.8
X$13729 10777 8403 8858 4774 11060 10770 109 77 AOI221_X2
* cell instance $13732 r0 *1 67.07,135.8
X$13732 9152 11234 77 109 11233 NOR2_X1
* cell instance $13734 r0 *1 67.83,135.8
X$13734 11126 8229 11287 77 109 11235 MUX2_X1
* cell instance $13738 r0 *1 70.49,135.8
X$13738 11128 109 6290 77 BUF_X4
* cell instance $13739 r0 *1 71.82,135.8
X$13739 77 10974 18730 11063 11236 4086 109 DFFR_X1
* cell instance $13741 r0 *1 76,135.8
X$13741 11063 8345 77 109 11130 NOR2_X1
* cell instance $13742 r0 *1 76.57,135.8
X$13742 11130 6290 10975 77 11060 109 AOI21_X1
* cell instance $13743 r0 *1 77.33,135.8
X$13743 11131 8993 10975 77 11061 109 AOI21_X1
* cell instance $13744 r0 *1 78.09,135.8
X$13744 11063 8068 77 109 11131 NOR2_X1
* cell instance $13746 r0 *1 79.04,135.8
X$13746 6452 109 11128 77 BUF_X4
* cell instance $13747 r0 *1 80.37,135.8
X$13747 77 11078 10598 11395 11238 8687 109 DFFR_X1
* cell instance $13749 m0 *1 81.89,135.8
X$13749 10885 10449 10598 77 109 10771 MUX2_X1
* cell instance $13752 r0 *1 84.17,135.8
X$13752 11240 8359 77 6745 109 OR2_X4
* cell instance $13754 m0 *1 86.07,135.8
X$13754 9830 10773 77 109 10774 NOR2_X1
* cell instance $13756 m0 *1 86.64,135.8
X$13756 77 11078 10776 11073 10891 8687 109 DFFR_X1
* cell instance $13757 m0 *1 90.44,135.8
X$13757 10777 8369 8250 5887 11061 10154 109 77 AOI221_X2
* cell instance $13758 m0 *1 92.53,135.8
X$13758 77 11078 10450 11083 11080 8201 109 DFFR_X1
* cell instance $13759 m0 *1 96.33,135.8
X$13759 11083 6380 10157 77 109 11080 MUX2_X1
* cell instance $13763 m0 *1 101.65,135.8
X$13763 9341 77 109 10605 CLKBUF_X3
* cell instance $13764 m0 *1 102.6,135.8
X$13764 10605 77 109 19246 CLKBUF_X1
* cell instance $13765 m0 *1 103.17,135.8
X$13765 7643 10780 7631 7627 10906 109 77 11092 OAI221_X1
* cell instance $13768 r0 *1 86.64,135.8
X$13768 77 5449 109 6666 BUF_X8
* cell instance $13772 r0 *1 91.2,135.8
X$13772 6125 10451 8209 77 8499 109 NAND3_X4
* cell instance $13773 r0 *1 93.67,135.8
X$13773 10449 109 8250 77 BUF_X4
* cell instance $13774 r0 *1 95,135.8
X$13774 6185 11132 8363 77 109 NOR2_X4
* cell instance $13777 r0 *1 100.13,135.8
X$13777 11248 9631 10781 77 109 11249 MUX2_X1
* cell instance $13778 r0 *1 101.46,135.8
X$13778 77 10605 11134 11248 11249 8201 109 DFFR_X1
* cell instance $13779 r0 *1 105.26,135.8
X$13779 11134 9831 10976 77 109 10977 MUX2_X1
* cell instance $13781 m0 *1 105.45,135.8
X$13781 11134 9337 10976 77 109 10979 MUX2_X1
* cell instance $13782 m0 *1 109.82,135.8
X$13782 10910 9985 9989 77 109 10909 MUX2_X1
* cell instance $13784 m0 *1 112.67,135.8
X$13784 6125 10299 77 6185 109 NAND2_X4
* cell instance $13785 m0 *1 114.38,135.8
X$13785 9989 8232 11095 77 109 10980 MUX2_X1
* cell instance $13786 m0 *1 115.71,135.8
X$13786 77 10982 10981 11095 10980 4086 109 DFFR_X1
* cell instance $13788 r0 *1 106.59,135.8
X$13788 10979 7283 10978 77 109 11136 MUX2_X1
* cell instance $13789 r0 *1 107.92,135.8
X$13789 11136 7202 77 109 11091 NAND2_X1
* cell instance $13790 r0 *1 108.49,135.8
X$13790 3445 77 109 9341 CLKBUF_X3
* cell instance $13791 r0 *1 109.44,135.8
X$13791 11092 11091 6546 77 109 11259 NAND3_X1
* cell instance $13793 r0 *1 110.39,135.8
X$13793 9989 7636 11252 77 109 11253 MUX2_X1
* cell instance $13794 r0 *1 111.72,135.8
X$13794 77 11416 10785 11252 11253 8201 109 DFFR_X1
* cell instance $13800 r0 *1 118.94,135.8
X$13800 11255 6140 11256 77 109 11096 MUX2_X1
* cell instance $13801 m0 *1 120.08,135.8
X$13801 77 10982 11258 10915 10786 4086 109 DFFR_X1
* cell instance $13803 m0 *1 123.88,135.8
X$13803 11098 7283 10983 77 109 11099 MUX2_X1
* cell instance $13804 m0 *1 125.21,135.8
X$13804 11099 6372 77 109 11100 NAND2_X1
* cell instance $13805 m0 *1 125.78,135.8
X$13805 10984 11100 7580 77 109 11141 NAND3_X1
* cell instance $13811 r0 *1 121.79,135.8
X$13811 11139 10299 11258 77 109 11256 MUX2_X1
* cell instance $13813 r0 *1 123.5,135.8
X$13813 11139 6291 11258 77 109 11098 MUX2_X1
* cell instance $13815 r0 *1 125.21,135.8
X$13815 6652 11141 11259 77 10986 109 AOI21_X2
* cell instance $13817 m0 *1 127.49,135.8
X$13817 10738 10986 9130 77 109 NOR2_X4
* cell instance $13818 m0 *1 126.92,135.8
X$13818 4608 10985 77 109 11097 NAND2_X1
* cell instance $13820 m0 *1 129.39,135.8
X$13820 10791 10790 10987 77 11094 109 NAND3_X4
* cell instance $13822 m0 *1 132.05,135.8
X$13822 10790 10791 10987 10927 109 77 10793 AND4_X1
* cell instance $13823 m0 *1 133.19,135.8
X$13823 11094 10988 10929 10617 109 77 10935 OAI22_X2
* cell instance $13824 m0 *1 134.9,135.8
X$13824 10932 10796 11093 109 11090 77 OAI21_X1
* cell instance $13825 m0 *1 135.66,135.8
X$13825 10569 10932 77 109 10992 NAND2_X1
* cell instance $13826 m0 *1 136.23,135.8
X$13826 10992 10990 10930 77 109 10799 NOR3_X1
* cell instance $13827 m0 *1 136.99,135.8
X$13827 10992 10798 10994 77 109 10995 NOR3_X1
* cell instance $13829 m0 *1 138.51,135.8
X$13829 6695 10996 10997 109 77 5482 MUX2_X2
* cell instance $13832 r0 *1 127.3,135.8
X$13832 10986 10738 77 109 11261 OR2_X2
* cell instance $13834 r0 *1 129.01,135.8
X$13834 11142 9168 9000 109 77 10790 OAI21_X4
* cell instance $13836 r0 *1 131.67,135.8
X$13836 11302 11430 11143 109 77 11260 OAI21_X2
* cell instance $13838 r0 *1 133.19,135.8
X$13838 10791 10790 77 109 10990 NAND2_X1
* cell instance $13840 r0 *1 133.95,135.8
X$13840 10989 10794 10932 77 109 10988 NAND3_X1
* cell instance $13841 r0 *1 134.71,135.8
X$13841 10469 10993 10795 77 109 11093 OR3_X1
* cell instance $13843 r0 *1 135.85,135.8
X$13843 10989 10930 10932 77 109 10991 NAND3_X1
* cell instance $13844 r0 *1 136.61,135.8
X$13844 10794 77 109 10994 BUF_X1
* cell instance $13846 r0 *1 138.7,135.8
X$13846 77 11089 10725 10996 5300 109 NOR3_X4
* cell instance $13848 m0 *1 141.55,135.8
X$13848 10313 7026 10310 77 10998 109 AOI21_X1
* cell instance $13850 m0 *1 142.31,135.8
X$13850 10999 10998 77 109 10007 NOR2_X2
* cell instance $13851 m0 *1 143.26,135.8
X$13851 8334 10470 10311 109 10999 77 OAI21_X1
* cell instance $13855 r0 *1 143.45,135.8
X$13855 9422 10470 10311 109 11251 77 OAI21_X1
* cell instance $13857 m0 *1 145.16,135.8
X$13857 11088 11087 77 109 10530 NOR2_X2
* cell instance $13858 m0 *1 144.4,135.8
X$13858 10313 7197 10310 77 11087 109 AOI21_X1
* cell instance $13861 r0 *1 144.4,135.8
X$13861 10313 6430 10310 77 11308 109 AOI21_X1
* cell instance $13864 r0 *1 145.73,135.8
X$13864 11147 109 8712 77 BUF_X4
* cell instance $13866 r0 *1 147.82,135.8
X$13866 11000 7521 11086 109 77 11082 HA_X1
* cell instance $13867 m0 *1 148.2,135.8
X$13867 11084 77 109 11000 INV_X1
* cell instance $13869 m0 *1 148.58,135.8
X$13869 10802 10166 11085 77 10474 109 AOI21_X1
* cell instance $13870 m0 *1 149.34,135.8
X$13870 11084 7964 19042 109 77 10944 HA_X1
* cell instance $13872 m0 *1 152,135.8
X$13872 11246 7114 19043 109 77 10805 HA_X1
* cell instance $13873 m0 *1 153.9,135.8
X$13873 11079 7285 11081 109 77 11077 HA_X1
* cell instance $13874 m0 *1 155.8,135.8
X$13874 11077 77 109 10806 INV_X1
* cell instance $13876 m0 *1 157.7,135.8
X$13876 11152 77 109 11076 INV_X1
* cell instance $13877 m0 *1 158.08,135.8
X$13877 8014 11076 11074 109 77 11071 HA_X1
* cell instance $13878 m0 *1 159.98,135.8
X$13878 11074 9856 9362 11071 9287 77 109 11154 AOI221_X1
* cell instance $13879 m0 *1 161.12,135.8
X$13879 11148 77 109 11070 INV_X1
* cell instance $13880 m0 *1 161.5,135.8
X$13880 6932 11070 19044 109 77 11069 HA_X1
* cell instance $13881 m0 *1 163.4,135.8
X$13881 11068 10322 77 109 10812 NOR2_X1
* cell instance $13883 m0 *1 164.16,135.8
X$13883 11069 77 109 10921 INV_X1
* cell instance $13887 r0 *1 151.24,135.8
X$13887 10171 11149 11247 109 77 9514 AND3_X2
* cell instance $13888 r0 *1 152.38,135.8
X$13888 10165 77 109 10628 CLKBUF_X3
* cell instance $13889 r0 *1 153.33,135.8
X$13889 11246 77 109 11079 INV_X1
* cell instance $13894 r0 *1 156.56,135.8
X$13894 11075 11150 10628 77 11151 109 AOI21_X1
* cell instance $13895 r0 *1 157.32,135.8
X$13895 7519 11152 19077 109 77 11153 HA_X1
* cell instance $13896 r0 *1 159.22,135.8
X$13896 11154 11153 9858 77 11075 109 AOI21_X1
* cell instance $13899 r0 *1 161.12,135.8
X$13899 11155 11148 11242 109 77 11001 HA_X1
* cell instance $13900 r0 *1 163.02,135.8
X$13900 11001 9597 11242 9447 77 109 11068 AOI22_X1
* cell instance $13903 r0 *1 164.92,135.8
X$13903 11064 8572 77 109 8974 NOR2_X1
* cell instance $13904 r0 *1 165.49,135.8
X$13904 11157 7968 10628 77 11066 109 AOI21_X1
* cell instance $13906 m0 *1 166.82,135.8
X$13906 9593 77 109 19108 INV_X2
* cell instance $13907 m0 *1 166.44,135.8
X$13907 11065 77 109 9141 INV_X1
* cell instance $13908 m0 *1 167.39,135.8
X$13908 8477 77 109 9593 CLKBUF_X3
* cell instance $13909 m0 *1 168.34,135.8
X$13909 10813 8957 9524 77 11062 109 AOI21_X1
* cell instance $13911 m0 *1 169.29,135.8
X$13911 11048 11059 77 109 8014 NAND2_X2
* cell instance $13913 r0 *1 166.44,135.8
X$13913 11241 11239 6755 6855 11062 109 77 11065 OAI221_X1
* cell instance $13915 r0 *1 167.77,135.8
X$13915 9853 11036 77 109 11002 NAND2_X1
* cell instance $13916 r0 *1 168.34,135.8
X$13916 6855 11002 11322 77 11064 109 AOI21_X1
* cell instance $13918 r0 *1 169.29,135.8
X$13918 7664 77 109 7872 INV_X2
* cell instance $13921 m0 *1 172.33,135.8
X$13921 11056 9399 9524 77 11057 109 AOI21_X1
* cell instance $13922 m0 *1 170.62,135.8
X$13922 11003 11058 11057 9219 109 77 9773 OAI22_X2
* cell instance $13923 m0 *1 173.09,135.8
X$13923 11160 77 109 10899 INV_X1
* cell instance $13924 m0 *1 173.47,135.8
X$13924 10424 77 109 10322 CLKBUF_X3
* cell instance $13925 m0 *1 174.42,135.8
X$13925 10893 11055 10322 77 11056 109 AOI21_X1
* cell instance $13928 r0 *1 170.81,135.8
X$13928 11237 77 109 9298 INV_X1
* cell instance $13933 r0 *1 171.38,135.8
X$13933 9859 8717 9853 77 11004 109 AOI21_X1
* cell instance $13936 r0 *1 172.71,135.8
X$13936 7370 11160 19063 109 77 11055 HA_X1
* cell instance $13938 r0 *1 175.37,135.8
X$13938 10815 11398 77 7524 109 NAND2_X4
* cell instance $13940 m0 *1 176.32,135.8
X$13940 11005 9124 77 109 11051 NAND2_X1
* cell instance $13943 m0 *1 177.27,135.8
X$13943 11052 9124 77 109 11053 NAND2_X1
* cell instance $13944 m0 *1 178.03,135.8
X$13944 11046 11051 77 7114 109 NAND2_X4
* cell instance $13947 m0 *1 181.45,135.8
X$13947 10889 109 7368 77 BUF_X4
* cell instance $13948 m0 *1 182.78,135.8
X$13948 6005 11009 77 109 11006 NOR2_X1
* cell instance $13949 m0 *1 183.35,135.8
X$13949 11006 8105 8282 11007 77 109 11048 AOI22_X2
* cell instance $13950 m0 *1 185.06,135.8
X$13950 77 11044 8105 11046 8789 10485 109 AOI22_X4
* cell instance $13951 m0 *1 188.29,135.8
X$13951 77 11223 8105 10815 8789 7141 109 AOI22_X4
* cell instance $13952 m0 *1 191.52,135.8
X$13952 10640 8716 10175 77 109 11045 MUX2_X1
* cell instance $13957 r0 *1 179.17,135.8
X$13957 77 10638 18848 10483 11230 3676 109 DFFR_X1
* cell instance $13959 r0 *1 183.35,135.8
X$13959 10485 8106 11228 77 109 11164 MUX2_X1
* cell instance $13962 r0 *1 185.25,135.8
X$13962 10486 8106 10556 77 109 11227 MUX2_X1
* cell instance $13963 r0 *1 186.58,135.8
X$13963 77 11221 8105 11225 8789 10486 109 AOI22_X4
* cell instance $13966 r0 *1 190.76,135.8
X$13966 11220 9694 8789 7422 77 109 11159 AOI22_X2
* cell instance $13967 r0 *1 192.47,135.8
X$13967 11041 9696 109 77 11223 AND2_X1
* cell instance $13968 r0 *1 193.23,135.8
X$13968 10520 9696 109 77 11221 AND2_X1
* cell instance $13969 m0 *1 194.75,135.8
X$13969 11010 11009 77 109 10880 NOR2_X2
* cell instance $13970 m0 *1 193.99,135.8
X$13970 10489 9696 109 77 11044 AND2_X1
* cell instance $13972 r0 *1 193.99,135.8
X$13972 11008 9696 109 77 11220 AND2_X1
* cell instance $13973 r0 *1 194.75,135.8
X$13973 11041 11008 10013 77 109 11010 NAND3_X1
* cell instance $13975 r0 *1 195.89,135.8
X$13975 11010 9863 77 109 11219 NOR2_X1
* cell instance $13977 m0 *1 196.08,135.8
X$13977 9863 77 109 10817 INV_X1
* cell instance $13978 m0 *1 197.22,135.8
X$13978 10879 11008 10013 77 109 11011 NAND3_X1
* cell instance $13983 r0 *1 196.84,135.8
X$13983 10817 10013 77 109 11166 NAND2_X1
* cell instance $13986 r0 *1 197.98,135.8
X$13986 11217 11011 109 77 8161 XNOR2_X1
* cell instance $13987 r0 *1 199.12,135.8
X$13987 11012 77 109 10175 BUF_X1
* cell instance $13991 m0 *1 202.35,135.8
X$13991 8616 11009 77 109 11042 NOR2_X1
* cell instance $13993 m0 *1 202.92,135.8
X$13993 8616 109 8895 77 BUF_X4
* cell instance $13994 m0 *1 204.25,135.8
X$13994 11042 11013 8895 77 8120 109 AOI21_X2
* cell instance $13997 r0 *1 202.16,135.8
X$13997 11167 77 109 11009 INV_X1
* cell instance $14000 r0 *1 203.11,135.8
X$14000 10375 77 109 19286 CLKBUF_X1
* cell instance $14001 r0 *1 203.68,135.8
X$14001 6817 77 109 10375 CLKBUF_X3
* cell instance $14002 r0 *1 204.63,135.8
X$14002 11041 8895 11328 77 109 5814 MUX2_X1
* cell instance $14004 r0 *1 206.34,135.8
X$14004 77 18417 11168 11209 10375 109 DFF_X1
* cell instance $14005 m0 *1 206.91,135.8
X$14005 11039 11008 5913 77 6987 109 AOI21_X2
* cell instance $14007 m0 *1 208.24,135.8
X$14007 5913 11014 77 109 11039 NOR2_X1
* cell instance $14009 m0 *1 211.85,135.8
X$14009 10494 9398 77 109 11016 NAND2_X1
* cell instance $14010 m0 *1 212.42,135.8
X$14010 4307 3630 11016 109 11015 77 OAI21_X1
* cell instance $14012 m0 *1 213.37,135.8
X$14012 4185 109 8907 77 BUF_X4
* cell instance $14013 m0 *1 214.7,135.8
X$14013 3593 77 109 9079 CLKBUF_X3
* cell instance $14015 m0 *1 215.84,135.8
X$14015 77 10825 10186 18289 10821 109 DFF_X2
* cell instance $14016 m0 *1 219.45,135.8
X$14016 8749 109 3210 77 BUF_X4
* cell instance $14018 r0 *1 209.57,135.8
X$14018 11168 77 109 11014 INV_X1
* cell instance $14021 r0 *1 210.52,135.8
X$14021 4185 3593 11014 10209 109 11169 77 NOR4_X2
* cell instance $14022 r0 *1 212.23,135.8
X$14022 9398 11208 11014 11015 77 109 11209 AOI22_X1
* cell instance $14023 r0 *1 213.18,135.8
X$14023 4307 11207 77 109 11208 OR2_X1
* cell instance $14025 r0 *1 214.13,135.8
X$14025 10494 8907 9079 11014 77 109 11207 NOR4_X1
* cell instance $14026 r0 *1 215.08,135.8
X$14026 10822 77 109 11171 INV_X1
* cell instance $14028 r0 *1 215.65,135.8
X$14028 11171 10494 8907 9079 77 109 11204 NOR4_X1
* cell instance $14031 r0 *1 218.5,135.8
X$14031 8899 11174 3210 109 77 11175 OAI21_X2
* cell instance $14034 r0 *1 220.97,135.8
X$14034 10342 4961 7822 109 77 11956 OAI21_X2
* cell instance $14036 m0 *1 221.16,135.8
X$14036 5653 7822 77 109 11017 NAND2_X1
* cell instance $14037 m0 *1 221.92,135.8
X$14037 11017 9237 11012 77 11018 109 AOI21_X2
* cell instance $14039 m0 *1 223.44,135.8
X$14039 11035 9237 11036 77 11037 109 AOI21_X1
* cell instance $14041 m0 *1 224.39,135.8
X$14041 77 18365 11020 11033 10186 109 DFF_X1
* cell instance $14042 m0 *1 227.62,135.8
X$14042 11020 11197 11029 109 11019 77 OAI21_X1
* cell instance $14044 m0 *1 228.57,135.8
X$14044 10829 3884 11025 77 109 11029 OR3_X1
* cell instance $14046 r0 *1 222.3,135.8
X$14046 7822 4961 77 109 11177 NOR2_X1
* cell instance $14048 r0 *1 223.63,135.8
X$14048 11037 77 109 11200 INV_X2
* cell instance $14056 r0 *1 227.05,135.8
X$14056 11030 10204 11019 77 11033 109 AOI21_X1
* cell instance $14057 r0 *1 227.81,135.8
X$14057 11027 11020 2348 77 11030 109 AOI21_X1
* cell instance $14060 r0 *1 229.71,135.8
X$14060 11182 11183 77 109 11025 OR2_X1
* cell instance $14062 m0 *1 229.9,135.8
X$14062 11025 9880 77 109 11027 XOR2_X1
* cell instance $14063 r0 *1 230.47,135.8
X$14063 11182 11183 11360 11026 109 10030 77 OR4_X2
* cell instance $14064 m0 *1 233.89,135.8
X$14064 10832 77 109 10656 INV_X1
* cell instance $14065 m0 *1 231.42,135.8
X$14065 77 10830 9087 11023 8933 109 AOI21_X4
* cell instance $14068 m0 *1 235.22,135.8
X$14068 10196 77 109 19219 CLKBUF_X1
* cell instance $14069 m0 *1 235.79,135.8
X$14069 10662 77 109 10835 BUF_X1
* cell instance $14070 m0 *1 236.36,135.8
X$14070 77 18358 10833 10840 10196 109 DFF_X1
* cell instance $14072 r0 *1 231.8,135.8
X$14072 11021 10663 10830 77 109 11183 NAND3_X1
* cell instance $14074 r0 *1 232.75,135.8
X$14074 11191 77 109 11023 INV_X1
* cell instance $14075 r0 *1 233.13,135.8
X$14075 77 18387 11191 11185 10196 109 DFF_X1
* cell instance $14076 r0 *1 236.36,135.8
X$14076 77 18488 11188 11190 10196 109 DFF_X1
* cell instance $14078 m0 *1 228.19,169.4
X$14078 77 18379 13980 13982 13854 109 DFF_X1
* cell instance $14080 m0 *1 231.42,169.4
X$14080 77 18371 13969 14104 13476 109 DFF_X1
* cell instance $14081 m0 *1 234.65,169.4
X$14081 13969 13201 13970 77 109 14104 MUX2_X1
* cell instance $14082 m0 *1 235.98,169.4
X$14082 8957 77 109 13975 BUF_X1
* cell instance $14084 m0 *1 236.74,169.4
X$14084 13970 77 109 13971 BUF_X1
* cell instance $14085 m0 *1 237.31,169.4
X$14085 14103 77 109 13973 BUF_X1
* cell instance $14089 r0 *1 228,169.4
X$14089 11186 77 109 13854 CLKBUF_X3
* cell instance $14090 r0 *1 228.95,169.4
X$14090 14241 13613 13607 77 109 14098 MUX2_X1
* cell instance $14091 r0 *1 230.28,169.4
X$14091 14241 13201 14098 77 109 14251 MUX2_X1
* cell instance $14093 r0 *1 231.99,169.4
X$14093 10556 77 109 14248 BUF_X1
* cell instance $14094 r0 *1 232.56,169.4
X$14094 14379 13613 10847 77 109 14242 MUX2_X1
* cell instance $14095 r0 *1 233.89,169.4
X$14095 14243 13613 13609 77 109 14244 MUX2_X1
* cell instance $14098 r0 *1 236.36,169.4
X$14098 14098 77 109 14245 BUF_X1
* cell instance $14101 r0 *1 237.88,169.4
X$14101 14248 77 109 14099 BUF_X1
* cell instance $14109 m0 *1 1.9,141.4
X$14109 77 11262 11440 11581 11512 4909 109 DFFR_X1
* cell instance $14116 r0 *1 5.13,141.4
X$14116 10752 6876 11581 77 109 11512 MUX2_X1
* cell instance $14118 m0 *1 6.08,141.4
X$14118 11440 8005 11441 77 109 11263 MUX2_X1
* cell instance $14120 r0 *1 6.46,141.4
X$14120 11440 9178 11441 77 109 11264 MUX2_X1
* cell instance $14123 r0 *1 10.07,141.4
X$14123 77 11028 11583 11582 11638 4909 109 DFFR_X1
* cell instance $14124 m0 *1 11.02,141.4
X$14124 11514 4065 10752 77 109 11352 MUX2_X1
* cell instance $14127 m0 *1 12.54,141.4
X$14127 9961 77 109 11028 CLKBUF_X3
* cell instance $14131 r0 *1 13.87,141.4
X$14131 77 11028 11641 11518 11640 4909 109 DFFR_X1
* cell instance $14133 m0 *1 16.15,141.4
X$14133 11355 3786 10429 77 109 11354 MUX2_X1
* cell instance $14134 m0 *1 17.67,141.4
X$14134 11265 9976 11356 77 109 11442 MUX2_X1
* cell instance $14135 m0 *1 19,141.4
X$14135 11642 11278 11266 77 109 11269 MUX2_X1
* cell instance $14137 m0 *1 20.52,141.4
X$14137 11520 5461 11442 77 109 11523 MUX2_X1
* cell instance $14141 r0 *1 17.86,141.4
X$14141 11583 9976 11641 77 109 11520 MUX2_X1
* cell instance $14143 r0 *1 19.38,141.4
X$14143 77 11701 11270 11644 11643 9814 109 DFFR_X1
* cell instance $14144 m0 *1 24.32,141.4
X$14144 11523 10065 11524 77 109 11113 MUX2_X1
* cell instance $14145 m0 *1 22.99,141.4
X$14145 11357 5461 11522 77 109 11524 MUX2_X1
* cell instance $14149 r0 *1 23.37,141.4
X$14149 11644 4126 10429 77 109 11643 MUX2_X1
* cell instance $14152 r0 *1 26.6,141.4
X$14152 11646 7468 10752 77 109 11647 MUX2_X1
* cell instance $14153 r0 *1 27.93,141.4
X$14153 77 10951 11584 11646 11647 9814 109 DFFR_X1
* cell instance $14154 m0 *1 29.26,141.4
X$14154 3896 109 9976 77 BUF_X4
* cell instance $14157 m0 *1 30.78,141.4
X$14157 11443 6885 10425 77 109 11531 MUX2_X1
* cell instance $14158 m0 *1 32.11,141.4
X$14158 77 5446 10283 109 BUF_X16
* cell instance $14162 r0 *1 33.44,141.4
X$14162 77 5446 8407 109 BUF_X16
* cell instance $14163 m0 *1 37.43,141.4
X$14163 6383 11443 11537 109 11535 77 OAI21_X1
* cell instance $14166 r0 *1 38.19,141.4
X$14166 6694 109 7917 77 BUF_X4
* cell instance $14168 m0 *1 38.57,141.4
X$14168 9810 11443 11444 109 11533 77 OAI21_X1
* cell instance $14169 m0 *1 39.52,141.4
X$14169 77 11116 11446 11275 11368 9814 109 DFFR_X1
* cell instance $14171 m0 *1 43.51,141.4
X$14171 11117 7059 11446 77 109 11539 MUX2_X1
* cell instance $14173 r0 *1 39.52,141.4
X$14173 11584 7321 77 109 11444 NAND2_X1
* cell instance $14174 r0 *1 40.09,141.4
X$14174 11584 6371 77 109 11537 NAND2_X1
* cell instance $14177 r0 *1 41.61,141.4
X$14177 6694 77 109 7617 CLKBUF_X3
* cell instance $14179 r0 *1 42.75,141.4
X$14179 11445 7059 11654 77 109 11657 MUX2_X1
* cell instance $14180 r0 *1 44.08,141.4
X$14180 11445 9178 11654 77 109 11447 MUX2_X1
* cell instance $14182 m0 *1 45.22,141.4
X$14182 11447 4320 11373 77 109 11540 MUX2_X1
* cell instance $14183 r0 *1 45.41,141.4
X$14183 11657 11278 11539 77 109 11658 MUX2_X1
* cell instance $14186 m0 *1 46.93,141.4
X$14186 11279 7063 11540 77 109 11551 MUX2_X1
* cell instance $14187 r0 *1 48.26,141.4
X$14187 11374 5818 11658 77 109 11550 MUX2_X1
* cell instance $14189 m0 *1 48.64,141.4
X$14189 77 9974 11450 11377 11376 9814 109 DFFR_X1
* cell instance $14190 m0 *1 52.63,141.4
X$14190 11450 6627 11451 77 109 11660 MUX2_X1
* cell instance $14191 m0 *1 53.96,141.4
X$14191 11450 10138 11451 77 109 11545 MUX2_X1
* cell instance $14192 m0 *1 55.29,141.4
X$14192 11452 8407 11545 77 109 11547 MUX2_X1
* cell instance $14193 m0 *1 56.62,141.4
X$14193 11282 10368 11547 77 109 11453 MUX2_X1
* cell instance $14198 r0 *1 50.54,141.4
X$14198 11586 11448 9027 77 11542 109 AOI21_X1
* cell instance $14200 r0 *1 51.49,141.4
X$14200 9027 11659 77 109 11586 NOR2_X1
* cell instance $14204 r0 *1 54.15,141.4
X$14204 11587 10966 11588 77 109 11452 MUX2_X1
* cell instance $14206 r0 *1 57,141.4
X$14206 77 11283 11587 11664 11663 9814 109 DFFR_X1
* cell instance $14211 m0 *1 59.09,141.4
X$14211 77 11283 11285 11284 11384 9814 109 DFFR_X1
* cell instance $14214 m0 *1 65.36,141.4
X$14214 11552 10969 6380 77 11590 109 AOI21_X1
* cell instance $14216 m0 *1 66.88,141.4
X$14216 6380 11553 77 109 11552 NOR2_X1
* cell instance $14221 r0 *1 63.27,141.4
X$14221 11454 10969 6524 77 11589 109 AOI21_X1
* cell instance $14223 r0 *1 64.22,141.4
X$14223 6524 11670 77 109 11454 NOR2_X1
* cell instance $14224 r0 *1 64.79,141.4
X$14224 77 10974 11712 11553 11590 9814 109 DFFR_X1
* cell instance $14225 m0 *1 68.02,141.4
X$14225 11391 7156 11392 77 109 11456 MUX2_X1
* cell instance $14227 m0 *1 69.35,141.4
X$14227 11456 5455 77 109 11554 NAND2_X1
* cell instance $14231 r0 *1 69.35,141.4
X$14231 10973 11591 6719 77 109 11826 NOR3_X1
* cell instance $14232 r0 *1 70.11,141.4
X$14232 11555 11554 77 109 11592 NAND2_X1
* cell instance $14233 r0 *1 70.68,141.4
X$14233 12004 6666 5967 5451 11455 77 109 11555 AOI221_X1
* cell instance $14234 m0 *1 71.25,141.4
X$14234 77 10974 11458 11557 11560 4086 109 DFFR_X1
* cell instance $14236 m0 *1 75.05,141.4
X$14236 77 11593 11595 11562 11290 8687 109 DFFR_X1
* cell instance $14240 m0 *1 84.17,141.4
X$14240 77 11078 11460 11399 11459 8687 109 DFFR_X1
* cell instance $14241 m0 *1 87.97,141.4
X$14241 11460 8984 11294 77 109 12019 MUX2_X1
* cell instance $14243 m0 *1 90.82,141.4
X$14243 8068 109 10149 77 BUF_X4
* cell instance $14245 m0 *1 92.91,141.4
X$14245 11463 11461 11464 77 109 11570 MUX2_X1
* cell instance $14246 m0 *1 94.24,141.4
X$14246 11463 10149 11464 77 109 11599 MUX2_X1
* cell instance $14253 r0 *1 75.43,141.4
X$14253 11594 7636 11674 77 109 11828 MUX2_X1
* cell instance $14256 r0 *1 77.9,141.4
X$14256 11458 7447 11595 77 109 11596 MUX2_X1
* cell instance $14259 r0 *1 79.8,141.4
X$14259 77 11291 11835 11677 11675 8687 109 DFFR_X1
* cell instance $14260 r0 *1 83.6,141.4
X$14260 9034 2931 11677 77 109 11675 MUX2_X1
* cell instance $14263 r0 *1 89.49,141.4
X$14263 77 11078 11844 11462 11681 8201 109 DFFR_X1
* cell instance $14264 r0 *1 93.29,141.4
X$14264 11462 9027 11289 77 109 11681 MUX2_X1
* cell instance $14268 r0 *1 96.71,141.4
X$14268 9341 77 109 11296 CLKBUF_X3
* cell instance $14269 r0 *1 97.66,141.4
X$14269 9034 77 109 11594 BUF_X2
* cell instance $14272 r0 *1 98.99,141.4
X$14272 8864 109 11461 77 BUF_X4
* cell instance $14274 m0 *1 100.7,141.4
X$14274 9034 77 109 11573 BUF_X2
* cell instance $14280 r0 *1 103.36,141.4
X$14280 77 10605 11135 11465 11689 8201 109 DFFR_X1
* cell instance $14281 m0 *1 107.35,141.4
X$14281 11578 9152 11293 77 109 11575 MUX2_X1
* cell instance $14283 m0 *1 108.68,141.4
X$14283 77 11416 11466 11578 11575 8201 109 DFFR_X1
* cell instance $14288 r0 *1 107.16,141.4
X$14288 11465 9503 10781 77 109 11689 MUX2_X1
* cell instance $14292 r0 *1 110.58,141.4
X$14292 9341 77 109 11416 CLKBUF_X3
* cell instance $14293 r0 *1 111.53,141.4
X$14293 11466 8067 11467 77 109 12035 MUX2_X1
* cell instance $14294 r0 *1 112.86,141.4
X$14294 11692 9632 10781 77 109 11693 MUX2_X1
* cell instance $14295 r0 *1 114.19,141.4
X$14295 77 11416 11696 11692 11693 4086 109 DFFR_X1
* cell instance $14300 r0 *1 118.18,141.4
X$14300 11696 6291 11729 77 109 11580 MUX2_X1
* cell instance $14302 m0 *1 118.18,141.4
X$14302 11468 8984 11579 77 109 10611 MUX2_X1
* cell instance $14304 r0 *1 119.7,141.4
X$14304 11694 9815 10781 77 109 11695 MUX2_X1
* cell instance $14305 m0 *1 120.08,141.4
X$14305 9341 77 109 10982 CLKBUF_X3
* cell instance $14307 m0 *1 121.03,141.4
X$14307 10982 77 109 19251 CLKBUF_X1
* cell instance $14309 m0 *1 121.79,141.4
X$14309 11470 10299 11469 77 109 11579 MUX2_X1
* cell instance $14310 m0 *1 123.12,141.4
X$14310 11470 6291 11469 77 109 10983 MUX2_X1
* cell instance $14315 r0 *1 121.22,141.4
X$14315 77 10982 11470 11694 11695 4086 109 DFFR_X1
* cell instance $14318 m0 *1 127.3,141.4
X$14318 11471 10789 77 109 11577 NOR2_X1
* cell instance $14320 m0 *1 127.87,141.4
X$14320 11576 10789 77 109 11425 NOR2_X1
* cell instance $14321 m0 *1 128.44,141.4
X$14321 9044 109 9673 77 BUF_X4
* cell instance $14322 m0 *1 129.77,141.4
X$14322 10125 9465 9675 109 77 11303 OAI21_X4
* cell instance $14323 m0 *1 132.24,141.4
X$14323 11473 11682 77 109 10987 OR2_X2
* cell instance $14324 m0 *1 133.19,141.4
X$14324 10930 10617 109 77 11574 AND2_X1
* cell instance $14326 m0 *1 134.14,141.4
X$14326 7793 5434 6430 77 109 11473 NAND3_X2
* cell instance $14328 r0 *1 127.3,141.4
X$14328 8426 11473 8996 77 109 11691 OR3_X1
* cell instance $14329 r0 *1 128.25,141.4
X$14329 11472 6474 11893 109 11576 77 OAI21_X1
* cell instance $14332 r0 *1 130.15,141.4
X$14332 9044 11473 77 109 11690 NAND2_X1
* cell instance $14333 r0 *1 130.72,141.4
X$14333 77 10125 11665 9675 11605 9465 109 OAI211_X4
* cell instance $14335 r0 *1 134.14,141.4
X$14335 6430 6698 5472 7793 77 11687 109 NAND4_X2
* cell instance $14336 r0 *1 135.85,141.4
X$14336 7035 7095 6698 109 11686 77 NOR3_X2
* cell instance $14337 m0 *1 136.61,141.4
X$14337 11571 11306 10797 11572 11307 11475 77 109 OAI221_X2
* cell instance $14338 m0 *1 135.85,141.4
X$14338 7035 7095 7627 77 109 11568 NOR3_X1
* cell instance $14339 m0 *1 138.7,141.4
X$14339 11306 11474 10797 11569 11307 10803 77 109 OAI221_X2
* cell instance $14341 m0 *1 141.55,141.4
X$14341 11212 11306 11307 109 11567 77 OAI21_X1
* cell instance $14342 m0 *1 142.31,141.4
X$14342 11567 11565 77 109 11246 NOR2_X2
* cell instance $14344 m0 *1 144.02,141.4
X$14344 11566 11476 77 109 11084 NOR2_X2
* cell instance $14345 m0 *1 144.97,141.4
X$14345 10313 7338 10310 77 11477 109 AOI21_X1
* cell instance $14346 m0 *1 145.73,141.4
X$14346 11600 77 109 11479 INV_X1
* cell instance $14347 m0 *1 146.11,141.4
X$14347 7368 77 109 11478 INV_X1
* cell instance $14348 m0 *1 146.49,141.4
X$14348 7368 11600 19056 109 77 11145 HA_X1
* cell instance $14349 m0 *1 148.39,141.4
X$14349 11482 5552 77 109 11679 XNOR2_X2
* cell instance $14350 m0 *1 150.29,141.4
X$14350 4189 11482 109 77 11740 XNOR2_X1
* cell instance $14351 m0 *1 151.43,141.4
X$14351 11480 11160 109 77 11481 XNOR2_X1
* cell instance $14352 m0 *1 152.57,141.4
X$14352 11475 77 109 11488 BUF_X1
* cell instance $14354 m0 *1 153.33,141.4
X$14354 11483 7518 11314 109 77 11564 HA_X1
* cell instance $14357 m0 *1 156.94,141.4
X$14357 10807 77 109 11561 INV_X1
* cell instance $14358 m0 *1 157.32,141.4
X$14358 6603 11561 19046 109 77 11318 HA_X1
* cell instance $14362 r0 *1 137.56,141.4
X$14362 11473 109 11309 77 BUF_X4
* cell instance $14363 r0 *1 138.89,141.4
X$14363 11306 11685 10797 11568 11307 11483 77 109 OAI221_X2
* cell instance $14365 r0 *1 141.36,141.4
X$14365 11684 11306 11307 109 11566 77 OAI21_X1
* cell instance $14367 r0 *1 142.88,141.4
X$14367 11678 11683 109 77 11836 XNOR2_X1
* cell instance $14368 r0 *1 144.02,141.4
X$14368 11678 11738 109 77 11680 XNOR2_X1
* cell instance $14371 r0 *1 148.58,141.4
X$14371 3926 11482 109 77 11907 XNOR2_X1
* cell instance $14373 r0 *1 150.48,141.4
X$14373 11480 10803 109 77 11601 XNOR2_X1
* cell instance $14375 r0 *1 151.81,141.4
X$14375 11482 11475 109 77 11602 XNOR2_X1
* cell instance $14377 r0 *1 153.33,141.4
X$14377 6859 11603 109 77 11604 XNOR2_X1
* cell instance $14378 r0 *1 154.47,141.4
X$14378 77 11603 11482 109 BUF_X16
* cell instance $14379 r0 *1 159.22,141.4
X$14379 4745 11480 109 77 11606 XNOR2_X1
* cell instance $14380 r0 *1 160.36,141.4
X$14380 8264 11676 5716 109 11559 77 OAI21_X1
* cell instance $14382 m0 *1 161.31,141.4
X$14382 7369 11484 19031 109 77 11556 HA_X1
* cell instance $14384 m0 *1 163.21,141.4
X$14384 11556 9361 11558 109 10634 77 OAI21_X1
* cell instance $14387 r0 *1 161.5,141.4
X$14387 4297 11603 109 77 11607 XNOR2_X1
* cell instance $14389 r0 *1 162.83,141.4
X$14389 77 11603 109 11549 BUF_X8
* cell instance $14390 m0 *1 165.3,141.4
X$14390 77 11549 10302 9643 9673 109 AOI21_X4
* cell instance $14392 m0 *1 167.77,141.4
X$14392 7872 11411 19048 109 77 11486 HA_X1
* cell instance $14393 m0 *1 169.67,141.4
X$14393 11486 9361 11487 77 109 11322 MUX2_X1
* cell instance $14394 m0 *1 171,141.4
X$14394 7235 11488 19041 109 77 11548 HA_X1
* cell instance $14395 m0 *1 172.9,141.4
X$14395 11488 77 109 11489 INV_X1
* cell instance $14398 r0 *1 165.3,141.4
X$14398 11608 10302 9044 9643 11672 109 77 AOI211_X2
* cell instance $14399 r0 *1 167.01,141.4
X$14399 11613 10302 9673 9643 11538 109 77 AOI211_X2
* cell instance $14401 r0 *1 168.91,141.4
X$14401 11673 11303 11672 11611 77 109 8718 AOI211_X4
* cell instance $14402 r0 *1 171,141.4
X$14402 11612 11609 77 109 11673 NOR2_X1
* cell instance $14407 r0 *1 173.09,141.4
X$14407 11612 11549 11491 11492 109 11669 77 NOR4_X2
* cell instance $14408 m0 *1 175.37,141.4
X$14408 11493 11492 11491 77 109 11544 NOR3_X1
* cell instance $14409 m0 *1 174.42,141.4
X$14409 11491 11490 11492 77 109 11546 OR3_X1
* cell instance $14411 m0 *1 176.32,141.4
X$14411 8925 11494 11543 11324 109 11498 77 OR4_X2
* cell instance $14412 m0 *1 177.65,141.4
X$14412 11494 109 9396 77 BUF_X4
* cell instance $14417 m0 *1 184.49,141.4
X$14417 77 10638 18543 11007 11326 3676 109 DFFR_X1
* cell instance $14419 r0 *1 174.8,141.4
X$14419 11303 11614 11546 11612 11615 11667 77 109 OAI221_X2
* cell instance $14420 r0 *1 176.89,141.4
X$14420 11666 11544 11667 11669 109 11494 77 NOR4_X2
* cell instance $14421 r0 *1 178.6,141.4
X$14421 11490 11493 11621 109 77 11665 AND3_X2
* cell instance $14422 r0 *1 179.74,141.4
X$14422 11616 11493 77 109 11617 NAND2_X1
* cell instance $14423 r0 *1 180.31,141.4
X$14423 11618 11620 77 109 11495 NAND2_X1
* cell instance $14425 r0 *1 181.07,141.4
X$14425 11662 11620 77 109 8925 XNOR2_X2
* cell instance $14426 r0 *1 182.97,141.4
X$14426 11619 11622 77 109 11662 NOR2_X1
* cell instance $14427 r0 *1 183.54,141.4
X$14427 11661 11622 77 11496 109 NAND2_X4
* cell instance $14431 r0 *1 187.34,141.4
X$14431 11768 11616 109 77 11812 AND2_X1
* cell instance $14432 r0 *1 188.1,141.4
X$14432 11624 11623 11165 77 109 NOR2_X4
* cell instance $14433 m0 *1 188.86,141.4
X$14433 77 10638 11497 3676 18919 7422 109 DFFR_X2
* cell instance $14437 m0 *1 193.99,141.4
X$14437 77 9556 11498 11536 11499 6863 109 NOR4_X4
* cell instance $14440 r0 *1 190.19,141.4
X$14440 11624 11623 4619 109 8608 77 NOR3_X2
* cell instance $14441 r0 *1 191.52,141.4
X$14441 11763 11625 11538 77 109 11501 OR3_X1
* cell instance $14442 r0 *1 192.47,141.4
X$14442 11538 11625 11763 109 11628 77 OAI21_X1
* cell instance $14446 r0 *1 195.32,141.4
X$14446 77 4619 11626 11653 11652 11500 109 NOR4_X4
* cell instance $14447 m0 *1 197.98,141.4
X$14447 77 11089 11499 11536 11498 11534 109 OR4_X4
* cell instance $14451 m0 *1 201.4,141.4
X$14451 77 11217 11041 11381 10375 109 DFF_X1
* cell instance $14454 m0 *1 205.58,141.4
X$14454 77 11532 11172 18291 11013 109 DFF_X2
* cell instance $14457 r0 *1 199.12,141.4
X$14457 9393 9243 77 109 11627 OR2_X1
* cell instance $14460 r0 *1 200.45,141.4
X$14460 77 9556 109 11534 BUF_X8
* cell instance $14461 r0 *1 202.92,141.4
X$14461 11651 11496 11605 77 11650 109 AOI21_X2
* cell instance $14463 r0 *1 204.44,141.4
X$14463 11628 11501 109 77 11649 AND2_X1
* cell instance $14464 r0 *1 205.2,141.4
X$14464 11649 109 11150 77 BUF_X4
* cell instance $14467 r0 *1 207.67,141.4
X$14467 11501 11628 9237 77 109 11629 NAND3_X2
* cell instance $14469 m0 *1 209.76,141.4
X$14469 11013 11503 109 77 11502 XNOR2_X1
* cell instance $14471 m0 *1 210.9,141.4
X$14471 11530 2348 11331 77 109 11504 MUX2_X1
* cell instance $14475 r0 *1 210.14,141.4
X$14475 2394 11502 11629 7983 77 109 11532 AOI22_X1
* cell instance $14477 r0 *1 211.85,141.4
X$14477 10819 10491 109 77 11803 XNOR2_X1
* cell instance $14478 r0 *1 212.99,141.4
X$14478 77 18485 11505 11529 11172 109 DFF_X1
* cell instance $14479 m0 *1 213.56,141.4
X$14479 8930 77 109 11530 INV_X1
* cell instance $14482 m0 *1 214.13,141.4
X$14482 2526 11332 11336 109 11529 77 OAI21_X1
* cell instance $14487 r0 *1 216.6,141.4
X$14487 77 18480 11527 11528 11172 109 DFF_X1
* cell instance $14489 m0 *1 217.55,141.4
X$14489 11527 77 109 11333 INV_X1
* cell instance $14491 m0 *1 218.31,141.4
X$14491 11527 11506 11525 77 109 11528 MUX2_X1
* cell instance $14494 m0 *1 222.11,141.4
X$14494 11334 11337 11525 109 77 11181 HA_X1
* cell instance $14495 m0 *1 224.01,141.4
X$14495 11181 11178 77 109 11519 XOR2_X1
* cell instance $14497 m0 *1 225.34,141.4
X$14497 11507 11506 11519 77 109 11517 MUX2_X1
* cell instance $14499 m0 *1 226.86,141.4
X$14499 10194 77 109 11506 CLKBUF_X3
* cell instance $14500 m0 *1 227.81,141.4
X$14500 11179 11508 11515 77 109 11516 MUX2_X1
* cell instance $14502 m0 *1 229.33,141.4
X$14502 11360 11340 109 77 11515 XNOR2_X1
* cell instance $14503 m0 *1 230.47,141.4
X$14503 10025 11358 11026 11360 77 109 11631 NOR4_X1
* cell instance $14505 m0 *1 231.61,141.4
X$14505 77 11341 11026 10025 11342 11509 109 NOR4_X4
* cell instance $14508 m0 *1 235.98,141.4
X$14508 77 18350 11510 11513 10196 109 DFF_X1
* cell instance $14511 r0 *1 221.35,141.4
X$14511 11630 77 109 11526 INV_X1
* cell instance $14512 r0 *1 221.73,141.4
X$14512 11630 11506 11335 77 109 11645 MUX2_X1
* cell instance $14515 r0 *1 223.63,141.4
X$14515 77 18423 11507 11517 11785 109 DFF_X1
* cell instance $14516 r0 *1 226.86,141.4
X$14516 77 18403 11179 11516 11785 109 DFF_X1
* cell instance $14523 r0 *1 232.18,141.4
X$14523 77 18399 11632 11639 11785 109 DFF_X1
* cell instance $14524 r0 *1 235.41,141.4
X$14524 11632 10498 11337 77 109 11793 MUX2_X1
* cell instance $14526 r0 *1 237.12,141.4
X$14526 11510 10500 11633 77 109 11513 MUX2_X1
* cell instance $14527 r0 *1 238.45,141.4
X$14527 11637 77 109 11636 BUF_X1
* cell instance $14528 r0 *1 239.02,141.4
X$14528 11633 77 109 11511 BUF_X1
* cell instance $14536 m0 *1 1.71,169.4
X$14536 77 13800 13916 14101 13974 9814 109 DFFR_X1
* cell instance $14540 m0 *1 6.08,169.4
X$14540 77 13800 13917 13977 14102 9814 109 DFFR_X1
* cell instance $14543 m0 *1 10.07,169.4
X$14543 13916 13257 13917 77 109 14035 MUX2_X1
* cell instance $14549 r0 *1 10.26,169.4
X$14549 5167 109 14187 77 BUF_X4
* cell instance $14551 m0 *1 11.97,169.4
X$14551 14035 5410 13803 77 109 13922 MUX2_X1
* cell instance $14555 r0 *1 12.35,169.4
X$14555 14118 3594 14166 77 109 14249 MUX2_X1
* cell instance $14558 r0 *1 14.25,169.4
X$14558 14118 3043 14169 77 109 14167 MUX2_X1
* cell instance $14560 m0 *1 14.44,169.4
X$14560 77 13672 13804 14037 14036 9814 109 DFFR_X1
* cell instance $14564 r0 *1 16.72,169.4
X$14564 14037 13682 13096 77 109 14036 MUX2_X1
* cell instance $14565 r0 *1 18.05,169.4
X$14565 77 14168 14170 14252 14250 9814 109 DFFR_X1
* cell instance $14567 m0 *1 19.38,169.4
X$14567 14107 10508 13096 77 109 13981 MUX2_X1
* cell instance $14569 m0 *1 25.27,169.4
X$14569 13920 13146 13096 77 109 14108 MUX2_X1
* cell instance $14570 m0 *1 26.6,169.4
X$14570 77 5039 109 4309 BUF_X8
* cell instance $14571 m0 *1 29.07,169.4
X$14571 14038 5656 14039 77 109 14113 MUX2_X1
* cell instance $14573 m0 *1 30.59,169.4
X$14573 13922 10368 14040 77 109 14126 MUX2_X1
* cell instance $14575 m0 *1 32.68,169.4
X$14575 14038 7330 13991 77 109 13990 MUX2_X1
* cell instance $14578 m0 *1 35.72,169.4
X$14578 77 14318 18496 13805 14119 9814 109 DFFR_X1
* cell instance $14579 m0 *1 39.52,169.4
X$14579 9895 13992 14042 8403 77 109 14123 AOI22_X1
* cell instance $14580 m0 *1 40.47,169.4
X$14580 14121 10065 14123 77 109 14125 MUX2_X1
* cell instance $14582 r0 *1 21.85,169.4
X$14582 7446 12709 14252 77 109 14250 MUX2_X1
* cell instance $14583 r0 *1 23.18,169.4
X$14583 7446 77 109 14038 BUF_X2
* cell instance $14584 r0 *1 23.94,169.4
X$14584 7446 77 109 14043 BUF_X2
* cell instance $14586 r0 *1 24.89,169.4
X$14586 7446 77 109 14118 BUF_X2
* cell instance $14588 r0 *1 26.03,169.4
X$14588 77 13984 14171 14039 14113 9814 109 DFFR_X1
* cell instance $14590 r0 *1 30.02,169.4
X$14590 14114 5455 77 109 14116 NAND2_X1
* cell instance $14592 r0 *1 30.78,169.4
X$14592 6299 14172 5449 77 14041 109 AOI21_X1
* cell instance $14594 r0 *1 31.73,169.4
X$14594 14254 5451 77 109 14256 NAND2_X1
* cell instance $14596 r0 *1 32.68,169.4
X$14596 14041 14256 14116 77 109 14261 NAND3_X1
* cell instance $14599 r0 *1 36.67,169.4
X$14599 14118 6888 13805 77 109 14119 MUX2_X1
* cell instance $14603 r0 *1 39.33,169.4
X$14603 14319 6291 4643 77 109 14260 NOR3_X1
* cell instance $14604 r0 *1 40.09,169.4
X$14604 77 14122 7776 14261 14177 9570 14125 11409 109 OAI222_X2
* cell instance $14605 m0 *1 42.37,169.4
X$14605 14126 6997 77 109 14127 NOR2_X2
* cell instance $14607 m0 *1 43.32,169.4
X$14607 14127 6997 14044 77 13410 109 AOI21_X2
* cell instance $14609 r0 *1 42.75,169.4
X$14609 77 6180 109 10129 BUF_X8
* cell instance $14611 m0 *1 45.03,169.4
X$14611 14130 14046 14043 77 109 14265 MUX2_X1
* cell instance $14614 r0 *1 45.6,169.4
X$14614 77 13551 14399 14130 14265 4086 109 DFFR_X1
* cell instance $14615 m0 *1 48.45,169.4
X$14615 8070 109 8858 77 BUF_X4
* cell instance $14617 m0 *1 49.78,169.4
X$14617 9632 14131 77 109 14129 NOR2_X1
* cell instance $14619 m0 *1 51.87,169.4
X$14619 14135 77 109 13551 CLKBUF_X3
* cell instance $14620 m0 *1 52.82,169.4
X$14620 6742 109 4210 77 BUF_X4
* cell instance $14622 m0 *1 54.91,169.4
X$14622 14132 10583 9945 77 14002 109 AOI21_X1
* cell instance $14627 r0 *1 53.96,169.4
X$14627 14048 5252 14269 77 109 14178 MUX2_X1
* cell instance $14628 r0 *1 55.29,169.4
X$14628 77 13551 14179 14269 14178 4086 109 DFFR_X1
* cell instance $14629 m0 *1 57,169.4
X$14629 3694 109 5017 77 BUF_X4
* cell instance $14633 m0 *1 60.61,169.4
X$14633 14048 5656 14271 77 109 14133 MUX2_X1
* cell instance $14640 r0 *1 59.85,169.4
X$14640 77 13553 14180 14271 14133 4086 109 DFFR_X1
* cell instance $14642 m0 *1 63.08,169.4
X$14642 77 5536 109 6158 BUF_X8
* cell instance $14645 r0 *1 63.65,169.4
X$14645 14135 77 109 13553 CLKBUF_X3
* cell instance $14646 r0 *1 64.6,169.4
X$14646 13553 77 109 19299 CLKBUF_X1
* cell instance $14650 r0 *1 67.64,169.4
X$14650 7290 109 8403 77 BUF_X4
* cell instance $14651 m0 *1 69.54,169.4
X$14651 14049 77 109 13555 CLKBUF_X3
* cell instance $14652 m0 *1 68.21,169.4
X$14652 8063 109 3599 77 BUF_X4
* cell instance $14653 m0 *1 70.49,169.4
X$14653 5734 109 3373 77 BUF_X4
* cell instance $14654 m0 *1 71.82,169.4
X$14654 14183 14047 13164 77 109 14184 MUX2_X1
* cell instance $14655 m0 *1 73.15,169.4
X$14655 14009 13926 13164 77 109 14007 MUX2_X1
* cell instance $14657 m0 *1 74.67,169.4
X$14657 77 13555 13891 14050 14141 8687 109 DFFR_X1
* cell instance $14658 m0 *1 78.47,169.4
X$14658 14050 14046 13164 77 109 14141 MUX2_X1
* cell instance $14660 m0 *1 82.84,169.4
X$14660 14049 77 109 13559 CLKBUF_X3
* cell instance $14663 r0 *1 69.35,169.4
X$14663 14140 5252 14273 77 109 14182 MUX2_X1
* cell instance $14664 r0 *1 70.68,169.4
X$14664 13555 77 109 19297 CLKBUF_X1
* cell instance $14665 r0 *1 71.25,169.4
X$14665 77 14475 13814 14183 14184 8687 109 DFFR_X1
* cell instance $14666 r0 *1 75.05,169.4
X$14666 14140 6716 14274 77 109 14186 MUX2_X1
* cell instance $14667 r0 *1 76.38,169.4
X$14667 77 13555 14275 14274 14186 8687 109 DFFR_X1
* cell instance $14668 r0 *1 80.18,169.4
X$14668 14275 77 109 14277 INV_X1
* cell instance $14670 r0 *1 80.75,169.4
X$14670 77 13559 14188 14051 14279 8687 109 DFFR_X1
* cell instance $14671 m0 *1 84.36,169.4
X$14671 14015 13145 13164 77 109 14143 MUX2_X1
* cell instance $14676 m0 *1 88.16,169.4
X$14676 14014 8645 14016 77 109 14190 MUX2_X1
* cell instance $14678 m0 *1 90.25,169.4
X$14678 6593 109 5887 77 BUF_X4
* cell instance $14679 m0 *1 91.58,169.4
X$14679 14022 8063 14053 77 109 13423 MUX2_X1
* cell instance $14681 m0 *1 93.67,169.4
X$14681 14054 13272 14055 77 109 14146 MUX2_X1
* cell instance $14682 m0 *1 95,169.4
X$14682 14054 8645 14055 77 109 13930 MUX2_X1
* cell instance $14683 m0 *1 96.33,169.4
X$14683 77 13687 14054 14150 14149 8201 109 DFFR_X1
* cell instance $14685 r0 *1 84.55,169.4
X$14685 14051 9631 13164 77 109 14279 MUX2_X1
* cell instance $14687 r0 *1 86.26,169.4
X$14687 14188 13040 14189 77 109 13376 MUX2_X1
* cell instance $14688 r0 *1 87.59,169.4
X$14688 14188 8645 14189 77 109 14281 MUX2_X1
* cell instance $14689 r0 *1 88.92,169.4
X$14689 14281 5734 14190 77 109 14053 MUX2_X1
* cell instance $14692 r0 *1 90.82,169.4
X$14692 14155 6158 77 109 14052 NOR2_X1
* cell instance $14693 r0 *1 91.39,169.4
X$14693 14283 14052 4632 77 109 14191 NOR3_X1
* cell instance $14694 r0 *1 92.15,169.4
X$14694 14286 7292 77 109 14283 NOR2_X1
* cell instance $14698 r0 *1 94.05,169.4
X$14698 14565 9023 14429 77 109 14286 MUX2_X1
* cell instance $14701 r0 *1 97.28,169.4
X$14701 14287 13926 14193 77 109 14288 MUX2_X1
* cell instance $14702 r0 *1 98.61,169.4
X$14702 77 13687 14195 14287 14288 8201 109 DFFR_X1
* cell instance $14703 m0 *1 100.7,169.4
X$14703 13276 8232 14150 77 109 14149 MUX2_X1
* cell instance $14707 r0 *1 102.41,169.4
X$14707 14026 77 109 13687 CLKBUF_X3
* cell instance $14708 m0 *1 104.5,169.4
X$14708 77 13819 14055 14151 14156 8201 109 DFFR_X1
* cell instance $14709 m0 *1 103.17,169.4
X$14709 13276 8008 14151 77 109 14156 MUX2_X1
* cell instance $14714 r0 *1 103.93,169.4
X$14714 14195 8345 14196 77 109 14155 MUX2_X1
* cell instance $14716 m0 *1 110.39,169.4
X$14716 77 14198 14029 14158 14291 8201 109 DFFR_X1
* cell instance $14718 m0 *1 114.19,169.4
X$14718 7590 14160 6745 14056 109 77 13690 OAI22_X1
* cell instance $14719 m0 *1 115.14,169.4
X$14719 13935 13002 14057 77 109 14160 MUX2_X1
* cell instance $14725 r0 *1 112.67,169.4
X$14725 12722 8166 14158 77 109 14291 MUX2_X1
* cell instance $14727 r0 *1 114.38,169.4
X$14727 14029 9023 14057 77 109 13789 MUX2_X1
* cell instance $14731 r0 *1 115.71,169.4
X$14731 14197 9023 14292 77 109 14058 MUX2_X1
* cell instance $14733 r0 *1 117.23,169.4
X$14733 77 14198 14292 14445 14295 12731 109 DFFR_X1
* cell instance $14735 m0 *1 117.61,169.4
X$14735 77 13053 13788 14161 14162 4086 109 DFFR_X1
* cell instance $14741 m0 *1 122.74,169.4
X$14741 13437 77 109 13171 CLKBUF_X3
* cell instance $14743 m0 *1 123.69,169.4
X$14743 13171 77 109 19136 INV_X1
* cell instance $14746 r0 *1 122.55,169.4
X$14746 14199 13822 14165 77 109 14297 MUX2_X1
* cell instance $14749 r0 *1 124.45,169.4
X$14749 77 13171 14202 14060 14299 12731 109 DFFR_X1
* cell instance $14751 m0 *1 127.49,169.4
X$14751 9122 13823 8957 77 109 14165 MUX2_X1
* cell instance $14754 r0 *1 128.44,169.4
X$14754 14060 13939 13825 77 109 14299 MUX2_X1
* cell instance $14755 r0 *1 129.77,169.4
X$14755 11261 14338 5149 77 109 14203 MUX2_X1
* cell instance $14759 r0 *1 132.43,169.4
X$14759 77 14205 14303 14304 14301 12731 109 DFFR_X1
* cell instance $14761 m0 *1 135.28,169.4
X$14761 77 14205 18505 13941 14164 12731 109 DFFR_X1
* cell instance $14763 m0 *1 142.88,169.4
X$14763 77 13901 18495 13798 13943 12731 109 DFFR_X1
* cell instance $14766 r0 *1 136.23,169.4
X$14766 14304 77 109 13946 INV_X1
* cell instance $14767 r0 *1 136.61,169.4
X$14767 13946 14206 14062 109 14301 77 OAI21_X1
* cell instance $14768 r0 *1 137.37,169.4
X$14768 8623 8830 14206 7009 8506 109 77 14062 OAI221_X1
* cell instance $14770 r0 *1 138.7,169.4
X$14770 11687 14061 12877 77 109 14307 NOR3_X1
* cell instance $14772 r0 *1 139.65,169.4
X$14772 14307 12877 14061 77 14163 109 AOI21_X1
* cell instance $14773 r0 *1 140.41,169.4
X$14773 11687 14061 77 109 14207 NAND2_X1
* cell instance $14774 r0 *1 140.98,169.4
X$14774 13056 77 109 13432 CLKBUF_X3
* cell instance $14775 r0 *1 141.93,169.4
X$14775 13056 77 109 14063 CLKBUF_X3
* cell instance $14776 r0 *1 142.88,169.4
X$14776 13437 77 109 19093 INV_X4
* cell instance $14778 r0 *1 144.21,169.4
X$14778 8506 7009 77 109 14306 OR2_X1
* cell instance $14782 r0 *1 147.63,169.4
X$14782 77 13901 18840 14209 14305 12731 109 DFFR_X1
* cell instance $14783 m0 *1 151.62,169.4
X$14783 13901 77 109 19228 CLKBUF_X1
* cell instance $14784 m0 *1 147.82,169.4
X$14784 77 13901 18598 13945 14159 12731 109 DFFR_X1
* cell instance $14785 m0 *1 152.19,169.4
X$14785 14070 13374 13939 77 109 NOR2_X4
* cell instance $14789 r0 *1 151.62,169.4
X$14789 77 9912 14208 14209 13287 14210 13948 13383 109 OAI222_X2
* cell instance $14791 r0 *1 154.47,169.4
X$14791 13182 109 13287 77 BUF_X4
* cell instance $14793 m0 *1 155.04,169.4
X$14793 77 13901 14144 12731 14157 14065 109 DFFR_X2
* cell instance $14794 m0 *1 159.41,169.4
X$14794 14066 13373 13182 77 14212 109 NAND3_X4
* cell instance $14795 m0 *1 161.88,169.4
X$14795 14067 5341 77 14070 109 NAND2_X4
* cell instance $14796 m0 *1 163.59,169.4
X$14796 14212 13178 12880 109 77 14154 OAI21_X2
* cell instance $14797 m0 *1 164.92,169.4
X$14797 77 13118 14148 12731 12994 13948 109 DFFR_X2
* cell instance $14798 m0 *1 169.1,169.4
X$14798 12600 77 109 10702 BUF_X2
* cell instance $14799 m0 *1 169.86,169.4
X$14799 13832 14018 77 109 14289 OR2_X1
* cell instance $14801 m0 *1 170.81,169.4
X$14801 12456 12454 109 77 11228 XNOR2_X1
* cell instance $14802 m0 *1 171.95,169.4
X$14802 14147 14068 13839 77 14148 109 AOI21_X1
* cell instance $14804 m0 *1 172.9,169.4
X$14804 13515 13702 13952 13298 10900 109 77 14138 OAI221_X1
* cell instance $14805 m0 *1 174.04,169.4
X$14805 13454 14070 13452 77 109 14144 MUX2_X1
* cell instance $14806 m0 *1 175.37,169.4
X$14806 14145 13067 13769 77 14078 109 AOI21_X1
* cell instance $14807 m0 *1 176.13,169.4
X$14807 14072 13580 13709 9396 13452 14068 109 77 AOI221_X2
* cell instance $14809 m0 *1 178.98,169.4
X$14809 13954 13303 77 109 14074 NAND2_X1
* cell instance $14810 m0 *1 179.55,169.4
X$14810 14076 13303 77 109 14075 NAND2_X1
* cell instance $14811 m0 *1 180.12,169.4
X$14811 14142 13706 14077 77 14076 109 AOI21_X1
* cell instance $14812 m0 *1 180.88,169.4
X$14812 14078 13706 77 109 14142 NOR2_X1
* cell instance $14813 m0 *1 181.45,169.4
X$14813 14081 109 13580 77 BUF_X4
* cell instance $14814 m0 *1 182.78,169.4
X$14814 13580 14078 13709 9101 14079 77 109 14080 AOI221_X1
* cell instance $14815 m0 *1 183.92,169.4
X$14815 14138 14080 14139 77 13958 109 AOI21_X1
* cell instance $14817 r0 *1 155.8,169.4
X$14817 13182 109 12996 77 BUF_X4
* cell instance $14818 r0 *1 157.13,169.4
X$14818 13373 109 13700 77 BUF_X4
* cell instance $14819 r0 *1 158.46,169.4
X$14819 14124 14211 77 13056 109 NAND2_X4
* cell instance $14820 r0 *1 160.17,169.4
X$14820 14211 77 109 14066 INV_X1
* cell instance $14822 r0 *1 160.74,169.4
X$14822 13361 109 10242 77 BUF_X4
* cell instance $14825 r0 *1 162.64,169.4
X$14825 13361 14296 12988 77 10934 109 AOI21_X2
* cell instance $14826 r0 *1 163.97,169.4
X$14826 14294 14214 77 109 10102 NOR2_X1
* cell instance $14828 r0 *1 164.92,169.4
X$14828 13232 14153 12822 109 14294 77 OAI21_X1
* cell instance $14830 r0 *1 166.06,169.4
X$14830 9912 13950 14152 109 14216 77 OAI21_X1
* cell instance $14831 r0 *1 166.82,169.4
X$14831 14216 13702 77 109 14290 NOR2_X1
* cell instance $14834 r0 *1 168.53,169.4
X$14834 14290 13948 13575 77 14147 109 AOI21_X1
* cell instance $14836 r0 *1 170.05,169.4
X$14836 13363 13702 14289 13298 11406 109 77 14285 OAI221_X1
* cell instance $14841 r0 *1 172.71,169.4
X$14841 14217 77 109 13067 BUF_X2
* cell instance $14842 r0 *1 173.47,169.4
X$14842 14285 14073 14075 77 14069 109 AOI21_X1
* cell instance $14844 r0 *1 174.42,169.4
X$14844 10892 13359 14282 13070 14215 109 77 14218 OAI221_X1
* cell instance $14846 r0 *1 175.75,169.4
X$14846 14218 14276 14074 77 14071 109 AOI21_X1
* cell instance $14847 r0 *1 176.51,169.4
X$14847 14278 12993 13841 77 14072 109 AOI21_X2
* cell instance $14848 r0 *1 177.84,169.4
X$14848 13959 8584 77 109 14278 NOR2_X1
* cell instance $14850 r0 *1 178.6,169.4
X$14850 14008 13580 13709 11201 13452 14276 109 77 AOI221_X2
* cell instance $14854 r0 *1 182.02,169.4
X$14854 14220 13580 13709 11150 14079 14073 109 77 AOI221_X2
* cell instance $14855 r0 *1 184.11,169.4
X$14855 14272 12816 13769 77 14220 109 AOI21_X1
* cell instance $14856 r0 *1 184.87,169.4
X$14856 13841 11165 77 109 14272 NOR2_X1
* cell instance $14858 m0 *1 185.06,169.4
X$14858 14136 13303 77 109 14139 NAND2_X1
* cell instance $14859 m0 *1 185.82,169.4
X$14859 14092 13585 14082 77 109 14136 MUX2_X1
* cell instance $14860 m0 *1 187.15,169.4
X$14860 14137 77 109 12897 BUF_X2
* cell instance $14861 m0 *1 187.91,169.4
X$14861 13712 11012 77 109 14134 NOR2_X1
* cell instance $14863 m0 *1 188.67,169.4
X$14863 14084 13716 77 109 14083 NOR2_X1
* cell instance $14864 m0 *1 189.24,169.4
X$14864 13959 109 13769 77 BUF_X4
* cell instance $14865 m0 *1 190.57,169.4
X$14865 14084 77 109 13959 CLKBUF_X3
* cell instance $14866 m0 *1 191.52,169.4
X$14866 13999 14085 13881 109 77 14084 OAI21_X4
* cell instance $14867 m0 *1 193.99,169.4
X$14867 14081 77 109 13643 INV_X2
* cell instance $14868 m0 *1 194.56,169.4
X$14868 13842 77 109 14086 INV_X1
* cell instance $14869 m0 *1 194.94,169.4
X$14869 14070 13643 13190 77 109 NOR2_X4
* cell instance $14870 m0 *1 196.65,169.4
X$14870 13640 14087 13633 13330 14128 77 109 OAI211_X2
* cell instance $14871 m0 *1 198.36,169.4
X$14871 14124 13457 77 109 13593 NAND2_X2
* cell instance $14874 m0 *1 200.26,169.4
X$14874 13769 13996 14234 109 13846 77 NOR3_X2
* cell instance $14875 m0 *1 201.59,169.4
X$14875 14077 13593 13874 109 13995 77 OAI21_X1
* cell instance $14876 m0 *1 202.35,169.4
X$14876 14120 14237 13846 77 14077 109 AOI21_X2
* cell instance $14877 m0 *1 203.68,169.4
X$14877 13962 77 109 14120 INV_X1
* cell instance $14881 r0 *1 186.58,169.4
X$14881 14134 12815 13769 77 14221 109 AOI21_X1
* cell instance $14882 r0 *1 187.34,169.4
X$14882 14082 14081 13709 14224 14079 14536 109 77 AOI221_X2
* cell instance $14883 r0 *1 189.43,169.4
X$14883 14083 12823 14223 77 13843 109 AOI21_X1
* cell instance $14884 r0 *1 190.19,169.4
X$14884 11012 77 109 14224 BUF_X1
* cell instance $14886 r0 *1 191.14,169.4
X$14886 13883 13843 14357 8584 14226 77 109 14227 AOI221_X1
* cell instance $14888 r0 *1 192.47,169.4
X$14888 14087 14072 14128 109 14228 77 OAI21_X1
* cell instance $14889 r0 *1 193.23,169.4
X$14889 14229 14263 13457 109 13960 77 OAI21_X1
* cell instance $14890 r0 *1 193.99,169.4
X$14890 12880 77 109 14085 BUF_X1
* cell instance $14892 r0 *1 194.75,169.4
X$14892 77 13844 14266 14232 14268 3676 109 DFFR_X1
* cell instance $14893 r0 *1 198.55,169.4
X$14893 14264 14232 13595 77 14231 109 AOI21_X1
* cell instance $14895 r0 *1 200.07,169.4
X$14895 14263 14234 77 109 14233 NAND2_X1
* cell instance $14897 r0 *1 200.83,169.4
X$14897 14234 13996 14223 77 109 13602 OR3_X2
* cell instance $14899 r0 *1 202.16,169.4
X$14899 14235 77 109 14234 CLKBUF_X2
* cell instance $14901 r0 *1 203.11,169.4
X$14901 14234 14236 14084 77 109 14259 OR3_X1
* cell instance $14902 r0 *1 204.06,169.4
X$14902 14259 77 109 13308 BUF_X2
* cell instance $14903 m0 *1 204.63,169.4
X$14903 14088 13593 14117 109 13964 77 OAI21_X1
* cell instance $14906 m0 *1 205.58,169.4
X$14906 13595 13993 77 109 14117 NAND2_X1
* cell instance $14908 m0 *1 206.34,169.4
X$14908 13965 77 109 14089 INV_X1
* cell instance $14909 m0 *1 206.72,169.4
X$14909 14090 77 109 14091 INV_X1
* cell instance $14914 r0 *1 205.96,169.4
X$14914 14089 14237 14091 77 14088 109 AOI21_X2
* cell instance $14916 m0 *1 209.19,169.4
X$14916 14112 77 109 14115 INV_X1
* cell instance $14917 m0 *1 208.24,169.4
X$14917 10855 77 109 13847 CLKBUF_X3
* cell instance $14919 r0 *1 208.81,169.4
X$14919 77 13847 14255 14390 14257 3676 109 DFFR_X1
* cell instance $14921 m0 *1 209.95,169.4
X$14921 14090 13329 14093 109 13957 77 OAI21_X1
* cell instance $14923 m0 *1 212.04,169.4
X$14923 13190 77 109 13967 CLKBUF_X3
* cell instance $14926 m0 *1 213.18,169.4
X$14926 14111 77 109 14094 INV_X1
* cell instance $14927 m0 *1 213.56,169.4
X$14927 11165 77 109 14105 BUF_X1
* cell instance $14928 m0 *1 214.13,169.4
X$14928 14090 13722 14095 109 13968 77 OAI21_X1
* cell instance $14929 m0 *1 214.89,169.4
X$14929 14110 14109 13968 13967 77 109 14111 AOI22_X1
* cell instance $14932 r0 *1 212.61,169.4
X$14932 77 13847 14095 14110 14094 3676 109 DFFR_X1
* cell instance $14934 m0 *1 217.17,169.4
X$14934 14106 14109 14092 13967 77 109 14096 AOI22_X1
* cell instance $14936 m0 *1 218.12,169.4
X$14936 14096 77 109 14097 INV_X1
* cell instance $14941 r0 *1 217.55,169.4
X$14941 77 13191 14387 14106 14097 3676 109 DFFR_X1
* cell instance $14945 r0 *1 226.29,169.4
X$14945 14239 13613 12296 77 109 14240 MUX2_X1
* cell instance $14956 m0 *1 112.48,239.4
X$14956 15258 77 109 18268 BUF_X1
* cell instance $14957 m0 *1 111.91,239.4
X$14957 15965 77 109 18267 BUF_X1
* cell instance $14958 m0 *1 113.05,239.4
X$14958 15834 77 109 18269 BUF_X1
* cell instance $14959 m0 *1 113.62,239.4
X$14959 15259 77 109 18266 BUF_X1
* cell instance $14961 m0 *1 117.61,239.4
X$14961 15875 77 109 18274 BUF_X1
* cell instance $14963 m0 *1 118.18,239.4
X$14963 15361 77 109 18275 BUF_X1
* cell instance $14965 m0 *1 118.94,239.4
X$14965 15555 77 109 18277 BUF_X1
* cell instance $14966 m0 *1 119.51,239.4
X$14966 16653 77 109 18276 BUF_X1
* cell instance $14971 m0 *1 121.41,239.4
X$14971 10919 77 109 18278 BUF_X1
* cell instance $14985 m0 *1 193.42,239.4
X$14985 17971 16482 77 109 18262 NOR2_X1
* cell instance $14989 m0 *1 199.31,239.4
X$14989 17971 16353 77 109 18260 NOR2_X1
* cell instance $15005 r0 *1 154.28,1.4
X$15005 132 131 77 109 78 OR2_X1
* cell instance $15013 r0 *1 116.85,1.4
X$15013 77 18449 81 128 89 109 DFF_X1
* cell instance $15020 r0 *1 137.75,1.4
X$15020 77 18435 135 136 176 109 DFF_X1
* cell instance $15023 r0 *1 148.58,1.4
X$15023 98 77 109 19095 INV_X4
* cell instance $15029 r0 *1 100.51,1.4
X$15029 77 18455 154 114 172 109 DFF_X1
* cell instance $15031 m0 *1 1.33,82.6
X$15031 6012 77 109 4515 BUF_X2
* cell instance $15033 m0 *1 2.09,82.6
X$15033 6150 77 109 4782 BUF_X2
* cell instance $15035 m0 *1 3.04,82.6
X$15035 6013 77 109 3907 BUF_X2
* cell instance $15037 m0 *1 4.56,82.6
X$15037 6151 77 109 4512 BUF_X2
* cell instance $15040 m0 *1 6.27,82.6
X$15040 5572 6014 5934 77 109 6015 MUX2_X1
* cell instance $15043 m0 *1 9.31,82.6
X$15043 5864 6083 5441 77 109 6016 MUX2_X1
* cell instance $15044 m0 *1 10.64,82.6
X$15044 5866 6014 6016 77 109 6708 MUX2_X1
* cell instance $15048 m0 *1 15.96,82.6
X$15048 77 5103 6284 6086 6085 2157 109 DFFR_X1
* cell instance $15049 m0 *1 19.76,82.6
X$15049 6087 3786 5444 77 109 5938 MUX2_X1
* cell instance $15052 r0 *1 1.33,82.6
X$15052 6152 77 109 3914 BUF_X2
* cell instance $15053 r0 *1 2.09,82.6
X$15053 77 6153 6281 6216 6212 2157 109 DFFR_X1
* cell instance $15057 r0 *1 5.89,82.6
X$15057 3361 6214 6216 77 109 6212 MUX2_X1
* cell instance $15058 r0 *1 7.22,82.6
X$15058 6154 3599 5794 77 109 6347 MUX2_X1
* cell instance $15060 r0 *1 10.07,82.6
X$15060 5174 6214 6156 77 109 6155 MUX2_X1
* cell instance $15064 r0 *1 16.15,82.6
X$15064 6086 2459 6283 77 109 6085 MUX2_X1
* cell instance $15066 r0 *1 18.24,82.6
X$15066 77 5103 6157 6224 6226 2157 109 DFFR_X1
* cell instance $15067 m0 *1 22.8,82.6
X$15067 5719 6091 5868 77 109 6021 MUX2_X1
* cell instance $15068 m0 *1 21.47,82.6
X$15068 5796 6158 5720 77 109 6101 MUX2_X1
* cell instance $15069 m0 *1 24.13,82.6
X$15069 6093 4284 5649 77 109 6018 MUX2_X1
* cell instance $15070 m0 *1 25.46,82.6
X$15070 5869 6018 5959 109 77 6713 MUX2_X2
* cell instance $15072 m0 *1 27.36,82.6
X$15072 6092 5575 6094 77 109 6093 MUX2_X1
* cell instance $15073 m0 *1 28.69,82.6
X$15073 6019 5310 6020 77 109 6094 MUX2_X1
* cell instance $15074 m0 *1 30.02,82.6
X$15074 5871 6022 6024 77 109 6092 MUX2_X1
* cell instance $15075 m0 *1 31.35,82.6
X$15075 5871 5536 6019 77 109 6023 MUX2_X1
* cell instance $15076 m0 *1 32.68,82.6
X$15076 5870 5725 6025 77 109 6096 MUX2_X1
* cell instance $15077 m0 *1 34.01,82.6
X$15077 77 6232 6026 5948 5872 2157 109 DFFR_X1
* cell instance $15080 r0 *1 22.42,82.6
X$15080 6224 2631 6283 77 109 6226 MUX2_X1
* cell instance $15083 r0 *1 24.32,82.6
X$15083 5444 6159 6160 77 109 6228 MUX2_X1
* cell instance $15085 r0 *1 25.84,82.6
X$15085 77 5722 6020 6160 6228 2157 109 DFFR_X1
* cell instance $15086 r0 *1 29.64,82.6
X$15086 6021 77 109 6357 INV_X1
* cell instance $15088 r0 *1 30.4,82.6
X$15088 6023 77 109 6288 INV_X1
* cell instance $15089 r0 *1 30.78,82.6
X$15089 6024 6231 6020 77 109 6161 MUX2_X1
* cell instance $15090 r0 *1 32.11,82.6
X$15090 77 6232 6162 6164 6361 2157 109 DFFR_X1
* cell instance $15091 r0 *1 35.91,82.6
X$15091 6517 6234 6163 77 109 6364 MUX2_X1
* cell instance $15093 r0 *1 37.62,82.6
X$15093 3855 6236 77 109 6237 NOR2_X1
* cell instance $15094 r0 *1 38.19,82.6
X$15094 5728 109 5506 77 BUF_X4
* cell instance $15095 m0 *1 38.38,82.6
X$15095 5949 109 4128 77 BUF_X4
* cell instance $15097 m0 *1 39.71,82.6
X$15097 77 6100 4497 109 BUF_X32
* cell instance $15098 m0 *1 49.02,82.6
X$15098 5955 109 2786 77 BUF_X4
* cell instance $15099 m0 *1 50.35,82.6
X$15099 3793 6127 6246 109 6104 77 OAI21_X1
* cell instance $15100 m0 *1 51.11,82.6
X$15100 5730 109 5577 77 BUF_X4
* cell instance $15101 m0 *1 52.44,82.6
X$15101 77 5177 6106 6029 5954 4909 109 DFFR_X1
* cell instance $15102 m0 *1 56.24,82.6
X$15102 3613 6029 77 109 5956 NAND2_X1
* cell instance $15103 m0 *1 56.81,82.6
X$15103 6106 5310 5876 77 109 6108 MUX2_X1
* cell instance $15104 m0 *1 58.14,82.6
X$15104 6110 5575 6108 77 109 5878 MUX2_X1
* cell instance $15105 m0 *1 59.47,82.6
X$15105 6031 6022 6032 77 109 6110 MUX2_X1
* cell instance $15107 r0 *1 39.52,82.6
X$15107 6292 109 4708 77 BUF_X4
* cell instance $15108 r0 *1 40.85,82.6
X$15108 5135 6180 6101 77 6165 109 AOI21_X2
* cell instance $15109 r0 *1 42.18,82.6
X$15109 6166 109 5301 77 BUF_X4
* cell instance $15110 r0 *1 43.51,82.6
X$15110 5135 109 6291 77 BUF_X4
* cell instance $15111 r0 *1 44.84,82.6
X$15111 5118 5249 6030 109 77 5873 AND3_X1
* cell instance $15112 r0 *1 45.79,82.6
X$15112 6007 109 6014 77 BUF_X4
* cell instance $15113 r0 *1 47.12,82.6
X$15113 77 6443 6244 6247 6104 4909 109 DFFR_X1
* cell instance $15115 r0 *1 51.11,82.6
X$15115 2794 6293 77 6159 109 NAND2_X4
* cell instance $15116 r0 *1 52.82,82.6
X$15116 77 4319 109 3701 BUF_X8
* cell instance $15117 r0 *1 55.29,82.6
X$15117 3000 6298 109 77 6385 AND2_X1
* cell instance $15118 r0 *1 56.05,82.6
X$15118 5874 77 109 6251 INV_X1
* cell instance $15119 r0 *1 56.43,82.6
X$15119 77 6293 109 6133 BUF_X8
* cell instance $15120 r0 *1 58.9,82.6
X$15120 6031 5275 6106 77 109 6167 MUX2_X1
* cell instance $15125 r0 *1 60.61,82.6
X$15125 77 5034 6032 6253 6033 4909 109 DFFR_X1
* cell instance $15127 m0 *1 61.18,82.6
X$15127 5875 3903 6113 109 6033 77 OAI21_X1
* cell instance $15128 m0 *1 62.13,82.6
X$15128 4072 6253 77 109 6113 NAND2_X1
* cell instance $15130 m0 *1 62.89,82.6
X$15130 77 5034 6031 6116 6394 4909 109 DFFR_X1
* cell instance $15131 m0 *1 66.69,82.6
X$15131 4505 6116 77 109 6118 NAND2_X1
* cell instance $15133 m0 *1 67.45,82.6
X$15133 5881 6036 5950 77 109 NOR2_X4
* cell instance $15134 m0 *1 69.16,82.6
X$15134 77 3631 6037 6036 6030 109 NOR3_X4
* cell instance $15136 m0 *1 72.01,82.6
X$15136 6256 77 109 6127 CLKBUF_X3
* cell instance $15137 m0 *1 72.96,82.6
X$15137 77 6170 6171 6038 5828 1663 109 DFFR_X1
* cell instance $15138 m0 *1 76.76,82.6
X$15138 3621 4639 6123 109 6122 77 OAI21_X1
* cell instance $15139 m0 *1 77.52,82.6
X$15139 4509 109 5734 77 BUF_X4
* cell instance $15142 m0 *1 80.56,82.6
X$15142 3873 6125 5883 77 109 6039 MUX2_X1
* cell instance $15146 r0 *1 64.41,82.6
X$15146 5880 4639 6118 109 6394 77 OAI21_X1
* cell instance $15147 r0 *1 65.17,82.6
X$15147 6254 109 5167 77 BUF_X4
* cell instance $15148 r0 *1 66.5,82.6
X$15148 3380 6034 77 5178 109 NAND2_X4
* cell instance $15149 r0 *1 68.21,82.6
X$15149 2794 6034 77 4905 109 NAND2_X4
* cell instance $15151 r0 *1 70.11,82.6
X$15151 77 2797 6172 2945 6169 6256 109 NAND4_X4
* cell instance $15152 r0 *1 73.53,82.6
X$15152 77 6538 109 3621 BUF_X8
* cell instance $15153 r0 *1 76,82.6
X$15153 5118 6169 5249 6172 109 77 6254 AND4_X1
* cell instance $15155 r0 *1 77.33,82.6
X$15155 5135 109 6294 77 BUF_X4
* cell instance $15156 r0 *1 78.66,82.6
X$15156 4505 6405 77 109 6123 NAND2_X1
* cell instance $15160 r0 *1 81.89,82.6
X$15160 4505 6301 77 109 6259 NAND2_X1
* cell instance $15162 r0 *1 82.65,82.6
X$15162 5460 4639 6259 109 6407 77 OAI21_X1
* cell instance $15164 r0 *1 83.79,82.6
X$15164 6671 77 109 5540 CLKBUF_X3
* cell instance $15165 m0 *1 85.31,82.6
X$15165 6127 5973 77 109 6040 NAND2_X1
* cell instance $15166 m0 *1 84.55,82.6
X$15166 4327 6127 6040 109 5885 77 OAI21_X1
* cell instance $15167 m0 *1 85.88,82.6
X$15167 77 5540 6043 6173 6261 1663 109 DFFR_X1
* cell instance $15168 m0 *1 89.68,82.6
X$15168 5888 5318 5977 77 109 6041 MUX2_X1
* cell instance $15171 r0 *1 84.74,82.6
X$15171 5460 77 109 6302 CLKBUF_X3
* cell instance $15175 r0 *1 87.02,82.6
X$15175 4327 6262 6263 109 6261 77 OAI21_X1
* cell instance $15176 r0 *1 87.78,82.6
X$15176 6262 6173 77 109 6263 NAND2_X1
* cell instance $15180 r0 *1 90.82,82.6
X$15180 6041 5461 6264 77 109 6175 MUX2_X1
* cell instance $15181 m0 *1 93.48,82.6
X$15181 5743 6130 5979 77 109 6129 MUX2_X1
* cell instance $15182 m0 *1 92.15,82.6
X$15182 6043 5589 6176 77 109 6044 MUX2_X1
* cell instance $15186 r0 *1 92.15,82.6
X$15186 6043 5318 6176 77 109 6264 MUX2_X1
* cell instance $15188 r0 *1 94.24,82.6
X$15188 4327 6177 6266 109 6265 77 OAI21_X1
* cell instance $15190 r0 *1 95.19,82.6
X$15190 6177 6178 77 109 6266 NAND2_X1
* cell instance $15192 r0 *1 97.28,82.6
X$15192 6179 6180 4739 77 109 6412 MUX2_X1
* cell instance $15194 r0 *1 98.8,82.6
X$15194 6181 6180 4329 77 109 6413 MUX2_X1
* cell instance $15195 m0 *1 99.18,82.6
X$15195 6415 5186 3877 109 77 5460 OAI21_X2
* cell instance $15197 m0 *1 100.51,82.6
X$15197 77 6131 5324 5325 5545 109 AOI21_X4
* cell instance $15198 m0 *1 102.98,82.6
X$15198 5882 6310 77 109 6172 NOR2_X2
* cell instance $15199 m0 *1 103.93,82.6
X$15199 77 6034 6132 5323 5008 109 AOI21_X4
* cell instance $15200 m0 *1 106.4,82.6
X$15200 5984 5891 5323 5008 6133 109 77 AOI211_X2
* cell instance $15202 m0 *1 108.87,82.6
X$15202 77 6136 6137 6269 6135 109 DFF_X1
* cell instance $15203 m0 *1 112.1,82.6
X$15203 6136 109 6169 77 BUF_X4
* cell instance $15205 m0 *1 114.95,82.6
X$15205 6138 109 5882 77 BUF_X4
* cell instance $15206 m0 *1 116.28,82.6
X$15206 77 5749 6138 5988 5326 109 DFF_X1
* cell instance $15207 m0 *1 119.51,82.6
X$15207 5893 109 3919 77 BUF_X4
* cell instance $15208 m0 *1 120.84,82.6
X$15208 6140 6045 5989 77 109 6143 MUX2_X1
* cell instance $15209 m0 *1 122.17,82.6
X$15209 5749 77 109 6047 INV_X1
* cell instance $15210 m0 *1 122.55,82.6
X$15210 5599 6047 6049 5997 6141 109 77 AOI211_X2
* cell instance $15212 m0 *1 124.45,82.6
X$15212 4348 5748 5861 109 6142 77 OAI21_X1
* cell instance $15213 m0 *1 125.21,82.6
X$15213 6049 5997 6148 77 109 6050 NAND3_X2
* cell instance $15214 m0 *1 126.54,82.6
X$15214 5553 5897 109 77 6146 AND2_X2
* cell instance $15215 m0 *1 127.49,82.6
X$15215 77 5553 5338 5713 6148 6000 109 OAI211_X4
* cell instance $15216 m0 *1 130.72,82.6
X$15216 5862 5432 6191 5900 77 109 5746 AOI22_X1
* cell instance $15217 m0 *1 131.67,82.6
X$15217 5896 3469 3632 109 77 6149 MUX2_X2
* cell instance $15218 m0 *1 133.38,82.6
X$15218 77 6273 4752 6147 5602 5162 5193 6006 109 OAI222_X2
* cell instance $15219 m0 *1 136.04,82.6
X$15219 6145 6144 77 109 6051 NAND2_X1
* cell instance $15220 m0 *1 136.61,82.6
X$15220 5563 5433 4752 5435 5713 5603 77 109 6052 OAI33_X1
* cell instance $15221 m0 *1 137.94,82.6
X$15221 5903 5902 5904 6006 109 6139 77 OR4_X2
* cell instance $15222 m0 *1 139.27,82.6
X$15222 77 4529 109 6139 BUF_X8
* cell instance $15223 m0 *1 141.74,82.6
X$15223 6053 6051 77 109 6056 NOR2_X2
* cell instance $15224 m0 *1 142.69,82.6
X$15224 6054 6051 6053 6192 109 6058 77 OR4_X2
* cell instance $15225 m0 *1 144.02,82.6
X$15225 77 4054 5904 5902 5903 4758 109 OR4_X4
* cell instance $15226 m0 *1 146.49,82.6
X$15226 6055 77 109 6320 INV_X1
* cell instance $15227 m0 *1 146.87,82.6
X$15227 77 5346 5436 5756 5556 5905 109 NAND4_X4
* cell instance $15228 m0 *1 150.29,82.6
X$15228 6056 5193 6003 77 5437 109 NAND3_X4
* cell instance $15229 m0 *1 152.76,82.6
X$15229 6258 4542 6194 77 109 5485 NOR3_X1
* cell instance $15230 m0 *1 153.52,82.6
X$15230 5610 77 109 5613 INV_X1
* cell instance $15231 m0 *1 153.9,82.6
X$15231 6003 5906 77 5853 109 NAND2_X4
* cell instance $15232 m0 *1 155.61,82.6
X$15232 4994 5353 4988 77 109 6060 NAND3_X2
* cell instance $15233 m0 *1 156.94,82.6
X$15233 5912 6058 5714 77 109 4596 OR3_X4
* cell instance $15234 m0 *1 159.03,82.6
X$15234 4988 5907 5710 77 6128 109 AOI21_X1
* cell instance $15235 m0 *1 159.79,82.6
X$15235 5764 109 4357 77 BUF_X4
* cell instance $15237 m0 *1 161.31,82.6
X$15237 77 5484 5767 6063 6062 1146 109 DFFR_X1
* cell instance $15238 m0 *1 165.11,82.6
X$15238 6063 77 109 6196 INV_X1
* cell instance $15239 m0 *1 165.49,82.6
X$15239 5849 109 6066 77 BUF_X4
* cell instance $15240 m0 *1 166.82,82.6
X$15240 4360 77 109 4745 INV_X4
* cell instance $15241 m0 *1 167.77,82.6
X$15241 6059 4988 77 5912 109 NAND2_X4
* cell instance $15242 m0 *1 169.48,82.6
X$15242 6064 6060 77 109 6126 NAND2_X2
* cell instance $15244 m0 *1 170.62,82.6
X$15244 6124 4875 77 5920 109 NAND2_X4
* cell instance $15245 m0 *1 172.33,82.6
X$15245 5853 4538 5437 109 77 5910 OAI21_X2
* cell instance $15246 m0 *1 173.66,82.6
X$15246 5910 4988 6067 4485 5146 6121 109 77 AOI221_X2
* cell instance $15247 m0 *1 175.75,82.6
X$15247 6065 5911 6066 77 109 6115 NAND3_X1
* cell instance $15249 m0 *1 176.7,82.6
X$15249 6068 6120 77 109 5981 NOR2_X1
* cell instance $15251 m0 *1 177.46,82.6
X$15251 6068 4164 6119 6391 77 109 5619 AOI22_X1
* cell instance $15252 m0 *1 178.41,82.6
X$15252 5909 5549 5911 109 6114 77 OAI21_X1
* cell instance $15253 m0 *1 179.17,82.6
X$15253 5912 6117 4373 77 109 NOR2_X4
* cell instance $15254 m0 *1 180.88,82.6
X$15254 6115 5774 77 109 6112 NAND2_X1
* cell instance $15258 r0 *1 100.32,82.6
X$15258 5594 3579 4451 77 8816 109 AOI21_X2
* cell instance $15260 r0 *1 101.84,82.6
X$15260 5323 4451 4162 109 77 6267 AND3_X1
* cell instance $15261 r0 *1 102.79,82.6
X$15261 77 5186 109 6182 BUF_X8
* cell instance $15263 r0 *1 105.64,82.6
X$15263 5984 5891 77 109 6132 NAND2_X1
* cell instance $15265 r0 *1 106.4,82.6
X$15265 77 3631 5882 6036 6042 109 NOR3_X4
* cell instance $15268 r0 *1 110.01,82.6
X$15268 5985 6272 77 109 6270 NOR2_X1
* cell instance $15270 r0 *1 110.77,82.6
X$15270 4346 77 109 5984 INV_X2
* cell instance $15271 r0 *1 111.34,82.6
X$15271 5882 77 109 6037 INV_X4
* cell instance $15273 r0 *1 112.48,82.6
X$15273 3306 6120 77 109 6274 NAND2_X1
* cell instance $15274 r0 *1 113.05,82.6
X$15274 4087 3148 6274 109 6311 77 OAI21_X1
* cell instance $15275 r0 *1 113.81,82.6
X$15275 6036 77 109 6275 INV_X1
* cell instance $15276 r0 *1 114.19,82.6
X$15276 6275 3630 3391 109 6269 77 OAI21_X1
* cell instance $15281 r0 *1 115.14,82.6
X$15281 6428 4170 77 109 6183 NAND2_X1
* cell instance $15282 r0 *1 115.71,82.6
X$15282 6183 6184 6185 77 109 6009 OR3_X2
* cell instance $15283 r0 *1 116.85,82.6
X$15283 77 6004 6183 6184 6185 5608 109 NOR4_X4
* cell instance $15285 r0 *1 120.46,82.6
X$15285 6188 5553 77 109 6187 NAND2_X1
* cell instance $15287 r0 *1 121.22,82.6
X$15287 6276 6045 6046 77 109 6313 MUX2_X1
* cell instance $15288 r0 *1 122.55,82.6
X$15288 5895 6049 5997 77 6045 109 AOI21_X1
* cell instance $15289 r0 *1 123.31,82.6
X$15289 6187 6275 6190 6050 5550 109 77 AOI211_X2
* cell instance $15290 r0 *1 125.02,82.6
X$15290 6187 6050 6190 77 6189 109 AOI21_X2
* cell instance $15291 r0 *1 126.35,82.6
X$15291 5898 77 109 6278 BUF_X1
* cell instance $15293 r0 *1 127.3,82.6
X$15293 5899 5599 6277 77 109 NOR2_X4
* cell instance $15294 r0 *1 129.01,82.6
X$15294 5706 5068 6049 77 109 NOR2_X4
* cell instance $15295 r0 *1 130.72,82.6
X$15295 77 6315 5068 6191 5566 109 AOI21_X4
* cell instance $15296 r0 *1 133.19,82.6
X$15296 5900 5901 5751 5432 77 109 6273 AOI22_X2
* cell instance $15298 r0 *1 135.28,82.6
X$15298 5608 5478 6432 6271 5903 109 77 AOI211_X2
* cell instance $15299 r0 *1 136.99,82.6
X$15299 5563 5896 5199 6268 77 6192 109 NAND4_X2
* cell instance $15300 r0 *1 138.7,82.6
X$15300 5199 77 109 4890 INV_X4
* cell instance $15301 r0 *1 139.65,82.6
X$15301 5712 5714 4492 77 109 NOR2_X4
* cell instance $15303 r0 *1 141.55,82.6
X$15303 5896 5199 5563 77 6193 109 NAND3_X4
* cell instance $15304 r0 *1 144.02,82.6
X$15304 77 5479 6054 6193 6003 109 NOR3_X4
* cell instance $15305 r0 *1 146.68,82.6
X$15305 77 6193 6010 5605 5758 109 NOR3_X4
* cell instance $15307 r0 *1 149.53,82.6
X$15307 6321 4357 5713 77 109 6260 OR3_X4
* cell instance $15308 r0 *1 151.62,82.6
X$15308 5714 5569 6004 77 109 6057 OR3_X1
* cell instance $15309 r0 *1 152.57,82.6
X$15309 5714 6054 6004 6192 109 6117 77 OR4_X2
* cell instance $15310 r0 *1 153.9,82.6
X$15310 6117 6059 6058 5714 5353 77 109 OAI211_X2
* cell instance $15312 r0 *1 155.8,82.6
X$15312 77 5484 18832 6061 6128 1146 109 DFFR_X1
* cell instance $15314 r0 *1 159.79,82.6
X$15314 5006 6061 6059 77 109 NOR2_X4
* cell instance $15316 r0 *1 161.69,82.6
X$15316 5849 3919 6255 77 109 NOR2_X4
* cell instance $15318 r0 *1 163.59,82.6
X$15318 6196 5849 5907 5006 109 77 6248 AND4_X1
* cell instance $15320 r0 *1 164.92,82.6
X$15320 77 5907 5006 6196 6066 6325 109 NAND4_X4
* cell instance $15321 r0 *1 168.34,82.6
X$15321 77 6060 6064 4529 6206 5905 109 OAI211_X4
* cell instance $15325 r0 *1 171.57,82.6
X$15325 6059 5685 6202 77 109 NOR2_X4
* cell instance $15326 r0 *1 173.28,82.6
X$15326 5905 4529 77 109 6252 NOR2_X2
* cell instance $15327 r0 *1 174.23,82.6
X$15327 6197 6396 6198 77 109 6199 MUX2_X1
* cell instance $15328 r0 *1 175.56,82.6
X$15328 6198 6392 6604 77 109 6250 MUX2_X1
* cell instance $15329 r0 *1 176.89,82.6
X$15329 6250 6200 77 109 6249 NOR2_X1
* cell instance $15330 r0 *1 177.46,82.6
X$15330 6066 77 109 6068 INV_X1
* cell instance $15331 r0 *1 177.84,82.6
X$15331 6248 109 6390 77 BUF_X4
* cell instance $15332 r0 *1 179.17,82.6
X$15332 77 6245 18778 5263 6111 1146 109 DFFR_X1
* cell instance $15334 m0 *1 182.59,82.6
X$15334 6114 6066 77 109 6069 NAND2_X1
* cell instance $15336 m0 *1 184.11,82.6
X$15336 5263 4683 6201 77 109 6243 MUX2_X1
* cell instance $15338 r0 *1 182.97,82.6
X$15338 77 6245 18813 6201 6243 1146 109 DFFR_X1
* cell instance $15339 m0 *1 187.15,82.6
X$15339 6112 5625 4714 77 109 6070 NAND3_X1
* cell instance $15340 m0 *1 185.82,82.6
X$15340 6387 4554 5263 77 109 6111 MUX2_X1
* cell instance $15342 m0 *1 188.67,82.6
X$15342 6241 4554 4824 77 109 6109 MUX2_X1
* cell instance $15343 m0 *1 190,82.6
X$15343 6242 5779 77 109 5969 NOR2_X1
* cell instance $15347 r0 *1 186.77,82.6
X$15347 6201 5086 6070 109 6384 77 OAI21_X1
* cell instance $15350 r0 *1 188.48,82.6
X$15350 77 5491 18814 4824 6109 1146 109 DFFR_X1
* cell instance $15352 m0 *1 193.42,82.6
X$15352 4022 5509 6107 77 109 6240 MUX2_X1
* cell instance $15354 m0 *1 194.75,82.6
X$15354 6378 5625 5917 6071 1665 77 109 6107 AOI221_X1
* cell instance $15355 m0 *1 195.89,82.6
X$15355 5627 77 109 19216 CLKBUF_X1
* cell instance $15356 m0 *1 196.46,82.6
X$15356 1799 6071 5918 5629 6105 77 109 5823 AOI221_X1
* cell instance $15357 m0 *1 197.6,82.6
X$15357 3348 77 109 5627 CLKBUF_X3
* cell instance $15359 m0 *1 198.74,82.6
X$15359 5915 5629 77 109 6071 NOR2_X2
* cell instance $15362 r0 *1 193.99,82.6
X$15362 77 5627 6240 1146 18968 4022 109 DFFR_X2
* cell instance $15365 m0 *1 200.83,82.6
X$15365 5963 77 109 6103 INV_X1
* cell instance $15366 m0 *1 200.07,82.6
X$15366 6103 5631 6370 109 5965 77 OAI21_X1
* cell instance $15368 m0 *1 201.4,82.6
X$15368 5912 5437 6102 77 109 NOR2_X4
* cell instance $15369 m0 *1 203.11,82.6
X$15369 5912 5853 6073 77 109 NOR2_X4
* cell instance $15371 m0 *1 206.34,82.6
X$15371 4264 6354 6098 77 109 6099 MUX2_X1
* cell instance $15372 m0 *1 207.67,82.6
X$15372 1658 5259 6203 109 6098 77 OAI21_X1
* cell instance $15374 m0 *1 208.62,82.6
X$15374 5912 6074 5920 4686 109 77 6097 OAI22_X2
* cell instance $15378 r0 *1 201.02,82.6
X$15378 4355 6202 5495 6073 77 109 6230 AOI22_X1
* cell instance $15379 r0 *1 201.97,82.6
X$15379 5919 5841 4415 5756 6235 6233 109 77 AOI221_X2
* cell instance $15380 r0 *1 204.06,82.6
X$15380 77 6075 6099 992 18972 4264 109 DFFR_X2
* cell instance $15381 r0 *1 208.24,82.6
X$15381 6075 77 109 19263 CLKBUF_X1
* cell instance $15382 r0 *1 208.81,82.6
X$15382 77 6075 18709 6204 6205 3676 109 DFFR_X1
* cell instance $15383 m0 *1 211.28,82.6
X$15383 484 5781 6076 5631 5921 109 77 6095 OAI221_X1
* cell instance $15384 m0 *1 210.71,82.6
X$15384 6360 4944 77 109 6076 NAND2_X1
* cell instance $15385 m0 *1 212.42,82.6
X$15385 77 6075 6095 3676 18926 4008 109 DFFR_X2
* cell instance $15386 m0 *1 216.6,82.6
X$15386 4008 6209 6073 4003 77 109 6089 AOI22_X2
* cell instance $15388 m0 *1 219.83,82.6
X$15388 6225 4986 5788 77 109 5946 MUX2_X1
* cell instance $15391 m0 *1 224.96,82.6
X$15391 6077 4834 4577 109 6090 77 OAI21_X1
* cell instance $15393 m0 *1 227.24,82.6
X$15393 6089 3988 5920 109 77 6088 OAI21_X2
* cell instance $15394 m0 *1 228.57,82.6
X$15394 77 5635 18629 3270 5925 992 109 DFFR_X1
* cell instance $15395 m0 *1 232.37,82.6
X$15395 3270 6209 5501 6340 77 109 6084 AOI22_X1
* cell instance $15400 r0 *1 213.18,82.6
X$15400 6206 4714 6358 6230 109 77 6229 AND4_X2
* cell instance $15402 r0 *1 214.7,82.6
X$15402 6073 3333 5922 6102 5499 6221 109 77 AOI221_X2
* cell instance $15403 r0 *1 216.79,82.6
X$15403 6102 109 6209 77 BUF_X4
* cell instance $15404 r0 *1 218.12,82.6
X$15404 5920 5947 77 109 6227 NOR2_X1
* cell instance $15408 r0 *1 220.02,82.6
X$15408 77 5923 6338 3676 18994 3117 109 DFFR_X2
* cell instance $15410 r0 *1 225.72,82.6
X$15410 552 4960 6339 77 109 6208 MUX2_X1
* cell instance $15415 r0 *1 227.24,82.6
X$15415 6121 5633 77 109 6222 NAND2_X1
* cell instance $15416 r0 *1 227.81,82.6
X$15416 6222 6221 6206 77 109 6223 NAND3_X2
* cell instance $15418 r0 *1 229.33,82.6
X$15418 6081 5271 6202 77 109 6220 OR3_X1
* cell instance $15420 r0 *1 230.66,82.6
X$15420 6220 6218 6067 77 109 6219 NAND3_X1
* cell instance $15422 r0 *1 231.8,82.6
X$15422 6084 6219 77 109 6215 NAND2_X1
* cell instance $15424 r0 *1 232.56,82.6
X$15424 5524 5791 5773 77 109 6218 NAND3_X1
* cell instance $15426 r0 *1 233.7,82.6
X$15426 6217 4837 6079 77 109 6213 MUX2_X1
* cell instance $15427 m0 *1 234.65,82.6
X$15427 978 5233 6080 109 6079 77 OAI21_X1
* cell instance $15429 m0 *1 235.41,82.6
X$15429 4960 6081 77 109 6080 NAND2_X1
* cell instance $15433 m0 *1 238.45,82.6
X$15433 5928 77 109 6082 BUF_X1
* cell instance $15434 m0 *1 239.02,82.6
X$15434 5929 77 109 5930 BUF_X1
* cell instance $15436 r0 *1 235.03,82.6
X$15436 77 6210 5791 6081 6213 992 109 DFFR_X1
* cell instance $15438 r0 *1 239.02,82.6
X$15438 6211 77 109 5633 BUF_X1
* cell instance $15440 m0 *1 1.33,71.4
X$15440 5011 77 109 3386 BUF_X2
* cell instance $15444 r0 *1 1.33,71.4
X$15444 5012 77 109 3801 BUF_X2
* cell instance $15447 m0 *1 2.47,71.4
X$15447 77 4894 4895 4844 4954 2157 109 DFFR_X1
* cell instance $15454 r0 *1 6.46,71.4
X$15454 5100 77 109 4333 BUF_X2
* cell instance $15455 m0 *1 6.84,71.4
X$15455 77 4894 5166 4896 4957 2157 109 DFFR_X1
* cell instance $15457 m0 *1 10.64,71.4
X$15457 4896 4843 2540 77 109 4957 MUX2_X1
* cell instance $15462 r0 *1 9.31,71.4
X$15462 77 5103 5015 5013 5102 2157 109 DFFR_X1
* cell instance $15463 m0 *1 12.54,71.4
X$15463 5013 2400 4897 77 109 5102 MUX2_X1
* cell instance $15467 r0 *1 13.11,71.4
X$15467 77 5103 5170 5014 5104 2157 109 DFFR_X1
* cell instance $15468 m0 *1 15.96,71.4
X$15468 3101 77 109 19082 INV_X4
* cell instance $15469 m0 *1 15.01,71.4
X$15469 3445 77 109 3101 CLKBUF_X3
* cell instance $15471 m0 *1 18.43,71.4
X$15471 4959 2631 4897 77 109 4850 MUX2_X1
* cell instance $15473 m0 *1 19.95,71.4
X$15473 3781 77 109 4767 BUF_X2
* cell instance $15475 r0 *1 16.91,71.4
X$15475 5014 2459 4897 77 109 5104 MUX2_X1
* cell instance $15476 r0 *1 18.24,71.4
X$15476 3101 77 109 4389 CLKBUF_X3
* cell instance $15477 r0 *1 19.19,71.4
X$15477 4389 77 109 19282 CLKBUF_X1
* cell instance $15480 r0 *1 20.33,71.4
X$15480 5015 4287 4958 77 109 5016 MUX2_X1
* cell instance $15481 m0 *1 24.89,71.4
X$15481 4898 4126 4897 77 109 4964 MUX2_X1
* cell instance $15482 m0 *1 21.09,71.4
X$15482 77 4389 5106 4898 4964 2157 109 DFFR_X1
* cell instance $15485 m0 *1 27.93,71.4
X$15485 3887 109 5514 77 BUF_X4
* cell instance $15488 r0 *1 21.66,71.4
X$15488 77 4389 5018 5019 5108 2157 109 DFFR_X1
* cell instance $15489 r0 *1 25.46,71.4
X$15489 5019 4128 4897 77 109 5108 MUX2_X1
* cell instance $15492 r0 *1 29.07,71.4
X$15492 5109 5110 4767 77 109 5243 MUX2_X1
* cell instance $15494 r0 *1 30.78,71.4
X$15494 5111 5020 4767 77 109 5021 MUX2_X1
* cell instance $15495 r0 *1 32.11,71.4
X$15495 77 4899 5024 5111 5021 2157 109 DFFR_X1
* cell instance $15496 m0 *1 35.91,71.4
X$15496 5022 3624 5024 77 109 5023 MUX2_X1
* cell instance $15498 m0 *1 37.24,71.4
X$15498 77 4899 4969 5114 5026 2157 109 DFFR_X1
* cell instance $15499 m0 *1 41.04,71.4
X$15499 5027 3607 4968 77 109 4316 MUX2_X1
* cell instance $15500 m0 *1 42.37,71.4
X$15500 5027 3364 4900 77 109 5028 MUX2_X1
* cell instance $15501 m0 *1 43.7,71.4
X$15501 4900 3042 4969 77 109 4862 MUX2_X1
* cell instance $15503 r0 *1 35.91,71.4
X$15503 5022 3607 5024 77 109 5025 MUX2_X1
* cell instance $15505 r0 *1 38,71.4
X$15505 5174 4905 5114 77 109 5026 MUX2_X1
* cell instance $15507 r0 *1 39.71,71.4
X$15507 77 3894 4968 5119 5116 2157 109 DFFR_X1
* cell instance $15509 r0 *1 43.7,71.4
X$15509 5118 5249 2794 109 77 5251 AND3_X1
* cell instance $15510 r0 *1 44.65,71.4
X$15510 77 3894 4582 4973 5122 2157 109 DFFR_X1
* cell instance $15511 m0 *1 46.17,71.4
X$15511 4970 4903 4319 109 77 5122 OAI21_X4
* cell instance $15512 m0 *1 45.41,71.4
X$15512 5029 5176 5121 109 4901 77 OAI21_X1
* cell instance $15513 m0 *1 48.64,71.4
X$15513 4719 3373 4582 77 109 5179 MUX2_X1
* cell instance $15514 m0 *1 49.97,71.4
X$15514 4204 5403 77 109 5121 NAND2_X1
* cell instance $15515 m0 *1 50.54,71.4
X$15515 4204 5030 77 109 4971 NAND2_X1
* cell instance $15516 m0 *1 51.11,71.4
X$15516 4904 5125 4972 109 4721 77 OAI21_X1
* cell instance $15517 m0 *1 51.87,71.4
X$15517 4903 4973 77 109 4970 NAND2_X1
* cell instance $15519 m0 *1 53.96,71.4
X$15519 4904 5180 4975 109 5031 77 OAI21_X1
* cell instance $15521 m0 *1 54.91,71.4
X$15521 4903 5128 77 109 4975 NAND2_X1
* cell instance $15522 m0 *1 55.48,71.4
X$15522 4905 77 109 3799 CLKBUF_X3
* cell instance $15525 r0 *1 48.45,71.4
X$15525 77 5177 4775 5030 5126 2157 109 DFFR_X1
* cell instance $15526 r0 *1 52.25,71.4
X$15526 77 3698 4778 5128 5031 2157 109 DFFR_X1
* cell instance $15527 r0 *1 56.05,71.4
X$15527 77 4504 5032 4906 5131 2157 109 DFFR_X1
* cell instance $15528 m0 *1 57.76,71.4
X$15528 2158 4642 4977 109 5131 77 OAI21_X1
* cell instance $15532 m0 *1 58.9,71.4
X$15532 3799 4906 77 109 4977 NAND2_X1
* cell instance $15537 m0 *1 59.85,71.4
X$15537 4779 77 109 4904 CLKBUF_X3
* cell instance $15538 m0 *1 60.99,71.4
X$15538 4779 77 109 2222 CLKBUF_X3
* cell instance $15539 m0 *1 61.94,71.4
X$15539 4504 77 109 19225 CLKBUF_X1
* cell instance $15540 m0 *1 62.51,71.4
X$15540 77 4504 5132 4640 4908 4909 109 DFFR_X1
* cell instance $15544 r0 *1 61.37,71.4
X$15544 77 4504 5262 5133 5033 4909 109 DFFR_X1
* cell instance $15545 r0 *1 65.17,71.4
X$15545 4780 5133 77 109 5261 NAND2_X1
* cell instance $15548 r0 *1 66.69,71.4
X$15548 77 5034 5265 5134 5035 4909 109 DFFR_X1
* cell instance $15549 m0 *1 67.64,71.4
X$15549 2161 5125 5036 109 5035 77 OAI21_X1
* cell instance $15551 m0 *1 68.4,71.4
X$15551 4318 5134 77 109 5036 NAND2_X1
* cell instance $15552 m0 *1 68.97,71.4
X$15552 77 1663 4909 109 BUF_X32
* cell instance $15553 m0 *1 78.28,71.4
X$15553 3799 4912 77 109 5136 NAND2_X1
* cell instance $15556 r0 *1 71.25,71.4
X$15556 2228 4509 2641 77 109 5038 MUX2_X1
* cell instance $15557 r0 *1 72.58,71.4
X$15557 3495 4509 3271 77 109 4786 MUX2_X1
* cell instance $15558 r0 *1 73.91,71.4
X$15558 4910 5135 4787 77 109 5040 MUX2_X1
* cell instance $15560 r0 *1 76,71.4
X$15560 5136 4642 2415 109 77 4870 OAI21_X4
* cell instance $15561 r0 *1 78.47,71.4
X$15561 2543 77 109 4324 CLKBUF_X3
* cell instance $15562 m0 *1 80.56,71.4
X$15562 4913 4914 5041 77 109 5138 MUX2_X1
* cell instance $15563 m0 *1 79.23,71.4
X$15563 2163 4789 4871 77 109 5041 MUX2_X1
* cell instance $15564 m0 *1 81.89,71.4
X$15564 3129 4789 4328 77 109 4987 MUX2_X1
* cell instance $15565 m0 *1 83.22,71.4
X$15565 4915 4914 4987 77 109 5042 MUX2_X1
* cell instance $15570 r0 *1 79.99,71.4
X$15570 4213 5039 2163 77 109 5274 MUX2_X1
* cell instance $15572 r0 *1 82.08,71.4
X$15572 3384 5039 3129 77 109 5273 MUX2_X1
* cell instance $15575 r0 *1 84.36,71.4
X$15575 5042 5415 5138 77 109 5043 MUX2_X1
* cell instance $15577 m0 *1 87.02,71.4
X$15577 77 4216 18600 4790 4989 1663 109 DFFR_X1
* cell instance $15578 m0 *1 85.69,71.4
X$15578 3500 109 4914 77 BUF_X4
* cell instance $15579 m0 *1 90.82,71.4
X$15579 4911 2235 4791 77 109 4990 MUX2_X1
* cell instance $15583 r0 *1 87.4,71.4
X$15583 5462 4903 5044 109 5277 77 OAI21_X1
* cell instance $15584 r0 *1 88.16,71.4
X$15584 4903 5279 77 109 5044 NAND2_X1
* cell instance $15587 r0 *1 89.87,71.4
X$15587 5045 2235 5047 77 109 5046 MUX2_X1
* cell instance $15588 r0 *1 91.2,71.4
X$15588 77 4216 18738 5047 5046 1663 109 DFFR_X1
* cell instance $15589 m0 *1 94.24,71.4
X$15589 4792 2804 4917 77 109 5280 MUX2_X1
* cell instance $15591 m0 *1 95.57,71.4
X$15591 4791 3060 4911 3062 77 109 5142 AOI22_X2
* cell instance $15592 m0 *1 97.28,71.4
X$15592 3059 4992 4993 109 5048 77 OAI21_X1
* cell instance $15594 m0 *1 98.23,71.4
X$15594 4918 4874 3059 77 109 4993 NAND3_X1
* cell instance $15595 m0 *1 98.99,71.4
X$15595 5049 2952 77 109 4921 NAND2_X1
* cell instance $15597 m0 *1 99.75,71.4
X$15597 3059 4920 4794 3062 3389 109 77 4998 OAI221_X1
* cell instance $15598 m0 *1 100.89,71.4
X$15598 4921 4920 3016 77 109 5051 NAND3_X1
* cell instance $15599 m0 *1 101.65,71.4
X$15599 3136 4921 3295 5144 109 77 4997 OAI22_X1
* cell instance $15600 m0 *1 102.6,71.4
X$15600 4997 4995 4998 77 5052 109 AOI21_X1
* cell instance $15601 m0 *1 103.36,71.4
X$15601 3914 4518 4005 77 109 4922 MUX2_X1
* cell instance $15602 m0 *1 104.69,71.4
X$15602 3907 4518 3804 77 109 4923 MUX2_X1
* cell instance $15603 m0 *1 106.02,71.4
X$15603 4922 4081 4923 77 109 5000 MUX2_X1
* cell instance $15604 m0 *1 107.35,71.4
X$15604 4923 3302 77 109 5054 NOR2_X1
* cell instance $15605 m0 *1 107.92,71.4
X$15605 4924 4451 77 109 5053 NAND2_X2
* cell instance $15607 m0 *1 109.06,71.4
X$15607 5002 4521 3136 77 109 4878 MUX2_X1
* cell instance $15609 r0 *1 95,71.4
X$15609 4512 3627 4790 77 109 5281 MUX2_X1
* cell instance $15612 r0 *1 97.28,71.4
X$15612 5142 3295 4918 3136 109 77 5284 OAI22_X2
* cell instance $15613 r0 *1 98.99,71.4
X$15613 4782 2649 5047 77 109 5143 MUX2_X1
* cell instance $15614 r0 *1 100.32,71.4
X$15614 5047 3060 3062 5045 77 109 5144 AOI22_X1
* cell instance $15615 r0 *1 101.27,71.4
X$15615 3059 5143 5051 109 5050 77 OAI21_X1
* cell instance $15618 r0 *1 102.98,71.4
X$15618 3580 2647 5185 109 5286 77 OAI21_X1
* cell instance $15619 r0 *1 103.74,71.4
X$15619 5053 77 109 5185 INV_X1
* cell instance $15621 r0 *1 104.88,71.4
X$15621 5053 4080 3581 77 5145 109 AOI21_X2
* cell instance $15622 r0 *1 106.21,71.4
X$15622 4922 3136 77 109 5147 NOR2_X1
* cell instance $15624 r0 *1 107.16,71.4
X$15624 5054 5147 2647 109 5148 77 NOR3_X2
* cell instance $15625 r0 *1 108.49,71.4
X$15625 5149 4521 3387 77 109 5290 MUX2_X1
* cell instance $15627 m0 *1 111.53,71.4
X$15627 77 4225 5005 4796 5056 4086 109 DFFR_X1
* cell instance $15628 m0 *1 110.77,71.4
X$15628 5291 77 109 4518 BUF_X2
* cell instance $15629 m0 *1 115.33,71.4
X$15629 5005 77 109 5062 BUF_X2
* cell instance $15634 r0 *1 114.19,71.4
X$15634 4798 5055 5057 77 109 5056 MUX2_X1
* cell instance $15638 r0 *1 115.52,71.4
X$15638 5327 5058 5189 77 5152 109 AOI21_X1
* cell instance $15640 r0 *1 116.47,71.4
X$15640 5187 5152 5060 109 5059 77 OAI21_X1
* cell instance $15641 m0 *1 116.66,71.4
X$15641 5059 4926 4927 77 5055 109 AOI21_X2
* cell instance $15643 m0 *1 117.99,71.4
X$15643 3998 77 109 19089 INV_X4
* cell instance $15644 m0 *1 118.94,71.4
X$15644 1236 77 109 3998 CLKBUF_X3
* cell instance $15645 m0 *1 119.89,71.4
X$15645 4797 5062 77 109 4095 NAND2_X2
* cell instance $15646 m0 *1 120.84,71.4
X$15646 4797 4928 4798 77 109 5063 NAND3_X1
* cell instance $15648 m0 *1 121.79,71.4
X$15648 4927 4926 77 109 5155 NAND2_X1
* cell instance $15649 m0 *1 122.36,71.4
X$15649 77 4926 4803 4928 4929 5008 109 NAND4_X4
* cell instance $15650 m0 *1 125.78,71.4
X$15650 4930 109 4884 77 BUF_X4
* cell instance $15651 m0 *1 127.11,71.4
X$15651 4347 4091 5065 77 109 NOR2_X4
* cell instance $15652 m0 *1 128.82,71.4
X$15652 3816 4233 5066 77 109 NOR2_X4
* cell instance $15653 m0 *1 130.53,71.4
X$15653 4303 4347 77 109 5067 NAND2_X1
* cell instance $15654 m0 *1 131.1,71.4
X$15654 77 4090 109 4883 BUF_X8
* cell instance $15655 m0 *1 133.57,71.4
X$15655 4470 109 4662 77 BUF_X4
* cell instance $15656 m0 *1 134.9,71.4
X$15656 4807 4932 4347 109 4933 77 NOR3_X2
* cell instance $15657 m0 *1 136.23,71.4
X$15657 4528 77 109 5069 INV_X2
* cell instance $15658 m0 *1 136.8,71.4
X$15658 4233 3816 77 4889 109 OR2_X4
* cell instance $15659 m0 *1 138.51,71.4
X$15659 77 4230 18561 5007 5074 1146 109 DFFR_X1
* cell instance $15660 m0 *1 142.31,71.4
X$15660 5068 4887 4933 5070 77 109 5162 OR4_X1
* cell instance $15661 m0 *1 143.45,71.4
X$15661 77 3818 18573 4808 4934 1146 109 DFFR_X1
* cell instance $15662 m0 *1 147.25,71.4
X$15662 4935 5003 4624 4238 4620 4760 109 77 AOI221_X2
* cell instance $15663 m0 *1 149.34,71.4
X$15663 5198 4531 4812 109 5003 77 OAI21_X1
* cell instance $15664 m0 *1 150.1,71.4
X$15664 5001 4937 4624 77 109 4891 NOR3_X1
* cell instance $15665 m0 *1 150.86,71.4
X$15665 4238 4813 5078 109 5001 77 OAI21_X1
* cell instance $15666 m0 *1 151.62,71.4
X$15666 77 4484 4485 4935 4667 4936 4994 4937 109 AOI222_X2
* cell instance $15667 m0 *1 154.28,71.4
X$15667 4238 4667 4665 77 5078 109 NAND3_X4
* cell instance $15668 m0 *1 156.75,71.4
X$15668 77 4354 4358 4240 4815 109 NOR3_X4
* cell instance $15669 m0 *1 159.41,71.4
X$15669 3401 4048 3220 109 4991 77 OAI21_X1
* cell instance $15670 m0 *1 160.17,71.4
X$15670 5150 4988 77 109 5151 NAND2_X1
* cell instance $15671 m0 *1 160.74,71.4
X$15671 4613 4363 77 109 4541 NOR2_X2
* cell instance $15673 m0 *1 161.88,71.4
X$15673 4244 4049 109 77 5079 AND2_X1
* cell instance $15675 m0 *1 162.83,71.4
X$15675 3651 5081 4940 109 77 4673 AND3_X2
* cell instance $15677 m0 *1 164.16,71.4
X$15677 4297 4491 77 109 4176 NAND2_X2
* cell instance $15679 m0 *1 165.3,71.4
X$15679 4940 5081 3651 4056 77 4365 109 NAND4_X2
* cell instance $15681 r0 *1 117.23,71.4
X$15681 4797 5058 4798 77 109 5060 NAND3_X1
* cell instance $15683 r0 *1 118.18,71.4
X$15683 5061 5062 5327 77 109 5154 NAND3_X1
* cell instance $15685 r0 *1 119.13,71.4
X$15685 4800 5189 77 109 5061 NAND2_X1
* cell instance $15686 r0 *1 119.7,71.4
X$15686 5063 129 5293 109 5294 77 OAI21_X1
* cell instance $15687 r0 *1 120.46,71.4
X$15687 5153 5155 77 109 4801 NAND2_X1
* cell instance $15689 r0 *1 121.22,71.4
X$15689 4095 4927 5154 4799 129 109 77 5295 OAI221_X1
* cell instance $15690 r0 *1 122.36,71.4
X$15690 5192 4928 77 109 4799 NAND2_X1
* cell instance $15693 r0 *1 123.88,71.4
X$15693 4803 4809 4929 77 109 4934 NOR3_X1
* cell instance $15695 r0 *1 124.83,71.4
X$15695 77 5066 4931 4884 4348 5430 109 NAND4_X4
* cell instance $15697 r0 *1 128.44,71.4
X$15697 5064 5065 109 77 5158 AND2_X2
* cell instance $15698 r0 *1 129.39,71.4
X$15698 4883 4091 5069 77 5476 109 NAND3_X4
* cell instance $15699 r0 *1 131.86,71.4
X$15699 77 5068 4887 4933 5070 5160 109 NOR4_X4
* cell instance $15700 r0 *1 135.28,71.4
X$15700 4752 5072 4090 4306 77 109 5071 NOR4_X1
* cell instance $15701 r0 *1 136.23,71.4
X$15701 77 4233 4883 4932 5072 5070 109 NOR4_X4
* cell instance $15702 r0 *1 139.65,71.4
X$15702 4529 4525 77 109 5568 NOR2_X2
* cell instance $15703 r0 *1 140.6,71.4
X$15703 77 4892 4529 5195 5075 109 NOR3_X4
* cell instance $15704 r0 *1 143.26,71.4
X$15704 5297 77 109 4350 INV_X4
* cell instance $15705 r0 *1 144.21,71.4
X$15705 5002 77 109 5163 INV_X4
* cell instance $15706 r0 *1 145.16,71.4
X$15706 5074 4934 77 109 5076 OR2_X2
* cell instance $15708 r0 *1 146.3,71.4
X$15708 77 4096 4097 4238 4665 5077 109 NOR4_X4
* cell instance $15709 r0 *1 149.72,71.4
X$15709 4665 4099 4097 77 109 4191 NAND3_X2
* cell instance $15710 r0 *1 151.05,71.4
X$15710 77 4097 4238 4665 5146 109 NOR3_X4
* cell instance $15711 r0 *1 153.71,71.4
X$15711 4355 4814 77 109 4531 OR2_X2
* cell instance $15712 r0 *1 154.66,71.4
X$15712 77 4667 5156 4665 4875 109 NOR3_X4
* cell instance $15714 r0 *1 157.7,71.4
X$15714 4492 3220 3401 4048 5201 77 109 OAI211_X2
* cell instance $15715 r0 *1 159.41,71.4
X$15715 4529 4758 77 109 4616 NOR2_X2
* cell instance $15717 r0 *1 160.55,71.4
X$15717 4171 109 3648 77 BUF_X4
* cell instance $15718 r0 *1 161.88,71.4
X$15718 3775 5079 3937 5288 4938 77 109 OAI211_X2
* cell instance $15719 r0 *1 163.59,71.4
X$15719 5080 5081 4817 5082 109 77 3831 AND4_X2
* cell instance $15720 r0 *1 164.92,71.4
X$15720 4616 4360 5080 5081 109 77 4985 AND4_X1
* cell instance $15721 r0 *1 166.06,71.4
X$15721 5203 5080 77 109 3933 NOR2_X2
* cell instance $15722 r0 *1 167.01,71.4
X$15722 5080 5081 5205 5082 109 77 4820 AND4_X2
* cell instance $15723 m0 *1 170.81,71.4
X$15723 4984 3924 77 109 5141 NAND2_X1
* cell instance $15724 m0 *1 167.39,71.4
X$15724 77 4168 4983 3931 4985 3660 109 NAND4_X4
* cell instance $15725 m0 *1 171.38,71.4
X$15725 77 4820 4819 3926 4815 4685 109 NAND4_X4
* cell instance $15726 m0 *1 174.8,71.4
X$15726 4980 99 77 109 4941 OR2_X2
* cell instance $15728 m0 *1 175.94,71.4
X$15728 4942 4941 77 109 4945 NAND2_X2
* cell instance $15729 m0 *1 176.89,71.4
X$15729 4943 5083 4980 4942 77 109 4676 AOI22_X1
* cell instance $15731 m0 *1 178.03,71.4
X$15731 5206 77 109 5083 CLKBUF_X3
* cell instance $15732 m0 *1 178.98,71.4
X$15732 5207 2908 4373 77 4187 109 AOI21_X2
* cell instance $15733 m0 *1 180.31,71.4
X$15733 4980 3092 1311 77 109 4822 MUX2_X1
* cell instance $15735 m0 *1 183.16,71.4
X$15735 4979 77 109 4980 CLKBUF_X2
* cell instance $15737 r0 *1 168.34,71.4
X$15737 77 5205 5082 5080 5081 4163 109 NAND4_X4
* cell instance $15741 r0 *1 171.76,71.4
X$15741 5359 5428 77 109 5140 NAND2_X1
* cell instance $15743 r0 *1 172.71,71.4
X$15743 5272 4980 4942 77 5139 109 AOI21_X1
* cell instance $15744 r0 *1 173.47,71.4
X$15744 77 3160 18757 3329 5139 1146 109 DFFR_X1
* cell instance $15745 r0 *1 177.27,71.4
X$15745 77 5137 1146 3081 3160 109 DFFS_X2
* cell instance $15746 r0 *1 181.26,71.4
X$15746 4944 5084 5085 109 5137 77 OAI21_X1
* cell instance $15747 r0 *1 182.02,71.4
X$15747 4944 4602 77 109 5085 NAND2_X1
* cell instance $15749 r0 *1 182.78,71.4
X$15749 3092 1059 1156 77 109 5209 NAND3_X1
* cell instance $15751 m0 *1 184.49,71.4
X$15751 4946 4944 4873 4945 109 77 4978 OAI22_X1
* cell instance $15753 m0 *1 185.44,71.4
X$15753 77 5491 4978 1146 18903 4947 109 DFFR_X2
* cell instance $15754 m0 *1 189.62,71.4
X$15754 4373 4550 77 5086 109 NAND2_X4
* cell instance $15755 m0 *1 191.33,71.4
X$15755 777 3880 4868 77 109 NOR2_X4
* cell instance $15757 r0 *1 186.58,71.4
X$15757 77 2844 4955 3145 5263 4256 5210 4034 109 AOI222_X2
* cell instance $15758 r0 *1 189.24,71.4
X$15758 77 5491 18801 5087 5211 1146 109 DFFR_X1
* cell instance $15759 r0 *1 193.04,71.4
X$15759 5086 5088 5089 77 5212 109 NAND3_X4
* cell instance $15760 m0 *1 193.99,71.4
X$15760 77 4554 4826 4256 1783 109 AOI21_X4
* cell instance $15761 m0 *1 193.42,71.4
X$15761 4868 3094 77 109 5089 NAND2_X1
* cell instance $15762 m0 *1 196.46,71.4
X$15762 77 4376 18642 4829 4974 992 109 DFFR_X1
* cell instance $15763 m0 *1 200.26,71.4
X$15763 5127 554 4683 77 2720 109 AOI21_X1
* cell instance $15765 r0 *1 195.51,71.4
X$15765 5086 5088 77 109 4826 NAND2_X2
* cell instance $15767 r0 *1 197.98,71.4
X$15767 4419 5090 5214 5366 4830 109 77 4681 OAI221_X1
* cell instance $15768 r0 *1 199.12,71.4
X$15768 5090 77 109 4683 CLKBUF_X3
* cell instance $15770 r0 *1 200.45,71.4
X$15770 5129 4832 5092 4548 77 109 5091 AOI22_X1
* cell instance $15772 m0 *1 201.4,71.4
X$15772 77 4262 18667 2674 5124 992 109 DFFR_X1
* cell instance $15774 r0 *1 201.59,71.4
X$15774 5217 5220 4825 77 5124 109 AOI21_X1
* cell instance $15775 r0 *1 202.35,71.4
X$15775 2674 5095 5092 77 109 5123 MUX2_X1
* cell instance $15776 r0 *1 203.68,71.4
X$15776 77 4262 18807 5092 5123 992 109 DFFR_X1
* cell instance $15777 m0 *1 205.77,71.4
X$15777 5496 4825 3946 77 109 4949 MUX2_X1
* cell instance $15780 m0 *1 207.29,71.4
X$15780 5222 4825 4154 77 109 5120 MUX2_X1
* cell instance $15784 m0 *1 209,71.4
X$15784 77 4262 18691 4154 5120 3676 109 DFFR_X1
* cell instance $15785 m0 *1 213.56,71.4
X$15785 77 4947 2981 4865 2912 4950 109 AOI22_X4
* cell instance $15786 m0 *1 216.79,71.4
X$15786 5242 77 109 4950 INV_X1
* cell instance $15787 m0 *1 217.17,71.4
X$15787 1236 77 109 2894 CLKBUF_X3
* cell instance $15789 m0 *1 218.31,71.4
X$15789 2912 4962 2981 3301 5113 3239 109 77 AOI221_X2
* cell instance $15790 m0 *1 220.4,71.4
X$15790 5093 77 109 4962 INV_X1
* cell instance $15792 m0 *1 220.97,71.4
X$15792 4963 4834 4577 109 4143 77 OAI21_X1
* cell instance $15795 r0 *1 213.94,71.4
X$15795 77 4687 4118 5117 5115 3676 109 DFFR_X1
* cell instance $15796 r0 *1 217.74,71.4
X$15796 5241 4986 4966 77 109 5115 MUX2_X1
* cell instance $15799 r0 *1 220.21,71.4
X$15799 4867 109 4691 77 BUF_X4
* cell instance $15800 r0 *1 221.54,71.4
X$15800 77 4563 5112 3676 19007 3434 109 DFFR_X2
* cell instance $15802 m0 *1 222.11,71.4
X$15802 4961 4951 4692 77 109 4858 MUX2_X1
* cell instance $15804 m0 *1 225.15,71.4
X$15804 4867 77 109 4960 CLKBUF_X3
* cell instance $15807 r0 *1 226.48,71.4
X$15807 5107 4951 5094 77 109 5105 MUX2_X1
* cell instance $15808 m0 *1 226.67,71.4
X$15808 3670 4960 4953 77 109 5094 MUX2_X1
* cell instance $15815 r0 *1 227.81,71.4
X$15815 5381 4834 77 109 2604 OR2_X1
* cell instance $15817 m0 *1 230.85,71.4
X$15817 4563 77 109 19206 CLKBUF_X1
* cell instance $15818 m0 *1 229.9,71.4
X$15818 2894 77 109 4563 CLKBUF_X3
* cell instance $15820 m0 *1 232.18,71.4
X$15820 77 4563 4956 992 18945 4836 109 DFFR_X2
* cell instance $15822 m0 *1 237.12,71.4
X$15822 5097 77 109 4955 BUF_X1
* cell instance $15826 r0 *1 230.28,71.4
X$15826 5393 4834 4577 109 4564 77 OAI21_X1
* cell instance $15830 r0 *1 233.7,71.4
X$15830 5098 77 109 3124 BUF_X1
* cell instance $15832 r0 *1 234.46,71.4
X$15832 4836 5095 5099 77 109 5096 MUX2_X1
* cell instance $15833 r0 *1 235.79,71.4
X$15833 77 3677 18792 5099 5096 992 109 DFFR_X1
* cell instance $15834 m0 *1 239.02,71.4
X$15834 4386 77 109 4119 BUF_X1
* cell instance $15838 m0 *1 1.33,74.2
X$15838 5164 77 109 4217 BUF_X2
* cell instance $15840 m0 *1 2.09,74.2
X$15840 77 4894 5302 5165 5232 2157 109 DFFR_X1
* cell instance $15841 m0 *1 5.89,74.2
X$15841 5165 5167 4767 77 109 5232 MUX2_X1
* cell instance $15847 r0 *1 2.85,74.2
X$15847 3101 77 109 4894 CLKBUF_X3
* cell instance $15851 r0 *1 3.8,74.2
X$15851 5504 5301 4767 77 109 5440 MUX2_X1
* cell instance $15852 r0 *1 5.13,74.2
X$15852 4895 3041 5302 77 109 5643 MUX2_X1
* cell instance $15855 r0 *1 7.03,74.2
X$15855 77 4894 5645 5168 5234 2157 109 DFFR_X1
* cell instance $15856 m0 *1 10.07,74.2
X$15856 5168 5167 2540 77 109 5234 MUX2_X1
* cell instance $15860 r0 *1 10.83,74.2
X$15860 77 5103 5511 5235 5388 2157 109 DFFR_X1
* cell instance $15861 m0 *1 12.73,74.2
X$15861 5235 4768 4897 77 109 5388 MUX2_X1
* cell instance $15867 m0 *1 19,74.2
X$15867 5170 5169 5171 77 109 5390 MUX2_X1
* cell instance $15868 m0 *1 15.2,74.2
X$15868 77 4389 5171 5389 5303 2157 109 DFFR_X1
* cell instance $15869 m0 *1 20.33,74.2
X$15869 5015 5169 4958 77 109 5238 MUX2_X1
* cell instance $15870 m0 *1 21.66,74.2
X$15870 77 4389 5172 5173 5240 2157 109 DFFR_X1
* cell instance $15871 m0 *1 25.46,74.2
X$15871 5173 4708 4897 77 109 5240 MUX2_X1
* cell instance $15875 r0 *1 15.2,74.2
X$15875 5389 2786 4897 77 109 5303 MUX2_X1
* cell instance $15879 r0 *1 19,74.2
X$15879 5170 5310 5171 77 109 5445 MUX2_X1
* cell instance $15881 r0 *1 21.85,74.2
X$15881 3887 109 3484 77 BUF_X4
* cell instance $15882 r0 *1 23.18,74.2
X$15882 5390 3995 5238 77 109 5304 MUX2_X1
* cell instance $15883 r0 *1 24.51,74.2
X$15883 77 3600 109 5446 BUF_X8
* cell instance $15886 r0 *1 28.69,74.2
X$15886 5396 5577 4767 77 109 5397 MUX2_X1
* cell instance $15887 r0 *1 30.02,74.2
X$15887 77 4899 5305 5396 5397 2157 109 DFFR_X1
* cell instance $15888 m0 *1 34.77,74.2
X$15888 5305 3479 5306 77 109 5307 MUX2_X1
* cell instance $15889 m0 *1 30.97,74.2
X$15889 77 4899 5022 5109 5243 2157 109 DFFR_X1
* cell instance $15894 r0 *1 34.77,74.2
X$15894 5305 3624 5306 77 109 5447 MUX2_X1
* cell instance $15895 r0 *1 36.1,74.2
X$15895 5307 3600 5025 77 109 5578 MUX2_X1
* cell instance $15896 m0 *1 38.57,74.2
X$15896 77 4899 5027 5246 5308 2157 109 DFFR_X1
* cell instance $15897 m0 *1 37.24,74.2
X$15897 5174 5252 5119 77 109 5116 MUX2_X1
* cell instance $15898 m0 *1 42.37,74.2
X$15898 5950 5175 109 77 5309 AND2_X1
* cell instance $15899 m0 *1 43.13,74.2
X$15899 4968 4774 4969 77 109 5247 MUX2_X1
* cell instance $15900 m0 *1 44.46,74.2
X$15900 5400 109 3786 77 BUF_X4
* cell instance $15901 m0 *1 45.79,74.2
X$15901 6027 109 2400 77 BUF_X4
* cell instance $15902 m0 *1 47.12,74.2
X$15902 5251 109 2631 77 BUF_X4
* cell instance $15904 m0 *1 48.64,74.2
X$15904 2541 77 109 5177 CLKBUF_X3
* cell instance $15905 m0 *1 49.59,74.2
X$15905 5178 77 109 4204 CLKBUF_X3
* cell instance $15906 m0 *1 50.54,74.2
X$15906 5252 77 109 4318 CLKBUF_X3
* cell instance $15907 m0 *1 51.49,74.2
X$15907 5029 5125 5404 109 5253 77 OAI21_X1
* cell instance $15908 m0 *1 52.25,74.2
X$15908 4904 5176 4971 109 5126 77 OAI21_X1
* cell instance $15909 m0 *1 53.01,74.2
X$15909 3054 5175 109 77 5400 AND2_X1
* cell instance $15911 r0 *1 37.43,74.2
X$15911 2541 77 109 4899 CLKBUF_X3
* cell instance $15913 r0 *1 38.57,74.2
X$15913 2794 5175 109 77 5450 AND2_X1
* cell instance $15914 r0 *1 39.33,74.2
X$15914 77 5177 4900 5448 5658 2157 109 DFFR_X1
* cell instance $15915 r0 *1 43.13,74.2
X$15915 77 5451 5247 5402 5449 5028 5401 4412 109 AOI222_X2
* cell instance $15916 r0 *1 45.79,74.2
X$15916 77 5177 5452 5403 4901 2157 109 DFFR_X1
* cell instance $15917 r0 *1 49.59,74.2
X$15917 77 5177 5453 5257 5253 2157 109 DFFR_X1
* cell instance $15918 r0 *1 53.39,74.2
X$15918 77 3698 5454 5258 5256 2157 109 DFFR_X1
* cell instance $15919 m0 *1 54.91,74.2
X$15919 4318 5257 77 109 5404 NAND2_X1
* cell instance $15920 m0 *1 54.15,74.2
X$15920 5029 5180 5254 109 5256 77 OAI21_X1
* cell instance $15921 m0 *1 55.48,74.2
X$15921 4903 5258 77 109 5254 NAND2_X1
* cell instance $15924 m0 *1 58.33,74.2
X$15924 2795 5181 77 109 5125 NAND2_X2
* cell instance $15926 m0 *1 60.04,74.2
X$15926 2794 5181 77 109 4642 NAND2_X2
* cell instance $15928 m0 *1 61.18,74.2
X$15928 2474 4287 2603 77 109 5312 MUX2_X1
* cell instance $15929 m0 *1 62.51,74.2
X$15929 2222 5313 5261 109 5033 77 OAI21_X1
* cell instance $15936 r0 *1 59.09,74.2
X$15936 3266 5310 2940 77 109 5456 MUX2_X1
* cell instance $15937 r0 *1 60.42,74.2
X$15937 3266 5311 2940 77 109 5457 MUX2_X1
* cell instance $15938 r0 *1 61.75,74.2
X$15938 2474 5311 2603 77 109 5526 MUX2_X1
* cell instance $15940 m0 *1 64.6,74.2
X$15940 5262 77 109 5406 INV_X1
* cell instance $15941 m0 *1 63.65,74.2
X$15941 5181 3054 77 109 5180 NAND2_X2
* cell instance $15944 r0 *1 64.6,74.2
X$15944 3380 5181 77 109 5176 NAND2_X2
* cell instance $15948 m0 *1 66.12,74.2
X$15948 77 5034 5266 5182 5264 4909 109 DFFR_X1
* cell instance $15950 r0 *1 66.12,74.2
X$15950 4781 77 109 5314 CLKBUF_X3
* cell instance $15951 r0 *1 67.07,74.2
X$15951 5411 5410 5409 77 109 5531 MUX2_X1
* cell instance $15952 r0 *1 68.4,74.2
X$15952 5530 4784 5265 77 109 5411 MUX2_X1
* cell instance $15953 r0 *1 69.73,74.2
X$15953 4903 5182 77 109 5528 NAND2_X1
* cell instance $15954 r0 *1 70.3,74.2
X$15954 5266 4784 5037 77 109 5409 MUX2_X1
* cell instance $15955 m0 *1 72.39,74.2
X$15955 5267 5125 5316 109 77 5268 OAI21_X4
* cell instance $15956 m0 *1 71.06,74.2
X$15956 3271 4784 2641 77 109 5315 MUX2_X1
* cell instance $15957 m0 *1 74.86,74.2
X$15957 77 4324 5270 5183 5268 1663 109 DFFR_X1
* cell instance $15958 m0 *1 78.66,74.2
X$15958 4318 5183 77 109 5267 NAND2_X1
* cell instance $15961 m0 *1 80.94,74.2
X$15961 4788 5318 4871 77 109 5537 MUX2_X1
* cell instance $15963 m0 *1 82.46,74.2
X$15963 5274 5275 5273 77 109 5184 MUX2_X1
* cell instance $15967 r0 *1 71.82,74.2
X$15967 4785 5410 5315 77 109 5532 MUX2_X1
* cell instance $15970 r0 *1 74.86,74.2
X$15970 5413 5180 5316 109 77 5458 OAI21_X4
* cell instance $15971 r0 *1 77.33,74.2
X$15971 4903 5317 77 109 5413 NAND2_X1
* cell instance $15974 r0 *1 79.04,74.2
X$15974 5169 109 5311 77 BUF_X4
* cell instance $15978 r0 *1 81.7,74.2
X$15978 4434 5318 4328 77 109 5459 MUX2_X1
* cell instance $15981 r0 *1 83.98,74.2
X$15981 5460 77 109 2232 CLKBUF_X3
* cell instance $15984 m0 *1 84.93,74.2
X$15984 77 5540 5588 5279 5277 1663 109 DFFR_X1
* cell instance $15989 r0 *1 86.83,74.2
X$15989 4916 5461 4078 77 109 5463 MUX2_X1
* cell instance $15992 r0 *1 89.87,74.2
X$15992 3189 5318 3057 77 109 5464 MUX2_X1
* cell instance $15993 r0 *1 91.2,74.2
X$15993 2418 5318 3385 77 109 5544 MUX2_X1
* cell instance $15995 m0 *1 94.62,74.2
X$15995 5047 3627 5049 77 109 5282 MUX2_X1
* cell instance $15997 m0 *1 95.95,74.2
X$15997 5281 2804 5282 77 109 5283 MUX2_X1
* cell instance $15999 m0 *1 100.32,74.2
X$15999 3456 5283 3389 5320 77 109 5319 AOI22_X1
* cell instance $16000 m0 *1 101.27,74.2
X$16000 5050 77 109 5418 INV_X1
* cell instance $16001 m0 *1 101.65,74.2
X$16001 3581 5280 3389 5419 77 109 5322 AOI22_X1
* cell instance $16002 m0 *1 102.6,74.2
X$16002 5323 5284 4919 109 77 5285 OAI21_X2
* cell instance $16003 m0 *1 103.93,74.2
X$16003 5287 5186 5286 109 77 4781 OAI21_X2
* cell instance $16005 m0 *1 105.45,74.2
X$16005 3456 109 5325 77 BUF_X4
* cell instance $16007 m0 *1 106.97,74.2
X$16007 5053 3584 3456 77 5695 109 AOI21_X1
* cell instance $16011 r0 *1 96.52,74.2
X$16011 4652 3627 4515 77 109 5321 MUX2_X1
* cell instance $16012 r0 *1 97.85,74.2
X$16012 5048 77 109 5545 INV_X1
* cell instance $16014 r0 *1 98.42,74.2
X$16014 4512 3627 4782 77 109 5465 MUX2_X1
* cell instance $16015 r0 *1 99.75,74.2
X$16015 5465 2804 5466 77 109 5320 MUX2_X1
* cell instance $16017 r0 *1 101.27,74.2
X$16017 5321 2804 5467 77 109 5419 MUX2_X1
* cell instance $16019 r0 *1 102.98,74.2
X$16019 5185 5323 77 5324 109 NAND2_X4
* cell instance $16021 r0 *1 105.45,74.2
X$16021 77 5420 5324 3456 3454 109 AOI21_X4
* cell instance $16022 r0 *1 107.92,74.2
X$16022 5324 5325 4925 77 5548 109 AOI21_X2
* cell instance $16023 m0 *1 108.3,74.2
X$16023 77 5326 18585 5291 5290 4086 109 DFFR_X1
* cell instance $16030 r0 *1 110.39,74.2
X$16030 77 5326 18779 5426 5423 4086 109 DFFR_X1
* cell instance $16031 r0 *1 114.19,74.2
X$16031 5426 77 109 5327 CLKBUF_X3
* cell instance $16032 m0 *1 114.95,74.2
X$16032 5188 4928 5327 77 109 5057 NOR3_X1
* cell instance $16034 m0 *1 115.71,74.2
X$16034 4928 77 109 5058 INV_X1
* cell instance $16036 m0 *1 116.28,74.2
X$16036 5293 5062 77 109 5187 NAND2_X1
* cell instance $16037 m0 *1 116.85,74.2
X$16037 5327 77 109 5190 INV_X2
* cell instance $16038 m0 *1 117.42,74.2
X$16038 5189 5327 4797 77 109 NOR2_X4
* cell instance $16039 m0 *1 119.13,74.2
X$16039 5062 5189 77 109 5188 NAND2_X1
* cell instance $16041 m0 *1 119.89,74.2
X$16041 4798 5189 5062 77 109 5191 MUX2_X1
* cell instance $16042 m0 *1 121.22,74.2
X$16042 5190 5191 109 77 5192 AND2_X1
* cell instance $16044 m0 *1 122.17,74.2
X$16044 5192 5331 77 109 5332 OR2_X1
* cell instance $16045 m0 *1 122.93,74.2
X$16045 5295 5294 109 77 5276 AND2_X1
* cell instance $16047 m0 *1 123.88,74.2
X$16047 4807 4932 4090 109 5333 77 NOR3_X2
* cell instance $16048 m0 *1 125.21,74.2
X$16048 5334 109 4525 77 BUF_X4
* cell instance $16049 m0 *1 126.54,74.2
X$16049 4807 4932 77 109 5064 NOR2_X1
* cell instance $16051 m0 *1 127.3,74.2
X$16051 5069 4662 77 109 5335 NAND2_X1
* cell instance $16052 m0 *1 127.87,74.2
X$16052 4347 4303 109 77 5298 AND2_X1
* cell instance $16053 m0 *1 128.63,74.2
X$16053 4931 4347 77 109 5336 NOR2_X1
* cell instance $16054 m0 *1 129.2,74.2
X$16054 77 5069 5157 4306 4662 5338 109 NAND4_X4
* cell instance $16055 m0 *1 132.62,74.2
X$16055 5065 4883 4233 77 109 5433 NAND3_X2
* cell instance $16056 m0 *1 133.95,74.2
X$16056 77 4932 4807 5073 5193 109 NOR3_X4
* cell instance $16057 m0 *1 136.61,74.2
X$16057 5563 5193 77 109 5478 NAND2_X1
* cell instance $16058 m0 *1 137.18,74.2
X$16058 5073 4807 4932 77 109 5194 OR3_X4
* cell instance $16059 m0 *1 139.27,74.2
X$16059 77 5300 5075 4663 5561 4540 109 AOI22_X4
* cell instance $16060 m0 *1 142.5,74.2
X$16060 4350 5196 5480 4475 77 109 5299 AOI22_X1
* cell instance $16061 m0 *1 143.45,74.2
X$16061 5195 4892 5482 5481 2439 109 77 AOI211_X2
* cell instance $16062 m0 *1 145.16,74.2
X$16062 4884 4306 77 109 5435 NAND2_X1
* cell instance $16063 m0 *1 145.73,74.2
X$16063 5339 109 5297 77 BUF_X4
* cell instance $16064 m0 *1 147.06,74.2
X$16064 5343 5197 4812 77 109 4530 NAND3_X2
* cell instance $16065 m0 *1 148.39,74.2
X$16065 5197 5343 109 77 4621 AND2_X1
* cell instance $16066 m0 *1 149.15,74.2
X$16066 2395 4812 4621 77 5344 109 AOI21_X1
* cell instance $16067 m0 *1 149.91,74.2
X$16067 2395 4621 77 109 5198 OR2_X1
* cell instance $16068 m0 *1 150.67,74.2
X$16068 4191 5296 5347 5199 77 109 5438 NAND4_X1
* cell instance $16069 m0 *1 151.62,74.2
X$16069 5358 4485 5198 77 5348 109 AOI21_X1
* cell instance $16070 m0 *1 152.38,74.2
X$16070 5348 5439 77 109 5349 OR2_X1
* cell instance $16075 r0 *1 115.14,74.2
X$16075 5328 4928 5055 109 5329 77 OAI21_X1
* cell instance $16076 r0 *1 115.9,74.2
X$16076 5187 5190 5329 77 5423 109 AOI21_X1
* cell instance $16078 r0 *1 116.85,74.2
X$16078 4927 5189 5190 109 5427 77 OAI21_X1
* cell instance $16079 r0 *1 117.61,74.2
X$16079 5427 5598 77 109 4521 NAND2_X2
* cell instance $16080 r0 *1 118.56,74.2
X$16080 77 171 5470 4927 4797 109 AOI21_X4
* cell instance $16082 r0 *1 121.22,74.2
X$16082 5330 77 109 5429 INV_X1
* cell instance $16083 r0 *1 121.6,74.2
X$16083 77 5190 5471 5553 5555 5429 109 AOI22_X4
* cell instance $16085 r0 *1 125.02,74.2
X$16085 5430 77 109 4892 BUF_X1
* cell instance $16086 r0 *1 125.59,74.2
X$16086 5066 4884 5065 77 5334 109 NAND3_X4
* cell instance $16088 r0 *1 128.25,74.2
X$16088 5157 4931 4348 3918 77 109 5337 NAND4_X1
* cell instance $16089 r0 *1 129.2,74.2
X$16089 5066 4884 77 5475 109 NAND2_X4
* cell instance $16090 r0 *1 130.91,74.2
X$16090 5067 5064 5070 5432 5157 5560 109 77 AOI221_X2
* cell instance $16091 r0 *1 133,74.2
X$16091 4347 4348 77 109 5477 NOR2_X2
* cell instance $16092 r0 *1 133.95,74.2
X$16092 77 4347 4932 4807 4303 5434 109 NOR4_X4
* cell instance $16094 r0 *1 137.56,74.2
X$16094 77 4090 4932 4807 5072 5566 109 NOR4_X4
* cell instance $16096 r0 *1 141.36,74.2
X$16096 77 4230 18751 5339 5299 1146 109 DFFR_X1
* cell instance $16098 r0 *1 145.35,74.2
X$16098 4540 5436 5340 109 77 5483 AND3_X1
* cell instance $16099 r0 *1 146.3,74.2
X$16099 4763 5340 5341 109 5196 77 OAI21_X1
* cell instance $16100 r0 *1 147.06,74.2
X$16100 77 4890 4235 4619 4612 109 NOR3_X4
* cell instance $16101 r0 *1 149.72,74.2
X$16101 5344 5438 2526 4087 109 77 5345 OAI22_X1
* cell instance $16102 r0 *1 150.67,74.2
X$16102 5556 5756 5342 77 109 5351 NAND3_X1
* cell instance $16103 r0 *1 151.43,74.2
X$16103 77 5484 5349 1146 18982 5156 109 DFFR_X2
* cell instance $16104 m0 *1 154.28,74.2
X$16104 5350 5346 77 109 4622 NOR2_X1
* cell instance $16105 m0 *1 153.52,74.2
X$16105 99 5199 4980 77 4814 109 AOI21_X1
* cell instance $16106 m0 *1 154.85,74.2
X$16106 5156 109 4238 77 BUF_X4
* cell instance $16107 m0 *1 156.18,74.2
X$16107 5292 5762 5201 4879 5197 77 109 OAI211_X2
* cell instance $16108 m0 *1 157.89,74.2
X$16108 4879 5201 5292 109 5200 77 OAI21_X1
* cell instance $16109 m0 *1 158.65,74.2
X$16109 4879 4991 77 109 5352 OR2_X1
* cell instance $16110 m0 *1 159.41,74.2
X$16110 5151 5353 77 109 4886 NOR2_X1
* cell instance $16111 m0 *1 159.98,74.2
X$16111 4991 4879 5289 109 4539 77 OAI21_X1
* cell instance $16112 m0 *1 160.74,74.2
X$16112 4616 109 4044 77 BUF_X4
* cell instance $16113 m0 *1 162.07,74.2
X$16113 4297 4749 4171 77 109 4049 NOR3_X1
* cell instance $16114 m0 *1 162.83,74.2
X$16114 3651 4616 5080 5081 109 77 5288 AND4_X1
* cell instance $16117 r0 *1 155.8,74.2
X$16117 4620 4099 5271 77 109 NOR2_X4
* cell instance $16118 r0 *1 157.51,74.2
X$16118 4529 4492 5487 77 5292 109 AOI21_X2
* cell instance $16119 r0 *1 158.84,74.2
X$16119 5437 5853 77 109 4754 NAND2_X1
* cell instance $16120 r0 *1 159.41,74.2
X$16120 5341 5355 4488 109 77 3075 AND3_X1
* cell instance $16121 r0 *1 160.36,74.2
X$16121 5354 5341 5355 77 2356 109 NAND3_X4
* cell instance $16122 r0 *1 162.83,74.2
X$16122 5356 4751 4940 77 5289 109 AOI21_X1
* cell instance $16123 r0 *1 163.59,74.2
X$16123 5357 4940 5356 109 3399 77 NOR3_X2
* cell instance $16124 m0 *1 165.3,74.2
X$16124 3646 3650 3775 3648 5204 5202 77 109 OAI221_X2
* cell instance $16125 m0 *1 164.35,74.2
X$16125 4360 4613 77 109 5082 NOR2_X2
* cell instance $16126 m0 *1 167.39,74.2
X$16126 5081 4745 77 109 5203 NAND2_X2
* cell instance $16128 m0 *1 168.53,74.2
X$16128 4363 4054 77 109 5205 NOR2_X2
* cell instance $16129 m0 *1 169.48,74.2
X$16129 77 4171 5278 5203 3937 109 NOR3_X4
* cell instance $16130 m0 *1 172.14,74.2
X$16130 5078 4485 77 109 4942 NOR2_X2
* cell instance $16132 r0 *1 164.92,74.2
X$16132 5356 4940 5357 77 109 5431 OR3_X1
* cell instance $16134 r0 *1 166.06,74.2
X$16134 5431 109 777 77 BUF_X4
* cell instance $16135 r0 *1 167.39,74.2
X$16135 5203 5080 4171 77 109 3776 NOR3_X1
* cell instance $16136 r0 *1 168.15,74.2
X$16136 3924 3880 5487 109 77 5354 OAI21_X4
* cell instance $16137 r0 *1 170.62,74.2
X$16137 4486 5146 77 109 5358 NAND2_X1
* cell instance $16141 r0 *1 171.19,74.2
X$16141 4055 109 3924 77 BUF_X4
* cell instance $16142 r0 *1 172.52,74.2
X$16142 5276 77 109 5541 BUF_X2
* cell instance $16143 r0 *1 173.28,74.2
X$16143 5428 77 109 5360 INV_X1
* cell instance $16144 m0 *1 174.42,74.2
X$16144 5271 4485 4941 109 77 5296 OAI21_X2
* cell instance $16145 m0 *1 173.47,74.2
X$16145 99 4942 3329 5269 77 109 5272 AOI22_X1
* cell instance $16147 r0 *1 173.66,74.2
X$16147 5237 5204 5296 77 5543 109 AOI21_X1
* cell instance $16149 r0 *1 174.8,74.2
X$16149 77 18280 5361 5424 3160 1146 109 DFFS_X1
* cell instance $16151 m0 *1 176.13,74.2
X$16151 3407 5354 4751 77 109 4370 NAND3_X1
* cell instance $16152 m0 *1 177.08,74.2
X$16152 5269 4945 109 77 5206 AND2_X1
* cell instance $16153 m0 *1 177.84,74.2
X$16153 5244 4596 4619 5163 109 77 5207 OAI22_X2
* cell instance $16155 m0 *1 179.74,74.2
X$16155 4596 3081 77 109 5362 NOR2_X1
* cell instance $16157 m0 *1 180.5,74.2
X$16157 4821 5237 77 109 5425 NOR2_X1
* cell instance $16158 m0 *1 181.07,74.2
X$16158 3081 3092 5209 109 5084 77 OAI21_X1
* cell instance $16160 m0 *1 182.02,74.2
X$16160 5210 3092 5209 109 5208 77 OAI21_X1
* cell instance $16165 r0 *1 180.31,74.2
X$16165 5362 5425 5490 109 5424 77 OAI21_X1
* cell instance $16167 r0 *1 181.26,74.2
X$16167 4944 5208 5533 109 5422 77 OAI21_X1
* cell instance $16168 r0 *1 182.02,74.2
X$16168 77 5422 1146 5210 5491 109 DFFS_X2
* cell instance $16169 r0 *1 186.01,74.2
X$16169 77 5491 18879 4111 5421 1146 109 DFFR_X1
* cell instance $16171 m0 *1 186.2,74.2
X$16171 5623 4355 77 109 4679 NOR2_X2
* cell instance $16172 m0 *1 187.91,74.2
X$16172 4554 5260 5363 109 5421 77 OAI21_X1
* cell instance $16174 m0 *1 188.86,74.2
X$16174 4111 4683 5087 77 109 5211 MUX2_X1
* cell instance $16176 m0 *1 190.38,74.2
X$16176 1311 5259 5365 5366 5087 109 77 5260 OAI221_X1
* cell instance $16178 m0 *1 191.71,74.2
X$16178 77 2586 4679 2261 4868 109 AOI21_X4
* cell instance $16180 m0 *1 194.37,74.2
X$16180 77 4376 18619 5213 5255 992 109 DFFR_X1
* cell instance $16181 m0 *1 198.17,74.2
X$16181 5216 1924 77 109 5214 NAND2_X1
* cell instance $16183 m0 *1 198.93,74.2
X$16183 4829 5095 5213 77 109 5255 MUX2_X1
* cell instance $16184 m0 *1 200.26,74.2
X$16184 4373 4829 77 109 5367 NAND2_X1
* cell instance $16186 r0 *1 189.81,74.2
X$16186 5364 5492 4678 4382 4281 109 77 5365 OAI221_X1
* cell instance $16188 r0 *1 191.33,74.2
X$16188 77 3880 4831 777 6239 109 NOR3_X4
* cell instance $16189 r0 *1 193.99,74.2
X$16189 5369 109 5095 77 BUF_X4
* cell instance $16190 r0 *1 195.32,74.2
X$16190 5417 3094 2261 5494 77 109 2899 AOI22_X2
* cell instance $16193 r0 *1 197.6,74.2
X$16193 5416 5090 5214 5366 5213 109 77 4827 OAI221_X1
* cell instance $16195 r0 *1 198.93,74.2
X$16195 4596 4948 4281 4382 5367 5405 77 109 OAI221_X2
* cell instance $16196 r0 *1 201.02,74.2
X$16196 5368 5414 2586 471 5369 4409 109 77 AOI221_X2
* cell instance $16197 m0 *1 202.16,74.2
X$16197 5216 969 77 109 5218 NAND2_X1
* cell instance $16198 m0 *1 201.21,74.2
X$16198 5212 5091 5218 109 77 5217 AND3_X1
* cell instance $16200 m0 *1 202.92,74.2
X$16200 2674 77 109 5220 INV_X1
* cell instance $16203 r0 *1 203.3,74.2
X$16203 5412 5221 1822 4678 109 77 4260 OAI22_X1
* cell instance $16204 m0 *1 205.39,74.2
X$16204 5248 5221 4678 503 109 77 2864 OAI22_X2
* cell instance $16205 m0 *1 203.68,74.2
X$16205 5250 5221 4678 978 109 77 4127 OAI22_X2
* cell instance $16206 m0 *1 207.1,74.2
X$16206 5245 1822 5216 77 5222 109 AOI21_X1
* cell instance $16207 m0 *1 207.86,74.2
X$16207 4154 5095 5223 77 109 5224 MUX2_X1
* cell instance $16208 m0 *1 209.19,74.2
X$16208 77 4687 18694 5223 5224 3676 109 DFFR_X1
* cell instance $16214 r0 *1 204.82,74.2
X$16214 5407 5221 996 4678 109 77 4422 OAI22_X1
* cell instance $16215 r0 *1 205.77,74.2
X$16215 5408 5221 4678 839 109 77 4570 OAI22_X2
* cell instance $16218 r0 *1 208.05,74.2
X$16218 5370 5369 5223 5086 109 77 5245 OAI22_X1
* cell instance $16220 r0 *1 210.52,74.2
X$16220 5370 5498 77 109 5373 NAND2_X1
* cell instance $16221 r0 *1 211.09,74.2
X$16221 1822 5372 5373 5374 5375 109 77 5520 OAI221_X1
* cell instance $16222 r0 *1 212.23,74.2
X$16222 4558 77 109 5375 INV_X1
* cell instance $16225 r0 *1 213.75,74.2
X$16225 2894 77 109 4687 CLKBUF_X3
* cell instance $16228 m0 *1 215.84,74.2
X$16228 4558 5237 4573 4154 77 109 5377 AOI22_X2
* cell instance $16231 r0 *1 215.84,74.2
X$16231 5376 77 109 5372 CLKBUF_X3
* cell instance $16232 r0 *1 216.79,74.2
X$16232 5377 4118 5392 109 77 5519 OAI21_X2
* cell instance $16233 m0 *1 221.73,74.2
X$16233 3434 5212 5225 77 109 5112 MUX2_X1
* cell instance $16234 m0 *1 217.93,74.2
X$16234 77 4687 18628 5113 5518 3676 109 DFFR_X1
* cell instance $16237 r0 *1 218.88,74.2
X$16237 5378 5498 77 109 5379 NAND2_X1
* cell instance $16238 r0 *1 219.45,74.2
X$16238 996 5372 5379 5374 5380 109 77 5518 OAI221_X1
* cell instance $16239 r0 *1 220.59,74.2
X$16239 5113 77 109 5380 INV_X1
* cell instance $16242 r0 *1 221.54,74.2
X$16242 5113 5237 3434 4573 77 109 5515 AOI22_X1
* cell instance $16243 r0 *1 222.49,74.2
X$16243 996 5384 5399 109 5225 77 OAI21_X1
* cell instance $16245 r0 *1 223.44,74.2
X$16245 5378 5385 5226 5228 77 109 5399 AOI22_X1
* cell instance $16246 m0 *1 224.77,74.2
X$16246 77 4563 18614 5226 5239 3676 109 DFFR_X1
* cell instance $16247 m0 *1 223.44,74.2
X$16247 3434 5095 5226 77 109 5239 MUX2_X1
* cell instance $16248 m0 *1 228.57,74.2
X$16248 2865 77 109 5395 INV_X1
* cell instance $16251 r0 *1 224.39,74.2
X$16251 996 5233 5398 109 5500 77 OAI21_X1
* cell instance $16252 r0 *1 225.15,74.2
X$16252 4960 5512 77 109 5398 NAND2_X1
* cell instance $16253 r0 *1 225.72,74.2
X$16253 4986 77 109 4837 CLKBUF_X3
* cell instance $16259 r0 *1 227.24,74.2
X$16259 5236 5498 77 109 5382 NAND2_X1
* cell instance $16260 r0 *1 227.81,74.2
X$16260 839 5372 5382 5374 5395 109 77 5394 OAI221_X1
* cell instance $16261 r0 *1 228.95,74.2
X$16261 77 4563 5394 992 19028 2865 109 DFFR_X2
* cell instance $16262 m0 *1 234.08,74.2
X$16262 4836 5509 5383 77 109 4956 MUX2_X1
* cell instance $16263 m0 *1 232.37,74.2
X$16263 2865 5237 4573 4836 77 109 5391 AOI22_X2
* cell instance $16264 m0 *1 235.41,74.2
X$16264 5236 5385 5099 5228 77 109 5386 AOI22_X1
* cell instance $16265 m0 *1 236.36,74.2
X$16265 839 5233 5507 109 5227 77 OAI21_X1
* cell instance $16268 m0 *1 238.07,74.2
X$16268 5229 77 109 4274 BUF_X1
* cell instance $16269 m0 *1 238.64,74.2
X$16269 5230 77 109 3512 CLKBUF_X3
* cell instance $16271 r0 *1 233.13,74.2
X$16271 5391 4835 5392 109 77 5510 OAI21_X2
* cell instance $16273 r0 *1 234.65,74.2
X$16273 839 5384 5386 109 5383 77 OAI21_X1
* cell instance $16274 r0 *1 235.41,74.2
X$16274 5387 4837 5227 77 109 5505 MUX2_X1
* cell instance $16277 r0 *1 237.88,74.2
X$16277 5231 77 109 2881 BUF_X1
* cell instance $16282 r0 *1 169.1,1.4
X$16282 121 77 109 103 BUF_X2
* cell instance $16286 m0 *1 114.57,239.4
X$16286 15553 77 109 18271 BUF_X1
* cell instance $16287 m0 *1 115.33,239.4
X$16287 15966 77 109 18272 BUF_X1
* cell instance $16288 m0 *1 115.9,239.4
X$16288 15874 77 109 18273 BUF_X1
* cell instance $16289 m0 *1 116.47,239.4
X$16289 15263 77 109 18270 BUF_X1
* cell instance $16295 m0 *1 184.11,119
X$16295 77 9425 18664 9526 9587 3676 109 DFFR_X1
* cell instance $16296 m0 *1 188.1,119
X$16296 77 9425 18660 9426 9366 3676 109 DFFR_X1
* cell instance $16297 m0 *1 191.9,119
X$16297 6817 77 109 9425 CLKBUF_X3
* cell instance $16298 m0 *1 192.85,119
X$16298 9412 77 109 8110 BUF_X2
* cell instance $16299 m0 *1 193.61,119
X$16299 9581 9367 109 77 9531 XNOR2_X1
* cell instance $16300 m0 *1 194.75,119
X$16300 9531 8110 77 109 7415 NAND2_X1
* cell instance $16301 m0 *1 195.32,119
X$16301 9576 9370 109 77 9416 XNOR2_X1
* cell instance $16302 m0 *1 196.46,119
X$16302 9060 9369 9061 77 109 9370 NAND3_X1
* cell instance $16304 r0 *1 184.11,119
X$16304 9526 7965 9556 77 109 9587 MUX2_X1
* cell instance $16306 r0 *1 185.82,119
X$16306 6145 8327 9526 6391 77 109 9533 AOI22_X1
* cell instance $16308 r0 *1 187.15,119
X$16308 9528 77 109 7282 INV_X1
* cell instance $16311 r0 *1 189.81,119
X$16311 9425 77 109 19269 CLKBUF_X1
* cell instance $16312 r0 *1 190.38,119
X$16312 9368 9058 9694 109 77 9529 AND3_X1
* cell instance $16313 r0 *1 191.33,119
X$16313 77 9581 9530 9697 9425 109 DFF_X1
* cell instance $16315 r0 *1 195.32,119
X$16315 9530 9061 9369 9423 109 77 9701 AND4_X2
* cell instance $16316 r0 *1 196.65,119
X$16316 9530 8895 9698 77 109 7002 MUX2_X1
* cell instance $16317 m0 *1 197.79,119
X$16317 9423 2428 9374 77 109 9532 MUX2_X1
* cell instance $16322 r0 *1 198.36,119
X$16322 77 9576 9423 9532 9425 109 DFF_X1
* cell instance $16323 m0 *1 200.45,119
X$16323 9413 9412 9410 77 5663 109 AOI21_X2
* cell instance $16325 m0 *1 201.78,119
X$16325 9578 9372 109 77 9410 XNOR2_X1
* cell instance $16328 r0 *1 202.35,119
X$16328 9373 9704 77 109 9372 NAND2_X1
* cell instance $16329 r0 *1 202.92,119
X$16329 9534 9704 77 109 9574 NAND2_X1
* cell instance $16330 m0 *1 203.49,119
X$16330 9534 9865 9368 77 109 9231 NAND3_X1
* cell instance $16333 m0 *1 205.77,119
X$16333 9423 8895 9374 77 109 6778 MUX2_X1
* cell instance $16336 r0 *1 203.49,119
X$16336 9573 6936 9533 77 109 5407 MUX2_X1
* cell instance $16337 r0 *1 204.82,119
X$16337 9571 9574 109 77 9573 XNOR2_X1
* cell instance $16340 r0 *1 207.86,119
X$16340 77 9571 9368 9569 9108 109 DFF_X1
* cell instance $16341 m0 *1 208.43,119
X$16341 6817 77 109 9108 CLKBUF_X3
* cell instance $16343 m0 *1 209.38,119
X$16343 9108 77 109 19138 INV_X1
* cell instance $16346 m0 *1 210.71,119
X$16346 9368 8614 9376 77 109 9569 MUX2_X1
* cell instance $16349 m0 *1 212.61,119
X$16349 77 18376 9234 9568 9108 109 DFF_X1
* cell instance $16352 m0 *1 216.03,119
X$16352 9560 9380 3306 9540 77 109 9565 NOR4_X1
* cell instance $16354 m0 *1 217.17,119
X$16354 9538 77 109 9380 INV_X1
* cell instance $16355 m0 *1 217.55,119
X$16355 9560 9380 9539 77 109 9379 NOR3_X1
* cell instance $16357 m0 *1 218.5,119
X$16357 9376 77 109 9539 INV_X1
* cell instance $16360 r0 *1 212.8,119
X$16360 9234 3210 77 109 9567 OR2_X1
* cell instance $16361 r0 *1 213.56,119
X$16361 3630 9567 9566 109 9708 77 OAI21_X1
* cell instance $16362 r0 *1 214.32,119
X$16362 9708 9565 77 109 9568 NOR2_X1
* cell instance $16364 r0 *1 215.08,119
X$16364 4307 9535 9536 109 9566 77 OAI21_X1
* cell instance $16365 r0 *1 215.84,119
X$16365 9234 9537 9538 77 9535 109 AOI21_X1
* cell instance $16367 r0 *1 216.98,119
X$16367 9537 9234 77 109 9560 NAND2_X1
* cell instance $16370 r0 *1 218.12,119
X$16370 9540 77 109 9536 INV_X1
* cell instance $16373 m0 *1 220.4,119
X$16373 9559 2394 9558 77 9381 109 AOI21_X1
* cell instance $16374 m0 *1 219.26,119
X$16374 9376 9561 109 77 9558 XNOR2_X1
* cell instance $16376 m0 *1 224.2,119
X$16376 9548 3592 77 109 9710 OR2_X2
* cell instance $16378 r0 *1 219.64,119
X$16378 9560 9541 9068 9066 77 109 9561 NOR4_X1
* cell instance $16380 r0 *1 220.97,119
X$16380 9542 4812 9556 77 9559 109 AOI21_X2
* cell instance $16381 r0 *1 222.3,119
X$16381 77 9734 9554 18294 9261 109 DFF_X2
* cell instance $16382 m0 *1 227.24,119
X$16382 8734 109 9237 77 BUF_X4
* cell instance $16383 m0 *1 225.53,119
X$16383 9391 3592 9540 77 109 NOR2_X4
* cell instance $16388 r0 *1 226.48,119
X$16388 8750 4812 9552 77 9728 109 AOI21_X2
* cell instance $16394 r0 *1 228.95,119
X$16394 9383 9374 9371 77 109 9724 NAND3_X2
* cell instance $16396 m0 *1 230.66,119
X$16396 6206 109 8124 77 BUF_X4
* cell instance $16399 m0 *1 233.51,119
X$16399 9371 9389 109 77 9387 XNOR2_X1
* cell instance $16400 m0 *1 234.65,119
X$16400 9543 77 109 9371 BUF_X2
* cell instance $16401 m0 *1 235.41,119
X$16401 77 18386 9543 9386 8735 109 DFF_X1
* cell instance $16406 r0 *1 231.42,119
X$16406 9071 9549 8907 9079 77 109 9547 NOR4_X1
* cell instance $16407 r0 *1 232.37,119
X$16407 9383 9371 77 109 9549 NAND2_X1
* cell instance $16409 r0 *1 233.7,119
X$16409 9374 9547 109 77 9716 XNOR2_X1
* cell instance $16410 r0 *1 234.84,119
X$16410 9544 77 109 7252 BUF_X1
* cell instance $16412 r0 *1 235.79,119
X$16412 8735 77 109 19317 CLKBUF_X1
* cell instance $16415 r0 *1 236.93,119
X$16415 9717 77 109 5387 BUF_X1
* cell instance $16421 m0 *1 235.6,113.4
X$16421 9086 77 109 4961 BUF_X2
* cell instance $16422 m0 *1 236.55,113.4
X$16422 9082 77 109 5107 CLKBUF_X2
* cell instance $16426 r0 *1 235.6,113.4
X$16426 77 9085 8735 18293 9062 109 DFF_X2
* cell instance $16430 m0 *1 99.75,51.8
X$16430 213 2650 276 77 109 3061 MUX2_X1
* cell instance $16431 m0 *1 101.27,51.8
X$16431 2091 3060 325 3062 77 109 2956 AOI22_X2
* cell instance $16433 r0 *1 99.75,51.8
X$16433 2803 3016 3061 77 109 3192 MUX2_X1
* cell instance $16434 r0 *1 101.08,51.8
X$16434 3136 3063 2956 3295 2954 3293 77 109 OAI221_X2
* cell instance $16436 m0 *1 104.12,51.8
X$16436 252 2952 77 109 3063 NAND2_X1
* cell instance $16437 m0 *1 103.36,51.8
X$16437 3063 2807 3016 77 109 2957 NAND3_X1
* cell instance $16440 r0 *1 103.36,51.8
X$16440 3059 2958 2957 109 3297 77 OAI21_X1
* cell instance $16441 r0 *1 104.12,51.8
X$16441 2654 3193 2952 77 109 3194 NOR3_X1
* cell instance $16443 r0 *1 105.07,51.8
X$16443 2291 3060 125 3062 77 109 3141 AOI22_X2
* cell instance $16444 m0 *1 106.02,51.8
X$16444 325 2655 252 77 109 3064 MUX2_X1
* cell instance $16449 r0 *1 106.78,51.8
X$16449 3198 2804 3064 77 109 3197 MUX2_X1
* cell instance $16451 r0 *1 108.3,51.8
X$16451 125 2655 126 77 109 3199 MUX2_X1
* cell instance $16453 m0 *1 112.1,51.8
X$16453 3020 1983 2204 2764 2572 3144 109 77 AOI221_X2
* cell instance $16454 m0 *1 110.01,51.8
X$16454 2959 2424 2237 2421 3019 3458 77 109 OAI221_X2
* cell instance $16455 m0 *1 114.19,51.8
X$16455 1094 2889 2813 2961 2561 3148 109 77 AOI221_X2
* cell instance $16456 m0 *1 116.28,51.8
X$16456 1754 1503 2012 109 3311 77 OAI21_X1
* cell instance $16459 r0 *1 112.67,51.8
X$16459 2099 1503 77 109 3200 NOR2_X1
* cell instance $16460 r0 *1 113.24,51.8
X$16460 3200 2626 2960 1476 109 77 3305 OAI22_X2
* cell instance $16461 r0 *1 114.95,51.8
X$16461 1589 3311 2812 109 3310 77 OAI21_X1
* cell instance $16467 r0 *1 117.42,51.8
X$16467 1995 2427 1388 109 3201 77 OAI21_X1
* cell instance $16468 m0 *1 118.94,51.8
X$16468 2561 2962 2563 2965 77 109 3150 AOI22_X1
* cell instance $16469 m0 *1 118.18,51.8
X$16469 2424 2964 3150 109 3065 77 OAI21_X1
* cell instance $16470 m0 *1 119.89,51.8
X$16470 2965 2563 1172 77 2964 109 AOI21_X1
* cell instance $16471 m0 *1 120.65,51.8
X$16471 1172 2098 77 109 2963 NAND2_X1
* cell instance $16472 m0 *1 121.22,51.8
X$16472 2022 1500 2209 109 3030 77 OAI21_X1
* cell instance $16473 m0 *1 121.98,51.8
X$16473 2572 1754 2209 109 3313 77 OAI21_X1
* cell instance $16477 r0 *1 118.75,51.8
X$16477 1757 2026 1388 109 3312 77 OAI21_X1
* cell instance $16478 r0 *1 119.51,51.8
X$16478 1767 2572 1500 77 109 3202 MUX2_X1
* cell instance $16482 r0 *1 121.41,51.8
X$16482 2026 2211 3203 109 3314 77 OAI21_X1
* cell instance $16483 r0 *1 122.17,51.8
X$16483 3313 2026 77 109 3203 NAND2_X1
* cell instance $16484 r0 *1 122.74,51.8
X$16484 2427 2421 3158 77 109 3308 MUX2_X1
* cell instance $16485 m0 *1 123.69,51.8
X$16485 3030 2424 77 109 3066 NAND2_X1
* cell instance $16486 m0 *1 123.12,51.8
X$16486 2966 3156 77 109 3155 NOR2_X1
* cell instance $16488 m0 *1 125.02,51.8
X$16488 77 3031 2421 2137 1810 1396 3066 3317 109 OAI222_X2
* cell instance $16490 m0 *1 127.87,51.8
X$16490 2424 1400 2022 77 3316 109 AOI21_X1
* cell instance $16492 m0 *1 128.82,51.8
X$16492 1400 2969 3067 109 2970 77 OAI21_X1
* cell instance $16496 r0 *1 124.64,51.8
X$16496 1757 2421 1589 77 3204 109 AOI21_X1
* cell instance $16497 r0 *1 125.4,51.8
X$16497 2967 1841 1754 77 3158 109 AOI21_X1
* cell instance $16501 r0 *1 128.25,51.8
X$16501 3316 2967 77 109 3067 NOR2_X1
* cell instance $16503 r0 *1 129.2,51.8
X$16503 2900 1997 2970 109 77 3753 AND3_X1
* cell instance $16505 m0 *1 129.96,51.8
X$16505 2022 77 109 2563 CLKBUF_X3
* cell instance $16509 r0 *1 130.91,51.8
X$16509 3161 3205 1341 77 109 3321 MUX2_X1
* cell instance $16510 r0 *1 132.24,51.8
X$16510 77 3322 3161 3321 2343 109 DFF_X1
* cell instance $16511 m0 *1 133.76,51.8
X$16511 2343 77 109 19253 CLKBUF_X1
* cell instance $16515 r0 *1 135.47,51.8
X$16515 2430 77 109 2343 CLKBUF_X3
* cell instance $16517 m0 *1 136.23,51.8
X$16517 77 3068 3037 3038 3325 109 DFF_X1
* cell instance $16519 m0 *1 141.17,51.8
X$16519 3069 3039 77 109 2910 OR2_X1
* cell instance $16520 m0 *1 141.93,51.8
X$16520 2816 2972 2971 3165 77 109 3039 AOI22_X1
* cell instance $16521 m0 *1 142.88,51.8
X$16521 3210 133 2817 109 3165 77 OAI21_X1
* cell instance $16527 r0 *1 139.08,51.8
X$16527 2174 1126 1656 109 77 3327 OAI21_X4
* cell instance $16529 r0 *1 141.74,51.8
X$16529 2816 3330 2972 77 3328 109 AOI21_X1
* cell instance $16531 r0 *1 143.26,51.8
X$16531 3069 2817 77 109 3330 NAND2_X1
* cell instance $16533 r0 *1 145.35,51.8
X$16533 77 3070 18771 3216 3214 1146 109 DFFR_X1
* cell instance $16534 m0 *1 145.73,51.8
X$16534 77 3070 2818 2819 2917 1663 109 DFFR_X1
* cell instance $16536 m0 *1 149.53,51.8
X$16536 2819 2042 2043 77 109 3040 OR3_X1
* cell instance $16537 m0 *1 150.48,51.8
X$16537 2042 2918 77 109 3335 NAND2_X1
* cell instance $16540 r0 *1 149.15,51.8
X$16540 3216 77 109 2817 BUF_X2
* cell instance $16542 r0 *1 150.67,51.8
X$16542 77 3070 18760 2824 3337 1146 109 DFFR_X1
* cell instance $16544 m0 *1 152.95,51.8
X$16544 2042 2433 2974 2043 1799 77 109 3337 AOI221_X1
* cell instance $16546 r0 *1 154.47,51.8
X$16546 3070 77 109 19313 CLKBUF_X1
* cell instance $16548 m0 *1 156.18,51.8
X$16548 1772 2825 969 3217 109 77 2530 OAI22_X1
* cell instance $16549 m0 *1 155.23,51.8
X$16549 2826 77 109 2042 CLKBUF_X3
* cell instance $16550 m0 *1 157.13,51.8
X$16550 2175 3074 2435 2433 109 77 3166 AND4_X1
* cell instance $16551 m0 *1 158.27,51.8
X$16551 3073 3074 3075 109 77 2826 AND3_X1
* cell instance $16552 m0 *1 159.22,51.8
X$16552 3075 3074 3073 77 109 1772 NAND3_X1
* cell instance $16554 m0 *1 160.74,51.8
X$16554 1418 2828 77 109 3077 NOR2_X1
* cell instance $16556 r0 *1 155.42,51.8
X$16556 2575 3167 3071 77 109 3341 MUX2_X1
* cell instance $16558 r0 *1 157.13,51.8
X$16558 3166 3075 3073 77 109 3167 NAND3_X1
* cell instance $16559 r0 *1 157.89,51.8
X$16559 3072 77 109 2043 BUF_X2
* cell instance $16560 r0 *1 158.65,51.8
X$16560 3074 77 109 3342 INV_X1
* cell instance $16561 r0 *1 159.03,51.8
X$16561 3036 3075 3074 3073 77 109 3076 NAND4_X1
* cell instance $16563 r0 *1 160.36,51.8
X$16563 2828 3076 3077 77 109 3343 MUX2_X1
* cell instance $16564 m0 *1 161.88,51.8
X$16564 77 3070 18556 3034 3164 1146 109 DFFR_X1
* cell instance $16567 m0 *1 166.44,51.8
X$16567 796 77 109 3350 INV_X1
* cell instance $16568 m0 *1 166.82,51.8
X$16568 3032 2826 3163 77 3162 109 AOI21_X1
* cell instance $16569 m0 *1 167.58,51.8
X$16569 2042 3033 3162 1658 2043 77 109 3347 AOI221_X1
* cell instance $16570 m0 *1 168.72,51.8
X$16570 2667 1418 77 109 3032 OR2_X1
* cell instance $16571 m0 *1 169.48,51.8
X$16571 77 3160 18536 2831 3159 1146 109 DFFR_X1
* cell instance $16572 m0 *1 173.28,51.8
X$16572 3078 1416 3029 2832 2831 77 109 3159 AOI221_X1
* cell instance $16574 m0 *1 174.61,51.8
X$16574 2441 109 2581 77 BUF_X4
* cell instance $16576 m0 *1 176.13,51.8
X$16576 3026 2581 77 109 3153 NOR2_X1
* cell instance $16577 m0 *1 176.7,51.8
X$16577 77 2444 3153 3007 3154 109 NOR3_X4
* cell instance $16578 m0 *1 179.36,51.8
X$16578 2145 2581 696 2443 3139 3152 77 109 OAI221_X2
* cell instance $16579 m0 *1 181.45,51.8
X$16579 1106 2443 77 109 3083 NOR2_X1
* cell instance $16581 m0 *1 182.78,51.8
X$16581 77 3147 18688 2976 3022 1146 109 DFFR_X1
* cell instance $16586 r0 *1 165.3,51.8
X$16586 2975 77 109 3346 INV_X1
* cell instance $16587 r0 *1 165.68,51.8
X$16587 2040 3476 778 77 109 NOR2_X4
* cell instance $16588 r0 *1 167.39,51.8
X$16588 77 3160 18713 2667 3347 1146 109 DFFR_X1
* cell instance $16594 r0 *1 171.76,51.8
X$16594 494 77 109 3078 INV_X1
* cell instance $16595 r0 *1 172.14,51.8
X$16595 2308 2441 77 109 3151 NOR2_X1
* cell instance $16596 r0 *1 172.71,51.8
X$16596 1037 3400 3401 109 3157 77 NOR3_X2
* cell instance $16597 r0 *1 174.04,51.8
X$16597 3222 109 2443 77 BUF_X4
* cell instance $16598 r0 *1 175.37,51.8
X$16598 1998 2441 77 109 3223 NOR2_X1
* cell instance $16599 r0 *1 175.94,51.8
X$16599 2761 2441 77 109 3359 NOR2_X1
* cell instance $16601 r0 *1 176.7,51.8
X$16601 3081 4034 2041 2838 77 109 3080 AOI22_X1
* cell instance $16603 r0 *1 177.84,51.8
X$16603 1680 2581 77 109 3084 NOR2_X2
* cell instance $16604 r0 *1 178.79,51.8
X$16604 77 3082 2833 3151 3138 3358 109 NOR4_X4
* cell instance $16605 r0 *1 182.21,51.8
X$16605 2835 3084 3085 77 109 3357 OR3_X2
* cell instance $16606 r0 *1 183.35,51.8
X$16606 77 2835 3084 3085 3356 109 NOR3_X4
* cell instance $16609 m0 *1 187.15,51.8
X$16609 2981 1783 109 77 3146 AND2_X1
* cell instance $16611 m0 *1 187.91,51.8
X$16611 77 3147 18524 3086 3143 1146 109 DFFR_X1
* cell instance $16612 m0 *1 191.71,51.8
X$16612 548 1722 3086 77 109 3143 MUX2_X1
* cell instance $16615 r0 *1 187.34,51.8
X$16615 3146 77 109 3092 CLKBUF_X3
* cell instance $16619 r0 *1 190.95,51.8
X$16619 3078 2728 3351 109 3087 77 OAI21_X1
* cell instance $16622 m0 *1 193.61,51.8
X$16622 3142 2585 2977 77 109 3017 MUX2_X1
* cell instance $16626 m0 *1 197.22,51.8
X$16626 631 2728 3140 109 3012 77 OAI21_X1
* cell instance $16628 r0 *1 193.61,51.8
X$16628 3348 77 109 2447 CLKBUF_X3
* cell instance $16632 r0 *1 195.89,51.8
X$16632 1311 1892 3226 77 109 3088 MUX2_X1
* cell instance $16633 r0 *1 197.22,51.8
X$16633 3528 2585 3228 77 109 3227 MUX2_X1
* cell instance $16635 m0 *1 198.36,51.8
X$16635 2841 109 2978 77 BUF_X4
* cell instance $16636 m0 *1 199.88,51.8
X$16636 3410 2842 2897 109 77 2737 AND3_X1
* cell instance $16639 r0 *1 200.07,51.8
X$16639 2588 3339 3089 109 3338 77 OAI21_X1
* cell instance $16640 r0 *1 200.83,51.8
X$16640 77 3411 18812 3134 3338 1146 109 DFFR_X1
* cell instance $16641 m0 *1 201.78,51.8
X$16641 2844 3558 3137 2709 1465 3135 109 77 AOI221_X2
* cell instance $16642 m0 *1 201.21,51.8
X$16642 2588 3134 77 109 3089 NAND2_X1
* cell instance $16644 m0 *1 204.06,51.8
X$16644 2980 3092 399 77 109 3014 MUX2_X1
* cell instance $16647 m0 *1 207.67,51.8
X$16647 2675 3133 3091 3232 109 77 2668 AND4_X1
* cell instance $16648 m0 *1 208.81,51.8
X$16648 2980 2981 2132 2843 77 109 3133 AOI22_X1
* cell instance $16649 m0 *1 209.76,51.8
X$16649 2709 109 2843 77 BUF_X4
* cell instance $16655 r0 *1 207.29,51.8
X$16655 3326 2904 1982 2276 77 109 3231 AOI22_X1
* cell instance $16657 r0 *1 208.43,51.8
X$16657 3087 2585 3093 77 109 3319 MUX2_X1
* cell instance $16659 r0 *1 209.95,51.8
X$16659 77 2360 18822 3093 3319 1146 109 DFFR_X1
* cell instance $16661 m0 *1 212.23,51.8
X$16661 2982 3092 554 77 109 3008 MUX2_X1
* cell instance $16663 m0 *1 215.27,51.8
X$16663 3095 3006 3128 77 109 3007 NAND3_X2
* cell instance $16664 m0 *1 216.6,51.8
X$16664 2841 109 1629 77 BUF_X4
* cell instance $16665 m0 *1 217.93,51.8
X$16665 2982 2981 2363 3124 77 109 2678 AOI22_X2
* cell instance $16666 m0 *1 219.64,51.8
X$16666 3125 2681 1542 2361 77 109 3005 AOI22_X2
* cell instance $16667 m0 *1 221.35,51.8
X$16667 2677 2984 3237 2709 2059 77 109 3096 AOI221_X1
* cell instance $16669 m0 *1 222.68,51.8
X$16669 2057 2983 2189 2978 77 109 3097 AOI22_X1
* cell instance $16671 m0 *1 223.82,51.8
X$16671 77 2847 2878 3119 3117 2904 3099 2453 109 AOI222_X2
* cell instance $16674 r0 *1 214.13,51.8
X$16674 3315 3094 3093 2261 77 109 3128 AOI22_X1
* cell instance $16675 r0 *1 215.08,51.8
X$16675 2847 1870 77 109 3127 NAND2_X1
* cell instance $16676 r0 *1 215.65,51.8
X$16676 77 674 2709 3307 3303 3301 841 2841 109 AOI222_X2
* cell instance $16677 r0 *1 218.31,51.8
X$16677 77 3675 18766 3236 3294 992 109 DFFR_X1
* cell instance $16678 r0 *1 222.11,51.8
X$16678 3119 3097 3238 3096 109 77 2282 AND4_X1
* cell instance $16679 r0 *1 223.25,51.8
X$16679 3434 3094 2276 1879 77 109 3284 AOI22_X2
* cell instance $16680 r0 *1 224.96,51.8
X$16680 3118 1543 2876 1294 77 109 3416 AOI22_X2
* cell instance $16681 r0 *1 226.67,51.8
X$16681 3098 77 109 3240 INV_X1
* cell instance $16682 m0 *1 227.05,51.8
X$16682 987 2978 2363 2461 77 109 3281 AOI22_X2
* cell instance $16684 m0 *1 228.76,51.8
X$16684 2984 109 2261 77 BUF_X4
* cell instance $16685 m0 *1 230.09,51.8
X$16685 77 2128 3108 3109 3110 3085 109 NAND4_X4
* cell instance $16686 m0 *1 233.51,51.8
X$16686 2983 109 2123 77 BUF_X4
* cell instance $16687 m0 *1 234.84,51.8
X$16687 1073 2843 1299 2983 77 109 3105 AOI22_X1
* cell instance $16688 m0 *1 235.79,51.8
X$16688 77 3677 18551 2988 2990 992 109 DFFR_X1
* cell instance $16693 r0 *1 227.05,51.8
X$16693 2847 109 2276 77 BUF_X4
* cell instance $16694 r0 *1 228.38,51.8
X$16694 3099 2057 77 109 3419 NAND2_X1
* cell instance $16695 r0 *1 228.95,51.8
X$16695 3241 3234 2985 3421 109 77 3139 AND4_X1
* cell instance $16696 r0 *1 230.09,51.8
X$16696 2844 109 2363 77 BUF_X4
* cell instance $16697 r0 *1 231.42,51.8
X$16697 3270 3233 1214 2978 77 109 3267 AOI22_X1
* cell instance $16698 r0 *1 232.37,51.8
X$16698 3268 77 109 3242 INV_X1
* cell instance $16699 r0 *1 232.75,51.8
X$16699 2844 3104 3243 2593 2988 3108 109 77 AOI221_X2
* cell instance $16700 r0 *1 234.84,51.8
X$16700 1966 2843 1872 2983 77 109 3244 AOI22_X1
* cell instance $16701 r0 *1 235.79,51.8
X$16701 2984 109 2598 77 BUF_X4
* cell instance $16702 r0 *1 237.12,51.8
X$16702 2690 2997 1872 3100 77 109 3254 AOI22_X1
* cell instance $16703 r0 *1 238.07,51.8
X$16703 3254 1789 3423 77 3102 109 AOI21_X1
* cell instance $16704 r0 *1 238.83,51.8
X$16704 3252 77 109 2452 BUF_X2
* cell instance $16708 m0 *1 1.52,121.8
X$16708 77 9790 9792 9470 9644 4909 109 DFFR_X1
* cell instance $16709 m0 *1 5.32,121.8
X$16709 77 9790 9721 9550 9720 4909 109 DFFR_X1
* cell instance $16710 m0 *1 9.12,121.8
X$16710 9793 6014 9645 77 109 9646 MUX2_X1
* cell instance $16713 m0 *1 14.25,121.8
X$16713 9723 4065 8837 77 109 9647 MUX2_X1
* cell instance $16714 m0 *1 15.58,121.8
X$16714 77 9005 9650 9723 9647 4909 109 DFFR_X1
* cell instance $16716 m0 *1 19.57,121.8
X$16716 9649 5169 9650 77 109 9726 MUX2_X1
* cell instance $16717 m0 *1 20.9,121.8
X$16717 9725 6017 9651 77 109 9729 MUX2_X1
* cell instance $16718 m0 *1 22.23,121.8
X$16718 9479 4284 9730 77 109 9732 MUX2_X1
* cell instance $16719 m0 *1 23.56,121.8
X$16719 9729 5818 9480 77 109 9653 MUX2_X1
* cell instance $16720 m0 *1 24.89,121.8
X$16720 9653 5959 9732 77 109 9894 MUX2_X1
* cell instance $16721 m0 *1 26.22,121.8
X$16721 9482 109 9546 77 BUF_X4
* cell instance $16722 m0 *1 27.55,121.8
X$16722 9482 109 8837 77 BUF_X4
* cell instance $16723 m0 *1 28.88,121.8
X$16723 8837 7330 9737 77 109 9654 MUX2_X1
* cell instance $16724 m0 *1 30.21,121.8
X$16724 77 8525 9483 9737 9654 4909 109 DFFR_X1
* cell instance $16725 m0 *1 34.01,121.8
X$16725 9736 9799 7022 109 9738 77 NOR3_X2
* cell instance $16727 m0 *1 36.86,121.8
X$16727 9735 10366 7022 109 9740 77 NOR3_X2
* cell instance $16729 m0 *1 38.38,121.8
X$16729 6510 9742 4851 9801 9177 9741 77 109 OAI221_X2
* cell instance $16738 r0 *1 3.8,121.8
X$16738 77 9790 9953 9791 9885 4909 109 DFFR_X1
* cell instance $16741 r0 *1 8.55,121.8
X$16741 9792 6701 9721 77 109 9645 MUX2_X1
* cell instance $16745 r0 *1 11.97,121.8
X$16745 77 9957 9649 9794 9888 4909 109 DFFR_X1
* cell instance $16746 r0 *1 15.77,121.8
X$16746 9794 3786 8837 77 109 9888 MUX2_X1
* cell instance $16749 r0 *1 18.81,121.8
X$16749 9476 5169 9477 77 109 9795 MUX2_X1
* cell instance $16751 r0 *1 20.52,121.8
X$16751 9795 9895 9726 77 109 9896 MUX2_X1
* cell instance $16752 r0 *1 21.85,121.8
X$16752 9482 77 109 9473 BUF_X2
* cell instance $16757 r0 *1 26.98,121.8
X$16757 9893 6719 9891 77 109 9903 MUX2_X1
* cell instance $16759 r0 *1 29.83,121.8
X$16759 9967 5310 9796 77 109 9898 MUX2_X1
* cell instance $16761 r0 *1 31.92,121.8
X$16761 9898 5575 9797 77 109 9899 MUX2_X1
* cell instance $16762 r0 *1 33.25,121.8
X$16762 9899 7338 77 109 9798 NAND2_X1
* cell instance $16763 r0 *1 33.82,121.8
X$16763 7617 9798 9743 109 77 9799 AND3_X1
* cell instance $16764 r0 *1 34.77,121.8
X$16764 77 9902 9738 9894 8152 109 AOI21_X4
* cell instance $16765 r0 *1 37.24,121.8
X$16765 77 9805 9740 8152 6965 109 AOI21_X4
* cell instance $16766 r0 *1 39.71,121.8
X$16766 7561 9403 9802 109 9655 77 OAI21_X1
* cell instance $16767 r0 *1 40.47,121.8
X$16767 7631 9903 7742 9804 9656 9803 77 109 OAI221_X2
* cell instance $16769 m0 *1 40.85,121.8
X$16769 9325 9657 77 109 9656 NAND2_X1
* cell instance $16771 m0 *1 41.8,121.8
X$16771 6742 109 5959 77 BUF_X4
* cell instance $16773 m0 *1 44.08,121.8
X$16773 5660 109 8463 77 BUF_X4
* cell instance $16774 m0 *1 45.41,121.8
X$16774 77 8674 9182 9748 9745 4909 109 DFFR_X1
* cell instance $16776 m0 *1 50.73,121.8
X$16776 77 8676 9807 9806 9907 1663 109 DFFR_X1
* cell instance $16778 m0 *1 55.29,121.8
X$16778 5314 6823 9658 109 9808 77 OAI21_X1
* cell instance $16780 m0 *1 56.24,121.8
X$16780 6823 9911 77 109 9658 NAND2_X1
* cell instance $16785 r0 *1 43.89,121.8
X$16785 6694 109 6997 77 BUF_X4
* cell instance $16789 r0 *1 47.69,121.8
X$16789 6125 109 9175 77 BUF_X4
* cell instance $16790 r0 *1 49.02,121.8
X$16790 2400 109 9152 77 BUF_X4
* cell instance $16793 r0 *1 52.25,121.8
X$16793 5314 6972 9909 109 9907 77 OAI21_X1
* cell instance $16795 r0 *1 53.39,121.8
X$16795 7201 9806 77 109 9909 NAND2_X1
* cell instance $16796 r0 *1 53.96,121.8
X$16796 77 8676 9809 9911 9808 1663 109 DFFR_X1
* cell instance $16798 m0 *1 57.19,121.8
X$16798 9809 5318 9486 77 109 9975 MUX2_X1
* cell instance $16800 r0 *1 57.76,121.8
X$16800 9809 9810 9486 77 109 9913 MUX2_X1
* cell instance $16805 r0 *1 59.28,121.8
X$16805 9755 9810 9659 77 109 9811 MUX2_X1
* cell instance $16806 m0 *1 63.46,121.8
X$16806 77 8855 10143 9660 9756 4086 109 DFFR_X1
* cell instance $16807 m0 *1 59.66,121.8
X$16807 77 8855 9755 9757 9754 1663 109 DFFR_X1
* cell instance $16808 m0 *1 67.26,121.8
X$16808 77 9763 10144 9761 9760 4086 109 DFFR_X1
* cell instance $16812 m0 *1 73.53,121.8
X$16812 7912 109 3861 77 BUF_X4
* cell instance $16815 m0 *1 75.81,121.8
X$16815 77 9491 9493 9594 9661 4086 109 DFFR_X1
* cell instance $16816 m0 *1 79.61,121.8
X$16816 77 9491 9770 9768 9767 4086 109 DFFR_X1
* cell instance $16818 m0 *1 84.17,121.8
X$16818 9818 3048 9770 77 109 9495 MUX2_X1
* cell instance $16820 m0 *1 87.02,121.8
X$16820 77 9028 9931 9662 9823 8687 109 DFFR_X1
* cell instance $16821 m0 *1 90.82,121.8
X$16821 9824 9662 77 109 9930 NOR2_X1
* cell instance $16823 r0 *1 60.61,121.8
X$16823 9811 6120 9913 77 109 9914 MUX2_X1
* cell instance $16827 r0 *1 65.55,121.8
X$16827 9490 8463 77 109 10072 NOR2_X1
* cell instance $16830 r0 *1 67.26,121.8
X$16830 9490 9812 77 109 10076 NOR2_X1
* cell instance $16834 r0 *1 71.44,121.8
X$16834 9918 9492 9815 77 9916 109 AOI21_X1
* cell instance $16836 r0 *1 72.58,121.8
X$16836 9815 9816 77 109 9918 NOR2_X1
* cell instance $16838 r0 *1 74.67,121.8
X$16838 3619 9492 9919 109 9817 77 OAI21_X1
* cell instance $16841 r0 *1 76,121.8
X$16841 3613 9920 77 109 9919 NAND2_X1
* cell instance $16842 r0 *1 76.57,121.8
X$16842 77 9763 9983 10087 9819 4086 109 DFFR_X1
* cell instance $16843 r0 *1 80.37,121.8
X$16843 77 9924 9821 10092 9984 4086 109 DFFR_X1
* cell instance $16845 r0 *1 84.36,121.8
X$16845 9820 3896 9821 77 109 9926 MUX2_X1
* cell instance $16846 r0 *1 85.69,121.8
X$16846 9822 4320 9926 77 109 9935 MUX2_X1
* cell instance $16849 r0 *1 87.59,121.8
X$16849 9930 9492 9824 77 9823 109 AOI21_X1
* cell instance $16851 r0 *1 89.87,121.8
X$16851 9774 8068 9931 77 109 9825 MUX2_X1
* cell instance $16853 m0 *1 91.96,121.8
X$16853 9775 4774 9445 77 109 9776 MUX2_X1
* cell instance $16855 m0 *1 93.29,121.8
X$16855 77 5449 9776 9612 5451 9664 5401 9935 109 AOI222_X2
* cell instance $16856 m0 *1 95.95,121.8
X$16856 77 8544 9663 9616 9778 8687 109 DFFR_X1
* cell instance $16859 m0 *1 100.7,121.8
X$16859 9781 8816 77 109 9813 NOR2_X2
* cell instance $16860 m0 *1 101.65,121.8
X$16860 9780 6416 5892 109 77 9666 MUX2_X2
* cell instance $16863 m0 *1 104.31,121.8
X$16863 77 8544 9339 9782 9784 8201 109 DFFR_X1
* cell instance $16867 r0 *1 92.53,121.8
X$16867 9445 5740 9663 77 109 9933 MUX2_X1
* cell instance $16870 r0 *1 94.43,121.8
X$16870 9933 9030 77 109 9827 NOR2_X1
* cell instance $16872 r0 *1 95.38,121.8
X$16872 10105 9029 6524 77 10106 109 AOI21_X1
* cell instance $16875 r0 *1 96.71,121.8
X$16875 9665 9029 6380 77 9778 109 AOI21_X1
* cell instance $16878 r0 *1 99.18,121.8
X$16878 9937 9829 10157 77 109 9828 MUX2_X1
* cell instance $16879 r0 *1 100.51,121.8
X$16879 77 9938 5980 5186 9939 109 AOI21_X4
* cell instance $16880 r0 *1 102.98,121.8
X$16880 77 9986 9988 9940 10115 8201 109 DFFR_X1
* cell instance $16881 r0 *1 106.78,121.8
X$16881 9782 9832 7647 77 109 9784 MUX2_X1
* cell instance $16882 r0 *1 108.11,121.8
X$16882 77 9833 9629 9942 9941 8201 109 DFFR_X1
* cell instance $16883 m0 *1 112.29,121.8
X$16883 9668 9667 7647 77 109 9785 MUX2_X1
* cell instance $16884 m0 *1 108.49,121.8
X$16884 77 9036 9633 9668 9785 8201 109 DFFR_X1
* cell instance $16888 m0 *1 117.61,121.8
X$16888 9669 6180 9670 77 109 9343 MUX2_X1
* cell instance $16889 m0 *1 118.94,121.8
X$16889 9669 6140 9670 77 109 9504 MUX2_X1
* cell instance $16893 r0 *1 112.29,121.8
X$16893 9946 9834 8686 77 109 9944 MUX2_X1
* cell instance $16894 r0 *1 113.62,121.8
X$16894 77 9833 9199 9946 9944 4086 109 DFFR_X1
* cell instance $16898 r0 *1 117.42,121.8
X$16898 9948 9945 8686 77 109 10123 MUX2_X1
* cell instance $16904 m0 *1 121.41,121.8
X$16904 77 8692 9670 9950 9789 4086 109 DFFR_X1
* cell instance $16905 m0 *1 125.97,121.8
X$16905 7908 109 9508 77 BUF_X4
* cell instance $16906 m0 *1 127.3,121.8
X$16906 9509 109 9675 77 BUF_X4
* cell instance $16907 m0 *1 128.63,121.8
X$16907 9508 9673 9674 77 109 9672 OR3_X1
* cell instance $16908 m0 *1 129.58,121.8
X$16908 9507 8877 9839 77 109 NOR2_X4
* cell instance $16910 r0 *1 121.41,121.8
X$16910 9950 10590 8686 77 109 9789 MUX2_X1
* cell instance $16912 r0 *1 125.78,121.8
X$16912 9506 77 109 9951 BUF_X1
* cell instance $16913 r0 *1 126.35,121.8
X$16913 9506 7908 9044 77 109 9835 OR3_X1
* cell instance $16914 r0 *1 127.3,121.8
X$16914 9508 7651 109 77 9836 XNOR2_X1
* cell instance $16915 r0 *1 128.44,121.8
X$16915 9836 9673 9671 9512 109 77 9837 OAI22_X2
* cell instance $16916 r0 *1 130.15,121.8
X$16916 9203 9511 77 109 9674 NOR2_X1
* cell instance $16917 r0 *1 130.72,121.8
X$16917 77 9842 9951 9952 9839 109 AOI21_X4
* cell instance $16919 m0 *1 131.67,121.8
X$16919 9673 9676 77 8879 109 NAND2_X4
* cell instance $16920 m0 *1 133.57,121.8
X$16920 77 9678 9840 9842 8879 9841 109 OR4_X4
* cell instance $16921 m0 *1 136.04,121.8
X$16921 8696 77 109 9676 BUF_X1
* cell instance $16922 m0 *1 136.61,121.8
X$16922 9839 9511 77 109 9677 NAND2_X1
* cell instance $16924 m0 *1 137.37,121.8
X$16924 9681 109 8699 77 BUF_X4
* cell instance $16926 r0 *1 133.19,121.8
X$16926 77 9841 8879 9842 9840 9681 109 NOR4_X4
* cell instance $16927 r0 *1 136.61,121.8
X$16927 9676 77 109 9843 BUF_X2
* cell instance $16929 r0 *1 137.56,121.8
X$16929 77 9856 9947 9949 9677 109 AOI21_X4
* cell instance $16930 m0 *1 140.41,121.8
X$16930 9783 8712 9679 77 9787 109 AOI21_X1
* cell instance $16931 m0 *1 139.08,121.8
X$16931 7293 9787 5892 109 9781 77 NOR3_X2
* cell instance $16934 m0 *1 141.74,121.8
X$16934 9678 109 8704 77 BUF_X4
* cell instance $16936 m0 *1 143.07,121.8
X$16936 9678 8504 9171 77 109 NOR2_X4
* cell instance $16937 m0 *1 144.78,121.8
X$16937 8706 109 8705 77 BUF_X4
* cell instance $16939 m0 *1 147.63,121.8
X$16939 9351 109 8504 77 BUF_X4
* cell instance $16940 m0 *1 148.96,121.8
X$16940 8504 77 109 8882 CLKBUF_X3
* cell instance $16942 m0 *1 150.1,121.8
X$16942 9680 8705 77 109 9846 NOR2_X1
* cell instance $16948 r0 *1 145.73,121.8
X$16948 9210 77 109 8706 CLKBUF_X3
* cell instance $16949 r0 *1 146.68,121.8
X$16949 9516 8882 77 109 9943 NAND2_X1
* cell instance $16951 r0 *1 147.44,121.8
X$16951 9681 8564 9351 77 109 10473 NAND3_X1
* cell instance $16952 r0 *1 148.2,121.8
X$16952 9678 9210 77 109 9844 NOR2_X1
* cell instance $16953 r0 *1 148.77,121.8
X$16953 9845 9927 77 109 9621 NOR2_X2
* cell instance $16954 r0 *1 149.72,121.8
X$16954 9848 9846 8704 77 109 9845 NOR3_X1
* cell instance $16955 r0 *1 150.48,121.8
X$16955 9848 9846 8574 109 9847 77 NOR3_X2
* cell instance $16957 r0 *1 152,121.8
X$16957 8709 9171 9849 9844 8564 77 109 9936 AOI221_X1
* cell instance $16959 m0 *1 152.57,121.8
X$16959 9352 9349 77 109 9683 NAND2_X1
* cell instance $16963 r0 *1 153.71,121.8
X$16963 9936 9219 77 109 10111 NOR2_X1
* cell instance $16965 r0 *1 154.47,121.8
X$16965 8635 9517 9850 109 77 9851 AND3_X1
* cell instance $16966 m0 *1 155.99,121.8
X$16966 3477 8572 9682 9779 9219 9780 109 77 AOI221_X2
* cell instance $16967 m0 *1 155.04,121.8
X$16967 8439 8706 8820 109 77 9928 AND3_X1
* cell instance $16969 r0 *1 155.42,121.8
X$16969 9850 9934 9852 8709 9454 9682 109 77 AOI221_X2
* cell instance $16970 r0 *1 157.51,121.8
X$16970 9681 9517 109 77 9934 AND2_X1
* cell instance $16973 m0 *1 158.46,121.8
X$16973 9683 6755 77 109 9519 NAND2_X1
* cell instance $16974 r0 *1 159.03,121.8
X$16974 9517 8635 77 109 10108 NAND2_X1
* cell instance $16975 m0 *1 159.6,121.8
X$16975 77 9482 6754 9620 9932 109 AOI21_X4
* cell instance $16982 r0 *1 162.45,121.8
X$16982 8712 9685 9925 109 77 9932 OAI21_X2
* cell instance $16983 m0 *1 162.64,121.8
X$16983 8635 9684 109 77 9685 AND2_X1
* cell instance $16986 m0 *1 163.59,121.8
X$16986 6855 9923 9683 77 9929 109 AOI21_X1
* cell instance $16988 m0 *1 164.54,121.8
X$16988 9681 9356 109 77 9687 AND2_X1
* cell instance $16990 m0 *1 165.49,121.8
X$16990 9689 9686 10236 9684 8699 7039 109 77 AOI221_X2
* cell instance $16993 r0 *1 163.78,121.8
X$16993 10102 9929 3583 9928 77 109 9927 OR4_X1
* cell instance $16995 r0 *1 165.3,121.8
X$16995 10098 9854 77 109 9925 NAND2_X1
* cell instance $16996 r0 *1 165.87,121.8
X$16996 9686 9687 77 109 9854 NAND2_X1
* cell instance $16998 r0 *1 166.82,121.8
X$16998 9687 9688 9917 9862 9853 77 109 9855 AOI221_X1
* cell instance $17000 r0 *1 168.15,121.8
X$17000 9855 9219 77 109 9439 NOR2_X1
* cell instance $17001 r0 *1 168.72,121.8
X$17001 9921 8584 9853 77 9923 109 AOI21_X1
* cell instance $17003 m0 *1 168.72,121.8
X$17003 9689 9688 77 109 9771 NAND2_X1
* cell instance $17004 m0 *1 170.81,121.8
X$17004 9219 9771 9769 77 9134 109 AOI21_X2
* cell instance $17005 m0 *1 172.14,121.8
X$17005 6543 9693 9690 109 77 9857 HA_X1
* cell instance $17008 r0 *1 169.67,121.8
X$17008 7520 5080 19080 109 77 9922 HA_X1
* cell instance $17013 r0 *1 171.76,121.8
X$17013 9691 9922 9858 77 9921 109 AOI21_X1
* cell instance $17015 r0 *1 172.71,121.8
X$17015 9690 9856 9362 9857 9287 77 109 9915 AOI221_X1
* cell instance $17017 r0 *1 174.04,121.8
X$17017 9915 8578 9858 77 9859 109 AOI21_X1
* cell instance $17018 m0 *1 174.61,121.8
X$17018 9693 77 109 7809 INV_X2
* cell instance $17020 m0 *1 175.18,121.8
X$17020 8479 9527 9765 8889 9766 9693 77 109 OAI221_X2
* cell instance $17021 m0 *1 177.27,121.8
X$17021 8888 6825 77 109 9766 NAND2_X1
* cell instance $17025 m0 *1 181.83,121.8
X$17025 77 9694 9759 7520 9764 9056 7528 8789 109 AOI222_X2
* cell instance $17026 m0 *1 184.49,121.8
X$17026 9528 8716 9396 77 109 9695 MUX2_X1
* cell instance $17027 m0 *1 185.82,121.8
X$17027 5832 109 9412 77 BUF_X4
* cell instance $17028 m0 *1 187.15,121.8
X$17028 9758 9694 8789 9426 77 109 9762 AOI22_X2
* cell instance $17029 m0 *1 188.86,121.8
X$17029 9530 6427 109 77 9759 AND2_X1
* cell instance $17035 r0 *1 177.65,121.8
X$17035 7586 77 109 7962 INV_X2
* cell instance $17036 r0 *1 178.22,121.8
X$17036 8888 9861 77 109 9860 NAND2_X1
* cell instance $17037 r0 *1 178.79,121.8
X$17037 9861 8106 9862 77 109 10082 MUX2_X1
* cell instance $17039 r0 *1 180.88,121.8
X$17039 9126 109 9694 77 BUF_X4
* cell instance $17040 r0 *1 182.21,121.8
X$17040 77 9694 9908 7235 9912 9056 9528 8789 109 AOI222_X2
* cell instance $17041 r0 *1 184.87,121.8
X$17041 77 9425 18881 9528 9695 3676 109 DFFR_X1
* cell instance $17042 r0 *1 188.67,121.8
X$17042 9699 6427 109 77 9908 AND2_X1
* cell instance $17044 m0 *1 190.19,121.8
X$17044 9423 9696 109 77 9758 AND2_X1
* cell instance $17046 m0 *1 190.95,121.8
X$17046 9058 9369 77 109 9527 NAND2_X1
* cell instance $17047 m0 *1 191.52,121.8
X$17047 9530 2428 9698 77 109 9697 MUX2_X1
* cell instance $17050 r0 *1 191.14,121.8
X$17050 9703 9058 109 77 10071 AND2_X1
* cell instance $17052 r0 *1 192.28,121.8
X$17052 77 9752 9425 9700 9699 109 DFF_X2
* cell instance $17053 m0 *1 194.56,121.8
X$17053 9700 9751 109 77 8322 XNOR2_X1
* cell instance $17054 m0 *1 193.23,121.8
X$17054 9699 2428 9702 77 109 9752 MUX2_X1
* cell instance $17055 m0 *1 195.7,121.8
X$17055 9701 9060 77 109 9751 NAND2_X1
* cell instance $17057 m0 *1 196.46,121.8
X$17057 9701 9060 9699 77 109 9863 NAND3_X2
* cell instance $17061 m0 *1 200.26,121.8
X$17061 9699 8895 9702 77 109 6360 MUX2_X1
* cell instance $17064 r0 *1 196.08,121.8
X$17064 9059 9699 9701 77 9864 109 NAND3_X4
* cell instance $17067 r0 *1 201.78,121.8
X$17067 9750 6936 9906 77 109 5250 MUX2_X1
* cell instance $17068 m0 *1 202.73,121.8
X$17068 9747 9705 109 77 9750 XNOR2_X1
* cell instance $17069 m0 *1 201.97,121.8
X$17069 9703 9749 109 77 9373 AND2_X1
* cell instance $17072 m0 *1 206.15,121.8
X$17072 77 9747 9703 9746 9108 109 DFF_X1
* cell instance $17073 m0 *1 209.38,121.8
X$17073 9703 8614 9707 77 109 9746 MUX2_X1
* cell instance $17076 r0 *1 203.11,121.8
X$17076 9749 9865 77 109 9705 NAND2_X1
* cell instance $17079 r0 *1 204.25,121.8
X$17079 9905 6936 9904 77 109 5248 MUX2_X1
* cell instance $17082 m0 *1 213.18,121.8
X$17082 9703 9707 8725 109 77 5924 MUX2_X2
* cell instance $17083 m0 *1 211.85,121.8
X$17083 10019 8725 9706 77 109 6947 MUX2_X1
* cell instance $17084 m0 *1 214.89,121.8
X$17084 9706 9707 109 77 9709 AND2_X1
* cell instance $17085 m0 *1 215.65,121.8
X$17085 9261 9709 109 77 9537 AND2_X1
* cell instance $17086 m0 *1 216.41,121.8
X$17086 9709 9538 8893 9710 77 109 9900 NAND4_X1
* cell instance $17088 m0 *1 217.55,121.8
X$17088 9707 9706 9538 77 9870 109 AOI21_X1
* cell instance $17093 r0 *1 212.99,121.8
X$17093 9867 77 109 8614 CLKBUF_X3
* cell instance $17095 r0 *1 214.32,121.8
X$17095 9867 77 109 8893 CLKBUF_X3
* cell instance $17097 r0 *1 215.46,121.8
X$17097 9707 3210 9867 77 109 9868 OR3_X1
* cell instance $17098 r0 *1 216.41,121.8
X$17098 9900 9868 9869 109 77 9901 AND3_X1
* cell instance $17100 r0 *1 217.55,121.8
X$17100 77 18483 9897 9901 10018 109 DFF_X1
* cell instance $17101 m0 *1 220.4,121.8
X$17101 9707 9706 77 109 9711 NAND2_X1
* cell instance $17103 m0 *1 220.97,121.8
X$17103 9711 9541 9068 9066 77 109 9712 NOR4_X1
* cell instance $17104 m0 *1 221.92,121.8
X$17104 9261 9712 109 77 9713 XNOR2_X1
* cell instance $17105 m0 *1 223.06,121.8
X$17105 9728 2394 9713 77 9734 109 AOI21_X1
* cell instance $17106 m0 *1 223.82,121.8
X$17106 9724 9071 77 109 9875 OR2_X1
* cell instance $17107 m0 *1 224.58,121.8
X$17107 77 18362 9727 9731 9554 109 DFF_X1
* cell instance $17108 m0 *1 227.81,121.8
X$17108 9727 77 109 9698 BUF_X2
* cell instance $17109 m0 *1 228.57,121.8
X$17109 9396 4812 77 109 9714 NAND2_X1
* cell instance $17110 m0 *1 229.14,121.8
X$17110 9397 9714 77 109 9715 NAND2_X1
* cell instance $17113 m0 *1 231.99,121.8
X$17113 9383 77 109 9722 INV_X1
* cell instance $17114 m0 *1 232.37,121.8
X$17114 9722 9078 8907 9079 77 109 9389 NOR4_X1
* cell instance $17117 r0 *1 220.78,121.8
X$17117 9897 77 109 9707 BUF_X1
* cell instance $17119 r0 *1 222.87,121.8
X$17119 9875 9871 77 109 9873 OR2_X1
* cell instance $17122 r0 *1 225.34,121.8
X$17122 3592 8924 77 109 9890 OR2_X1
* cell instance $17125 r0 *1 226.67,121.8
X$17125 9875 8907 9079 9877 77 109 9889 NOR4_X1
* cell instance $17129 r0 *1 227.62,121.8
X$17129 9698 77 109 9877 INV_X1
* cell instance $17130 r0 *1 228,121.8
X$17130 9702 9889 109 77 10037 XNOR2_X1
* cell instance $17131 r0 *1 229.14,121.8
X$17131 9715 2348 77 109 9887 NOR2_X1
* cell instance $17133 r0 *1 229.9,121.8
X$17133 77 18466 9878 9886 8735 109 DFF_X1
* cell instance $17134 r0 *1 233.13,121.8
X$17134 10030 9715 109 77 9884 XNOR2_X1
* cell instance $17135 r0 *1 234.27,121.8
X$17135 9883 2526 9884 77 109 9881 MUX2_X1
* cell instance $17137 m0 *1 234.46,121.8
X$17137 2526 9716 9880 109 9719 77 OAI21_X1
* cell instance $17138 r0 *1 235.6,121.8
X$17138 77 18487 9882 9881 8735 109 DFF_X1
* cell instance $17139 m0 *1 235.79,121.8
X$17139 77 9719 8735 18290 9374 109 DFF_X2
* cell instance $17143 r0 *1 238.83,121.8
X$17143 9882 77 109 10027 INV_X1
* cell instance $17147 m0 *1 158.46,37.8
X$17147 602 788 2008 109 2035 77 OAI21_X1
* cell instance $17148 m0 *1 159.41,37.8
X$17148 2152 77 109 1263 CLKBUF_X3
* cell instance $17149 m0 *1 160.36,37.8
X$17149 1186 1951 572 77 2087 109 AOI21_X1
* cell instance $17150 m0 *1 161.12,37.8
X$17150 1989 1322 77 109 572 NAND2_X1
* cell instance $17153 m0 *1 162.64,37.8
X$17153 2006 2087 77 109 2038 NOR2_X1
* cell instance $17154 m0 *1 163.21,37.8
X$17154 1954 1953 1185 77 2006 109 AOI21_X1
* cell instance $17156 m0 *1 165.49,37.8
X$17156 1858 1928 1186 1955 109 77 2004 OAI22_X1
* cell instance $17157 m0 *1 166.44,37.8
X$17157 2004 77 109 2039 INV_X1
* cell instance $17158 m0 *1 166.82,37.8
X$17158 77 1523 18529 2003 2039 1663 109 DFFR_X1
* cell instance $17159 m0 *1 170.62,37.8
X$17159 2003 77 109 1858 BUF_X2
* cell instance $17160 m0 *1 171.38,37.8
X$17160 1902 605 606 1112 77 109 2080 AOI22_X2
* cell instance $17161 m0 *1 173.09,37.8
X$17161 1861 2000 109 77 2001 AND2_X1
* cell instance $17162 m0 *1 173.85,37.8
X$17162 77 1146 1663 109 BUF_X32
* cell instance $17164 m0 *1 183.92,37.8
X$17164 1865 109 1279 77 BUF_X4
* cell instance $17167 r0 *1 158.65,37.8
X$17167 2152 77 109 1447 CLKBUF_X3
* cell instance $17169 r0 *1 160.36,37.8
X$17169 77 1130 1952 1663 19006 1926 109 DFFR_X2
* cell instance $17172 r0 *1 165.11,37.8
X$17172 1925 109 759 77 BUF_X4
* cell instance $17175 r0 *1 167.58,37.8
X$17175 2040 2041 1273 109 77 1331 MUX2_X2
* cell instance $17177 r0 *1 170.05,37.8
X$17177 1136 2040 1776 77 109 NOR2_X4
* cell instance $17183 r0 *1 172.33,37.8
X$17183 2042 1774 996 2043 77 109 2000 AOI22_X1
* cell instance $17185 r0 *1 173.66,37.8
X$17185 2079 375 377 1926 77 109 2146 AOI22_X2
* cell instance $17186 r0 *1 175.37,37.8
X$17186 733 109 375 77 BUF_X4
* cell instance $17187 r0 *1 176.7,37.8
X$17187 2046 1110 980 1255 77 109 2145 AOI22_X2
* cell instance $17189 r0 *1 178.6,37.8
X$17189 2070 1776 77 109 2074 OR2_X1
* cell instance $17190 r0 *1 179.36,37.8
X$17190 2044 1863 2073 2072 2070 77 109 2076 AOI221_X1
* cell instance $17191 r0 *1 180.5,37.8
X$17191 2074 1412 2045 77 2073 109 AOI21_X1
* cell instance $17193 r0 *1 181.45,37.8
X$17193 1412 2045 109 77 2072 AND2_X1
* cell instance $17195 r0 *1 182.4,37.8
X$17195 2046 1461 109 77 2045 AND2_X1
* cell instance $17196 r0 *1 183.16,37.8
X$17196 2046 2070 109 77 1617 AND2_X1
* cell instance $17198 r0 *1 184.11,37.8
X$17198 778 2116 77 109 1136 OR2_X2
* cell instance $17200 m0 *1 185.82,37.8
X$17200 2047 1279 1866 77 2067 109 AOI21_X1
* cell instance $17202 m0 *1 186.58,37.8
X$17202 1822 1863 2067 1957 1902 77 109 1990 AOI221_X1
* cell instance $17206 r0 *1 186.2,37.8
X$17206 2046 1776 77 109 2068 OR2_X1
* cell instance $17207 r0 *1 186.96,37.8
X$17207 2068 1279 1461 77 2048 109 AOI21_X1
* cell instance $17208 r0 *1 187.72,37.8
X$17208 1865 1461 109 77 2140 AND2_X1
* cell instance $17210 m0 *1 192.66,37.8
X$17210 1989 77 109 552 INV_X2
* cell instance $17211 m0 *1 188.86,37.8
X$17211 77 1364 18492 1902 1990 1146 109 DFFR_X1
* cell instance $17214 r0 *1 192.28,37.8
X$17214 1311 1621 2138 77 109 2139 MUX2_X1
* cell instance $17216 m0 *1 193.8,37.8
X$17216 1924 77 109 1622 INV_X2
* cell instance $17220 m0 *1 198.17,37.8
X$17220 349 77 109 1713 CLKBUF_X3
* cell instance $17222 m0 *1 199.31,37.8
X$17222 1622 1462 2136 77 109 1959 MUX2_X1
* cell instance $17224 m0 *1 202.16,37.8
X$17224 969 1892 2062 77 109 2049 MUX2_X1
* cell instance $17228 r0 *1 195.32,37.8
X$17228 77 1713 18816 2118 2064 1146 109 DFFR_X1
* cell instance $17229 r0 *1 199.12,37.8
X$17229 77 1553 18856 2136 1959 1146 109 DFFR_X1
* cell instance $17230 r0 *1 202.92,37.8
X$17230 77 1553 18855 2062 2049 1146 109 DFFR_X1
* cell instance $17232 m0 *1 205.39,37.8
X$17232 77 1553 18539 1982 1960 1146 109 DFFR_X1
* cell instance $17234 m0 *1 212.99,37.8
X$17234 1869 109 1892 77 BUF_X4
* cell instance $17235 m0 *1 214.32,37.8
X$17235 494 1722 1977 77 109 2060 MUX2_X1
* cell instance $17236 m0 *1 215.65,37.8
X$17236 903 1462 1975 77 109 1978 MUX2_X1
* cell instance $17241 r0 *1 207.86,37.8
X$17241 772 1722 2121 77 109 2050 MUX2_X1
* cell instance $17242 r0 *1 209.19,37.8
X$17242 77 1553 18823 2121 2050 1146 109 DFFR_X1
* cell instance $17244 r0 *1 213.75,37.8
X$17244 77 1961 18699 1977 2060 992 109 DFFR_X1
* cell instance $17246 r0 *1 217.93,37.8
X$17246 693 1722 2059 77 109 1962 MUX2_X1
* cell instance $17247 m0 *1 218.31,37.8
X$17247 77 1961 18594 2059 1962 992 109 DFFR_X1
* cell instance $17250 r0 *1 219.26,37.8
X$17250 1783 2123 77 1470 109 NAND2_X4
* cell instance $17252 m0 *1 222.68,37.8
X$17252 77 1721 18525 1871 1963 992 109 DFFR_X1
* cell instance $17256 m0 *1 227.43,37.8
X$17256 77 1721 1965 992 18941 1970 109 DFFR_X2
* cell instance $17259 m0 *1 232.56,37.8
X$17259 413 1621 2052 77 109 2054 MUX2_X1
* cell instance $17261 r0 *1 222.49,37.8
X$17261 693 1470 2057 77 109 2129 MUX2_X1
* cell instance $17267 r0 *1 227.62,37.8
X$17267 548 1470 2122 77 109 2055 MUX2_X1
* cell instance $17268 r0 *1 228.95,37.8
X$17268 77 2051 2055 992 19027 2122 109 DFFR_X2
* cell instance $17269 r0 *1 233.13,37.8
X$17269 77 1873 18722 2052 2054 992 109 DFFR_X1
* cell instance $17270 m0 *1 234.46,37.8
X$17270 413 1462 1966 77 109 1968 MUX2_X1
* cell instance $17272 m0 *1 235.79,37.8
X$17272 77 1873 18564 1966 1968 992 109 DFFR_X1
* cell instance $17279 m0 *1 132.81,130.2
X$17279 9043 77 109 10571 INV_X1
* cell instance $17280 m0 *1 133.38,130.2
X$17280 10571 9172 10468 109 77 10567 HA_X1
* cell instance $17282 m0 *1 135.47,130.2
X$17282 7172 6436 77 10797 109 NAND2_X4
* cell instance $17284 m0 *1 137.37,130.2
X$17284 10469 9856 10314 9173 10168 77 109 10307 AOI221_X1
* cell instance $17285 m0 *1 138.51,130.2
X$17285 10423 77 109 6695 INV_X2
* cell instance $17286 m0 *1 139.08,130.2
X$17286 6695 5566 77 109 10726 NAND2_X1
* cell instance $17288 r0 *1 132.81,130.2
X$17288 10468 77 109 10469 CLKBUF_X3
* cell instance $17290 r0 *1 134.52,130.2
X$17290 10616 10469 77 109 10729 NAND2_X1
* cell instance $17291 r0 *1 135.09,130.2
X$17291 10469 10467 10569 109 77 10728 AND3_X1
* cell instance $17293 r0 *1 136.42,130.2
X$17293 10161 77 109 10618 BUF_X1
* cell instance $17294 r0 *1 136.99,130.2
X$17294 9511 10618 77 109 10305 NOR2_X1
* cell instance $17296 r0 *1 137.94,130.2
X$17296 10726 10619 10727 10725 77 109 10620 NOR4_X1
* cell instance $17297 r0 *1 138.89,130.2
X$17297 10423 6863 10620 77 109 5715 MUX2_X1
* cell instance $17298 m0 *1 140.22,130.2
X$17298 6436 77 109 10470 CLKBUF_X3
* cell instance $17300 m0 *1 141.17,130.2
X$17300 10313 6699 10310 77 10471 109 AOI21_X1
* cell instance $17302 m0 *1 142.12,130.2
X$17302 7996 10470 10311 109 10564 77 OAI21_X1
* cell instance $17303 m0 *1 142.88,130.2
X$17303 9902 10470 10311 109 10562 77 OAI21_X1
* cell instance $17304 m0 *1 143.64,130.2
X$17304 10562 10312 77 109 10177 NOR2_X2
* cell instance $17309 r0 *1 140.41,130.2
X$17309 8153 10470 10311 109 10723 77 OAI21_X1
* cell instance $17311 r0 *1 141.36,130.2
X$17311 10723 10471 77 109 10633 NOR2_X2
* cell instance $17312 r0 *1 142.31,130.2
X$17312 10564 10472 77 109 10408 NOR2_X2
* cell instance $17313 r0 *1 143.26,130.2
X$17313 8168 10470 10311 109 10721 77 OAI21_X1
* cell instance $17314 r0 *1 144.02,130.2
X$17314 10721 10623 77 109 10622 NOR2_X2
* cell instance $17316 m0 *1 147.44,130.2
X$17316 10553 10473 10625 77 109 10560 NAND3_X1
* cell instance $17318 m0 *1 148.2,130.2
X$17318 10306 10474 10473 109 10559 77 OAI21_X1
* cell instance $17319 m0 *1 148.96,130.2
X$17319 10476 10473 77 109 10558 NAND2_X1
* cell instance $17320 m0 *1 149.53,130.2
X$17320 8820 9171 10559 9853 10556 77 109 10477 AOI221_X1
* cell instance $17322 m0 *1 150.86,130.2
X$17322 10477 9219 77 109 10557 NOR2_X1
* cell instance $17325 m0 *1 152.38,130.2
X$17325 10628 9243 77 109 10553 NAND2_X1
* cell instance $17328 r0 *1 148.39,130.2
X$17328 6396 10622 10475 109 77 10626 HA_X1
* cell instance $17330 r0 *1 151.05,130.2
X$17330 10627 10166 10717 77 109 10476 MUX2_X1
* cell instance $17332 m0 *1 153.52,130.2
X$17332 5552 9046 10317 109 77 10478 HA_X1
* cell instance $17334 m0 *1 155.42,130.2
X$17334 10322 10551 10315 109 8994 77 OAI21_X1
* cell instance $17336 r0 *1 155.42,130.2
X$17336 10630 6859 19076 109 77 10715 HA_X1
* cell instance $17337 m0 *1 156.75,130.2
X$17337 6605 77 109 10630 INV_X1
* cell instance $17341 r0 *1 157.51,130.2
X$17341 9858 10715 77 109 10547 NAND2_X1
* cell instance $17343 m0 *1 157.51,130.2
X$17343 4356 7230 10479 109 77 10545 HA_X1
* cell instance $17344 m0 *1 159.6,130.2
X$17344 10408 77 109 10543 INV_X1
* cell instance $17345 m0 *1 159.98,130.2
X$17345 7231 10543 19039 109 77 10542 HA_X1
* cell instance $17346 m0 *1 161.88,130.2
X$17346 10319 9360 10424 10320 9355 77 109 10480 AOI221_X1
* cell instance $17347 m0 *1 163.02,130.2
X$17347 10480 10542 10322 77 10000 109 AOI21_X1
* cell instance $17350 m0 *1 166.06,130.2
X$17350 6479 7869 19052 109 77 10539 HA_X1
* cell instance $17352 r0 *1 158.08,130.2
X$17352 10632 10545 10424 77 10631 109 AOI21_X1
* cell instance $17356 r0 *1 161.5,130.2
X$17356 9602 10634 9524 9236 77 109 9218 AOI22_X2
* cell instance $17357 r0 *1 163.21,130.2
X$17357 9602 10713 8718 10628 77 109 10635 AOI22_X1
* cell instance $17358 r0 *1 164.16,130.2
X$17358 6758 3926 19061 109 77 10916 HA_X1
* cell instance $17361 r0 *1 167.2,130.2
X$17361 10539 10166 10481 109 10713 77 OAI21_X1
* cell instance $17363 m0 *1 168.53,130.2
X$17363 10633 7234 19049 109 77 10535 HA_X1
* cell instance $17365 m0 *1 170.43,130.2
X$17365 10406 9360 10424 10535 9355 77 109 10482 AOI221_X1
* cell instance $17369 r0 *1 169.48,130.2
X$17369 7517 10636 19074 109 77 10710 HA_X1
* cell instance $17373 r0 *1 171.38,130.2
X$17373 10711 10710 10322 77 10709 109 AOI21_X1
* cell instance $17375 r0 *1 172.33,130.2
X$17375 9853 10665 10533 10706 10322 9295 109 77 AOI221_X2
* cell instance $17376 m0 *1 174.42,130.2
X$17376 10532 9858 77 109 10533 NOR2_X1
* cell instance $17378 m0 *1 174.99,130.2
X$17378 10531 9597 10708 9447 77 109 10532 AOI22_X1
* cell instance $17379 m0 *1 175.94,130.2
X$17379 10530 6541 19059 109 77 10531 HA_X1
* cell instance $17382 r0 *1 174.8,130.2
X$17382 10530 77 109 10707 INV_X1
* cell instance $17384 r0 *1 175.37,130.2
X$17384 10707 7871 10708 109 77 10705 HA_X1
* cell instance $17387 r0 *1 177.84,130.2
X$17387 10705 77 109 10706 INV_X1
* cell instance $17390 m0 *1 178.22,130.2
X$17390 8888 10483 77 109 10324 NAND2_X1
* cell instance $17391 m0 *1 178.98,130.2
X$17391 8888 10701 77 109 10529 NAND2_X1
* cell instance $17393 m0 *1 179.74,130.2
X$17393 10526 9056 10394 8888 10325 10704 109 77 AOI221_X2
* cell instance $17395 m0 *1 182.02,130.2
X$17395 10325 8106 10528 77 109 10484 MUX2_X1
* cell instance $17398 r0 *1 178.79,130.2
X$17398 10701 8106 10702 77 109 10637 MUX2_X1
* cell instance $17401 r0 *1 180.69,130.2
X$17401 10704 109 6932 77 BUF_X4
* cell instance $17403 r0 *1 182.21,130.2
X$17403 77 10638 18892 10325 10484 3676 109 DFFR_X1
* cell instance $17405 m0 *1 183.73,130.2
X$17405 6390 10485 9412 7561 6255 10487 109 77 AOI221_X2
* cell instance $17406 m0 *1 186.01,130.2
X$17406 6390 10486 9412 6120 8327 10523 109 77 AOI221_X2
* cell instance $17408 m0 *1 188.29,130.2
X$17408 6391 10328 9412 7202 8327 10386 109 77 AOI221_X2
* cell instance $17410 m0 *1 190.57,130.2
X$17410 77 10010 18547 10328 10329 3676 109 DFFR_X1
* cell instance $17411 m0 *1 194.37,130.2
X$17411 6817 77 109 10010 CLKBUF_X3
* cell instance $17413 m0 *1 195.51,130.2
X$17413 77 10489 10332 10488 10520 10333 109 NAND4_X4
* cell instance $17414 m0 *1 198.93,130.2
X$17414 10523 8582 10687 77 7411 109 AOI21_X1
* cell instance $17416 m0 *1 199.88,130.2
X$17416 10521 10489 10520 10488 77 109 10518 NAND4_X1
* cell instance $17418 m0 *1 201.02,130.2
X$17418 10516 10518 109 77 10519 XNOR2_X1
* cell instance $17421 m0 *1 203.11,130.2
X$17421 10390 8616 10517 77 109 5780 MUX2_X1
* cell instance $17423 m0 *1 205.2,130.2
X$17423 77 10337 10018 10516 10332 109 DFF_X2
* cell instance $17426 r0 *1 186.01,130.2
X$17426 6391 11007 9412 6372 8327 10697 109 77 AOI221_X2
* cell instance $17427 r0 *1 188.1,130.2
X$17427 6391 10639 9412 6652 8327 10694 109 77 AOI221_X2
* cell instance $17429 r0 *1 190.95,130.2
X$17429 6391 10640 9412 7580 8327 10693 109 77 AOI221_X2
* cell instance $17431 r0 *1 193.23,130.2
X$17431 10697 8582 10642 77 7575 109 AOI21_X1
* cell instance $17433 r0 *1 194.37,130.2
X$17433 10684 10641 109 77 10331 XNOR2_X1
* cell instance $17435 r0 *1 195.7,130.2
X$17435 10694 8582 10689 77 7414 109 AOI21_X1
* cell instance $17437 r0 *1 196.65,130.2
X$17437 10693 8582 10643 77 7571 109 AOI21_X1
* cell instance $17438 r0 *1 197.41,130.2
X$17438 10382 9863 77 109 10521 NOR2_X1
* cell instance $17439 r0 *1 197.98,130.2
X$17439 10487 8582 10690 77 7567 109 AOI21_X1
* cell instance $17440 r0 *1 198.74,130.2
X$17440 10521 10488 77 109 10688 NAND2_X1
* cell instance $17441 r0 *1 199.31,130.2
X$17441 10646 10688 109 77 10687 XNOR2_X1
* cell instance $17443 r0 *1 200.83,130.2
X$17443 77 10683 10375 10684 10390 109 DFF_X2
* cell instance $17444 r0 *1 204.44,130.2
X$17444 10390 10336 10517 77 109 10683 MUX2_X1
* cell instance $17447 r0 *1 207.48,130.2
X$17447 10647 10336 10682 77 109 10820 MUX2_X1
* cell instance $17450 r0 *1 209.76,130.2
X$17450 10647 10682 8895 109 77 5785 MUX2_X2
* cell instance $17451 m0 *1 210.14,130.2
X$17451 10489 10821 8895 109 77 5800 MUX2_X2
* cell instance $17453 m0 *1 211.85,130.2
X$17453 10680 10209 9375 10342 77 109 10490 NOR4_X1
* cell instance $17454 m0 *1 212.8,130.2
X$17454 77 18360 10367 10678 10018 109 DFF_X1
* cell instance $17458 r0 *1 211.66,130.2
X$17458 10494 9068 9066 10680 109 10491 77 NOR4_X2
* cell instance $17459 r0 *1 213.37,130.2
X$17459 10675 10339 10490 77 109 10678 NOR3_X1
* cell instance $17460 r0 *1 214.13,130.2
X$17460 10342 2348 10677 77 10675 109 AOI21_X1
* cell instance $17463 r0 *1 216.79,130.2
X$17463 10209 10363 77 109 10650 OR2_X1
* cell instance $17465 m0 *1 217.17,130.2
X$17465 10492 10017 77 109 10493 NAND2_X1
* cell instance $17466 r0 *1 217.55,130.2
X$17466 10493 10650 77 109 9538 NOR2_X2
* cell instance $17468 m0 *1 218.12,130.2
X$17468 10017 10492 10515 77 10365 109 AOI21_X1
* cell instance $17469 m0 *1 219.07,130.2
X$17469 10494 10363 10493 77 109 9541 OR3_X1
* cell instance $17471 m0 *1 220.21,130.2
X$17471 10363 77 109 10514 INV_X1
* cell instance $17473 m0 *1 220.78,130.2
X$17473 10514 10338 10340 77 109 10513 NAND3_X1
* cell instance $17475 m0 *1 221.73,130.2
X$17475 10513 10494 9068 9066 77 109 10512 NOR4_X1
* cell instance $17480 r0 *1 219.07,130.2
X$17480 10650 8907 9079 10652 77 109 10651 NOR4_X1
* cell instance $17481 r0 *1 220.02,130.2
X$17481 10340 77 109 10652 INV_X1
* cell instance $17483 r0 *1 221.92,130.2
X$17483 10363 10494 9068 9066 77 109 10670 NOR4_X1
* cell instance $17484 r0 *1 222.87,130.2
X$17484 10340 10670 109 77 10668 XNOR2_X1
* cell instance $17486 m0 *1 223.82,130.2
X$17486 10183 10512 109 77 10510 XNOR2_X1
* cell instance $17489 r0 *1 224.39,130.2
X$17489 10654 10204 10668 77 10653 109 AOI21_X1
* cell instance $17492 r0 *1 226.1,130.2
X$17492 10655 77 109 10340 CLKBUF_X2
* cell instance $17494 m0 *1 226.1,130.2
X$17494 10192 10204 10510 77 10509 109 AOI21_X1
* cell instance $17500 r0 *1 227.05,130.2
X$17500 10495 9237 10665 77 10654 109 AOI21_X2
* cell instance $17501 m0 *1 228.19,130.2
X$17501 8918 10034 77 109 10495 NAND2_X1
* cell instance $17505 m0 *1 230.47,130.2
X$17505 10497 10194 10496 77 109 10506 MUX2_X1
* cell instance $17506 m0 *1 231.8,130.2
X$17506 77 18363 10497 10506 9554 109 DFF_X1
* cell instance $17507 m0 *1 235.03,130.2
X$17507 10499 10498 10343 77 109 10658 MUX2_X1
* cell instance $17509 m0 *1 237.88,130.2
X$17509 10503 77 109 10502 BUF_X1
* cell instance $17514 r0 *1 230.09,130.2
X$17514 10343 11182 109 77 10496 XNOR2_X1
* cell instance $17516 r0 *1 231.99,130.2
X$17516 77 18470 10499 10661 9554 109 DFF_X1
* cell instance $17517 r0 *1 235.22,130.2
X$17517 10499 10500 10658 77 109 10661 MUX2_X1
* cell instance $17519 r0 *1 238.07,130.2
X$17519 10658 77 109 10657 BUF_X1
* cell instance $17521 r0 *1 239.02,130.2
X$17521 10346 77 109 10501 BUF_X1
* cell instance $17525 m0 *1 137.18,113.4
X$17525 8971 9139 109 9170 77 AND2_X4
* cell instance $17526 m0 *1 138.89,113.4
X$17526 9209 8699 77 109 8880 NAND2_X1
* cell instance $17528 r0 *1 136.99,113.4
X$17528 9206 9171 8568 77 7750 109 AOI21_X2
* cell instance $17529 r0 *1 138.32,113.4
X$17529 77 5892 9158 9167 9169 109 NOR3_X4
* cell instance $17530 m0 *1 140.6,113.4
X$17530 8882 8574 77 109 8821 NOR2_X1
* cell instance $17531 m0 *1 139.84,113.4
X$17531 8574 8701 8881 109 6555 77 OAI21_X1
* cell instance $17532 m0 *1 141.17,113.4
X$17532 8994 8439 8700 77 8703 109 AOI21_X1
* cell instance $17535 r0 *1 141.17,113.4
X$17535 8704 9164 9208 77 9167 109 AOI21_X2
* cell instance $17536 m0 *1 142.5,113.4
X$17536 5895 6696 8506 7009 6427 8883 77 109 OAI221_X2
* cell instance $17540 m0 *1 145.54,113.4
X$17540 8374 77 109 8569 CLKBUF_X3
* cell instance $17545 r0 *1 143.26,113.4
X$17545 9159 8705 77 109 9164 NAND2_X1
* cell instance $17547 r0 *1 144.21,113.4
X$17547 7453 8378 8029 77 109 9460 MUX2_X1
* cell instance $17548 r0 *1 145.54,113.4
X$17548 8029 8569 9210 77 109 9212 NAND3_X1
* cell instance $17549 r0 *1 146.3,113.4
X$17549 8432 8505 7453 9214 77 109 9213 AOI22_X2
* cell instance $17551 m0 *1 149.34,113.4
X$17551 7886 8569 8095 77 9159 109 AOI21_X1
* cell instance $17553 m0 *1 150.1,113.4
X$17553 7886 9210 8569 8095 8983 109 77 AOI211_X2
* cell instance $17555 m0 *1 152,113.4
X$17555 8504 7507 8569 77 9048 109 AOI21_X2
* cell instance $17556 m0 *1 153.33,113.4
X$17556 8885 8882 8635 9048 8564 109 77 9153 OAI221_X1
* cell instance $17559 m0 *1 156.75,113.4
X$17559 77 8572 2739 8978 9050 9217 109 AOI22_X4
* cell instance $17562 m0 *1 162.26,113.4
X$17562 8574 8802 8976 8704 8974 8970 77 109 OAI221_X2
* cell instance $17568 r0 *1 150.86,113.4
X$17568 8966 7295 8884 109 77 9158 OAI21_X2
* cell instance $17569 r0 *1 152.19,113.4
X$17569 6401 77 109 9046 INV_X2
* cell instance $17570 r0 *1 152.76,113.4
X$17570 8885 8882 9048 8564 8699 9147 77 109 OAI221_X2
* cell instance $17573 r0 *1 155.8,113.4
X$17573 8189 8429 8438 77 109 9299 MUX2_X1
* cell instance $17576 r0 *1 158.84,113.4
X$17576 9153 9298 109 77 9050 AND2_X1
* cell instance $17578 r0 *1 159.79,113.4
X$17578 8432 8095 109 77 9052 AND2_X1
* cell instance $17580 r0 *1 160.93,113.4
X$17580 6762 77 109 7804 INV_X1
* cell instance $17581 r0 *1 161.31,113.4
X$17581 6762 4237 9144 109 77 9448 HA_X1
* cell instance $17584 r0 *1 163.78,113.4
X$17584 8573 8704 9140 9052 9141 7109 77 109 OAI221_X2
* cell instance $17585 m0 *1 165.68,113.4
X$17585 77 8572 2749 8973 8972 9220 109 AOI22_X4
* cell instance $17587 m0 *1 168.91,113.4
X$17587 8971 9139 8104 77 109 8283 NAND3_X2
* cell instance $17589 m0 *1 171.76,113.4
X$17589 3578 9286 77 109 8966 NOR2_X1
* cell instance $17591 m0 *1 172.52,113.4
X$17591 8883 8887 8964 77 6483 109 NAND3_X4
* cell instance $17593 m0 *1 175.18,113.4
X$17593 7719 77 109 7869 INV_X2
* cell instance $17595 m0 *1 175.94,113.4
X$17595 6696 5895 9126 77 109 NOR2_X4
* cell instance $17596 m0 *1 177.65,113.4
X$17596 77 8789 109 5895 BUF_X8
* cell instance $17597 m0 *1 180.12,113.4
X$17597 8888 6826 77 109 8960 NAND2_X1
* cell instance $17598 m0 *1 180.69,113.4
X$17598 8888 7425 77 109 9125 NAND2_X1
* cell instance $17599 m0 *1 181.26,113.4
X$17599 5541 77 109 8716 CLKBUF_X3
* cell instance $17603 r0 *1 167.01,113.4
X$17603 8712 9054 109 77 9053 AND2_X1
* cell instance $17606 r0 *1 168.91,113.4
X$17606 4984 7719 9291 109 77 9135 HA_X1
* cell instance $17612 r0 *1 171.95,113.4
X$17612 77 8889 9130 8715 6401 8104 109 OAI22_X4
* cell instance $17614 r0 *1 175.56,113.4
X$17614 77 9056 6005 6872 6471 109 AOI21_X4
* cell instance $17616 r0 *1 178.79,113.4
X$17616 8889 9127 9125 8479 9118 109 77 9128 OAI221_X1
* cell instance $17617 r0 *1 179.93,113.4
X$17617 77 9126 9123 7233 9122 9056 9057 8888 109 AOI222_X2
* cell instance $17619 m0 *1 182.59,113.4
X$17619 6005 8892 77 109 9123 NOR2_X1
* cell instance $17621 m0 *1 184.11,113.4
X$17621 9057 7965 8957 77 109 9121 MUX2_X1
* cell instance $17622 m0 *1 185.44,113.4
X$17622 6817 77 109 7966 CLKBUF_X3
* cell instance $17623 m0 *1 186.39,113.4
X$17623 9057 77 109 7143 INV_X1
* cell instance $17626 m0 *1 187.72,113.4
X$17626 77 8890 8891 8947 7966 109 DFF_X1
* cell instance $17629 r0 *1 182.59,113.4
X$17629 9056 109 9124 77 BUF_X4
* cell instance $17631 r0 *1 184.3,113.4
X$17631 77 7966 18849 9057 9121 3676 109 DFFR_X1
* cell instance $17633 r0 *1 188.48,113.4
X$17633 8891 9058 109 77 9270 AND2_X1
* cell instance $17636 r0 *1 189.81,113.4
X$17636 9426 77 109 8444 INV_X1
* cell instance $17637 r0 *1 190.19,113.4
X$17637 9058 8773 77 109 9118 NAND2_X1
* cell instance $17638 r0 *1 190.76,113.4
X$17638 9058 9061 77 109 8782 NAND2_X1
* cell instance $17641 m0 *1 192.66,113.4
X$17641 8722 8773 77 109 9115 NAND2_X1
* cell instance $17642 m0 *1 192.09,113.4
X$17642 8779 8892 77 109 8722 NOR2_X1
* cell instance $17645 m0 *1 194.94,113.4
X$17645 8618 8893 8894 77 109 8724 MUX2_X1
* cell instance $17646 m0 *1 196.27,113.4
X$17646 8618 8895 8894 77 109 5416 MUX2_X1
* cell instance $17649 m0 *1 198.55,113.4
X$17649 8891 8893 8901 77 109 8947 MUX2_X1
* cell instance $17650 m0 *1 199.88,113.4
X$17650 8891 8895 8901 77 109 5129 MUX2_X1
* cell instance $17653 r0 *1 192.47,113.4
X$17653 9115 8721 77 109 9060 NOR2_X2
* cell instance $17654 r0 *1 193.42,113.4
X$17654 8583 9115 77 109 9059 NOR2_X2
* cell instance $17658 r0 *1 196.46,113.4
X$17658 9113 9060 109 77 7673 XNOR2_X1
* cell instance $17660 r0 *1 197.79,113.4
X$17660 9061 8893 9062 77 109 9112 MUX2_X1
* cell instance $17663 r0 *1 200.07,113.4
X$17663 9061 8616 9062 77 109 7820 MUX2_X1
* cell instance $17665 r0 *1 201.78,113.4
X$17665 77 9111 8771 9110 9108 109 DFF_X1
* cell instance $17667 m0 *1 203.11,113.4
X$17667 9111 9231 77 109 8290 XOR2_X1
* cell instance $17669 m0 *1 207.48,113.4
X$17669 2526 8940 8899 109 9064 77 OAI21_X1
* cell instance $17672 r0 *1 205.01,113.4
X$17672 8771 8614 9063 77 109 9110 MUX2_X1
* cell instance $17673 r0 *1 206.34,113.4
X$17673 77 8313 8609 9064 9108 109 DFF_X1
* cell instance $17675 m0 *1 209.38,113.4
X$17675 8936 8609 3306 77 8940 109 AOI21_X1
* cell instance $17677 r0 *1 209.57,113.4
X$17677 77 9065 9069 9067 4186 8313 109 FA_X1
* cell instance $17679 m0 *1 211.28,113.4
X$17679 3327 77 109 9065 INV_X1
* cell instance $17681 m0 *1 213.37,113.4
X$17681 8726 9104 109 77 8935 XNOR2_X1
* cell instance $17684 r0 *1 212.61,113.4
X$17684 9068 9066 9067 77 109 8936 NOR3_X1
* cell instance $17686 r0 *1 213.56,113.4
X$17686 9068 9066 9069 77 109 9104 NOR3_X1
* cell instance $17688 r0 *1 214.51,113.4
X$17688 9069 77 109 9235 INV_X1
* cell instance $17691 r0 *1 215.46,113.4
X$17691 9078 4185 3593 9070 77 109 9103 NOR4_X1
* cell instance $17692 m0 *1 216.79,113.4
X$17692 77 18377 8931 8731 7824 109 DFF_X1
* cell instance $17693 m0 *1 215.65,113.4
X$17693 8901 9103 109 77 8934 XNOR2_X1
* cell instance $17694 m0 *1 220.02,113.4
X$17694 8931 77 109 8901 BUF_X1
* cell instance $17696 m0 *1 220.78,113.4
X$17696 9099 5802 7822 109 77 8930 OAI21_X2
* cell instance $17698 m0 *1 222.3,113.4
X$17698 8894 9073 109 77 8902 XNOR2_X1
* cell instance $17699 m0 *1 223.44,113.4
X$17699 8903 2394 8902 77 9096 109 AOI21_X1
* cell instance $17702 m0 *1 226.48,113.4
X$17702 8901 8894 77 109 9074 NAND2_X1
* cell instance $17703 m0 *1 227.05,113.4
X$17703 8894 8901 8775 109 77 8906 AND3_X1
* cell instance $17704 m0 *1 228,113.4
X$17704 77 18382 8775 8905 8735 109 DFF_X1
* cell instance $17706 r0 *1 216.41,113.4
X$17706 8894 77 109 9070 INV_X1
* cell instance $17708 r0 *1 219.83,113.4
X$17708 5952 8734 9101 77 9072 109 AOI21_X1
* cell instance $17709 r0 *1 220.59,113.4
X$17709 9072 7822 77 109 9099 NAND2_X1
* cell instance $17711 r0 *1 221.92,113.4
X$17711 9071 9068 9066 77 109 9073 NOR3_X1
* cell instance $17713 r0 *1 223.06,113.4
X$17713 77 18425 9249 9096 7982 109 DFF_X1
* cell instance $17714 r0 *1 226.29,113.4
X$17714 9071 9074 8907 9079 77 109 9075 NOR4_X1
* cell instance $17718 r0 *1 227.24,113.4
X$17718 8775 9075 109 77 9076 XNOR2_X1
* cell instance $17719 r0 *1 228.38,113.4
X$17719 77 9246 8921 8734 8957 109 AOI21_X4
* cell instance $17721 r0 *1 231.04,113.4
X$17721 8896 9062 8906 109 77 9383 AND3_X1
* cell instance $17722 m0 *1 231.8,113.4
X$17722 8917 8124 77 109 9093 NAND2_X1
* cell instance $17724 m0 *1 232.37,113.4
X$17724 8906 8896 77 109 9091 NAND2_X1
* cell instance $17725 m0 *1 232.94,113.4
X$17725 9071 9091 8907 9079 77 109 8908 NOR4_X1
* cell instance $17726 m0 *1 233.89,113.4
X$17726 8909 77 109 5802 BUF_X1
* cell instance $17729 r0 *1 231.99,113.4
X$17729 8906 77 109 9077 INV_X1
* cell instance $17730 r0 *1 232.37,113.4
X$17730 9077 9078 8907 9079 77 109 9090 NOR4_X1
* cell instance $17731 r0 *1 233.32,113.4
X$17731 9062 8908 109 77 9080 XNOR2_X1
* cell instance $17732 r0 *1 234.46,113.4
X$17732 9087 2394 9080 77 9085 109 AOI21_X1
* cell instance $17736 m0 *1 1.52,99.4
X$17736 77 6875 7685 7540 7539 4909 109 DFFR_X1
* cell instance $17739 m0 *1 7.03,99.4
X$17739 2932 6214 7611 77 109 7686 MUX2_X1
* cell instance $17741 m0 *1 9.12,99.4
X$17741 7178 109 6876 77 BUF_X4
* cell instance $17742 m0 *1 10.45,99.4
X$17742 77 7914 7687 7543 7458 4909 109 DFFR_X1
* cell instance $17744 m0 *1 14.44,99.4
X$17744 7687 4138 7612 77 109 8053 MUX2_X1
* cell instance $17753 r0 *1 4.56,99.4
X$17753 77 6875 7981 7611 7686 4909 109 DFFR_X1
* cell instance $17756 r0 *1 10.07,99.4
X$17756 7410 109 6280 77 BUF_X4
* cell instance $17757 r0 *1 11.4,99.4
X$17757 6572 7070 7833 77 109 7834 MUX2_X1
* cell instance $17760 r0 *1 13.87,99.4
X$17760 7687 8005 7612 77 109 7757 MUX2_X1
* cell instance $17761 r0 *1 15.2,99.4
X$17761 77 7459 7613 7689 7836 4909 109 DFFR_X1
* cell instance $17762 m0 *1 17.86,99.4
X$17762 7689 5726 7062 77 109 7836 MUX2_X1
* cell instance $17766 m0 *1 21.47,99.4
X$17766 7613 6591 7758 77 109 7692 MUX2_X1
* cell instance $17770 r0 *1 19.19,99.4
X$17770 77 7459 7758 7759 7839 4909 109 DFFR_X1
* cell instance $17771 r0 *1 22.99,99.4
X$17771 7759 5301 7062 77 109 7839 MUX2_X1
* cell instance $17772 m0 *1 25.27,99.4
X$17772 77 7464 7614 7465 7695 4909 109 DFFR_X1
* cell instance $17773 m0 *1 23.94,99.4
X$17773 7550 5729 7692 77 109 7463 MUX2_X1
* cell instance $17774 m0 *1 29.07,99.4
X$17774 7465 5577 7062 77 109 7695 MUX2_X1
* cell instance $17777 r0 *1 24.51,99.4
X$17777 7462 7760 7840 77 109 7916 MUX2_X1
* cell instance $17781 r0 *1 27.93,99.4
X$17781 7842 5805 7062 77 109 7843 MUX2_X1
* cell instance $17782 r0 *1 29.26,99.4
X$17782 7614 6022 7761 77 109 7845 MUX2_X1
* cell instance $17783 r0 *1 30.59,99.4
X$17783 7614 7844 7761 77 109 7762 MUX2_X1
* cell instance $17784 m0 *1 30.97,99.4
X$17784 7466 7844 7181 77 109 7615 MUX2_X1
* cell instance $17786 m0 *1 32.3,99.4
X$17786 7466 4287 7181 77 109 7697 MUX2_X1
* cell instance $17789 m0 *1 34.58,99.4
X$17789 7616 7338 77 109 7847 NAND2_X1
* cell instance $17791 m0 *1 35.34,99.4
X$17791 6955 7917 77 109 7471 NOR2_X1
* cell instance $17793 r0 *1 31.92,99.4
X$17793 7762 5729 7615 77 109 7853 MUX2_X1
* cell instance $17794 r0 *1 33.25,99.4
X$17794 7845 5575 7697 77 109 7616 MUX2_X1
* cell instance $17795 r0 *1 34.58,99.4
X$17795 7617 7847 7848 109 77 7846 AND3_X1
* cell instance $17797 r0 *1 35.91,99.4
X$17797 7471 7700 7997 109 8058 77 NOR3_X2
* cell instance $17799 m0 *1 36.29,99.4
X$17799 7617 7699 7701 109 77 7700 AND3_X1
* cell instance $17800 m0 *1 37.43,99.4
X$17800 7618 4965 7619 7620 7621 109 77 7701 OAI221_X1
* cell instance $17802 m0 *1 38.76,99.4
X$17802 7561 7183 7564 109 7622 77 OAI21_X1
* cell instance $17804 m0 *1 39.71,99.4
X$17804 7463 6546 77 109 7919 NAND2_X1
* cell instance $17805 m0 *1 40.28,99.4
X$17805 7703 7625 5727 7643 6546 7763 77 109 OAI221_X2
* cell instance $17810 r0 *1 37.81,99.4
X$17810 7618 5727 7619 7620 7622 109 77 7848 OAI221_X1
* cell instance $17811 r0 *1 38.95,99.4
X$17811 5672 109 7580 77 BUF_X4
* cell instance $17812 r0 *1 40.28,99.4
X$17812 7853 7580 77 109 7624 NAND2_X1
* cell instance $17813 r0 *1 40.85,99.4
X$17813 7763 7624 7631 77 109 7854 NAND3_X2
* cell instance $17814 r0 *1 42.18,99.4
X$17814 6866 109 7764 77 BUF_X4
* cell instance $17815 r0 *1 43.51,99.4
X$17815 7703 109 7627 77 BUF_X4
* cell instance $17816 m0 *1 44.84,99.4
X$17816 77 7269 7626 7568 7706 4909 109 DFFR_X1
* cell instance $17817 m0 *1 43.51,99.4
X$17817 5728 109 7477 77 BUF_X4
* cell instance $17819 r0 *1 44.84,99.4
X$17819 6645 77 109 7269 CLKBUF_X3
* cell instance $17821 r0 *1 46.17,99.4
X$17821 5029 7765 7920 109 8002 77 OAI21_X1
* cell instance $17822 r0 *1 46.93,99.4
X$17822 7269 77 109 19271 CLKBUF_X1
* cell instance $17825 r0 *1 48.64,99.4
X$17825 5029 7767 7769 109 7766 77 OAI21_X1
* cell instance $17826 m0 *1 49.21,99.4
X$17826 77 7269 7628 7569 7476 4909 109 DFFR_X1
* cell instance $17828 m0 *1 53.01,99.4
X$17828 7626 7477 7628 77 109 7629 MUX2_X1
* cell instance $17829 m0 *1 54.34,99.4
X$17829 7626 7403 7628 77 109 7710 MUX2_X1
* cell instance $17830 m0 *1 55.67,99.4
X$17830 7412 7477 7071 77 109 7630 MUX2_X1
* cell instance $17833 m0 *1 58.71,99.4
X$17833 7711 7580 77 109 7712 NAND2_X1
* cell instance $17834 m0 *1 59.28,99.4
X$17834 7479 6546 77 109 7865 NAND2_X1
* cell instance $17836 r0 *1 49.4,99.4
X$17836 7070 109 7767 77 BUF_X4
* cell instance $17837 r0 *1 50.73,99.4
X$17837 6645 77 109 6978 CLKBUF_X3
* cell instance $17838 r0 *1 51.68,99.4
X$17838 7768 7403 7858 77 109 7862 MUX2_X1
* cell instance $17839 r0 *1 53.01,99.4
X$17839 7770 7760 7629 77 109 7771 MUX2_X1
* cell instance $17840 r0 *1 54.34,99.4
X$17840 7771 6704 7860 77 109 7863 MUX2_X1
* cell instance $17841 r0 *1 55.67,99.4
X$17841 7478 7760 7630 77 109 7860 MUX2_X1
* cell instance $17842 r0 *1 57,99.4
X$17842 7862 7283 7710 77 109 7711 MUX2_X1
* cell instance $17844 r0 *1 58.71,99.4
X$17844 7577 7764 77 109 7867 NAND2_X1
* cell instance $17848 r0 *1 59.28,99.4
X$17848 7865 7712 7202 77 109 7772 NAND3_X2
* cell instance $17850 m0 *1 60.23,99.4
X$17850 5725 109 7636 77 BUF_X4
* cell instance $17851 r0 *1 60.61,99.4
X$17851 7327 8064 77 109 7866 NAND2_X1
* cell instance $17852 r0 *1 61.18,99.4
X$17852 7617 7867 7773 109 77 7774 AND3_X1
* cell instance $17854 m0 *1 61.94,99.4
X$17854 7327 7579 77 109 7481 NAND2_X1
* cell instance $17855 r0 *1 62.13,99.4
X$17855 7618 5822 7619 7620 7632 109 77 7773 OAI221_X1
* cell instance $17856 m0 *1 63.08,99.4
X$17856 7561 7633 7715 109 7632 77 OAI21_X1
* cell instance $17858 m0 *1 63.84,99.4
X$17858 7868 7482 7631 77 109 7716 NAND3_X2
* cell instance $17859 m0 *1 65.17,99.4
X$17859 6372 7633 7483 109 7718 77 OAI21_X1
* cell instance $17862 r0 *1 63.46,99.4
X$17862 7627 7718 5822 7643 6546 7868 77 109 OAI221_X2
* cell instance $17864 r0 *1 65.93,99.4
X$17864 77 8019 18755 7633 7634 1663 109 DFFR_X1
* cell instance $17865 m0 *1 66.5,99.4
X$17865 5029 7329 7720 109 7634 77 OAI21_X1
* cell instance $17867 m0 *1 67.26,99.4
X$17867 7775 7633 77 109 7720 NAND2_X1
* cell instance $17869 m0 *1 68.59,99.4
X$17869 6720 7722 77 109 7721 NAND2_X1
* cell instance $17871 m0 *1 69.92,99.4
X$17871 77 8019 7635 7722 7725 1663 109 DFFR_X1
* cell instance $17872 m0 *1 73.72,99.4
X$17872 3445 77 109 5962 CLKBUF_X3
* cell instance $17873 m0 *1 74.67,99.4
X$17873 5962 77 109 19084 INV_X4
* cell instance $17874 m0 *1 75.62,99.4
X$17874 6833 7585 77 109 7421 NAND2_X1
* cell instance $17876 m0 *1 76.38,99.4
X$17876 3903 6302 7728 109 7637 77 OAI21_X1
* cell instance $17878 m0 *1 77.33,99.4
X$17878 4072 7874 77 109 7728 NAND2_X1
* cell instance $17880 m0 *1 78.66,99.4
X$17880 6302 3794 7587 109 7729 77 OAI21_X1
* cell instance $17882 m0 *1 80.94,99.4
X$17882 7639 5513 7484 77 109 7875 MUX2_X1
* cell instance $17884 m0 *1 83.03,99.4
X$17884 77 6585 7591 7732 7778 1663 109 DFFR_X1
* cell instance $17885 m0 *1 86.83,99.4
X$17885 5680 7486 7882 109 77 7734 OAI21_X2
* cell instance $17888 m0 *1 90.44,99.4
X$17888 7735 6308 7488 77 109 7640 MUX2_X1
* cell instance $17891 m0 *1 95,99.4
X$17891 7736 7580 77 109 7738 NAND2_X1
* cell instance $17892 m0 *1 95.57,99.4
X$17892 5462 7331 7739 109 7439 77 OAI21_X1
* cell instance $17894 m0 *1 96.52,99.4
X$17894 5592 7331 7491 109 7492 77 OAI21_X1
* cell instance $17895 m0 *1 97.28,99.4
X$17895 7331 7595 77 109 7739 NAND2_X1
* cell instance $17900 r0 *1 70.87,99.4
X$17900 6888 77 109 7775 CLKBUF_X3
* cell instance $17901 r0 *1 71.82,99.4
X$17901 5967 5135 77 7776 109 NAND2_X4
* cell instance $17904 r0 *1 74.1,99.4
X$17904 5827 77 109 7638 INV_X4
* cell instance $17907 r0 *1 75.62,99.4
X$17907 77 6585 7639 7874 7637 1663 109 DFFR_X1
* cell instance $17909 r0 *1 79.61,99.4
X$17909 7932 7496 77 109 5827 NOR2_X2
* cell instance $17911 r0 *1 80.75,99.4
X$17911 7875 8024 7876 7928 7334 109 77 7882 OAI221_X1
* cell instance $17913 r0 *1 82.65,99.4
X$17913 2493 7877 7639 77 109 7730 MUX2_X1
* cell instance $17914 r0 *1 83.98,99.4
X$17914 7878 7732 77 109 8026 NAND2_X1
* cell instance $17916 r0 *1 84.74,99.4
X$17916 77 7205 7487 7780 7779 1663 109 DFFR_X1
* cell instance $17917 r0 *1 88.54,99.4
X$17917 7776 7336 7597 7734 7885 8084 77 109 OAI221_X2
* cell instance $17920 r0 *1 91.2,99.4
X$17920 7084 6302 7887 109 8030 77 OAI21_X1
* cell instance $17923 r0 *1 93.1,99.4
X$17923 7084 7889 77 109 7887 NAND2_X1
* cell instance $17927 r0 *1 95,99.4
X$17927 7643 6678 6546 7627 7781 109 77 7890 OAI221_X1
* cell instance $17928 r0 *1 96.14,99.4
X$17928 7890 7738 7597 7631 77 109 7885 NAND4_X1
* cell instance $17932 r0 *1 99.18,99.4
X$17932 7775 7782 77 109 7893 NAND2_X1
* cell instance $17933 r0 *1 99.75,99.4
X$17933 7337 77 109 19171 INV_X1
* cell instance $17934 m0 *1 101.08,99.4
X$17934 6457 7631 7494 7742 7645 7644 77 109 OAI221_X2
* cell instance $17935 m0 *1 99.75,99.4
X$17935 7209 7642 7493 77 109 7641 MUX2_X1
* cell instance $17936 m0 *1 103.17,99.4
X$17936 7495 109 7335 77 BUF_X4
* cell instance $17937 m0 *1 104.5,99.4
X$17937 5729 109 7283 77 BUF_X4
* cell instance $17940 m0 *1 106.78,99.4
X$17940 7647 7636 7646 77 109 7744 MUX2_X1
* cell instance $17942 m0 *1 108.3,99.4
X$17942 77 6900 7746 7748 7745 4086 109 DFFR_X1
* cell instance $17943 m0 *1 112.1,99.4
X$17943 7647 6993 7748 77 109 7745 MUX2_X1
* cell instance $17945 m0 *1 113.62,99.4
X$17945 3306 7580 77 109 7601 NAND2_X1
* cell instance $17947 m0 *1 115.71,99.4
X$17947 77 18295 7751 7214 6739 109 DFF_X1
* cell instance $17950 m0 *1 120.65,99.4
X$17950 7751 77 109 7752 BUF_X2
* cell instance $17952 r0 *1 100.13,99.4
X$17952 7638 6369 6461 77 7896 109 AOI21_X1
* cell instance $17954 r0 *1 101.08,99.4
X$17954 6652 7900 7896 109 7645 77 OAI21_X1
* cell instance $17955 r0 *1 101.84,99.4
X$17955 7644 109 8360 77 BUF_X4
* cell instance $17956 r0 *1 103.17,99.4
X$17956 7627 7898 6858 7643 109 77 7900 OAI22_X1
* cell instance $17957 r0 *1 104.12,99.4
X$17957 6389 7782 7901 109 7898 77 OAI21_X1
* cell instance $17959 r0 *1 105.07,99.4
X$17959 77 6900 7783 7646 7744 4086 109 DFFR_X1
* cell instance $17960 r0 *1 108.87,99.4
X$17960 7783 7844 7746 77 109 7902 MUX2_X1
* cell instance $17961 r0 *1 110.2,99.4
X$17961 7783 7642 7746 77 109 7903 MUX2_X1
* cell instance $17962 r0 *1 111.53,99.4
X$17962 6671 77 109 6900 CLKBUF_X3
* cell instance $17963 r0 *1 112.48,99.4
X$17963 6900 77 109 19172 INV_X1
* cell instance $17966 r0 *1 113.43,99.4
X$17966 77 7784 7905 7648 6008 109 DFF_X1
* cell instance $17970 r0 *1 116.66,99.4
X$17970 7905 109 7932 77 BUF_X4
* cell instance $17974 r0 *1 121.41,99.4
X$17974 6466 7497 7217 7752 7785 109 77 AOI211_X2
* cell instance $17975 m0 *1 121.98,99.4
X$17975 7498 6145 77 109 7753 NOR2_X1
* cell instance $17977 m0 *1 122.55,99.4
X$17977 7217 109 5711 77 BUF_X4
* cell instance $17978 m0 *1 123.88,99.4
X$17978 7649 109 7652 77 BUF_X4
* cell instance $17979 m0 *1 125.21,99.4
X$17979 7649 77 109 5861 INV_X4
* cell instance $17980 m0 *1 126.16,99.4
X$17980 7649 7216 77 109 7498 NAND2_X2
* cell instance $17981 m0 *1 127.11,99.4
X$17981 6469 7217 77 109 7500 NAND2_X1
* cell instance $17982 m0 *1 127.68,99.4
X$17982 4660 7346 7755 7498 7754 7501 77 109 OAI221_X2
* cell instance $17984 m0 *1 129.96,99.4
X$17984 5475 7650 5476 5990 6191 5430 77 109 7756 OAI33_X1
* cell instance $17985 m0 *1 131.29,99.4
X$17985 6469 7652 6698 77 109 6467 NAND3_X2
* cell instance $17989 r0 *1 123.69,99.4
X$17989 7450 7785 109 77 7906 AND2_X1
* cell instance $17991 r0 *1 124.83,99.4
X$17991 7497 77 109 7174 INV_X4
* cell instance $17992 r0 *1 125.78,99.4
X$17992 6145 77 109 7499 INV_X1
* cell instance $17993 r0 *1 126.16,99.4
X$17993 7786 7753 6698 109 7909 77 OAI21_X1
* cell instance $17994 r0 *1 126.92,99.4
X$17994 7787 109 7219 77 BUF_X4
* cell instance $17995 r0 *1 128.25,99.4
X$17995 5472 6698 7652 7314 109 77 7788 AND4_X1
* cell instance $17996 r0 *1 129.39,99.4
X$17996 7904 7317 8043 7788 7789 7908 109 77 AOI221_X2
* cell instance $17997 r0 *1 131.48,99.4
X$17997 7609 7314 7500 109 7907 77 OAI21_X1
* cell instance $17998 r0 *1 132.24,99.4
X$17998 5990 7314 5557 77 7755 109 AOI21_X1
* cell instance $17999 m0 *1 134.71,99.4
X$17999 7316 77 109 7754 BUF_X1
* cell instance $18000 m0 *1 133,99.4
X$18000 5430 6191 7653 77 109 NOR2_X4
* cell instance $18002 m0 *1 138.32,99.4
X$18002 7655 7502 77 109 7654 NOR2_X1
* cell instance $18003 m0 *1 138.89,99.4
X$18003 7655 7159 7353 77 7749 109 AOI21_X2
* cell instance $18005 m0 *1 140.41,99.4
X$18005 7353 7159 77 109 7747 NAND2_X1
* cell instance $18008 r0 *1 133.19,99.4
X$18008 7906 7791 7347 7793 7792 5904 109 77 AOI221_X2
* cell instance $18009 r0 *1 135.28,99.4
X$18009 7316 77 109 7789 BUF_X1
* cell instance $18010 r0 *1 135.85,99.4
X$18010 6467 5475 77 109 7904 NOR2_X1
* cell instance $18013 r0 *1 137.56,99.4
X$18013 7797 7794 7747 7654 77 109 8090 AOI22_X1
* cell instance $18014 r0 *1 138.51,99.4
X$18014 7795 7796 109 77 7794 AND2_X1
* cell instance $18016 r0 *1 140.79,99.4
X$18016 7504 7305 7727 109 77 7899 AND3_X1
* cell instance $18018 m0 *1 141.36,99.4
X$18018 7603 7305 7504 77 109 7795 NAND3_X1
* cell instance $18019 r0 *1 141.74,99.4
X$18019 6913 6915 7727 109 7949 77 OAI21_X1
* cell instance $18020 r0 *1 142.5,99.4
X$18020 7899 7100 7731 77 7897 109 AOI21_X1
* cell instance $18022 m0 *1 142.5,99.4
X$18022 7731 7159 7505 77 109 7946 MUX2_X1
* cell instance $18025 m0 *1 144.97,99.4
X$18025 7743 7656 77 109 7800 OR2_X1
* cell instance $18026 m0 *1 144.21,99.4
X$18026 7656 7743 7096 77 109 7798 NOR3_X1
* cell instance $18028 r0 *1 144.4,99.4
X$18028 7356 7797 7800 77 109 7799 MUX2_X1
* cell instance $18029 r0 *1 145.73,99.4
X$18029 7658 7100 7894 77 109 7892 MUX2_X1
* cell instance $18030 m0 *1 146.3,99.4
X$18030 7740 7657 7504 7305 77 109 7656 AOI22_X1
* cell instance $18033 m0 *1 147.44,99.4
X$18033 7443 6923 77 109 7657 NAND2_X1
* cell instance $18034 m0 *1 148.01,99.4
X$18034 7443 7662 7659 77 109 7603 MUX2_X1
* cell instance $18036 r0 *1 147.06,99.4
X$18036 7223 7221 7892 77 7891 109 AOI21_X2
* cell instance $18037 r0 *1 148.39,99.4
X$18037 7296 7305 7504 77 109 7801 NAND3_X1
* cell instance $18038 r0 *1 149.15,99.4
X$18038 7098 7052 7741 7660 7221 7886 109 77 AOI221_X2
* cell instance $18040 m0 *1 149.72,99.4
X$18040 7659 6920 77 109 7740 NAND2_X1
* cell instance $18042 m0 *1 150.67,99.4
X$18042 7297 6923 7884 77 7658 109 AOI21_X2
* cell instance $18043 m0 *1 152.76,99.4
X$18043 7362 7096 7661 77 109 7737 MUX2_X1
* cell instance $18044 m0 *1 154.09,99.4
X$18044 7511 7100 7363 77 109 7660 MUX2_X1
* cell instance $18045 m0 *1 155.42,99.4
X$18045 7502 7661 77 109 7881 OR2_X1
* cell instance $18047 m0 *1 156.37,99.4
X$18047 6920 77 109 7662 CLKBUF_X3
* cell instance $18048 m0 *1 157.32,99.4
X$18048 7518 6926 7519 77 109 7659 MUX2_X1
* cell instance $18051 r0 *1 151.62,99.4
X$18051 6401 6483 7229 109 77 7884 MUX2_X2
* cell instance $18055 r0 *1 155.42,99.4
X$18055 7357 7803 7881 109 8274 77 OAI21_X1
* cell instance $18056 r0 *1 156.18,99.4
X$18056 7159 7880 7733 109 7803 77 OAI21_X1
* cell instance $18057 r0 *1 156.94,99.4
X$18057 7804 6926 7879 77 109 7604 MUX2_X1
* cell instance $18058 r0 *1 158.27,99.4
X$18058 6920 7805 109 77 7806 XNOR2_X1
* cell instance $18060 m0 *1 159.03,99.4
X$18060 7513 6920 7522 77 109 7731 MUX2_X1
* cell instance $18061 m0 *1 161.88,99.4
X$18061 7522 6920 7663 77 109 7807 MUX2_X1
* cell instance $18063 m0 *1 163.97,99.4
X$18063 6398 7516 7285 77 109 7808 MUX2_X1
* cell instance $18064 m0 *1 165.3,99.4
X$18064 7808 6923 7663 77 109 7727 MUX2_X1
* cell instance $18065 m0 *1 166.63,99.4
X$18065 7520 7516 7521 77 109 7663 MUX2_X1
* cell instance $18067 r0 *1 159.41,99.4
X$18067 7514 77 109 8023 INV_X1
* cell instance $18070 r0 *1 160.93,99.4
X$18070 7514 7802 7807 77 109 7956 MUX2_X1
* cell instance $18071 r0 *1 162.26,99.4
X$18071 7807 77 109 7957 INV_X1
* cell instance $18073 r0 *1 162.83,99.4
X$18073 7516 77 109 7805 CLKBUF_X3
* cell instance $18076 r0 *1 164.35,99.4
X$18076 274 77 109 1236 CLKBUF_X3
* cell instance $18077 r0 *1 165.3,99.4
X$18077 7662 7808 77 109 7873 OR2_X1
* cell instance $18078 r0 *1 166.06,99.4
X$18078 7869 7232 7872 77 109 7360 MUX2_X1
* cell instance $18082 m0 *1 168.34,99.4
X$18082 7726 6923 7523 77 109 7363 MUX2_X1
* cell instance $18083 m0 *1 170.43,99.4
X$18083 7719 6926 7664 77 109 7726 MUX2_X1
* cell instance $18085 m0 *1 171.95,99.4
X$18085 6198 7517 6604 77 109 7724 MUX2_X1
* cell instance $18086 m0 *1 173.28,99.4
X$18086 6764 7519 6931 77 109 7723 MUX2_X1
* cell instance $18087 m0 *1 174.61,99.4
X$18087 7723 6200 77 109 7588 NOR2_X1
* cell instance $18089 m0 *1 175.37,99.4
X$18089 6931 7719 6764 77 109 7717 MUX2_X1
* cell instance $18090 m0 *1 176.7,99.4
X$18090 7717 6659 77 109 7665 NOR2_X1
* cell instance $18091 m0 *1 177.27,99.4
X$18091 77 6659 7714 3577 1398 7664 109 OAI22_X4
* cell instance $18092 m0 *1 180.5,99.4
X$18092 77 6659 7713 2742 1381 7586 109 OAI22_X4
* cell instance $18093 m0 *1 183.73,99.4
X$18093 1126 5913 7709 77 109 6608 MUX2_X1
* cell instance $18096 r0 *1 168.72,99.4
X$18096 7809 7232 7871 77 109 7361 MUX2_X1
* cell instance $18101 r0 *1 171.57,99.4
X$18101 6198 7520 6604 77 109 8007 MUX2_X1
* cell instance $18103 r0 *1 173.09,99.4
X$18103 77 6200 7724 3578 1809 7810 109 OAI22_X4
* cell instance $18105 r0 *1 176.7,99.4
X$18105 77 1084 7665 7869 3358 109 AOI21_X4
* cell instance $18107 r0 *1 179.55,99.4
X$18107 6764 7809 6931 77 109 7525 MUX2_X1
* cell instance $18109 r0 *1 181.26,99.4
X$18109 7811 7809 2739 77 7669 109 AOI21_X2
* cell instance $18110 r0 *1 182.59,99.4
X$18110 7584 6659 77 109 7666 NOR2_X1
* cell instance $18112 r0 *1 183.92,99.4
X$18112 7864 77 109 7115 INV_X1
* cell instance $18113 r0 *1 184.3,99.4
X$18113 77 7816 18860 7864 7812 3676 109 DFFR_X1
* cell instance $18115 m0 *1 185.44,99.4
X$18115 1126 3306 7709 77 109 7708 MUX2_X1
* cell instance $18116 m0 *1 187.34,99.4
X$18116 77 18342 7861 7708 6945 109 DFF_X1
* cell instance $18119 m0 *1 191.33,99.4
X$18119 5090 109 4552 77 BUF_X4
* cell instance $18121 m0 *1 193.42,99.4
X$18121 5417 5090 7670 77 109 7707 MUX2_X1
* cell instance $18125 r0 *1 190.38,99.4
X$18125 77 7816 18851 7670 7707 3676 109 DFFR_X1
* cell instance $18127 m0 *1 195.32,99.4
X$18127 7669 6071 7671 6492 7670 77 109 7672 AOI221_X1
* cell instance $18131 m0 *1 198.74,99.4
X$18131 7675 5915 109 77 7671 AND2_X1
* cell instance $18134 r0 *1 195.7,99.4
X$18134 7857 7242 7672 77 7859 109 AOI21_X1
* cell instance $18138 r0 *1 197.79,99.4
X$18138 6354 5417 77 109 7857 NOR2_X1
* cell instance $18139 r0 *1 198.36,99.4
X$18139 77 7816 18902 7818 7704 3676 109 DFFR_X1
* cell instance $18140 m0 *1 200.83,99.4
X$18140 3333 5090 7818 77 109 7704 MUX2_X1
* cell instance $18143 r0 *1 202.16,99.4
X$18143 7820 5915 109 77 7819 AND2_X1
* cell instance $18145 m0 *1 202.54,99.4
X$18145 77 6642 7674 3676 18933 3333 109 DFFR_X2
* cell instance $18147 m0 *1 207.67,99.4
X$18147 77 6642 7702 3676 18904 2999 109 DFFR_X2
* cell instance $18148 m0 *1 211.85,99.4
X$18148 77 6946 7676 3676 18936 5499 109 DFFR_X2
* cell instance $18153 r0 *1 203.11,99.4
X$18153 7856 7242 7821 77 7674 109 AOI21_X1
* cell instance $18156 r0 *1 204.82,99.4
X$18156 6354 3333 77 109 7856 NOR2_X1
* cell instance $18160 r0 *1 208.05,99.4
X$18160 5982 7855 77 7822 109 NAND2_X4
* cell instance $18161 r0 *1 209.76,99.4
X$18161 6067 5756 77 109 7855 NOR2_X1
* cell instance $18165 r0 *1 211.66,99.4
X$18165 7534 5083 77 109 7852 NOR2_X1
* cell instance $18168 r0 *1 213.18,99.4
X$18168 1063 6239 7852 6368 2695 77 109 7850 AOI221_X1
* cell instance $18169 r0 *1 214.32,99.4
X$18169 685 6239 7851 6368 2707 77 109 7823 AOI221_X1
* cell instance $18170 r0 *1 215.46,99.4
X$18170 7850 77 109 7849 INV_X1
* cell instance $18171 r0 *1 215.84,99.4
X$18171 7823 77 109 7698 INV_X1
* cell instance $18172 r0 *1 216.22,99.4
X$18172 77 7824 7849 3676 19023 2695 109 DFFR_X2
* cell instance $18173 m0 *1 222.49,99.4
X$18173 77 6500 6077 7693 7694 992 109 DFFR_X1
* cell instance $18174 m0 *1 218.69,99.4
X$18174 77 6946 4963 7552 7696 3676 109 DFFR_X1
* cell instance $18178 r0 *1 220.59,99.4
X$18178 2707 6209 6207 6340 77 109 7985 AOI22_X1
* cell instance $18180 r0 *1 221.73,99.4
X$18180 7387 7677 77 109 7984 NAND2_X1
* cell instance $18183 r0 *1 222.87,99.4
X$18183 7677 4951 7825 77 109 7694 MUX2_X1
* cell instance $18185 r0 *1 224.96,99.4
X$18185 7693 5271 6202 77 109 7826 OR3_X1
* cell instance $18186 r0 *1 225.91,99.4
X$18186 7826 7827 6067 77 109 7841 NAND3_X1
* cell instance $18187 r0 *1 226.67,99.4
X$18187 6202 6077 5773 77 109 7827 NAND3_X1
* cell instance $18192 m0 *1 227.62,99.4
X$18192 6202 109 5524 77 BUF_X4
* cell instance $18194 m0 *1 228.95,99.4
X$18194 2999 6209 4410 6340 77 109 7678 AOI22_X1
* cell instance $18195 m0 *1 229.9,99.4
X$18195 7678 7690 77 109 7828 NAND2_X1
* cell instance $18197 r0 *1 227.81,99.4
X$18197 4857 6209 6340 3700 77 109 7837 AOI22_X2
* cell instance $18198 r0 *1 229.52,99.4
X$18198 7835 7837 7546 77 109 7838 NAND3_X2
* cell instance $18199 m0 *1 231.8,99.4
X$18199 7691 7680 6067 77 109 7690 NAND3_X1
* cell instance $18200 m0 *1 230.85,99.4
X$18200 7679 5271 6202 77 109 7691 OR3_X1
* cell instance $18201 m0 *1 232.56,99.4
X$18201 5524 5936 5773 77 109 7830 NAND3_X1
* cell instance $18203 m0 *1 233.51,99.4
X$18203 6966 5385 7681 5228 77 109 7542 AOI22_X1
* cell instance $18205 m0 *1 234.65,99.4
X$18205 7683 77 109 4864 CLKBUF_X2
* cell instance $18206 m0 *1 235.41,99.4
X$18206 6792 6496 7681 77 109 7682 MUX2_X1
* cell instance $18208 m0 *1 238.26,99.4
X$18208 7538 77 109 7535 BUF_X1
* cell instance $18211 r0 *1 230.85,99.4
X$18211 7387 7544 77 109 7835 NAND2_X1
* cell instance $18213 r0 *1 231.61,99.4
X$18213 7831 5271 5524 77 109 7829 OR3_X1
* cell instance $18214 r0 *1 232.56,99.4
X$18214 5524 5101 5773 77 109 7680 NAND3_X1
* cell instance $18215 r0 *1 233.32,99.4
X$18215 1063 4691 7831 77 109 7832 MUX2_X1
* cell instance $18216 r0 *1 234.65,99.4
X$18216 7684 77 109 7677 BUF_X1
* cell instance $18219 r0 *1 235.79,99.4
X$18219 77 7976 18876 7681 7682 992 109 DFFR_X1
* cell instance $18223 m0 *1 1.52,119
X$18223 77 8661 9471 9545 9718 4909 109 DFFR_X1
* cell instance $18225 m0 *1 6.08,119
X$18225 9471 8005 9315 77 109 9472 MUX2_X1
* cell instance $18226 m0 *1 7.41,119
X$18226 9471 3048 9315 77 109 9474 MUX2_X1
* cell instance $18228 m0 *1 8.93,119
X$18228 9474 7156 9551 77 109 9388 MUX2_X1
* cell instance $18231 m0 *1 11.97,119
X$18231 77 9005 9476 9390 9317 4909 109 DFFR_X1
* cell instance $18232 m0 *1 15.77,119
X$18232 77 9005 9318 9478 9555 4909 109 DFFR_X1
* cell instance $18234 m0 *1 19.76,119
X$18234 8837 2931 9478 77 109 9555 MUX2_X1
* cell instance $18243 r0 *1 3.42,119
X$18243 9003 6876 9545 77 109 9718 MUX2_X1
* cell instance $18244 r0 *1 4.75,119
X$18244 9470 5726 9546 77 109 9644 MUX2_X1
* cell instance $18247 r0 *1 6.65,119
X$18247 9550 5301 9473 77 109 9720 MUX2_X1
* cell instance $18248 r0 *1 7.98,119
X$18248 9472 7760 9316 77 109 9475 MUX2_X1
* cell instance $18249 r0 *1 9.31,119
X$18249 9475 6704 9646 77 109 9564 MUX2_X1
* cell instance $18252 r0 *1 12.35,119
X$18252 77 9005 9477 9648 9553 4909 109 DFFR_X1
* cell instance $18253 r0 *1 16.15,119
X$18253 9648 3782 8837 77 109 9553 MUX2_X1
* cell instance $18256 r0 *1 18.62,119
X$18256 9476 5661 9477 77 109 9725 MUX2_X1
* cell instance $18258 r0 *1 20.14,119
X$18258 9649 6022 9650 77 109 9651 MUX2_X1
* cell instance $18261 m0 *1 21.47,119
X$18261 9557 5575 9395 77 109 9479 MUX2_X1
* cell instance $18263 r0 *1 22.99,119
X$18263 9319 9652 9388 77 109 9893 MUX2_X1
* cell instance $18267 m0 *1 1.52,91
X$18267 77 6875 6702 6700 6788 2157 109 DFFR_X1
* cell instance $18268 m0 *1 5.32,91
X$18268 6702 3041 6703 77 109 6504 MUX2_X1
* cell instance $18273 r0 *1 1.71,91
X$18273 77 6875 6703 7123 7122 2157 109 DFFR_X1
* cell instance $18279 r0 *1 6.65,91
X$18279 5174 6876 6877 77 109 7125 MUX2_X1
* cell instance $18281 m0 *1 7.79,91
X$18281 6705 6704 6015 77 109 6955 MUX2_X1
* cell instance $18283 m0 *1 10.07,91
X$18283 7126 6014 6707 77 109 6880 MUX2_X1
* cell instance $18284 m0 *1 11.4,91
X$18284 6880 6704 6708 77 109 6793 MUX2_X1
* cell instance $18292 r0 *1 9.31,91
X$18292 7055 3603 6878 77 109 6879 MUX2_X1
* cell instance $18294 r0 *1 10.83,91
X$18294 6879 3978 6709 77 109 6881 MUX2_X1
* cell instance $18295 r0 *1 12.16,91
X$18295 6881 3611 5867 77 109 6956 MUX2_X1
* cell instance $18299 r0 *1 16.15,91
X$18299 77 6710 7057 6882 6957 4909 109 DFFR_X1
* cell instance $18300 m0 *1 19.76,91
X$18300 6711 6290 6625 77 109 6797 MUX2_X1
* cell instance $18301 m0 *1 18.43,91
X$18301 6711 5660 6625 77 109 6798 MUX2_X1
* cell instance $18302 m0 *1 21.09,91
X$18302 7060 6017 6798 77 109 6806 MUX2_X1
* cell instance $18305 m0 *1 24.13,91
X$18305 6572 6159 6959 77 109 6801 MUX2_X1
* cell instance $18306 m0 *1 25.46,91
X$18306 6883 109 6283 77 BUF_X4
* cell instance $18307 m0 *1 26.79,91
X$18307 6884 6627 6958 77 109 6960 MUX2_X1
* cell instance $18308 m0 *1 28.12,91
X$18308 6714 6091 6960 77 109 6962 MUX2_X1
* cell instance $18311 m0 *1 32.68,91
X$18311 6883 5725 6575 77 109 6804 MUX2_X1
* cell instance $18312 m0 *1 34.01,91
X$18312 6806 5818 6633 77 109 6807 MUX2_X1
* cell instance $18313 m0 *1 35.34,91
X$18313 77 4393 109 5446 BUF_X8
* cell instance $18315 m0 *1 38.57,91
X$18315 77 6232 6717 6889 6969 4909 109 DFFR_X1
* cell instance $18316 m0 *1 42.37,91
X$18316 6889 6718 6163 77 109 6969 MUX2_X1
* cell instance $18319 m0 *1 44.65,91
X$18319 5950 5850 109 77 7064 AND2_X1
* cell instance $18321 r0 *1 19.95,91
X$18321 6882 2633 6283 77 109 6957 MUX2_X1
* cell instance $18323 r0 *1 21.47,91
X$18323 7130 6231 6797 77 109 6964 MUX2_X1
* cell instance $18325 r0 *1 22.99,91
X$18325 77 6710 6958 6959 6801 4909 109 DFFR_X1
* cell instance $18327 r0 *1 26.98,91
X$18327 6884 5580 6958 77 109 6715 MUX2_X1
* cell instance $18329 r0 *1 29.07,91
X$18329 6962 5017 6631 77 109 7135 MUX2_X1
* cell instance $18331 r0 *1 30.78,91
X$18331 6887 6885 4767 77 109 6886 MUX2_X1
* cell instance $18332 r0 *1 32.11,91
X$18332 77 5722 18829 6887 6886 4909 109 DFFR_X1
* cell instance $18334 r0 *1 36.67,91
X$18334 6964 7063 6576 77 109 7065 MUX2_X1
* cell instance $18338 r0 *1 40.09,91
X$18338 2787 6888 6968 77 109 7066 MUX2_X1
* cell instance $18341 r0 *1 43.32,91
X$18341 6956 6236 77 109 6971 NOR2_X2
* cell instance $18342 r0 *1 44.27,91
X$18342 4904 6890 6891 109 7067 77 OAI21_X1
* cell instance $18343 r0 *1 45.03,91
X$18343 4904 6972 6892 109 7270 77 OAI21_X1
* cell instance $18344 m0 *1 48.26,91
X$18344 77 6443 6979 6815 6647 4909 109 DFFR_X1
* cell instance $18345 m0 *1 45.79,91
X$18345 77 3541 109 5446 BUF_X8
* cell instance $18347 r0 *1 45.79,91
X$18347 7160 6977 77 109 6891 NAND2_X1
* cell instance $18348 r0 *1 46.36,91
X$18348 6578 109 6975 77 BUF_X4
* cell instance $18349 r0 *1 47.69,91
X$18349 6718 109 4631 77 BUF_X4
* cell instance $18350 r0 *1 49.02,91
X$18350 6979 5506 7069 77 109 7187 MUX2_X1
* cell instance $18352 r0 *1 50.73,91
X$18352 77 6978 7069 6722 6721 4909 109 DFFR_X1
* cell instance $18354 m0 *1 52.44,91
X$18354 3788 6177 6980 109 6721 77 OAI21_X1
* cell instance $18356 m0 *1 53.58,91
X$18356 6723 6722 77 109 6980 NAND2_X1
* cell instance $18357 m0 *1 54.34,91
X$18357 77 6978 7071 6724 6986 4909 109 DFFR_X1
* cell instance $18358 m0 *1 58.14,91
X$18358 6723 6724 77 109 6985 NAND2_X1
* cell instance $18362 r0 *1 55.48,91
X$18362 6718 109 6983 77 BUF_X4
* cell instance $18363 r0 *1 56.81,91
X$18363 5875 6177 6985 109 6986 77 OAI21_X1
* cell instance $18367 r0 *1 58.9,91
X$18367 3000 6030 77 109 6725 NAND2_X2
* cell instance $18371 m0 *1 62.89,91
X$18371 6725 6827 77 109 6822 NAND2_X1
* cell instance $18372 m0 *1 59.09,91
X$18372 77 6894 6990 6827 6989 4909 109 DFFR_X1
* cell instance $18374 r0 *1 59.85,91
X$18374 3000 5950 77 109 6988 NAND2_X2
* cell instance $18377 r0 *1 61.37,91
X$18377 6990 4287 6895 77 109 7073 MUX2_X1
* cell instance $18379 r0 *1 62.89,91
X$18379 6990 6371 6895 77 109 7074 MUX2_X1
* cell instance $18380 m0 *1 65.17,91
X$18380 5850 109 5181 77 BUF_X4
* cell instance $18381 m0 *1 63.84,91
X$18381 6287 109 6993 77 BUF_X4
* cell instance $18382 m0 *1 66.5,91
X$18382 6298 6034 77 6716 109 NAND2_X4
* cell instance $18383 m0 *1 68.21,91
X$18383 5029 6730 6999 109 6830 77 OAI21_X1
* cell instance $18385 m0 *1 69.16,91
X$18385 4507 6997 7000 77 109 NOR2_X4
* cell instance $18386 m0 *1 70.87,91
X$18386 6988 6998 77 109 6999 NAND2_X1
* cell instance $18389 r0 *1 64.41,91
X$18389 77 6894 6895 6998 6830 4909 109 DFFR_X1
* cell instance $18391 r0 *1 68.4,91
X$18391 6723 109 6177 77 BUF_X4
* cell instance $18392 r0 *1 69.73,91
X$18392 77 6726 7001 7000 6996 109 NOR3_X4
* cell instance $18393 m0 *1 75.62,91
X$18393 77 5316 109 3621 BUF_X8
* cell instance $18394 m0 *1 71.82,91
X$18394 77 6170 6834 6448 7003 1663 109 DFFR_X1
* cell instance $18396 m0 *1 78.28,91
X$18396 5401 3992 6839 7006 77 109 7007 AOI22_X2
* cell instance $18397 m0 *1 79.99,91
X$18397 7007 6727 6842 77 109 7009 AND3_X4
* cell instance $18398 m0 *1 82.08,91
X$18398 4509 77 109 6586 INV_X1
* cell instance $18400 r0 *1 72.39,91
X$18400 6170 77 109 19265 CLKBUF_X1
* cell instance $18401 r0 *1 72.96,91
X$18401 3613 7005 77 109 7151 NAND2_X1
* cell instance $18402 r0 *1 73.53,91
X$18402 6449 3794 6399 109 77 7003 OAI21_X4
* cell instance $18403 r0 *1 76,91
X$18403 77 3498 109 6896 BUF_X8
* cell instance $18404 r0 *1 78.47,91
X$18404 77 6452 109 6896 BUF_X8
* cell instance $18405 r0 *1 80.94,91
X$18405 7291 109 4509 77 BUF_X4
* cell instance $18407 r0 *1 82.46,91
X$18407 2493 6091 2726 77 109 7079 MUX2_X1
* cell instance $18408 m0 *1 83.41,91
X$18408 5738 6843 77 109 6728 NAND2_X1
* cell instance $18409 m0 *1 82.84,91
X$18409 6540 5887 77 109 7078 NOR2_X1
* cell instance $18414 r0 *1 83.98,91
X$18414 5462 6890 7080 109 7011 77 OAI21_X1
* cell instance $18415 r0 *1 84.74,91
X$18415 77 5540 7081 7161 7011 1663 109 DFFR_X1
* cell instance $18417 m0 *1 89.11,91
X$18417 6844 6174 7012 77 109 6846 MUX2_X1
* cell instance $18422 r0 *1 89.68,91
X$18422 77 6455 7163 7015 7013 1663 109 DFFR_X1
* cell instance $18424 m0 *1 91.58,91
X$18424 6302 6823 7014 109 7013 77 OAI21_X1
* cell instance $18426 m0 *1 94.05,91
X$18426 6455 77 109 19256 CLKBUF_X1
* cell instance $18427 m0 *1 94.62,91
X$18427 5462 6730 6731 109 6897 77 OAI21_X1
* cell instance $18429 m0 *1 95.57,91
X$18429 6671 77 109 6455 CLKBUF_X3
* cell instance $18431 m0 *1 96.71,91
X$18431 5592 6730 6898 109 6732 77 OAI21_X1
* cell instance $18432 m0 *1 97.47,91
X$18432 6730 6854 77 109 6898 NAND2_X1
* cell instance $18435 r0 *1 93.48,91
X$18435 6823 7015 77 109 7014 NAND2_X1
* cell instance $18436 r0 *1 94.05,91
X$18436 77 6455 7082 6851 6897 1663 109 DFFR_X1
* cell instance $18439 r0 *1 98.8,91
X$18439 6733 4914 6899 77 109 7085 MUX2_X1
* cell instance $18440 r0 *1 100.13,91
X$18440 6733 5039 6899 77 109 7166 MUX2_X1
* cell instance $18441 r0 *1 101.46,91
X$18441 77 5870 5847 5186 7016 109 AOI21_X4
* cell instance $18442 m0 *1 101.65,91
X$18442 77 6900 6733 6861 6735 1663 109 DFFR_X1
* cell instance $18445 m0 *1 106.21,91
X$18445 6737 7020 6666 77 6272 109 NAND3_X4
* cell instance $18446 m0 *1 108.68,91
X$18446 3296 6925 6182 109 77 7023 MUX2_X2
* cell instance $18447 m0 *1 110.39,91
X$18447 77 6896 109 7024 BUF_X8
* cell instance $18448 m0 *1 112.86,91
X$18448 77 6726 109 6130 BUF_X8
* cell instance $18450 r0 *1 103.93,91
X$18450 5415 109 6902 77 BUF_X4
* cell instance $18452 r0 *1 105.45,91
X$18452 7019 109 7168 77 BUF_X4
* cell instance $18454 r0 *1 107.16,91
X$18454 7021 109 6901 77 BUF_X4
* cell instance $18455 r0 *1 108.49,91
X$18455 77 7022 109 6318 BUF_X8
* cell instance $18456 r0 *1 110.96,91
X$18456 77 6904 7019 7025 6739 109 DFF_X1
* cell instance $18457 r0 *1 114.19,91
X$18457 7026 4462 2756 77 109 7025 MUX2_X1
* cell instance $18461 r0 *1 115.52,91
X$18461 6904 77 109 7088 INV_X1
* cell instance $18463 m0 *1 115.71,91
X$18463 6904 6464 6726 77 109 6864 MUX2_X1
* cell instance $18465 m0 *1 119.32,91
X$18465 6145 3813 1993 77 109 7214 MUX2_X1
* cell instance $18467 m0 *1 120.84,91
X$18467 6868 6141 6902 7031 7032 109 77 AOI211_X2
* cell instance $18468 m0 *1 122.55,91
X$18468 6049 5997 6742 77 109 6598 NAND3_X1
* cell instance $18469 m0 *1 123.31,91
X$18469 6906 77 109 6743 BUF_X2
* cell instance $18470 m0 *1 124.07,91
X$18470 6905 5706 6596 77 109 NOR2_X4
* cell instance $18472 r0 *1 115.9,91
X$18472 7088 6464 7022 77 109 7030 MUX2_X1
* cell instance $18475 r0 *1 118.18,91
X$18475 7173 6741 6319 7028 77 109 6560 AOI22_X1
* cell instance $18476 r0 *1 119.13,91
X$18476 6741 7030 7029 6319 77 109 6423 AOI22_X2
* cell instance $18479 r0 *1 121.22,91
X$18479 6906 77 109 6905 BUF_X1
* cell instance $18480 r0 *1 121.79,91
X$18480 5898 77 109 6906 BUF_X2
* cell instance $18481 r0 *1 122.55,91
X$18481 6872 7032 7090 109 77 6914 OAI21_X4
* cell instance $18482 r0 *1 125.02,91
X$18482 6740 77 109 6907 INV_X1
* cell instance $18483 r0 *1 125.4,91
X$18483 6188 6277 6907 77 109 7034 NAND3_X1
* cell instance $18484 m0 *1 128.25,91
X$18484 77 6049 6146 6277 5997 6909 109 NAND4_X4
* cell instance $18485 m0 *1 126.16,91
X$18485 6144 6312 6596 7034 6436 6873 77 109 OAI221_X2
* cell instance $18486 m0 *1 131.67,91
X$18486 6315 6188 6596 109 77 7035 MUX2_X2
* cell instance $18487 m0 *1 133.38,91
X$18487 77 6909 6864 7038 5488 6473 109 OAI22_X4
* cell instance $18488 m0 *1 136.61,91
X$18488 5996 6872 77 6473 109 NAND2_X4
* cell instance $18489 m0 *1 138.32,91
X$18489 77 6191 6912 6746 6913 109 NOR3_X4
* cell instance $18490 m0 *1 140.98,91
X$18490 6914 6912 6746 109 77 4300 OAI21_X2
* cell instance $18491 m0 *1 142.31,91
X$18491 5479 7044 4750 77 109 7164 NOR3_X1
* cell instance $18492 m0 *1 143.07,91
X$18492 7043 109 4758 77 BUF_X4
* cell instance $18493 m0 *1 144.4,91
X$18493 6917 6434 77 6859 109 NAND2_X4
* cell instance $18494 m0 *1 146.11,91
X$18494 6918 6434 6917 77 6852 109 AOI21_X2
* cell instance $18496 m0 *1 147.63,91
X$18496 6319 6693 77 4480 109 NAND2_X4
* cell instance $18497 m0 *1 149.34,91
X$18497 6753 6920 6921 77 109 6750 MUX2_X1
* cell instance $18498 m0 *1 150.67,91
X$18498 77 6920 109 6914 BUF_X8
* cell instance $18499 m0 *1 153.14,91
X$18499 7053 6319 77 109 6690 NAND2_X1
* cell instance $18501 r0 *1 126.16,91
X$18501 6469 109 5896 77 BUF_X4
* cell instance $18502 r0 *1 127.49,91
X$18502 6743 5706 6144 109 6908 77 NOR3_X2
* cell instance $18503 r0 *1 128.82,91
X$18503 7091 7174 77 109 7092 NAND2_X1
* cell instance $18504 r0 *1 129.39,91
X$18504 77 6911 7093 5997 6049 109 AOI21_X4
* cell instance $18506 r0 *1 132.05,91
X$18506 6464 6908 6600 109 77 7172 OAI21_X2
* cell instance $18508 r0 *1 133.57,91
X$18508 7171 6909 6697 6911 6563 6910 77 109 OAI221_X2
* cell instance $18509 r0 *1 135.66,91
X$18509 6563 6911 6697 109 77 4749 OAI21_X2
* cell instance $18511 r0 *1 137.37,91
X$18511 77 6917 7095 7041 5996 109 AOI21_X4
* cell instance $18512 r0 *1 139.84,91
X$18512 6915 6913 7310 77 109 NOR2_X4
* cell instance $18513 r0 *1 141.55,91
X$18513 6916 6191 109 77 7042 AND2_X1
* cell instance $18514 r0 *1 142.31,91
X$18514 7042 77 109 6915 CLKBUF_X3
* cell instance $18515 r0 *1 143.26,91
X$18515 6191 6916 77 109 7050 NAND2_X2
* cell instance $18516 r0 *1 144.21,91
X$18516 6917 6434 5713 77 109 7099 NAND3_X2
* cell instance $18517 r0 *1 145.54,91
X$18517 5860 5193 77 109 7043 NAND2_X1
* cell instance $18518 r0 *1 146.11,91
X$18518 6918 109 6923 77 BUF_X4
* cell instance $18519 r0 *1 147.44,91
X$18519 5714 6004 77 109 6010 OR2_X2
* cell instance $18520 r0 *1 148.39,91
X$18520 6752 7099 7050 77 7101 109 AOI21_X1
* cell instance $18521 r0 *1 149.15,91
X$18521 7102 7048 6919 109 7049 77 OAI21_X1
* cell instance $18522 r0 *1 149.91,91
X$18522 6472 6751 5552 77 109 6919 NOR3_X1
* cell instance $18523 r0 *1 150.67,91
X$18523 6914 77 109 6918 INV_X1
* cell instance $18525 r0 *1 151.24,91
X$18525 7103 3882 7105 77 109 7300 MUX2_X1
* cell instance $18527 r0 *1 152.76,91
X$18527 6921 6920 7107 77 109 7106 MUX2_X1
* cell instance $18528 r0 *1 154.09,91
X$18528 6921 6915 6913 77 109 7157 NOR3_X1
* cell instance $18529 m0 *1 154.85,91
X$18529 6923 6753 77 109 7051 OR2_X1
* cell instance $18530 m0 *1 154.09,91
X$18530 6920 6752 7051 109 6922 77 OAI21_X1
* cell instance $18531 m0 *1 155.61,91
X$18531 6146 3916 77 109 6688 NAND2_X1
* cell instance $18532 m0 *1 156.18,91
X$18532 6146 6145 77 109 6850 NAND2_X1
* cell instance $18534 m0 *1 156.94,91
X$18534 4240 6763 19036 109 77 7045 HA_X1
* cell instance $18535 m0 *1 158.84,91
X$18535 6923 109 3882 77 BUF_X4
* cell instance $18536 m0 *1 160.17,91
X$18536 6845 4523 77 109 6552 NAND2_X1
* cell instance $18539 m0 *1 163.97,91
X$18539 6478 77 109 6756 INV_X1
* cell instance $18540 m0 *1 164.35,91
X$18540 6326 77 109 6757 INV_X1
* cell instance $18542 m0 *1 164.92,91
X$18542 6758 6926 6929 77 109 6753 MUX2_X1
* cell instance $18543 m0 *1 166.25,91
X$18543 6759 7039 77 109 6925 NOR2_X2
* cell instance $18544 m0 *1 167.2,91
X$18544 77 6329 6760 2750 1924 7036 109 OAI22_X4
* cell instance $18545 m0 *1 170.43,91
X$18545 6392 6926 6927 77 109 6921 MUX2_X1
* cell instance $18546 m0 *1 171.76,91
X$18546 6663 77 109 6929 INV_X2
* cell instance $18547 m0 *1 172.33,91
X$18547 6761 77 109 6604 BUF_X2
* cell instance $18548 m0 *1 173.09,91
X$18548 6198 6929 6604 77 109 6829 MUX2_X1
* cell instance $18549 m0 *1 174.42,91
X$18549 6931 6763 6749 77 109 6832 MUX2_X1
* cell instance $18550 m0 *1 175.75,91
X$18550 77 6329 109 6659 BUF_X8
* cell instance $18551 m0 *1 178.22,91
X$18551 6066 5708 6325 6765 5626 6767 77 109 OAI221_X2
* cell instance $18552 m0 *1 180.31,91
X$18552 77 6200 109 6831 BUF_X8
* cell instance $18553 m0 *1 182.78,91
X$18553 7017 6659 77 109 7018 NOR2_X1
* cell instance $18554 m0 *1 183.35,91
X$18554 6933 6325 5626 6066 4471 109 77 6819 OAI221_X1
* cell instance $18555 m0 *1 184.49,91
X$18555 6934 6325 6936 6066 5760 109 77 6814 OAI221_X1
* cell instance $18556 m0 *1 185.63,91
X$18556 6608 5369 6768 5086 109 77 6938 OAI22_X1
* cell instance $18557 m0 *1 186.58,91
X$18557 77 6245 6769 1146 18909 2908 109 DFFR_X2
* cell instance $18558 m0 *1 190.76,91
X$18558 1893 6770 6771 109 4031 77 OAI21_X1
* cell instance $18560 m0 *1 191.71,91
X$18560 77 6945 18643 6942 7004 1146 109 DFFR_X1
* cell instance $18562 m0 *1 196.27,91
X$18562 1893 5384 6944 109 6811 77 OAI21_X1
* cell instance $18563 m0 *1 197.03,91
X$18563 6485 7380 6767 109 6072 77 OAI21_X1
* cell instance $18564 m0 *1 197.79,91
X$18564 6943 6336 77 109 6774 NAND2_X1
* cell instance $18566 r0 *1 154.85,91
X$18566 6922 6924 7310 109 77 7047 MUX2_X2
* cell instance $18567 r0 *1 156.56,91
X$18567 3882 7107 7046 109 6924 77 OAI21_X1
* cell instance $18568 r0 *1 157.32,91
X$18568 6920 6921 77 109 7046 OR2_X1
* cell instance $18569 r0 *1 158.08,91
X$18569 6474 6473 77 109 6685 NOR2_X1
* cell instance $18570 r0 *1 158.65,91
X$18570 6926 6605 77 109 7108 NOR2_X1
* cell instance $18572 r0 *1 159.6,91
X$18572 6910 109 4363 77 BUF_X4
* cell instance $18573 r0 *1 160.93,91
X$18573 6762 6926 6396 77 109 7154 MUX2_X1
* cell instance $18578 r0 *1 165.11,91
X$18578 7036 77 109 6758 INV_X2
* cell instance $18579 r0 *1 165.68,91
X$18579 6326 7233 6197 77 109 7110 MUX2_X1
* cell instance $18580 r0 *1 167.01,91
X$18580 2750 6755 77 109 6759 NOR2_X1
* cell instance $18581 r0 *1 167.58,91
X$18581 4363 7149 7037 109 77 7148 HA_X1
* cell instance $18582 r0 *1 169.48,91
X$18582 77 6329 7111 2523 1860 7234 109 OAI22_X4
* cell instance $18586 r0 *1 172.71,91
X$18586 77 6329 7033 3574 1867 7112 109 OAI22_X4
* cell instance $18587 r0 *1 175.94,91
X$18587 6764 6930 6931 77 109 7027 MUX2_X1
* cell instance $18588 r0 *1 177.27,91
X$18588 77 6831 7027 2299 631 7113 109 OAI22_X4
* cell instance $18589 r0 *1 180.5,91
X$18589 6766 6325 5626 6066 4249 109 77 6939 OAI221_X1
* cell instance $18590 r0 *1 181.64,91
X$18590 6749 6932 6761 77 109 7017 MUX2_X1
* cell instance $18591 r0 *1 182.97,91
X$18591 6325 109 5492 77 BUF_X4
* cell instance $18592 r0 *1 184.3,91
X$18592 7115 6325 6936 6937 4472 109 77 6935 OAI221_X1
* cell instance $18593 r0 *1 185.44,91
X$18593 7143 6325 6936 6937 4302 109 77 7008 OAI221_X1
* cell instance $18594 r0 *1 186.58,91
X$18594 5626 109 6936 77 BUF_X4
* cell instance $18595 r0 *1 187.91,91
X$18595 5625 77 109 5621 CLKBUF_X3
* cell instance $18596 r0 *1 188.86,91
X$18596 5626 7010 6939 109 5972 77 OAI21_X1
* cell instance $18597 r0 *1 189.62,91
X$18597 5625 77 109 6941 CLKBUF_X3
* cell instance $18599 r0 *1 190.95,91
X$18599 7008 7275 6941 6382 77 109 6771 NAND4_X1
* cell instance $18601 r0 *1 192.66,91
X$18601 6814 7274 6941 6382 77 109 7117 NAND4_X1
* cell instance $18603 r0 *1 194.37,91
X$18603 3741 5095 6942 77 109 7004 MUX2_X1
* cell instance $18606 r0 *1 196.27,91
X$18606 6943 5385 6942 5629 77 109 6944 AOI22_X1
* cell instance $18607 r0 *1 197.22,91
X$18607 5629 109 4548 77 BUF_X4
* cell instance $18608 r0 *1 198.55,91
X$18608 7002 4944 77 109 6809 NAND2_X1
* cell instance $18610 m0 *1 198.74,91
X$18610 77 6945 6775 992 18911 3736 109 DFFR_X2
* cell instance $18613 r0 *1 199.69,91
X$18613 5629 109 6492 77 BUF_X4
* cell instance $18614 r0 *1 201.02,91
X$18614 3326 5090 6995 77 109 7139 MUX2_X1
* cell instance $18615 r0 *1 202.35,91
X$18615 6991 5625 6995 5629 77 109 6994 AOI22_X1
* cell instance $18616 m0 *1 204.63,91
X$18616 77 6075 6805 3676 18917 3555 109 DFFR_X2
* cell instance $18617 m0 *1 203.3,91
X$18617 5629 109 5228 77 BUF_X4
* cell instance $18620 r0 *1 203.3,91
X$18620 3326 5212 7137 77 109 7136 MUX2_X1
* cell instance $18622 r0 *1 205.39,91
X$18622 6991 6336 77 109 6992 NAND2_X1
* cell instance $18625 r0 *1 207.1,91
X$18625 3555 6102 6073 3326 77 109 7404 AOI22_X2
* cell instance $18628 r0 *1 209.76,91
X$18628 6987 6336 77 109 6777 NAND2_X1
* cell instance $18629 r0 *1 210.33,91
X$18629 3724 6102 3666 6073 77 109 6970 AOI22_X1
* cell instance $18630 m0 *1 210.9,91
X$18630 6778 4944 77 109 6800 NAND2_X1
* cell instance $18632 m0 *1 211.47,91
X$18632 6982 77 109 6981 INV_X1
* cell instance $18634 m0 *1 212.61,91
X$18634 77 6946 6779 3676 18913 3303 109 DFFR_X2
* cell instance $18637 r0 *1 211.66,91
X$18637 77 6946 6981 3676 19020 2885 109 DFFR_X2
* cell instance $18638 r0 *1 215.84,91
X$18638 77 6946 18724 7118 6974 3676 109 DFFR_X1
* cell instance $18640 m0 *1 217.17,91
X$18640 3303 6102 4379 6073 77 109 6973 AOI22_X1
* cell instance $18641 m0 *1 218.88,91
X$18641 6976 5498 77 109 6780 NAND2_X1
* cell instance $18644 m0 *1 227.05,91
X$18644 6947 5498 77 109 6967 NAND2_X1
* cell instance $18645 m0 *1 227.62,91
X$18645 503 5372 6967 5374 6782 109 77 6781 OAI221_X1
* cell instance $18646 m0 *1 228.76,91
X$18646 77 6500 18645 6785 6963 992 109 DFFR_X1
* cell instance $18648 r0 *1 219.64,91
X$18648 6078 5095 7118 77 109 6974 MUX2_X1
* cell instance $18652 r0 *1 222.3,91
X$18652 4861 5920 6973 109 7132 77 OAI21_X1
* cell instance $18653 r0 *1 223.06,91
X$18653 4715 5920 6970 109 7131 77 OAI21_X1
* cell instance $18654 r0 *1 223.82,91
X$18654 77 6500 4861 7248 7260 992 109 DFFR_X1
* cell instance $18658 r0 *1 227.62,91
X$18658 6966 5498 77 109 6783 NAND2_X1
* cell instance $18663 r0 *1 231.04,91
X$18663 2695 5237 6078 4573 77 109 6961 AOI22_X1
* cell instance $18666 r0 *1 232.56,91
X$18666 6785 5237 6792 4573 77 109 6948 AOI22_X1
* cell instance $18667 m0 *1 233.89,91
X$18667 4573 6786 77 109 7127 NAND2_X1
* cell instance $18668 m0 *1 232.94,91
X$18668 6947 5385 6951 5228 77 109 6790 AOI22_X1
* cell instance $18669 m0 *1 234.46,91
X$18669 6786 6496 6951 77 109 6954 MUX2_X1
* cell instance $18670 m0 *1 235.79,91
X$18670 77 6210 18690 6951 6954 992 109 DFFR_X1
* cell instance $18673 r0 *1 234.27,91
X$18673 503 5384 6790 109 6950 77 OAI21_X1
* cell instance $18675 r0 *1 235.22,91
X$18675 503 5233 6953 109 7120 77 OAI21_X1
* cell instance $18676 r0 *1 235.98,91
X$18676 6787 77 109 6225 BUF_X1
* cell instance $18678 r0 *1 236.74,91
X$18678 4960 7121 77 109 6953 NAND2_X1
* cell instance $18680 r0 *1 237.69,91
X$18680 6210 77 109 19272 CLKBUF_X1
* cell instance $18681 r0 *1 238.26,91
X$18681 6952 77 109 6210 CLKBUF_X3
* cell instance $18685 r0 *1 150.1,1.4
X$18685 77 98 18884 132 78 102 109 DFFR_X1
* cell instance $18691 m0 *1 5.32,88.2
X$18691 6439 6701 6281 77 109 6620 MUX2_X1
* cell instance $18700 r0 *1 3.42,88.2
X$18700 4193 6876 6700 77 109 6788 MUX2_X1
* cell instance $18702 r0 *1 4.94,88.2
X$18702 6702 6701 6703 77 109 6791 MUX2_X1
* cell instance $18703 r0 *1 6.27,88.2
X$18703 6791 6014 6620 77 109 6705 MUX2_X1
* cell instance $18704 m0 *1 7.22,88.2
X$18704 77 6153 6706 6621 6505 2157 109 DFFR_X1
* cell instance $18711 r0 *1 10.07,88.2
X$18711 6706 5506 6282 77 109 6707 MUX2_X1
* cell instance $18712 r0 *1 11.4,88.2
X$18712 6706 3603 6282 77 109 6709 MUX2_X1
* cell instance $18714 m0 *1 18.24,88.2
X$18714 6571 4065 6572 77 109 6624 MUX2_X1
* cell instance $18715 m0 *1 14.44,88.2
X$18715 77 6153 6625 6571 6624 2157 109 DFFR_X1
* cell instance $18718 m0 *1 20.52,88.2
X$18718 6440 6627 6157 77 109 6629 MUX2_X1
* cell instance $18721 m0 *1 22.8,88.2
X$18721 6626 6091 6629 77 109 6631 MUX2_X1
* cell instance $18722 m0 *1 24.13,88.2
X$18722 77 5722 6573 6514 6512 2157 109 DFFR_X1
* cell instance $18726 r0 *1 16.53,88.2
X$18726 77 6710 6711 6712 6796 2157 109 DFFR_X1
* cell instance $18727 r0 *1 20.33,88.2
X$18727 6712 3786 6572 77 109 6796 MUX2_X1
* cell instance $18729 r0 *1 24.7,88.2
X$18729 6632 5661 6573 77 109 6802 MUX2_X1
* cell instance $18730 r0 *1 26.03,88.2
X$18730 6632 6290 6573 77 109 6714 MUX2_X1
* cell instance $18731 r0 *1 27.36,88.2
X$18731 6802 6017 6715 77 109 6574 MUX2_X1
* cell instance $18732 r0 *1 28.69,88.2
X$18732 6574 5818 6515 77 109 6808 MUX2_X1
* cell instance $18733 m0 *1 30.02,88.2
X$18733 77 5722 6632 6575 6804 2157 109 DFFR_X1
* cell instance $18739 r0 *1 32.3,88.2
X$18739 77 4773 5661 109 BUF_X16
* cell instance $18741 m0 *1 34.96,88.2
X$18741 6363 6017 6635 77 109 6633 MUX2_X1
* cell instance $18742 m0 *1 37.05,88.2
X$18742 6441 5522 6026 77 109 6635 MUX2_X1
* cell instance $18743 m0 *1 38.38,88.2
X$18743 6883 77 109 6163 BUF_X2
* cell instance $18744 m0 *1 39.14,88.2
X$18744 77 6443 6441 6577 6639 4909 109 DFFR_X1
* cell instance $18745 m0 *1 42.94,88.2
X$18745 6577 6578 6163 77 109 6639 MUX2_X1
* cell instance $18746 m0 *1 44.27,88.2
X$18746 6234 109 4768 77 BUF_X4
* cell instance $18747 m0 *1 45.6,88.2
X$18747 6578 109 4126 77 BUF_X4
* cell instance $18749 r0 *1 37.05,88.2
X$18749 6807 6808 5959 109 77 6965 MUX2_X2
* cell instance $18752 r0 *1 41.04,88.2
X$18752 5728 109 6701 77 BUF_X4
* cell instance $18755 r0 *1 43.32,88.2
X$18755 6719 109 6546 77 BUF_X4
* cell instance $18756 r0 *1 44.65,88.2
X$18756 3054 5850 109 77 6578 AND2_X1
* cell instance $18757 r0 *1 45.41,88.2
X$18757 77 6443 7068 6813 6579 4909 109 DFFR_X1
* cell instance $18758 m0 *1 48.64,88.2
X$18758 6645 77 109 6443 CLKBUF_X3
* cell instance $18759 m0 *1 47.31,88.2
X$18759 6644 109 4843 77 BUF_X4
* cell instance $18760 m0 *1 49.59,88.2
X$18760 3788 5738 6580 109 6579 77 OAI21_X1
* cell instance $18762 m0 *1 50.54,88.2
X$18762 3788 6262 6646 109 6647 77 OAI21_X1
* cell instance $18763 m0 *1 51.3,88.2
X$18763 3788 6127 6649 109 6643 77 OAI21_X1
* cell instance $18765 m0 *1 52.25,88.2
X$18765 77 6443 6581 6650 6526 4909 109 DFFR_X1
* cell instance $18766 m0 *1 56.05,88.2
X$18766 6234 109 6820 77 BUF_X4
* cell instance $18768 m0 *1 57.57,88.2
X$18768 6295 6652 77 109 6653 NAND2_X1
* cell instance $18769 m0 *1 58.14,88.2
X$18769 6127 6582 77 109 6583 NAND2_X1
* cell instance $18770 m0 *1 58.71,88.2
X$18770 77 6660 6653 6529 6654 109 AOI21_X4
* cell instance $18771 m0 *1 61.18,88.2
X$18771 5725 109 4505 77 BUF_X4
* cell instance $18774 r0 *1 49.4,88.2
X$18774 6833 6813 77 109 6580 NAND2_X1
* cell instance $18775 r0 *1 49.97,88.2
X$18775 5850 2795 109 77 6292 AND2_X1
* cell instance $18776 r0 *1 50.73,88.2
X$18776 6293 3054 77 6816 109 NAND2_X4
* cell instance $18777 r0 *1 52.44,88.2
X$18777 6720 6815 77 109 6646 NAND2_X1
* cell instance $18778 r0 *1 53.01,88.2
X$18778 6443 77 109 19117 INV_X2
* cell instance $18781 r0 *1 55.48,88.2
X$18781 5181 6298 109 77 6718 AND2_X1
* cell instance $18782 r0 *1 56.24,88.2
X$18782 6159 109 3794 77 BUF_X4
* cell instance $18785 r0 *1 58.52,88.2
X$18785 6159 109 3709 77 BUF_X4
* cell instance $18789 r0 *1 59.85,88.2
X$18789 5875 6823 6822 109 6989 77 OAI21_X1
* cell instance $18790 r0 *1 60.61,88.2
X$18790 77 6894 6824 6582 6828 4909 109 DFFR_X1
* cell instance $18791 m0 *1 64.22,88.2
X$18791 6533 77 109 6655 INV_X1
* cell instance $18792 m0 *1 62.89,88.2
X$18792 6287 109 3903 77 BUF_X4
* cell instance $18793 m0 *1 64.6,88.2
X$18793 4780 6534 77 109 6657 NAND2_X1
* cell instance $18794 m0 *1 65.17,88.2
X$18794 2945 6042 2797 109 77 6644 AND3_X1
* cell instance $18795 m0 *1 66.12,88.2
X$18795 6446 6127 6661 109 77 6662 OAI21_X2
* cell instance $18796 m0 *1 67.45,88.2
X$18796 6034 3054 77 5656 109 NAND2_X4
* cell instance $18797 m0 *1 69.16,88.2
X$18797 4593 6294 77 109 6447 NAND2_X1
* cell instance $18799 m0 *1 69.92,88.2
X$18799 77 6170 6664 6535 6662 1663 109 DFFR_X1
* cell instance $18800 m0 *1 73.72,88.2
X$18800 5962 77 109 6170 CLKBUF_X3
* cell instance $18801 m0 *1 74.67,88.2
X$18801 6400 3903 6399 109 77 6450 OAI21_X4
* cell instance $18803 r0 *1 64.41,88.2
X$18803 3710 6127 6583 109 6828 77 OAI21_X1
* cell instance $18805 r0 *1 65.36,88.2
X$18805 6716 77 109 4780 CLKBUF_X3
* cell instance $18807 r0 *1 66.5,88.2
X$18807 5950 2945 2797 77 6723 109 NAND3_X4
* cell instance $18808 r0 *1 68.97,88.2
X$18808 2797 2945 6030 77 6720 109 NAND3_X4
* cell instance $18809 r0 *1 71.44,88.2
X$18809 6042 2945 2797 77 6833 109 NAND3_X4
* cell instance $18811 r0 *1 74.67,88.2
X$18811 3498 109 6584 77 BUF_X4
* cell instance $18812 r0 *1 76,88.2
X$18812 6835 6451 6834 77 109 6837 MUX2_X1
* cell instance $18813 r0 *1 77.33,88.2
X$18813 6668 3906 6838 77 109 6839 MUX2_X1
* cell instance $18814 m0 *1 78.28,88.2
X$18814 2379 6452 2611 77 109 6587 MUX2_X1
* cell instance $18815 m0 *1 77.52,88.2
X$18815 5967 5736 6666 77 6727 109 AOI21_X1
* cell instance $18816 m0 *1 79.61,88.2
X$18816 6587 6586 6453 77 109 6667 MUX2_X1
* cell instance $18817 m0 *1 80.94,88.2
X$18817 6404 6452 6539 77 109 6668 MUX2_X1
* cell instance $18819 r0 *1 78.66,88.2
X$18819 6835 6452 6834 77 109 6838 MUX2_X1
* cell instance $18820 r0 *1 79.99,88.2
X$18820 6833 109 5738 77 BUF_X4
* cell instance $18821 r0 *1 81.32,88.2
X$18821 7077 5884 5455 6667 77 109 6842 AOI22_X1
* cell instance $18822 r0 *1 82.27,88.2
X$18822 77 5540 6589 6843 6588 1663 109 DFFR_X1
* cell instance $18823 m0 *1 82.84,88.2
X$18823 6302 5738 6728 109 6588 77 OAI21_X1
* cell instance $18825 m0 *1 83.6,88.2
X$18825 6542 5887 77 109 6670 NOR2_X1
* cell instance $18828 m0 *1 85.88,88.2
X$18828 6589 6591 6544 77 109 6590 MUX2_X1
* cell instance $18831 m0 *1 88.16,88.2
X$18831 6454 6591 6676 77 109 6673 MUX2_X1
* cell instance $18833 m0 *1 90.25,88.2
X$18833 77 6455 6676 6677 6848 1663 109 DFFR_X1
* cell instance $18835 r0 *1 86.07,88.2
X$18835 6589 5740 6544 77 109 6844 MUX2_X1
* cell instance $18836 r0 *1 87.4,88.2
X$18836 6590 5729 6673 77 109 6729 MUX2_X1
* cell instance $18837 r0 *1 88.73,88.2
X$18837 6454 5740 6676 77 109 7012 MUX2_X1
* cell instance $18840 r0 *1 91.77,88.2
X$18840 6302 6177 6849 109 6848 77 OAI21_X1
* cell instance $18842 r0 *1 92.91,88.2
X$18842 6177 6677 77 109 6849 NAND2_X1
* cell instance $18845 m0 *1 94.43,88.2
X$18845 77 6455 6678 6458 6592 1663 109 DFFR_X1
* cell instance $18848 r0 *1 95.57,88.2
X$18848 6730 6851 77 109 6731 NAND2_X1
* cell instance $18850 r0 *1 96.9,88.2
X$18850 77 6455 6899 6854 6732 1663 109 DFFR_X1
* cell instance $18852 m0 *1 98.61,88.2
X$18852 77 6455 6858 6682 6679 1663 109 DFFR_X1
* cell instance $18853 m0 *1 102.6,88.2
X$18853 77 6459 6007 109 BUF_X16
* cell instance $18854 m0 *1 107.35,88.2
X$18854 6675 6687 5186 109 6415 77 OAI21_X1
* cell instance $18855 m0 *1 108.11,88.2
X$18855 6652 4462 3305 77 109 6689 MUX2_X1
* cell instance $18856 m0 *1 109.44,88.2
X$18856 4017 6182 77 109 6594 NOR2_X2
* cell instance $18858 m0 *1 110.58,88.2
X$18858 6372 4462 3458 77 109 6691 MUX2_X1
* cell instance $18859 m0 *1 111.91,88.2
X$18859 3998 77 109 6135 CLKBUF_X3
* cell instance $18861 r0 *1 100.7,88.2
X$18861 4780 6682 77 109 6462 NAND2_X1
* cell instance $18864 r0 *1 102.22,88.2
X$18864 4327 6823 6736 109 6735 77 OAI21_X1
* cell instance $18865 r0 *1 102.98,88.2
X$18865 6823 6861 77 109 6736 NAND2_X1
* cell instance $18868 r0 *1 105.26,88.2
X$18868 77 6689 6135 6737 7021 109 DFF_X2
* cell instance $18870 r0 *1 109.25,88.2
X$18870 77 6862 7024 6691 6135 109 DFF_X1
* cell instance $18872 r0 *1 112.67,88.2
X$18872 77 18481 6595 6429 6135 109 DFF_X1
* cell instance $18873 m0 *1 113.43,88.2
X$18873 77 6593 6174 109 BUF_X16
* cell instance $18876 m0 *1 118.37,88.2
X$18876 6693 77 109 6599 INV_X4
* cell instance $18877 m0 *1 119.32,88.2
X$18877 6867 109 6466 77 BUF_X4
* cell instance $18878 m0 *1 120.65,88.2
X$18878 6186 6596 6694 77 109 6562 MUX2_X1
* cell instance $18879 m0 *1 121.98,88.2
X$18879 6596 6186 6598 109 6597 77 OAI21_X1
* cell instance $18881 m0 *1 122.93,88.2
X$18881 5897 5553 77 109 6557 NAND2_X2
* cell instance $18882 m0 *1 123.88,88.2
X$18882 6597 6277 6557 6189 4346 6565 109 77 AOI221_X2
* cell instance $18883 m0 *1 125.97,88.2
X$18883 6277 6743 5706 109 77 6190 OAI21_X2
* cell instance $18885 m0 *1 127.49,88.2
X$18885 6148 6740 6049 5997 6600 109 77 AOI211_X2
* cell instance $18887 m0 *1 129.39,88.2
X$18887 6596 6316 5996 6188 6600 5765 109 77 AOI221_X2
* cell instance $18888 m0 *1 131.48,88.2
X$18888 4345 109 4170 77 BUF_X4
* cell instance $18889 m0 *1 132.81,88.2
X$18889 6146 6464 6699 77 109 6697 NAND3_X2
* cell instance $18890 m0 *1 134.14,88.2
X$18890 5430 6191 6744 4752 5433 5558 77 109 6601 OAI33_X1
* cell instance $18891 m0 *1 135.47,88.2
X$18891 6698 6272 77 109 6568 OR2_X1
* cell instance $18892 m0 *1 136.23,88.2
X$18892 77 5560 6470 6052 6696 109 NOR3_X4
* cell instance $18893 m0 *1 138.89,88.2
X$18893 6052 6470 5560 77 109 6471 OR3_X4
* cell instance $18894 m0 *1 140.98,88.2
X$18894 6747 6695 5481 5430 109 77 5755 OAI22_X2
* cell instance $18895 m0 *1 142.69,88.2
X$18895 5194 109 5714 77 BUF_X4
* cell instance $18896 m0 *1 144.02,88.2
X$18896 5563 5896 77 109 5860 NAND2_X2
* cell instance $18897 m0 *1 144.97,88.2
X$18897 4890 5297 4300 4237 4240 7098 77 109 OAI221_X2
* cell instance $18898 m0 *1 147.06,88.2
X$18898 77 6692 5892 6853 2525 5987 109 NOR4_X4
* cell instance $18903 r0 *1 115.9,88.2
X$18903 6699 3813 1971 77 109 6738 MUX2_X1
* cell instance $18904 r0 *1 117.23,88.2
X$18904 77 6865 6739 6740 6867 109 DFF_X2
* cell instance $18907 r0 *1 121.22,88.2
X$18907 6464 6277 6436 77 109 6868 NAND3_X1
* cell instance $18908 r0 *1 121.98,88.2
X$18908 6871 5706 6148 6557 109 6741 77 NOR4_X2
* cell instance $18909 r0 *1 123.69,88.2
X$18909 6743 5706 6872 109 7031 77 OAI21_X1
* cell instance $18910 r0 *1 124.45,88.2
X$18910 6278 77 109 6871 BUF_X1
* cell instance $18911 r0 *1 125.02,88.2
X$18911 77 6312 6148 6049 5997 109 AOI21_X4
* cell instance $18912 r0 *1 127.49,88.2
X$18912 6188 6600 5996 6466 6190 6874 109 77 AOI221_X2
* cell instance $18913 r0 *1 129.58,88.2
X$18913 77 6315 6188 6475 6049 5997 109 AOI22_X4
* cell instance $18914 r0 *1 132.81,88.2
X$18914 6908 6188 6600 77 6870 109 AOI21_X1
* cell instance $18915 r0 *1 133.57,88.2
X$18915 5193 5990 6272 77 6749 109 NAND3_X4
* cell instance $18916 r0 *1 136.04,88.2
X$18916 6872 6869 6436 109 77 5766 OAI21_X4
* cell instance $18917 r0 *1 138.51,88.2
X$18917 6862 5194 5712 77 109 7040 OR3_X1
* cell instance $18918 r0 *1 139.46,88.2
X$18918 6745 6004 6748 6866 77 109 6860 NOR4_X1
* cell instance $18919 r0 *1 140.41,88.2
X$18919 5481 6747 6863 77 109 6425 NAND3_X2
* cell instance $18920 r0 *1 141.74,88.2
X$18920 6473 6599 4358 77 109 NOR2_X4
* cell instance $18921 r0 *1 143.45,88.2
X$18921 6737 5895 7043 77 109 6840 OR3_X1
* cell instance $18922 r0 *1 144.4,88.2
X$18922 6695 5481 77 109 6421 NAND2_X1
* cell instance $18923 r0 *1 144.97,88.2
X$18923 6859 5552 6916 109 77 6055 HA_X1
* cell instance $18925 r0 *1 147.06,88.2
X$18925 6857 6856 6855 5193 5860 6853 109 77 AOI221_X2
* cell instance $18926 r0 *1 149.15,88.2
X$18926 6063 4235 77 109 5858 NOR2_X1
* cell instance $18927 r0 *1 149.72,88.2
X$18927 77 6852 3775 7052 4356 5713 109 AOI22_X4
* cell instance $18929 m0 *1 150.86,88.2
X$18929 4483 77 109 4240 INV_X4
* cell instance $18930 m0 *1 152,88.2
X$18930 6690 6475 6688 109 77 4613 OAI21_X4
* cell instance $18931 m0 *1 154.47,88.2
X$18931 6192 6257 77 109 6195 OR2_X1
* cell instance $18933 r0 *1 152.95,88.2
X$18933 6475 6557 77 109 6845 NOR2_X2
* cell instance $18934 r0 *1 153.9,88.2
X$18934 77 6475 6850 6847 4360 6473 109 OAI22_X4
* cell instance $18935 m0 *1 158.08,88.2
X$18935 6684 6602 3149 109 77 6418 OAI21_X2
* cell instance $18936 m0 *1 155.61,88.2
X$18936 77 6479 6685 4460 6845 109 AOI21_X4
* cell instance $18938 m0 *1 159.6,88.2
X$18938 6602 2183 6681 6680 6182 5567 77 109 OAI221_X2
* cell instance $18939 m0 *1 161.69,88.2
X$18939 5764 77 109 3651 INV_X4
* cell instance $18940 m0 *1 162.64,88.2
X$18940 4363 77 109 4491 INV_X2
* cell instance $18941 m0 *1 163.21,88.2
X$18941 5765 5766 77 109 6406 OR2_X1
* cell instance $18942 m0 *1 163.97,88.2
X$18942 4046 6602 77 109 6675 NOR2_X1
* cell instance $18944 r0 *1 157.13,88.2
X$18944 6146 6430 77 109 6477 NAND2_X1
* cell instance $18946 r0 *1 157.89,88.2
X$18946 4758 109 6755 77 BUF_X4
* cell instance $18947 r0 *1 159.22,88.2
X$18947 5145 6841 6182 109 77 6754 MUX2_X2
* cell instance $18948 r0 *1 160.93,88.2
X$18948 6755 109 6602 77 BUF_X4
* cell instance $18949 r0 *1 162.26,88.2
X$18949 6478 6757 6748 109 77 6669 HA_X1
* cell instance $18950 r0 *1 164.16,88.2
X$18950 6756 6757 19079 109 77 6761 HA_X1
* cell instance $18951 m0 *1 165.68,88.2
X$18951 6257 5909 77 109 6324 NOR2_X1
* cell instance $18952 m0 *1 164.92,88.2
X$18952 5626 6196 4808 77 109 6323 NAND3_X1
* cell instance $18953 m0 *1 166.25,88.2
X$18953 3477 6398 77 109 6480 NAND2_X1
* cell instance $18954 m0 *1 166.82,88.2
X$18954 6672 6602 3025 109 77 5607 OAI21_X2
* cell instance $18955 m0 *1 168.15,88.2
X$18955 6669 109 6831 77 BUF_X4
* cell instance $18956 m0 *1 169.48,88.2
X$18956 3931 77 109 4298 INV_X4
* cell instance $18958 m0 *1 170.62,88.2
X$18958 3470 6603 77 109 6481 NAND2_X1
* cell instance $18959 m0 *1 171.19,88.2
X$18959 6326 6603 6197 77 109 6482 MUX2_X1
* cell instance $18960 m0 *1 172.52,88.2
X$18960 6604 6483 6198 77 109 6665 MUX2_X1
* cell instance $18961 m0 *1 173.85,88.2
X$18961 6197 6605 6326 77 109 6606 MUX2_X1
* cell instance $18962 m0 *1 175.18,88.2
X$18962 6749 77 109 6198 CLKBUF_X2
* cell instance $18963 m0 *1 175.94,88.2
X$18963 6604 6541 6198 77 109 6484 MUX2_X1
* cell instance $18964 m0 *1 177.27,88.2
X$18964 77 6200 6829 3024 1035 6663 109 OAI22_X4
* cell instance $18966 m0 *1 180.69,88.2
X$18966 6831 109 6659 77 BUF_X4
* cell instance $18968 m0 *1 182.21,88.2
X$18968 6656 109 1059 77 BUF_X4
* cell instance $18970 m0 *1 183.73,88.2
X$18970 6608 5083 6609 77 109 6658 MUX2_X1
* cell instance $18972 r0 *1 166.06,88.2
X$18972 6326 6758 6197 77 109 6760 MUX2_X1
* cell instance $18973 r0 *1 167.39,88.2
X$18973 3024 6755 77 109 6841 NOR2_X1
* cell instance $18975 r0 *1 168.15,88.2
X$18975 6761 6762 6749 77 109 6836 MUX2_X1
* cell instance $18976 r0 *1 169.48,88.2
X$18976 5080 77 109 5278 INV_X2
* cell instance $18977 r0 *1 170.05,88.2
X$18977 77 6831 6836 3025 1665 6762 109 OAI22_X4
* cell instance $18981 r0 *1 173.28,88.2
X$18981 6604 77 109 6197 BUF_X2
* cell instance $18983 r0 *1 174.23,88.2
X$18983 6329 6606 2182 6605 109 77 6656 OAI22_X2
* cell instance $18984 r0 *1 175.94,88.2
X$18984 77 6659 6832 4046 1799 6763 109 OAI22_X4
* cell instance $18985 r0 *1 179.17,88.2
X$18985 6749 77 109 6764 BUF_X2
* cell instance $18986 r0 *1 179.93,88.2
X$18986 6825 77 109 6766 INV_X1
* cell instance $18987 r0 *1 180.31,88.2
X$18987 6826 77 109 6607 INV_X1
* cell instance $18988 r0 *1 180.69,88.2
X$18988 77 6245 18827 6768 6821 1146 109 DFFR_X1
* cell instance $18989 r0 *1 184.49,88.2
X$18989 2908 6496 6768 77 109 6821 MUX2_X1
* cell instance $18991 m0 *1 185.44,88.2
X$18991 6656 5216 109 77 6330 AND2_X1
* cell instance $18993 r0 *1 186.2,88.2
X$18993 2908 5509 6610 77 109 6769 MUX2_X1
* cell instance $18995 m0 *1 186.58,88.2
X$18995 6938 6330 77 109 6610 NOR2_X1
* cell instance $18998 r0 *1 187.72,88.2
X$18998 5776 109 5369 77 BUF_X4
* cell instance $18999 m0 *1 188.48,88.2
X$18999 5369 109 6496 77 BUF_X4
* cell instance $19001 m0 *1 189.81,88.2
X$19001 6611 109 5384 77 BUF_X4
* cell instance $19002 m0 *1 191.14,88.2
X$19002 6611 109 5259 77 BUF_X4
* cell instance $19006 m0 *1 196.46,88.2
X$19006 6485 7673 6531 109 5966 77 OAI21_X1
* cell instance $19008 m0 *1 197.41,88.2
X$19008 6612 77 109 4551 INV_X1
* cell instance $19011 r0 *1 189.24,88.2
X$19011 5626 6818 6819 109 6242 77 OAI21_X1
* cell instance $19013 r0 *1 190.38,88.2
X$19013 1665 6770 6940 109 4290 77 OAI21_X1
* cell instance $19015 r0 *1 191.33,88.2
X$19015 1924 6770 6772 109 4443 77 OAI21_X1
* cell instance $19017 r0 *1 192.47,88.2
X$19017 1059 6770 6773 109 3142 77 OAI21_X1
* cell instance $19018 r0 *1 193.23,88.2
X$19018 1799 6770 6812 109 3447 77 OAI21_X1
* cell instance $19019 r0 *1 193.99,88.2
X$19019 77 6945 6612 6613 6810 992 109 DFFR_X1
* cell instance $19020 r0 *1 197.79,88.2
X$19020 1893 5372 6774 6521 6648 109 77 6810 OAI221_X1
* cell instance $19022 m0 *1 198.17,88.2
X$19022 6613 77 109 6648 INV_X1
* cell instance $19024 m0 *1 200.83,88.2
X$19024 6073 3741 4419 6102 4551 6638 109 77 AOI221_X2
* cell instance $19025 m0 *1 202.92,88.2
X$19025 77 6642 18687 6640 6641 3676 109 DFFR_X1
* cell instance $19028 r0 *1 199.12,88.2
X$19028 1989 5781 6809 5631 6776 109 77 6775 OAI221_X1
* cell instance $19029 r0 *1 200.26,88.2
X$19029 3736 77 109 6776 INV_X1
* cell instance $19032 r0 *1 201.78,88.2
X$19032 3736 6102 6073 3562 77 109 6794 AOI22_X2
* cell instance $19033 r0 *1 203.49,88.2
X$19033 5495 5095 6640 77 109 6641 MUX2_X1
* cell instance $19036 r0 *1 205.39,88.2
X$19036 1867 5372 6992 6521 6803 109 77 6805 OAI221_X1
* cell instance $19038 r0 *1 206.72,88.2
X$19038 6521 77 109 5631 CLKBUF_X3
* cell instance $19039 m0 *1 207.29,88.2
X$19039 77 6075 6337 6636 6637 3676 109 DFFR_X1
* cell instance $19041 m0 *1 211.09,88.2
X$19041 6521 77 109 5374 CLKBUF_X3
* cell instance $19042 m0 *1 212.04,88.2
X$19042 4003 6354 6516 77 109 6634 MUX2_X1
* cell instance $19045 m0 *1 215.08,88.2
X$19045 4003 4552 6493 77 109 6615 MUX2_X1
* cell instance $19046 m0 *1 216.41,88.2
X$19046 77 5923 18616 6493 6615 3676 109 DFFR_X1
* cell instance $19047 m0 *1 220.21,88.2
X$19047 3718 77 109 6616 INV_X1
* cell instance $19050 r0 *1 207.67,88.2
X$19050 3555 77 109 6803 INV_X1
* cell instance $19054 r0 *1 210.71,88.2
X$19054 494 5372 6777 6521 2885 109 77 6982 OAI221_X1
* cell instance $19058 r0 *1 213.18,88.2
X$19058 759 5781 6800 6799 5631 109 77 6779 OAI221_X1
* cell instance $19059 r0 *1 214.32,88.2
X$19059 3303 77 109 6799 INV_X1
* cell instance $19062 r0 *1 215.84,88.2
X$19062 5212 77 109 6354 CLKBUF_X3
* cell instance $19065 r0 *1 217.93,88.2
X$19065 6073 109 6340 77 BUF_X4
* cell instance $19066 r0 *1 219.26,88.2
X$19066 1398 5781 6780 5374 6616 109 77 6795 OAI221_X1
* cell instance $19067 r0 *1 220.4,88.2
X$19067 77 6500 6795 3676 18992 3718 109 DFFR_X2
* cell instance $19068 m0 *1 224.96,88.2
X$19068 4706 5392 6630 109 6511 77 OAI21_X1
* cell instance $19069 m0 *1 224.01,88.2
X$19069 3718 6209 3408 6340 77 109 6630 AOI22_X1
* cell instance $19073 r0 *1 225.72,88.2
X$19073 6794 6617 77 109 7119 NAND2_X1
* cell instance $19074 m0 *1 226.29,88.2
X$19074 6498 6497 6067 77 109 6617 NAND3_X1
* cell instance $19077 m0 *1 227.24,88.2
X$19077 6628 5498 77 109 6499 NAND2_X1
* cell instance $19079 m0 *1 228.57,88.2
X$19079 5920 109 5392 77 BUF_X4
* cell instance $19080 m0 *1 229.9,88.2
X$19080 6618 4831 4834 6623 4577 6784 77 109 OAI221_X2
* cell instance $19081 m0 *1 231.99,88.2
X$19081 6782 4831 4834 6949 4577 6622 77 109 OAI221_X2
* cell instance $19082 m0 *1 234.08,88.2
X$19082 6622 6786 3094 77 2470 109 AOI21_X2
* cell instance $19084 m0 *1 235.6,88.2
X$19084 6619 4837 6502 77 109 6341 MUX2_X1
* cell instance $19093 r0 *1 228.57,88.2
X$19093 578 5781 6783 5374 6618 109 77 6963 OAI221_X1
* cell instance $19095 r0 *1 230.47,88.2
X$19095 6784 6792 3094 77 2374 109 AOI21_X2
* cell instance $19096 r0 *1 231.8,88.2
X$19096 6785 77 109 6618 INV_X1
* cell instance $19099 r0 *1 234.08,88.2
X$19099 6786 5509 6950 77 109 6789 MUX2_X1
* cell instance $19100 r0 *1 235.41,88.2
X$19100 77 6210 18836 6786 6789 992 109 DFFR_X1
* cell instance $19114 m0 *1 10.07,183.4
X$19114 14461 77 109 15031 CLKBUF_X3
* cell instance $19115 m0 *1 6.27,183.4
X$19115 77 15031 15032 15313 15208 9814 109 DFFR_X1
* cell instance $19117 m0 *1 11.78,183.4
X$19117 15167 7054 15103 77 109 15101 MUX2_X1
* cell instance $19122 r0 *1 9.12,183.4
X$19122 15167 6876 15313 77 109 15208 MUX2_X1
* cell instance $19124 r0 *1 13.49,183.4
X$19124 15167 6214 15406 77 109 15315 MUX2_X1
* cell instance $19125 r0 *1 14.82,183.4
X$19125 15267 10129 15268 77 109 15210 MUX2_X1
* cell instance $19126 m0 *1 15.2,183.4
X$19126 15032 6083 15104 77 109 15316 MUX2_X1
* cell instance $19129 r0 *1 16.15,183.4
X$19129 15316 9326 15269 77 109 15322 MUX2_X1
* cell instance $19131 m0 *1 16.91,183.4
X$19131 15107 9895 15210 77 109 15113 MUX2_X1
* cell instance $19134 m0 *1 20.71,183.4
X$19134 15213 12481 14118 77 109 15109 MUX2_X1
* cell instance $19137 m0 *1 24.32,183.4
X$19137 77 14930 15220 15112 15111 9814 109 DFFR_X1
* cell instance $19138 m0 *1 28.12,183.4
X$19138 15168 6719 77 109 15170 NAND2_X1
* cell instance $19140 m0 *1 28.88,183.4
X$19140 15271 10142 15220 77 109 15169 MUX2_X1
* cell instance $19142 m0 *1 30.4,183.4
X$19142 15169 10860 15221 77 109 13923 MUX2_X1
* cell instance $19143 m0 *1 31.73,183.4
X$19143 14930 77 109 19230 CLKBUF_X1
* cell instance $19144 m0 *1 32.3,183.4
X$19144 77 14930 15038 15226 15224 4086 109 DFFR_X1
* cell instance $19145 m0 *1 36.1,183.4
X$19145 15113 7876 77 109 15227 NAND2_X1
* cell instance $19146 m0 *1 36.67,183.4
X$19146 15170 15227 7202 77 109 15119 NAND3_X2
* cell instance $19147 m0 *1 38,183.4
X$19147 7703 15039 15035 8157 6719 15116 77 109 OAI221_X2
* cell instance $19148 m0 *1 40.09,183.4
X$19148 77 15037 15119 11541 15172 6652 109 AOI22_X4
* cell instance $19149 m0 *1 43.32,183.4
X$19149 15228 15173 8671 77 109 15118 NOR3_X1
* cell instance $19151 r0 *1 17.48,183.4
X$19151 77 14168 15410 15318 15409 9814 109 DFFR_X1
* cell instance $19153 r0 *1 21.47,183.4
X$19153 15270 9326 15362 77 109 15323 MUX2_X1
* cell instance $19155 r0 *1 22.99,183.4
X$19155 15322 7619 15323 77 109 15214 MUX2_X1
* cell instance $19158 r0 *1 28.12,183.4
X$19158 15271 13257 15220 77 109 15328 MUX2_X1
* cell instance $19159 r0 *1 29.45,183.4
X$19159 15364 10142 15272 77 109 15221 MUX2_X1
* cell instance $19160 r0 *1 30.78,183.4
X$19160 15328 8407 15273 77 109 14040 MUX2_X1
* cell instance $19162 r0 *1 32.49,183.4
X$19162 15226 7468 15167 77 109 15224 MUX2_X1
* cell instance $19165 r0 *1 34.39,183.4
X$19165 15214 7917 77 109 15329 NOR2_X1
* cell instance $19169 r0 *1 36.29,183.4
X$19169 15329 15036 7997 109 15365 77 NOR3_X2
* cell instance $19171 r0 *1 40.66,183.4
X$19171 6294 15330 5672 77 15171 109 AOI21_X1
* cell instance $19172 r0 *1 41.42,183.4
X$19172 15274 5513 15332 77 109 15330 MUX2_X1
* cell instance $19174 r0 *1 42.94,183.4
X$19174 15275 6120 77 109 15173 NOR2_X1
* cell instance $19175 r0 *1 43.51,183.4
X$19175 77 7026 109 7997 BUF_X8
* cell instance $19177 m0 *1 44.46,183.4
X$19177 15174 7620 77 109 15228 NOR2_X1
* cell instance $19179 r0 *1 45.98,183.4
X$19179 15333 7917 77 109 15177 NOR2_X1
* cell instance $19181 r0 *1 46.74,183.4
X$19181 77 6120 109 10283 BUF_X8
* cell instance $19183 m0 *1 46.93,183.4
X$19183 77 7020 109 7292 BUF_X8
* cell instance $19184 m0 *1 50.16,183.4
X$19184 7638 6369 15175 77 15176 109 AOI21_X1
* cell instance $19186 r0 *1 49.21,183.4
X$19186 13355 109 9810 77 BUF_X4
* cell instance $19188 r0 *1 50.73,183.4
X$19188 15176 14935 77 109 15334 NAND2_X1
* cell instance $19190 m0 *1 51.49,183.4
X$19190 15177 14936 7997 109 15178 77 NOR3_X2
* cell instance $19193 r0 *1 51.68,183.4
X$19193 77 11474 15178 7026 15730 109 AOI21_X4
* cell instance $19195 m0 *1 53.2,183.4
X$19195 77 6379 109 9652 BUF_X8
* cell instance $19196 m0 *1 55.86,183.4
X$19196 14135 77 109 14710 CLKBUF_X3
* cell instance $19197 m0 *1 56.81,183.4
X$19197 15179 7338 77 109 15122 NAND2_X1
* cell instance $19201 r0 *1 54.91,183.4
X$19201 15371 9810 15276 77 109 15336 MUX2_X1
* cell instance $19203 r0 *1 56.43,183.4
X$19203 15336 6120 15423 77 109 15041 MUX2_X1
* cell instance $19204 r0 *1 57.76,183.4
X$19204 15426 5513 15425 77 109 15180 MUX2_X1
* cell instance $19205 m0 *1 58.71,183.4
X$19205 9570 5672 15180 77 15231 109 AOI21_X1
* cell instance $19216 r0 *1 59.85,183.4
X$19216 77 14710 15373 15277 15337 8687 109 DFFR_X1
* cell instance $19217 m0 *1 60.8,183.4
X$19217 15231 15040 77 109 15234 NAND2_X1
* cell instance $19219 m0 *1 61.37,183.4
X$19219 9742 15658 14548 9801 15234 10892 77 109 OAI221_X2
* cell instance $19220 m0 *1 63.46,183.4
X$19220 15233 6997 15232 77 15236 109 AOI21_X2
* cell instance $19222 r0 *1 63.65,183.4
X$19222 14712 6993 15277 77 109 15337 MUX2_X1
* cell instance $19225 m0 *1 65.17,183.4
X$19225 77 12101 15235 6726 15236 109 AOI21_X4
* cell instance $19226 m0 *1 68.4,183.4
X$19226 77 15126 15044 15129 15238 8687 109 DFFR_X1
* cell instance $19228 m0 *1 72.96,183.4
X$19228 15044 11563 15130 77 109 15181 MUX2_X1
* cell instance $19229 m0 *1 74.29,183.4
X$19229 15045 9429 15181 77 109 15431 MUX2_X1
* cell instance $19234 r0 *1 65.93,183.4
X$19234 15278 6997 77 109 15279 NOR2_X2
* cell instance $19237 r0 *1 67.45,183.4
X$19237 15429 4768 15339 77 109 15338 MUX2_X1
* cell instance $19240 r0 *1 69.35,183.4
X$19240 15280 4708 15339 77 109 15281 MUX2_X1
* cell instance $19243 r0 *1 76.95,183.4
X$19243 15182 11129 15434 77 109 15341 MUX2_X1
* cell instance $19245 r0 *1 78.47,183.4
X$19245 77 14803 15241 15436 15342 8687 109 DFFR_X1
* cell instance $19246 m0 *1 79.99,183.4
X$19246 9337 15182 15047 109 15134 77 OAI21_X1
* cell instance $19248 m0 *1 80.75,183.4
X$19248 7703 15134 15241 7643 109 77 15242 OAI22_X1
* cell instance $19250 m0 *1 81.89,183.4
X$19250 7876 15242 15183 109 15048 77 OAI21_X1
* cell instance $19252 m0 *1 83.41,183.4
X$19252 14803 77 109 19142 INV_X1
* cell instance $19254 r0 *1 82.27,183.4
X$19254 9570 5672 15475 77 15183 109 AOI21_X1
* cell instance $19256 m0 *1 84.36,183.4
X$19256 77 14803 14667 15050 15049 8687 109 DFFR_X1
* cell instance $19258 m0 *1 88.16,183.4
X$19258 15248 6180 77 109 15345 NAND2_X1
* cell instance $19259 m0 *1 88.73,183.4
X$19259 8362 15136 6130 9030 15184 109 77 15141 OAI221_X1
* cell instance $19260 m0 *1 89.87,183.4
X$19260 77 13272 11240 109 BUF_X16
* cell instance $19262 m0 *1 94.81,183.4
X$19262 15252 13682 14193 77 109 15251 MUX2_X1
* cell instance $19263 m0 *1 96.14,183.4
X$19263 77 14428 15056 15252 15251 8201 109 DFFR_X1
* cell instance $19264 m0 *1 99.94,183.4
X$19264 15253 13098 14440 77 109 15254 MUX2_X1
* cell instance $19265 m0 *1 101.27,183.4
X$19265 77 15149 15057 15253 15254 8201 109 DFFR_X1
* cell instance $19266 m0 *1 105.07,183.4
X$19266 15057 6584 15256 77 109 14948 MUX2_X1
* cell instance $19268 m0 *1 106.59,183.4
X$19268 15256 7335 15027 77 109 15058 MUX2_X1
* cell instance $19271 m0 *1 110.2,183.4
X$19271 14918 15185 77 109 15153 NOR2_X1
* cell instance $19272 m0 *1 110.77,183.4
X$19272 12101 15185 77 109 15059 NOR2_X1
* cell instance $19273 m0 *1 111.34,183.4
X$19273 15186 15286 109 77 15187 AND2_X2
* cell instance $19274 m0 *1 112.29,183.4
X$19274 15059 10787 15188 77 15258 109 AOI21_X2
* cell instance $19275 m0 *1 113.62,183.4
X$19275 13396 15185 77 109 15060 NOR2_X1
* cell instance $19276 m0 *1 114.19,183.4
X$19276 15060 10787 15262 77 15259 109 AOI21_X2
* cell instance $19278 m0 *1 115.71,183.4
X$19278 11684 15185 77 109 15062 NOR2_X1
* cell instance $19279 m0 *1 116.28,183.4
X$19279 15062 13141 15154 77 15263 109 AOI21_X2
* cell instance $19283 r0 *1 85.69,183.4
X$19283 13558 5672 15344 77 15245 109 AOI21_X1
* cell instance $19285 r0 *1 87.21,183.4
X$19285 15245 15137 77 109 15282 NAND2_X1
* cell instance $19287 r0 *1 87.97,183.4
X$19287 7403 15283 15345 109 15051 77 OAI21_X1
* cell instance $19288 r0 *1 88.73,183.4
X$19288 15248 4914 77 109 15347 NAND2_X1
* cell instance $19289 r0 *1 89.3,183.4
X$19289 8993 15283 15347 109 15184 77 OAI21_X1
* cell instance $19292 r0 *1 91.01,183.4
X$19292 15349 12481 14440 77 109 15350 MUX2_X1
* cell instance $19293 r0 *1 92.34,183.4
X$19293 77 15865 15054 15349 15350 8201 109 DFFR_X1
* cell instance $19295 r0 *1 96.52,183.4
X$19295 15380 15284 13297 77 109 NOR2_X4
* cell instance $19296 r0 *1 98.23,183.4
X$19296 15285 13146 14440 77 109 15352 MUX2_X1
* cell instance $19298 r0 *1 99.75,183.4
X$19298 14194 8375 77 109 15255 NAND2_X2
* cell instance $19300 r0 *1 102.22,183.4
X$19300 15353 13408 14440 77 109 15356 MUX2_X1
* cell instance $19301 r0 *1 103.55,183.4
X$19301 15149 77 109 19111 INV_X2
* cell instance $19302 r0 *1 104.12,183.4
X$19302 77 15149 15256 15353 15356 8201 109 DFFR_X1
* cell instance $19304 r0 *1 108.3,183.4
X$19304 77 15447 15358 15449 15151 14564 109 NOR4_X4
* cell instance $19305 r0 *1 111.72,183.4
X$19305 15286 15186 77 6847 109 NAND2_X4
* cell instance $19307 r0 *1 114.19,183.4
X$19307 12101 109 13060 77 BUF_X4
* cell instance $19314 r0 *1 115.52,183.4
X$19314 77 12264 15189 15454 15063 6869 15064 7028 109 AOI222_X2
* cell instance $19315 m0 *1 118.18,183.4
X$19315 77 7028 15063 15190 15064 15189 15065 15191 109 AOI222_X2
* cell instance $19318 r0 *1 118.18,183.4
X$19318 12828 77 109 19113 INV_X2
* cell instance $19319 r0 *1 118.75,183.4
X$19319 15360 10787 15190 77 15361 109 AOI21_X2
* cell instance $19320 r0 *1 120.08,183.4
X$19320 6869 12100 77 109 15360 NOR2_X1
* cell instance $19323 r0 *1 121.22,183.4
X$19323 15187 12100 77 109 15287 NOR2_X1
* cell instance $19325 m0 *1 121.22,183.4
X$19325 11846 77 109 15185 CLKBUF_X3
* cell instance $19327 r0 *1 122.55,183.4
X$19327 12264 109 15065 77 BUF_X4
* cell instance $19328 m0 *1 122.74,183.4
X$19328 12265 109 15064 77 BUF_X4
* cell instance $19330 m0 *1 124.07,183.4
X$19330 13437 77 109 14726 CLKBUF_X3
* cell instance $19334 r0 *1 124.07,183.4
X$19334 77 14726 14951 15192 15359 12731 109 DFFR_X1
* cell instance $19335 m0 *1 127.11,183.4
X$19335 15192 15193 15161 77 109 15359 MUX2_X1
* cell instance $19339 m0 *1 129.01,183.4
X$19339 13939 77 109 13822 CLKBUF_X3
* cell instance $19341 m0 *1 129.96,183.4
X$19341 13939 77 109 15193 CLKBUF_X3
* cell instance $19344 m0 *1 131.86,183.4
X$19344 13939 77 109 14206 CLKBUF_X3
* cell instance $19347 m0 *1 135.09,183.4
X$19347 14061 77 109 13823 CLKBUF_X3
* cell instance $19349 m0 *1 136.23,183.4
X$19349 14061 77 109 15069 CLKBUF_X3
* cell instance $19354 r0 *1 129.58,183.4
X$19354 77 14580 15288 15357 15457 12731 109 DFFR_X1
* cell instance $19355 r0 *1 133.38,183.4
X$19355 8047 13823 9552 77 109 15266 MUX2_X1
* cell instance $19358 r0 *1 135.28,183.4
X$19358 14851 15069 11228 77 109 15289 MUX2_X1
* cell instance $19359 r0 *1 136.61,183.4
X$19359 10228 15069 12539 77 109 15290 MUX2_X1
* cell instance $19360 r0 *1 137.94,183.4
X$19360 15354 14206 14924 77 109 15355 MUX2_X1
* cell instance $19363 r0 *1 140.22,183.4
X$19363 11438 77 109 15191 BUF_X1
* cell instance $19365 m0 *1 141.55,183.4
X$19365 8830 15265 14061 77 109 NOR2_X4
* cell instance $19370 m0 *1 145.73,183.4
X$19370 14306 77 109 15265 INV_X1
* cell instance $19371 m0 *1 146.11,183.4
X$19371 77 15071 11309 8264 5563 109 AOI21_X4
* cell instance $19372 m0 *1 148.58,183.4
X$19372 15072 7038 77 109 15264 NOR2_X1
* cell instance $19374 m0 *1 149.91,183.4
X$19374 77 15260 15264 11684 15072 109 AOI21_X4
* cell instance $19375 m0 *1 152.38,183.4
X$19375 12424 77 109 15024 BUF_X1
* cell instance $19376 m0 *1 152.95,183.4
X$19376 77 8047 13176 15194 13287 14210 15197 13018 109 OAI222_X2
* cell instance $19377 m0 *1 155.61,183.4
X$19377 11309 15092 15195 77 109 15073 NOR3_X1
* cell instance $19379 m0 *1 156.56,183.4
X$19379 77 14493 15079 12731 13127 14959 109 DFFR_X2
* cell instance $19380 m0 *1 160.74,183.4
X$19380 13127 77 109 15078 INV_X1
* cell instance $19381 m0 *1 161.12,183.4
X$19381 12816 15293 14737 77 109 15080 MUX2_X1
* cell instance $19382 m0 *1 162.45,183.4
X$19382 15250 15229 14958 109 15079 77 OAI21_X1
* cell instance $19383 m0 *1 163.21,183.4
X$19383 12985 13447 77 109 15249 NAND2_X1
* cell instance $19384 m0 *1 163.78,183.4
X$19384 13951 15196 14550 77 109 15246 NAND3_X1
* cell instance $19385 m0 *1 164.54,183.4
X$19385 15081 14620 15246 13951 15244 109 77 15247 OAI221_X1
* cell instance $19386 m0 *1 165.68,183.4
X$19386 15197 77 109 15244 INV_X1
* cell instance $19388 m0 *1 169.1,183.4
X$19388 15081 15138 15083 15198 14854 109 77 15240 OAI221_X1
* cell instance $19392 r0 *1 142.88,183.4
X$19392 10528 13281 9422 77 109 15351 MUX2_X1
* cell instance $19394 r0 *1 144.4,183.4
X$19394 14560 77 109 14849 CLKBUF_X3
* cell instance $19395 r0 *1 145.35,183.4
X$19395 77 14849 18780 15261 15291 12731 109 DFFR_X1
* cell instance $19397 r0 *1 149.53,183.4
X$19397 15166 11140 15348 109 77 15762 OAI21_X4
* cell instance $19399 r0 *1 152.38,183.4
X$19399 15072 12424 77 15292 109 NAND2_X4
* cell instance $19401 r0 *1 154.28,183.4
X$19401 15292 6474 15348 109 77 15346 OAI21_X4
* cell instance $19402 r0 *1 156.75,183.4
X$19402 15293 15296 77 109 15257 NAND2_X1
* cell instance $19403 r0 *1 157.32,183.4
X$19403 14927 14852 77 109 14956 NAND2_X1
* cell instance $19404 r0 *1 157.89,183.4
X$19404 15257 12755 15293 109 77 11433 OAI21_X2
* cell instance $19405 r0 *1 159.22,183.4
X$19405 14493 77 109 19307 CLKBUF_X1
* cell instance $19407 r0 *1 159.98,183.4
X$19407 13575 13908 77 109 15155 NAND2_X1
* cell instance $19409 r0 *1 160.93,183.4
X$19409 15343 15295 15293 77 15077 109 AOI21_X1
* cell instance $19411 r0 *1 161.88,183.4
X$19411 15293 12819 77 109 15343 NOR2_X1
* cell instance $19414 r0 *1 163.4,183.4
X$19414 14296 15196 15249 109 14922 77 OAI21_X1
* cell instance $19416 r0 *1 164.35,183.4
X$19416 77 14446 15247 12731 15340 15197 109 DFFR_X2
* cell instance $19417 r0 *1 168.53,183.4
X$19417 15340 77 109 12985 BUF_X2
* cell instance $19418 r0 *1 169.29,183.4
X$19418 15294 15295 15199 109 14963 77 OAI21_X1
* cell instance $19419 r0 *1 170.05,183.4
X$19419 15294 12819 77 109 15199 NAND2_X1
* cell instance $19421 m0 *1 170.81,183.4
X$19421 77 15239 15200 11406 15201 109 AOI21_X4
* cell instance $19423 m0 *1 173.28,183.4
X$19423 15237 5472 77 109 11244 NOR2_X2
* cell instance $19426 m0 *1 176.51,183.4
X$19426 15202 15230 109 77 14857 AND2_X1
* cell instance $19427 m0 *1 177.27,183.4
X$19427 15202 15230 13361 14296 12979 10077 109 77 AOI221_X2
* cell instance $19428 m0 *1 179.36,183.4
X$19428 15203 14296 77 109 13229 NOR2_X2
* cell instance $19431 r0 *1 170.81,183.4
X$19431 15294 12755 77 109 15298 NAND2_X1
* cell instance $19438 r0 *1 171.38,183.4
X$19438 15294 15296 15298 109 14967 77 OAI21_X1
* cell instance $19439 r0 *1 172.14,183.4
X$19439 15433 12995 15294 77 13517 109 AOI21_X1
* cell instance $19441 r0 *1 173.09,183.4
X$19441 15432 13071 15300 77 15237 109 AOI21_X1
* cell instance $19443 r0 *1 174.04,183.4
X$19443 15335 5472 77 109 11412 NOR2_X2
* cell instance $19445 r0 *1 175.37,183.4
X$19445 9272 15201 11118 77 109 15490 MUX2_X1
* cell instance $19447 r0 *1 177.46,183.4
X$19447 13295 15299 15301 77 15230 109 AOI21_X1
* cell instance $19449 r0 *1 178.41,183.4
X$19449 15300 15301 77 109 15331 NOR2_X1
* cell instance $19450 r0 *1 178.98,183.4
X$19450 15331 13112 15299 77 15203 109 AOI21_X1
* cell instance $19452 r0 *1 179.93,183.4
X$19452 77 15302 14970 12731 15327 14815 109 DFFR_X2
* cell instance $19453 m0 *1 185.06,183.4
X$19453 13959 12804 77 109 15086 NOR2_X1
* cell instance $19454 m0 *1 183.73,183.4
X$19454 11228 14223 15422 77 109 14973 MUX2_X1
* cell instance $19456 m0 *1 185.82,183.4
X$19456 12691 14223 15078 77 109 14975 MUX2_X1
* cell instance $19459 m0 *1 190.38,183.4
X$19459 15225 12983 13959 77 14977 109 AOI21_X1
* cell instance $19460 m0 *1 191.14,183.4
X$19460 14223 9862 77 109 15225 NOR2_X1
* cell instance $19463 r0 *1 184.11,183.4
X$19463 15327 77 109 13119 BUF_X2
* cell instance $19466 r0 *1 185.44,183.4
X$19466 12804 77 109 14731 BUF_X1
* cell instance $19469 r0 *1 186.58,183.4
X$19469 15326 77 109 12815 BUF_X2
* cell instance $19470 r0 *1 187.34,183.4
X$19470 77 13844 14748 12731 15326 14443 109 DFFR_X2
* cell instance $19473 m0 *1 192.85,183.4
X$19473 77 14358 18651 15092 15222 3676 109 DFFR_X1
* cell instance $19477 r0 *1 194.18,183.4
X$19477 15417 15324 15223 109 77 15321 HA_X1
* cell instance $19478 r0 *1 196.08,183.4
X$19478 15325 77 109 15304 INV_X1
* cell instance $19479 r0 *1 196.46,183.4
X$19479 15303 77 109 15416 INV_X1
* cell instance $19481 r0 *1 197.6,183.4
X$19481 15305 77 109 15324 INV_X1
* cell instance $19482 m0 *1 201.59,183.4
X$19482 15218 77 109 14457 CLKBUF_X3
* cell instance $19483 m0 *1 197.79,183.4
X$19483 77 18279 15218 15219 14358 3676 109 DFFS_X1
* cell instance $19489 r0 *1 201.4,183.4
X$19489 77 15413 15398 15301 15321 15306 109 FA_X1
* cell instance $19490 r0 *1 204.44,183.4
X$19490 15307 15321 15319 77 15317 109 AOI21_X2
* cell instance $19491 m0 *1 205.39,183.4
X$19491 77 14758 15094 15095 15217 3676 109 DFFR_X1
* cell instance $19493 m0 *1 209.19,183.4
X$19493 15216 77 109 15217 INV_X1
* cell instance $19498 r0 *1 206.72,183.4
X$19498 15308 15320 15399 109 77 15309 HA_X1
* cell instance $19501 r0 *1 209.57,183.4
X$19501 77 14758 15096 15204 15310 3676 109 DFFR_X1
* cell instance $19503 m0 *1 211.47,183.4
X$19503 15215 77 109 15310 INV_X1
* cell instance $19504 m0 *1 212.04,183.4
X$19504 15204 13309 15089 13605 77 109 15215 AOI22_X1
* cell instance $19508 r0 *1 213.56,183.4
X$19508 77 14758 15097 15211 15205 3676 109 DFFR_X1
* cell instance $19510 m0 *1 214.13,183.4
X$19510 15212 77 109 15205 INV_X1
* cell instance $19511 m0 *1 215.27,183.4
X$19511 15211 13309 15087 13605 77 109 15212 AOI22_X1
* cell instance $19519 m0 *1 224.96,183.4
X$19519 9101 77 109 15209 BUF_X1
* cell instance $19520 m0 *1 231.61,183.4
X$19520 15102 77 109 15206 BUF_X1
* cell instance $19522 m0 *1 232.94,183.4
X$19522 15209 77 109 15207 BUF_X1
* cell instance $19534 r0 *1 227.81,183.4
X$19534 9399 77 109 15405 BUF_X1
* cell instance $19539 r0 *1 234.08,183.4
X$19539 9552 77 109 15314 BUF_X1
* cell instance $19541 r0 *1 237.69,183.4
X$19541 8754 77 109 15505 BUF_X1
* cell instance $19543 r0 *1 238.45,183.4
X$19543 15314 77 109 15311 BUF_X1
* cell instance $19552 m0 *1 6.84,189
X$19552 15558 6876 15598 77 109 15599 MUX2_X1
* cell instance $19553 m0 *1 8.17,189
X$19553 77 15461 15601 15598 15599 9814 109 DFFR_X1
* cell instance $19554 m0 *1 11.97,189
X$19554 15558 7054 15697 77 109 15776 MUX2_X1
* cell instance $19557 m0 *1 15.01,189
X$19557 15601 12066 15725 77 109 15779 MUX2_X1
* cell instance $19570 r0 *1 11.78,189
X$19570 77 15461 15725 15697 15776 9814 109 DFFR_X1
* cell instance $19573 r0 *1 16.53,189
X$19573 15779 11278 15780 77 109 15709 MUX2_X1
* cell instance $19574 r0 *1 17.86,189
X$19574 77 15461 15559 15652 15781 9814 109 DFFR_X1
* cell instance $19575 m0 *1 22.61,189
X$19575 15651 10129 15559 77 109 15603 MUX2_X1
* cell instance $19576 m0 *1 21.28,189
X$19576 15651 12066 15559 77 109 15362 MUX2_X1
* cell instance $19579 m0 *1 26.22,189
X$19579 3445 77 109 14461 CLKBUF_X3
* cell instance $19580 m0 *1 27.17,189
X$19580 77 15727 15364 15560 15607 4086 109 DFFR_X1
* cell instance $19581 m0 *1 30.97,189
X$19581 15560 12312 13675 77 109 15607 MUX2_X1
* cell instance $19582 m0 *1 32.3,189
X$19582 15609 4631 15368 77 109 15610 MUX2_X1
* cell instance $19583 m0 *1 33.63,189
X$19583 77 15727 15035 15609 15610 4086 109 DFFR_X1
* cell instance $19584 m0 *1 37.43,189
X$19584 4632 109 7063 77 BUF_X4
* cell instance $19587 r0 *1 21.66,189
X$19587 15652 13145 15368 77 109 15781 MUX2_X1
* cell instance $19590 r0 *1 24.89,189
X$19590 15167 3043 15786 77 109 15726 MUX2_X1
* cell instance $19592 r0 *1 26.41,189
X$19592 77 15727 15728 15708 15782 4086 109 DFFR_X1
* cell instance $19593 r0 *1 30.21,189
X$19593 7598 12709 15708 77 109 15782 MUX2_X1
* cell instance $19595 r0 *1 33.06,189
X$19595 7598 109 15368 77 BUF_X4
* cell instance $19597 r0 *1 35.15,189
X$19597 15558 3043 15799 77 109 15916 MUX2_X1
* cell instance $19599 r0 *1 36.67,189
X$19599 15709 7619 15653 77 109 15333 MUX2_X1
* cell instance $19600 r0 *1 38,189
X$19600 77 15727 15421 15654 15805 4086 109 DFFR_X1
* cell instance $19602 m0 *1 39.9,189
X$19602 15465 13926 15368 77 109 15525 MUX2_X1
* cell instance $19604 m0 *1 42.18,189
X$19604 77 15620 15367 15806 15712 4086 109 DFFR_X1
* cell instance $19605 m0 *1 45.98,189
X$19605 15624 7468 15558 77 109 15561 MUX2_X1
* cell instance $19606 m0 *1 47.31,189
X$19606 77 15620 14842 15624 15561 4086 109 DFFR_X1
* cell instance $19609 m0 *1 52.06,189
X$19609 77 15369 15276 15562 15625 8687 109 DFFR_X1
* cell instance $19610 m0 *1 55.86,189
X$19610 15562 14046 15626 77 109 15625 MUX2_X1
* cell instance $19614 r0 *1 41.8,189
X$19614 15654 14046 15368 77 109 15805 MUX2_X1
* cell instance $19618 r0 *1 45.6,189
X$19618 15806 13767 15368 77 109 15712 MUX2_X1
* cell instance $19620 r0 *1 47.12,189
X$19620 9938 77 109 15558 BUF_X2
* cell instance $19623 r0 *1 51.11,189
X$19623 77 15369 15371 15655 15713 8687 109 DFFR_X1
* cell instance $19624 r0 *1 54.91,189
X$19624 15655 13926 15626 77 109 15713 MUX2_X1
* cell instance $19625 r0 *1 56.24,189
X$19625 14135 77 109 19192 CLKBUF_X3
* cell instance $19632 r0 *1 59.28,189
X$19632 6686 12709 15809 77 109 15808 MUX2_X1
* cell instance $19633 m0 *1 60.04,189
X$19633 6686 77 109 14048 BUF_X2
* cell instance $19636 m0 *1 61.56,189
X$19636 6686 77 109 15626 BUF_X2
* cell instance $19638 m0 *1 62.51,189
X$19638 15471 9429 15563 77 109 15732 MUX2_X1
* cell instance $19642 r0 *1 60.8,189
X$19642 15656 11563 15657 77 109 15563 MUX2_X1
* cell instance $19643 r0 *1 62.13,189
X$19643 15656 3970 15657 77 109 15627 MUX2_X1
* cell instance $19645 r0 *1 64.22,189
X$19645 15659 3970 15660 77 109 15564 MUX2_X1
* cell instance $19647 m0 *1 64.98,189
X$19647 15564 4322 15661 77 109 15472 MUX2_X1
* cell instance $19648 m0 *1 67.07,189
X$19648 15628 4126 15339 77 109 15629 MUX2_X1
* cell instance $19649 m0 *1 68.4,189
X$19649 77 15630 15473 15628 15629 8687 109 DFFR_X1
* cell instance $19651 r0 *1 65.55,189
X$19651 15662 3970 15942 77 109 15661 MUX2_X1
* cell instance $19654 r0 *1 69.16,189
X$19654 15717 4128 15339 77 109 15814 MUX2_X1
* cell instance $19655 r0 *1 70.49,189
X$19655 77 15630 15565 15717 15814 8687 109 DFFR_X1
* cell instance $19656 m0 *1 72.77,189
X$19656 15473 12153 15565 77 109 15632 MUX2_X1
* cell instance $19658 m0 *1 74.1,189
X$19658 15474 12240 15632 77 109 15733 MUX2_X1
* cell instance $19663 r0 *1 76.57,189
X$19663 15817 13767 15434 77 109 15663 MUX2_X1
* cell instance $19665 m0 *1 76.57,189
X$19665 15633 7468 15566 77 109 15536 MUX2_X1
* cell instance $19666 m0 *1 80.94,189
X$19666 16511 9742 15819 9801 15048 12990 77 109 OAI221_X2
* cell instance $19667 m0 *1 83.03,189
X$19667 15735 8421 9030 77 109 15719 NOR3_X1
* cell instance $19668 m0 *1 83.79,189
X$19668 15721 7590 77 109 15820 NOR2_X1
* cell instance $19669 m0 *1 84.36,189
X$19669 15665 6745 77 109 15667 NOR2_X1
* cell instance $19670 m0 *1 84.93,189
X$19670 14049 77 109 19105 INV_X2
* cell instance $19674 r0 *1 79.42,189
X$19674 15734 7877 15664 77 109 15721 MUX2_X1
* cell instance $19676 r0 *1 82.27,189
X$19676 16083 6276 8375 77 109 15720 NOR3_X1
* cell instance $19677 r0 *1 83.03,189
X$19677 15820 15719 15667 15720 109 15666 77 NOR4_X2
* cell instance $19678 r0 *1 84.74,189
X$19678 3445 77 109 14049 CLKBUF_X3
* cell instance $19680 r0 *1 86.07,189
X$19680 7335 109 10299 77 BUF_X4
* cell instance $19681 r0 *1 87.4,189
X$19681 77 15865 18843 15283 15821 8687 109 DFFR_X1
* cell instance $19682 m0 *1 87.59,189
X$19682 15283 11129 15737 77 109 15821 MUX2_X1
* cell instance $19687 r0 *1 91.2,189
X$19687 15952 15375 15669 77 109 15567 MUX2_X1
* cell instance $19689 r0 *1 92.72,189
X$19689 15824 7063 15733 77 109 15637 MUX2_X1
* cell instance $19690 m0 *1 93.29,189
X$19690 9742 15868 15637 9801 15282 9764 77 109 OAI221_X2
* cell instance $19693 m0 *1 95.57,189
X$19693 77 14942 15638 15724 15568 7053 109 NOR4_X4
* cell instance $19696 m0 *1 99.94,189
X$19696 15640 14047 15671 77 109 15547 MUX2_X1
* cell instance $19699 r0 *1 94.05,189
X$19699 16055 6296 77 109 15826 NOR2_X1
* cell instance $19700 r0 *1 94.62,189
X$19700 15826 15668 6379 109 15284 77 NOR3_X2
* cell instance $19701 r0 *1 95.95,189
X$19701 77 16338 15669 15670 15828 8201 109 DFFR_X1
* cell instance $19702 r0 *1 99.75,189
X$19702 15670 14046 15671 77 109 15828 MUX2_X1
* cell instance $19705 r0 *1 102.22,189
X$19705 15669 7877 15739 77 109 15723 MUX2_X1
* cell instance $19706 m0 *1 104.5,189
X$19706 77 8367 15569 15480 15643 15638 109 NOR4_X4
* cell instance $19707 m0 *1 103.17,189
X$19707 15723 6276 8689 109 15643 77 NOR3_X2
* cell instance $19709 m0 *1 108.11,189
X$19709 14717 8235 15644 77 109 15831 MUX2_X1
* cell instance $19710 m0 *1 109.44,189
X$19710 3445 77 109 14026 CLKBUF_X3
* cell instance $19711 m0 *1 110.39,189
X$19711 14026 77 109 19098 INV_X2
* cell instance $19714 r0 *1 105.07,189
X$19714 15477 10451 15830 77 109 15642 MUX2_X1
* cell instance $19716 r0 *1 107.16,189
X$19716 77 15672 15830 15644 15831 8201 109 DFFR_X1
* cell instance $19717 r0 *1 110.96,189
X$19717 14059 15185 77 109 15833 NOR2_X1
* cell instance $19719 m0 *1 111.34,189
X$19719 11838 15185 77 109 15673 NOR2_X1
* cell instance $19720 m0 *1 112.1,189
X$19720 77 6564 12875 15722 12728 9805 15065 12844 109 AOI222_X2
* cell instance $19721 m0 *1 114.76,189
X$19721 77 12875 12841 15570 12728 14059 15065 13249 109 AOI222_X2
* cell instance $19723 r0 *1 111.53,189
X$19723 15673 10787 15722 77 15834 109 AOI21_X2
* cell instance $19725 r0 *1 113.05,189
X$19725 15835 10787 15454 77 16003 109 AOI21_X2
* cell instance $19727 r0 *1 114.57,189
X$19727 13541 15185 77 109 15967 NOR2_X1
* cell instance $19731 r0 *1 115.14,189
X$19731 77 12264 12841 15968 15063 13249 15064 13541 109 AOI222_X2
* cell instance $19734 m0 *1 117.8,189
X$19734 77 12875 11474 15572 12728 15187 15065 6599 109 AOI222_X2
* cell instance $19735 r0 *1 117.99,189
X$19735 77 12264 9805 15970 15063 11838 15064 6564 109 AOI222_X2
* cell instance $19738 m0 *1 120.84,189
X$19738 77 7053 12875 15742 12728 12550 15065 13015 109 AOI222_X2
* cell instance $19739 m0 *1 123.69,189
X$19739 77 14726 15646 15573 15648 12731 109 DFFR_X1
* cell instance $19740 m0 *1 127.49,189
X$19740 15573 13822 15647 77 109 15648 MUX2_X1
* cell instance $19746 r0 *1 121.22,189
X$19746 77 12264 12550 15840 15063 11685 15064 7053 109 AOI222_X2
* cell instance $19747 r0 *1 123.88,189
X$19747 15841 13141 15840 77 16653 109 AOI21_X2
* cell instance $19749 r0 *1 125.4,189
X$19749 13015 12421 77 109 15841 NOR2_X1
* cell instance $19752 r0 *1 126.92,189
X$19752 14949 109 14200 77 BUF_X4
* cell instance $19754 r0 *1 128.63,189
X$19754 77 14580 15743 15718 15847 12731 109 DFFR_X1
* cell instance $19755 r0 *1 132.43,189
X$19755 15718 15193 15162 77 109 15847 MUX2_X1
* cell instance $19759 m0 *1 134.52,189
X$19759 9162 15069 14731 77 109 15744 MUX2_X1
* cell instance $19760 m0 *1 136.61,189
X$19760 8828 15069 9862 77 109 15650 MUX2_X1
* cell instance $19762 m0 *1 138.7,189
X$19762 10900 14338 9101 77 109 15675 MUX2_X1
* cell instance $19764 m0 *1 140.22,189
X$19764 15574 14063 15022 77 109 15649 MUX2_X1
* cell instance $19768 r0 *1 135.09,189
X$19768 14929 15069 15716 77 109 15981 MUX2_X1
* cell instance $19769 r0 *1 136.42,189
X$19769 9163 15069 10702 77 109 15848 MUX2_X1
* cell instance $19770 r0 *1 137.75,189
X$19770 10526 15069 10528 77 109 15975 MUX2_X1
* cell instance $19773 r0 *1 139.65,189
X$19773 9585 6397 10526 77 109 NOR2_X4
* cell instance $19776 r0 *1 142.31,189
X$19776 11838 9805 15484 109 77 15839 MUX2_X2
* cell instance $19777 m0 *1 142.88,189
X$19777 15716 13281 15383 77 109 15575 MUX2_X1
* cell instance $19779 m0 *1 144.21,189
X$19779 8153 77 109 15383 BUF_X1
* cell instance $19780 m0 *1 144.78,189
X$19780 77 14849 18656 14820 15645 12731 109 DFFR_X1
* cell instance $19784 r0 *1 144.4,189
X$19784 15187 15484 8153 77 109 16212 MUX2_X1
* cell instance $19785 r0 *1 145.73,189
X$19785 15195 15676 77 109 15838 OR2_X1
* cell instance $19786 r0 *1 146.49,189
X$19786 15838 77 109 15484 CLKBUF_X3
* cell instance $19787 r0 *1 147.44,189
X$19787 8383 13429 15072 109 77 15837 MUX2_X2
* cell instance $19788 r0 *1 149.15,189
X$19788 15484 11438 109 15576 77 AND2_X4
* cell instance $19789 m0 *1 149.91,189
X$19789 77 15639 15576 7028 15448 109 AOI21_X4
* cell instance $19791 m0 *1 152.38,189
X$19791 77 15578 15485 13668 15072 109 AOI21_X4
* cell instance $19793 r0 *1 150.86,189
X$19793 13249 15484 9422 77 109 15746 MUX2_X1
* cell instance $19794 r0 *1 152.19,189
X$19794 15074 16007 77 109 15747 NAND2_X1
* cell instance $19796 r0 *1 153.14,189
X$19796 6564 12541 15484 109 77 17016 MUX2_X2
* cell instance $19797 r0 *1 154.85,189
X$19797 7053 8462 15484 109 77 15829 MUX2_X2
* cell instance $19798 m0 *1 156.56,189
X$19798 11409 9263 15082 109 77 15715 MUX2_X2
* cell instance $19799 m0 *1 155.23,189
X$19799 15071 15195 15748 109 15486 77 NOR3_X2
* cell instance $19800 m0 *1 158.27,189
X$19800 15296 15390 15641 77 109 14736 MUX2_X1
* cell instance $19801 m0 *1 159.6,189
X$19801 10741 15201 8828 77 109 15987 MUX2_X1
* cell instance $19802 m0 *1 160.93,189
X$19802 9170 15677 10900 77 109 15714 MUX2_X1
* cell instance $19803 m0 *1 162.26,189
X$19803 15488 77 109 15390 CLKBUF_X3
* cell instance $19806 m0 *1 164.16,189
X$19806 15678 15577 14615 109 14214 77 NOR3_X2
* cell instance $19807 m0 *1 165.49,189
X$19807 15390 12993 77 109 15577 NOR2_X1
* cell instance $19808 m0 *1 166.06,189
X$19808 15636 16011 15294 109 77 13522 OAI21_X4
* cell instance $19809 m0 *1 168.53,189
X$19809 15635 13066 15294 77 15387 109 AOI21_X1
* cell instance $19810 m0 *1 169.29,189
X$19810 15711 14296 77 109 15636 NOR2_X1
* cell instance $19811 m0 *1 169.86,189
X$19811 15488 12593 77 109 15534 NOR2_X1
* cell instance $19815 r0 *1 157.7,189
X$19815 13951 14852 14550 8824 77 109 15750 NAND4_X1
* cell instance $19816 r0 *1 158.65,189
X$19816 15390 109 14852 77 BUF_X4
* cell instance $19817 r0 *1 159.98,189
X$19817 15677 109 15201 77 BUF_X4
* cell instance $19819 r0 *1 161.5,189
X$19819 9122 15201 9163 77 109 15827 MUX2_X1
* cell instance $19822 r0 *1 163.78,189
X$19822 15745 9165 77 109 15752 NOR2_X1
* cell instance $19824 r0 *1 164.54,189
X$19824 15751 15299 77 109 15678 NOR2_X1
* cell instance $19825 r0 *1 165.11,189
X$19825 15679 8264 77 109 13574 NAND2_X1
* cell instance $19827 r0 *1 165.87,189
X$19827 15822 15883 15390 77 14680 109 AOI21_X2
* cell instance $19829 r0 *1 167.58,189
X$19829 12823 15488 15753 77 109 15679 MUX2_X1
* cell instance $19831 r0 *1 169.1,189
X$19831 15606 15488 16012 77 109 14740 MUX2_X1
* cell instance $19832 r0 *1 170.43,189
X$19832 15604 15390 77 109 15711 NOR2_X1
* cell instance $19834 m0 *1 170.81,189
X$19834 15710 15680 14615 109 11404 77 NOR3_X2
* cell instance $19835 m0 *1 172.33,189
X$19835 15580 15390 15579 77 15198 109 AOI21_X1
* cell instance $19836 m0 *1 173.09,189
X$19836 15488 15414 77 109 15580 NOR2_X1
* cell instance $19837 m0 *1 173.66,189
X$19837 15634 16014 15294 109 77 14678 OAI21_X4
* cell instance $19838 m0 *1 176.13,189
X$19838 15294 15682 15631 109 13515 77 OAI21_X1
* cell instance $19839 m0 *1 176.89,189
X$19839 15390 15414 77 109 15529 NAND2_X1
* cell instance $19841 m0 *1 177.65,189
X$19841 8360 15201 11052 77 109 15707 MUX2_X1
* cell instance $19842 m0 *1 178.98,189
X$19842 15393 15299 109 77 15491 AND2_X1
* cell instance $19843 m0 *1 179.74,189
X$19843 15299 13115 77 109 15492 NAND2_X1
* cell instance $19844 m0 *1 180.31,189
X$19844 12593 15524 77 109 15681 OR2_X1
* cell instance $19846 m0 *1 182.59,189
X$19846 12972 15524 77 109 15683 OR2_X1
* cell instance $19848 m0 *1 184.11,189
X$19848 13119 15581 15495 109 15684 77 OAI21_X1
* cell instance $19849 m0 *1 184.87,189
X$19849 12815 15581 15623 109 15622 77 OAI21_X1
* cell instance $19850 m0 *1 185.63,189
X$19850 13286 15581 15621 109 15685 77 OAI21_X1
* cell instance $19852 m0 *1 189.43,189
X$19852 15704 15687 15619 109 77 15618 HA_X1
* cell instance $19855 r0 *1 171,189
X$19855 15604 15300 77 109 15710 NOR2_X1
* cell instance $19860 r0 *1 171.95,189
X$19860 13183 15201 10526 77 109 15754 MUX2_X1
* cell instance $19861 r0 *1 173.28,189
X$19861 13066 12546 77 109 15815 OR2_X1
* cell instance $19862 r0 *1 174.04,189
X$19862 15606 15386 77 109 15533 NOR2_X1
* cell instance $19864 r0 *1 174.8,189
X$19864 9764 10006 15082 109 77 15813 MUX2_X2
* cell instance $19866 r0 *1 176.89,189
X$19866 12753 15524 77 109 15756 OR2_X1
* cell instance $19868 r0 *1 178.03,189
X$19868 12990 9741 15082 109 77 15812 MUX2_X2
* cell instance $19870 r0 *1 180.5,189
X$19870 12983 15758 15681 109 15811 77 OAI21_X1
* cell instance $19872 r0 *1 182.78,189
X$19872 12989 15581 15683 109 15759 77 OAI21_X1
* cell instance $19874 r0 *1 183.73,189
X$19874 15760 15684 15686 14815 77 109 15796 AOI22_X2
* cell instance $19876 r0 *1 185.63,189
X$19876 15760 15685 15686 13794 77 109 15803 AOI22_X2
* cell instance $19877 r0 *1 187.34,189
X$19877 15760 15622 15686 14443 77 109 15938 AOI22_X2
* cell instance $19878 r0 *1 189.05,189
X$19878 11775 77 109 15716 BUF_X1
* cell instance $19879 r0 *1 189.62,189
X$19879 15526 15762 77 109 15763 NAND2_X1
* cell instance $19880 r0 *1 190.19,189
X$19880 15688 77 109 15704 INV_X1
* cell instance $19883 r0 *1 191.71,189
X$19883 15578 15690 77 109 15705 NOR2_X1
* cell instance $19885 r0 *1 192.47,189
X$19885 15689 77 109 15800 INV_X1
* cell instance $19886 m0 *1 192.66,189
X$19886 15703 15618 15519 109 77 15617 HA_X1
* cell instance $19889 r0 *1 192.85,189
X$19889 15801 15800 15703 109 77 15797 HA_X1
* cell instance $19891 m0 *1 195.13,189
X$19891 15890 15582 15395 109 77 15798 HA_X1
* cell instance $19895 r0 *1 194.94,189
X$19895 15639 15690 77 109 15582 NOR2_X1
* cell instance $19897 r0 *1 195.7,189
X$19897 77 15691 15765 15795 15929 15798 109 FA_X1
* cell instance $19898 m0 *1 198.36,189
X$19898 15617 15702 15496 109 77 15584 HA_X1
* cell instance $19901 r0 *1 198.74,189
X$19901 15797 15795 15702 109 77 15583 HA_X1
* cell instance $19903 m0 *1 202.54,189
X$19903 15616 77 109 15701 INV_X1
* cell instance $19904 m0 *1 200.64,189
X$19904 15583 15692 15615 109 77 15616 HA_X1
* cell instance $19905 m0 *1 202.92,189
X$19905 15922 15615 15585 109 77 15613 HA_X1
* cell instance $19906 m0 *1 204.82,189
X$19906 15613 77 109 15614 INV_X1
* cell instance $19908 m0 *1 205.39,189
X$19908 77 15701 15605 15611 15614 15586 109 FA_X1
* cell instance $19911 m0 *1 209.38,189
X$19911 15700 77 109 15612 INV_X1
* cell instance $19912 m0 *1 209.76,189
X$19912 77 15698 15699 15608 15612 15587 109 FA_X1
* cell instance $19914 r0 *1 200.83,189
X$19914 15764 15765 15692 109 77 15793 HA_X1
* cell instance $19918 r0 *1 204.06,189
X$19918 15793 15792 15790 109 77 15700 HA_X1
* cell instance $19921 r0 *1 206.53,189
X$19921 15791 77 109 15586 INV_X1
* cell instance $19922 r0 *1 206.91,189
X$19922 15790 15891 15791 109 77 15794 HA_X1
* cell instance $19923 r0 *1 208.81,189
X$19923 15794 77 109 15587 INV_X1
* cell instance $19926 r0 *1 210.9,189
X$19926 15789 77 109 15698 INV_X1
* cell instance $19927 r0 *1 211.28,189
X$19927 15788 15767 15789 109 77 15910 HA_X1
* cell instance $19928 m0 *1 213.56,189
X$19928 15509 77 109 15401 INV_X1
* cell instance $19929 m0 *1 213.18,189
X$19929 15608 77 109 15510 INV_X1
* cell instance $19930 m0 *1 213.94,189
X$19930 15605 77 109 15501 INV_X1
* cell instance $19932 m0 *1 215.08,189
X$19932 15589 15588 77 109 15606 XNOR2_X2
* cell instance $19935 r0 *1 213.56,189
X$19935 15699 77 109 15783 INV_X1
* cell instance $19938 r0 *1 215.08,189
X$19938 15787 15783 15784 109 77 15594 HA_X1
* cell instance $19939 r0 *1 216.98,189
X$19939 15784 77 109 15589 BUF_X2
* cell instance $19940 m0 *1 219.26,189
X$19940 15590 15592 15593 109 15591 77 OAI21_X1
* cell instance $19941 m0 *1 217.36,189
X$19941 15590 15502 77 109 15604 XNOR2_X2
* cell instance $19942 m0 *1 220.02,189
X$19942 15594 15589 15588 77 15592 109 AOI21_X1
* cell instance $19943 m0 *1 220.78,189
X$19943 15589 77 109 15602 INV_X1
* cell instance $19949 m0 *1 232.75,189
X$19949 12804 77 109 15696 BUF_X1
* cell instance $19950 m0 *1 233.32,189
X$19950 10665 77 109 15600 BUF_X1
* cell instance $19953 r0 *1 217.74,189
X$19953 15769 15591 77 109 15753 XNOR2_X2
* cell instance $19954 r0 *1 219.64,189
X$19954 15769 77 109 15770 INV_X2
* cell instance $19955 r0 *1 220.21,189
X$19955 15770 15590 15602 15508 109 15693 77 NOR4_X2
* cell instance $19963 r0 *1 232.18,189
X$19963 9245 77 109 15695 BUF_X1
* cell instance $19964 r0 *1 232.75,189
X$19964 11775 77 109 15777 BUF_X1
* cell instance $19967 r0 *1 233.89,189
X$19967 9862 77 109 15778 BUF_X1
* cell instance $19968 r0 *1 234.46,189
X$19968 9556 77 109 15896 BUF_X1
* cell instance $19970 m0 *1 235.22,189
X$19970 15600 77 109 15595 BUF_X1
* cell instance $19975 r0 *1 236.55,189
X$19975 15778 77 109 15773 BUF_X1
* cell instance $19977 r0 *1 237.88,189
X$19977 15696 77 109 15775 BUF_X1
* cell instance $19978 r0 *1 238.45,189
X$19978 15777 77 109 15596 BUF_X1
* cell instance $19979 r0 *1 239.02,189
X$19979 15695 77 109 15694 BUF_X1
* cell instance $19985 m0 *1 5.32,158.2
X$19985 9961 77 109 12552 CLKBUF_X3
* cell instance $19991 r0 *1 2.28,158.2
X$19991 77 12552 12845 13198 13318 4909 109 DFFR_X1
* cell instance $19996 r0 *1 6.46,158.2
X$19996 77 12552 13027 13143 13199 9814 109 DFFR_X1
* cell instance $19998 m0 *1 8.17,158.2
X$19998 77 12552 13026 12847 13025 9814 109 DFFR_X1
* cell instance $19999 r0 *1 10.26,158.2
X$19999 13143 4065 11858 77 109 13199 MUX2_X1
* cell instance $20001 m0 *1 16.15,158.2
X$20001 13091 12066 13027 77 109 13028 MUX2_X1
* cell instance $20002 m0 *1 12.35,158.2
X$20002 77 12555 13091 12848 12849 9814 109 DFFR_X1
* cell instance $20006 m0 *1 19.95,158.2
X$20006 13205 5513 12929 77 109 12853 MUX2_X1
* cell instance $20007 m0 *1 21.28,158.2
X$20007 12850 4128 12065 77 109 12930 MUX2_X1
* cell instance $20011 r0 *1 13.68,158.2
X$20011 13026 12066 13144 77 109 13204 MUX2_X1
* cell instance $20012 r0 *1 15.01,158.2
X$20012 13026 12189 13144 77 109 13205 MUX2_X1
* cell instance $20013 r0 *1 16.34,158.2
X$20013 13204 9326 13028 77 109 12852 MUX2_X1
* cell instance $20014 r0 *1 17.67,158.2
X$20014 5301 109 13145 77 BUF_X4
* cell instance $20017 r0 *1 21.28,158.2
X$20017 4496 109 12240 77 BUF_X4
* cell instance $20019 m0 *1 23.18,158.2
X$20019 77 5513 109 6231 BUF_X8
* cell instance $20022 r0 *1 25.65,158.2
X$20022 9142 77 109 13096 BUF_X2
* cell instance $20024 m0 *1 26.03,158.2
X$20024 77 12069 13029 12932 12854 9814 109 DFFR_X1
* cell instance $20026 r0 *1 26.41,158.2
X$20026 12069 77 109 19270 CLKBUF_X1
* cell instance $20028 r0 *1 27.17,158.2
X$20028 2631 109 13146 77 BUF_X4
* cell instance $20030 r0 *1 28.69,158.2
X$20030 13403 2938 13029 77 109 13147 MUX2_X1
* cell instance $20032 r0 *1 30.21,158.2
X$20032 13147 3173 13211 77 109 13218 MUX2_X1
* cell instance $20034 r0 *1 31.73,158.2
X$20034 13212 13149 13096 77 109 13215 MUX2_X1
* cell instance $20035 m0 *1 33.06,158.2
X$20035 12855 13098 13096 77 109 12938 MUX2_X1
* cell instance $20036 m0 *1 31.73,158.2
X$20036 2633 109 13149 77 BUF_X4
* cell instance $20038 m0 *1 35.91,158.2
X$20038 10142 109 10952 77 BUF_X4
* cell instance $20039 m0 *1 37.24,158.2
X$20039 12941 2938 13030 77 109 13031 MUX2_X1
* cell instance $20040 m0 *1 38.57,158.2
X$20040 6383 12792 13102 109 12857 77 OAI21_X1
* cell instance $20042 r0 *1 33.06,158.2
X$20042 77 12856 13150 13212 13215 9814 109 DFFR_X1
* cell instance $20043 r0 *1 36.86,158.2
X$20043 13150 6091 12941 77 109 13331 MUX2_X1
* cell instance $20045 r0 *1 38.38,158.2
X$20045 13262 3541 13031 77 109 13151 MUX2_X1
* cell instance $20046 m0 *1 39.9,158.2
X$20046 8463 109 7561 77 BUF_X4
* cell instance $20048 m0 *1 41.23,158.2
X$20048 77 11704 12793 12948 12944 9814 109 DFFR_X1
* cell instance $20050 m0 *1 45.22,158.2
X$20050 77 12860 13032 12950 12949 4086 109 DFFR_X1
* cell instance $20051 m0 *1 49.02,158.2
X$20051 13032 6371 77 109 13107 NAND2_X1
* cell instance $20054 m0 *1 51.87,158.2
X$20054 13263 13156 4210 77 109 12404 NOR3_X1
* cell instance $20056 m0 *1 53.39,158.2
X$20056 7703 13109 13225 8157 6719 13226 77 109 OAI221_X2
* cell instance $20058 m0 *1 57,158.2
X$20058 6820 13034 77 109 13033 NOR2_X1
* cell instance $20060 r0 *1 39.71,158.2
X$20060 13151 3482 13218 77 109 13220 MUX2_X1
* cell instance $20063 r0 *1 41.99,158.2
X$20063 13220 7197 77 109 13152 NOR2_X2
* cell instance $20065 r0 *1 43.32,158.2
X$20065 4774 109 10860 77 BUF_X4
* cell instance $20068 r0 *1 45.79,158.2
X$20068 13153 10583 11129 77 13340 109 AOI21_X1
* cell instance $20069 r0 *1 46.55,158.2
X$20069 11129 13154 77 109 13153 NOR2_X1
* cell instance $20072 r0 *1 47.69,158.2
X$20072 13154 8666 77 109 13222 NOR2_X1
* cell instance $20073 r0 *1 48.26,158.2
X$20073 13222 7321 13032 77 13223 109 AOI21_X1
* cell instance $20074 r0 *1 49.02,158.2
X$20074 10674 77 109 12860 CLKBUF_X3
* cell instance $20075 r0 *1 49.97,158.2
X$20075 9337 13154 13107 109 13109 77 OAI21_X1
* cell instance $20076 r0 *1 50.73,158.2
X$20076 12860 77 109 19168 INV_X1
* cell instance $20077 r0 *1 51.11,158.2
X$20077 13225 77 109 13155 INV_X1
* cell instance $20078 r0 *1 51.49,158.2
X$20078 77 12860 13225 13227 13157 4086 109 DFFR_X1
* cell instance $20079 r0 *1 55.29,158.2
X$20079 13228 11448 6983 77 13157 109 AOI21_X1
* cell instance $20080 r0 *1 56.05,158.2
X$20080 6983 13227 77 109 13228 NOR2_X1
* cell instance $20082 r0 *1 57,158.2
X$20082 5805 109 10590 77 BUF_X4
* cell instance $20083 m0 *1 58.14,158.2
X$20083 13035 7469 10763 77 13110 109 AOI21_X1
* cell instance $20085 m0 *1 58.9,158.2
X$20085 7469 13111 77 109 13035 NOR2_X1
* cell instance $20091 m0 *1 60.04,158.2
X$20091 77 11708 13036 13037 12958 4086 109 DFFR_X1
* cell instance $20095 m0 *1 67.64,158.2
X$20095 11594 5656 13114 77 109 12962 MUX2_X1
* cell instance $20096 m0 *1 68.97,158.2
X$20096 11594 5178 13158 77 109 13038 MUX2_X1
* cell instance $20098 m0 *1 70.49,158.2
X$20098 9440 77 109 12571 CLKBUF_X3
* cell instance $20100 m0 *1 74.48,158.2
X$20100 77 12571 13161 12975 12973 8687 109 DFFR_X1
* cell instance $20104 r0 *1 62.32,158.2
X$20104 13358 13761 4210 109 11710 77 NOR3_X2
* cell instance $20105 r0 *1 63.65,158.2
X$20105 13036 77 109 13357 INV_X1
* cell instance $20109 r0 *1 66.69,158.2
X$20109 77 12571 12863 13158 13038 4086 109 DFFR_X1
* cell instance $20111 r0 *1 71.25,158.2
X$20111 77 12571 13160 13159 13233 8687 109 DFFR_X1
* cell instance $20112 r0 *1 75.05,158.2
X$20112 13159 6820 13164 77 109 13233 MUX2_X1
* cell instance $20114 r0 *1 77.14,158.2
X$20114 13160 8847 13161 77 109 13235 MUX2_X1
* cell instance $20115 r0 *1 78.47,158.2
X$20115 13160 7926 13161 77 109 13237 MUX2_X1
* cell instance $20116 m0 *1 78.85,158.2
X$20116 13039 8847 13120 77 109 13041 MUX2_X1
* cell instance $20118 m0 *1 80.18,158.2
X$20118 13039 13040 13120 77 109 13122 MUX2_X1
* cell instance $20120 m0 *1 81.7,158.2
X$20120 13121 9829 12717 77 109 13123 MUX2_X1
* cell instance $20121 m0 *1 83.03,158.2
X$20121 77 12576 13042 13121 13123 8687 109 DFFR_X1
* cell instance $20122 m0 *1 86.83,158.2
X$20122 13042 7912 13043 77 109 13125 MUX2_X1
* cell instance $20123 m0 *1 88.16,158.2
X$20123 13042 13040 13043 77 109 13045 MUX2_X1
* cell instance $20125 m0 *1 91.01,158.2
X$20125 13046 7912 13047 77 109 13048 MUX2_X1
* cell instance $20126 m0 *1 92.34,158.2
X$20126 12867 6593 8369 77 109 NOR2_X4
* cell instance $20128 m0 *1 94.81,158.2
X$20128 77 13049 109 12831 BUF_X8
* cell instance $20129 m0 *1 97.28,158.2
X$20129 77 12870 13131 13130 13129 8201 109 DFFR_X1
* cell instance $20130 m0 *1 101.08,158.2
X$20130 77 12870 12720 12869 13050 8201 109 DFFR_X1
* cell instance $20131 m0 *1 104.88,158.2
X$20131 7168 109 10449 77 BUF_X4
* cell instance $20135 r0 *1 79.8,158.2
X$20135 13235 8349 13041 77 109 13245 MUX2_X1
* cell instance $20136 r0 *1 81.13,158.2
X$20136 13237 8359 77 109 13162 NOR2_X1
* cell instance $20138 r0 *1 82.08,158.2
X$20138 13122 8239 77 109 13163 NOR2_X1
* cell instance $20142 r0 *1 84.74,158.2
X$20142 7167 77 109 13164 BUF_X2
* cell instance $20145 r0 *1 86.64,158.2
X$20145 13165 7912 13269 77 109 13240 MUX2_X1
* cell instance $20147 r0 *1 88.35,158.2
X$20147 13125 8349 13240 77 109 13247 MUX2_X1
* cell instance $20148 r0 *1 89.68,158.2
X$20148 13045 11132 8359 77 109 13243 NOR3_X1
* cell instance $20149 r0 *1 90.44,158.2
X$20149 13046 13040 13047 77 109 13166 MUX2_X1
* cell instance $20150 r0 *1 91.77,158.2
X$20150 12831 109 13040 77 BUF_X4
* cell instance $20151 r0 *1 93.1,158.2
X$20151 11594 8166 13130 77 109 13129 MUX2_X1
* cell instance $20152 r0 *1 94.43,158.2
X$20152 77 13049 10716 109 BUF_X16
* cell instance $20155 r0 *1 100.13,158.2
X$20155 77 12870 12868 13392 13250 8201 109 DFFR_X1
* cell instance $20158 r0 *1 104.88,158.2
X$20158 9341 77 109 12870 CLKBUF_X3
* cell instance $20160 r0 *1 106.21,158.2
X$20160 6901 77 109 5967 INV_X4
* cell instance $20162 r0 *1 108.68,158.2
X$20162 77 12870 13167 13136 13135 8201 109 DFFR_X1
* cell instance $20163 m0 *1 109.06,158.2
X$20163 13136 9832 12722 77 109 13135 MUX2_X1
* cell instance $20168 r0 *1 112.48,158.2
X$20168 12416 10142 13167 77 109 13051 MUX2_X1
* cell instance $20169 m0 *1 114.38,158.2
X$20169 13051 10860 12873 77 109 13052 MUX2_X1
* cell instance $20170 m0 *1 113.05,158.2
X$20170 13168 10065 12417 77 109 13254 MUX2_X1
* cell instance $20171 m0 *1 115.71,158.2
X$20171 12723 9023 13004 77 109 13170 MUX2_X1
* cell instance $20174 r0 *1 113.81,158.2
X$20174 9742 13254 13253 7742 12575 10086 77 109 OAI221_X2
* cell instance $20178 r0 *1 115.9,158.2
X$20178 13052 9652 13169 77 109 13253 MUX2_X1
* cell instance $20179 r0 *1 117.23,158.2
X$20179 77 13053 13277 13398 13280 4086 109 DFFR_X1
* cell instance $20181 m0 *1 118.18,158.2
X$20181 12722 7279 13005 77 109 13139 MUX2_X1
* cell instance $20186 m0 *1 123.12,158.2
X$20186 77 13074 13142 13141 13054 109 AOI21_X4
* cell instance $20188 m0 *1 125.59,158.2
X$20188 77 13088 13055 13141 12876 109 AOI21_X4
* cell instance $20192 r0 *1 124.07,158.2
X$20192 77 13171 18719 13172 13252 12731 109 DFFR_X1
* cell instance $20193 r0 *1 127.87,158.2
X$20193 13282 13056 13172 77 109 13252 MUX2_X1
* cell instance $20195 m0 *1 128.44,158.2
X$20195 8996 77 109 12550 INV_X2
* cell instance $20197 m0 *1 129.96,158.2
X$20197 13140 13056 13057 77 109 13138 MUX2_X1
* cell instance $20199 m0 *1 132.81,158.2
X$20199 8250 109 6318 77 BUF_X4
* cell instance $20200 m0 *1 134.14,158.2
X$20200 13137 13056 13134 77 109 13251 MUX2_X1
* cell instance $20204 r0 *1 129.39,158.2
X$20204 77 13430 18734 13057 13138 12731 109 DFFR_X1
* cell instance $20205 r0 *1 133.19,158.2
X$20205 77 13430 18874 13134 13251 12731 109 DFFR_X1
* cell instance $20209 r0 *1 138.32,158.2
X$20209 8717 12877 13249 77 109 13173 MUX2_X1
* cell instance $20211 m0 *1 138.89,158.2
X$20211 12877 109 12734 77 BUF_X4
* cell instance $20213 m0 *1 144.78,158.2
X$20213 13058 13175 13059 77 10993 109 AOI21_X2
* cell instance $20214 m0 *1 146.11,158.2
X$20214 13393 11309 77 109 13059 NOR2_X1
* cell instance $20217 m0 *1 148.39,158.2
X$20217 7038 12887 13177 77 109 12112 MUX2_X1
* cell instance $20219 m0 *1 149.91,158.2
X$20219 13060 12832 13133 109 13062 77 OAI21_X1
* cell instance $20221 m0 *1 151.43,158.2
X$20221 11212 12832 13179 109 12885 77 OAI21_X1
* cell instance $20223 r0 *1 139.65,158.2
X$20223 13173 13056 13174 77 109 13394 MUX2_X1
* cell instance $20227 r0 *1 143.64,158.2
X$20227 7009 8506 13292 109 13248 77 NOR3_X2
* cell instance $20228 r0 *1 144.97,158.2
X$20228 77 13248 13246 13181 13175 8996 109 OAI22_X4
* cell instance $20230 r0 *1 148.58,158.2
X$20230 77 10086 13176 13172 13287 13178 12365 13177 109 OAI222_X2
* cell instance $20231 r0 *1 151.24,158.2
X$20231 13244 13288 77 109 13133 NAND2_X1
* cell instance $20233 r0 *1 152,158.2
X$20233 13241 13288 77 109 13242 NAND2_X1
* cell instance $20235 m0 *1 152.76,158.2
X$20235 11894 12832 13289 109 12271 77 OAI21_X1
* cell instance $20237 m0 *1 153.52,158.2
X$20237 12424 12832 13291 109 13006 77 OAI21_X1
* cell instance $20238 m0 *1 154.28,158.2
X$20238 9902 12832 13180 109 12673 77 OAI21_X1
* cell instance $20240 m0 *1 155.8,158.2
X$20240 6476 13181 13064 77 109 12590 MUX2_X1
* cell instance $20242 r0 *1 152.76,158.2
X$20242 77 9272 13176 13057 13182 13178 13185 12743 109 OAI222_X2
* cell instance $20244 r0 *1 155.61,158.2
X$20244 77 13183 13176 13174 13182 13178 13186 13064 109 OAI222_X2
* cell instance $20245 m0 *1 157.7,158.2
X$20245 13128 6564 13065 77 12042 109 AOI21_X1
* cell instance $20248 r0 *1 158.27,158.2
X$20248 77 9122 13292 13134 13182 13178 13072 13239 109 OAI222_X2
* cell instance $20249 m0 *1 159.03,158.2
X$20249 13239 13065 77 109 13128 NOR2_X1
* cell instance $20251 m0 *1 159.6,158.2
X$20251 13184 7053 13065 77 12439 109 AOI21_X1
* cell instance $20253 m0 *1 160.55,158.2
X$20253 13127 12999 13068 77 109 12892 OR3_X1
* cell instance $20254 m0 *1 161.5,158.2
X$20254 10242 109 12999 77 BUF_X4
* cell instance $20256 m0 *1 163.02,158.2
X$20256 8572 13124 13363 77 11427 109 AOI21_X2
* cell instance $20257 m0 *1 164.35,158.2
X$20257 11309 5472 13067 77 13124 109 AOI21_X1
* cell instance $20262 m0 *1 166.44,158.2
X$20262 13071 12894 12895 77 109 12438 OR3_X1
* cell instance $20263 m0 *1 165.49,158.2
X$20263 13236 12894 12895 77 109 12589 OR3_X1
* cell instance $20264 m0 *1 167.39,158.2
X$20264 13520 12894 12895 77 109 12524 OR3_X1
* cell instance $20265 m0 *1 168.34,158.2
X$20265 13521 12999 13068 77 109 13116 OR3_X1
* cell instance $20266 m0 *1 169.29,158.2
X$20266 6755 13069 13229 109 77 9609 OAI21_X2
* cell instance $20268 m0 *1 170.81,158.2
X$20268 77 13118 13117 12731 12593 12893 109 DFFR_X2
* cell instance $20269 m0 *1 174.99,158.2
X$20269 13070 11412 77 109 13113 NAND2_X1
* cell instance $20272 r0 *1 166.06,158.2
X$20272 13232 13072 12822 109 11241 77 OAI21_X1
* cell instance $20275 r0 *1 168.72,158.2
X$20275 13234 12999 13068 77 109 12752 OR3_X1
* cell instance $20276 r0 *1 169.67,158.2
X$20276 13232 13185 12822 109 13069 77 OAI21_X1
* cell instance $20277 r0 *1 170.43,158.2
X$20277 8264 13186 12822 109 11323 77 OAI21_X1
* cell instance $20281 r0 *1 171.19,158.2
X$20281 11829 13187 12822 109 13231 77 OAI21_X1
* cell instance $20283 r0 *1 172.14,158.2
X$20283 77 13118 13230 12731 12753 13186 109 DFFR_X2
* cell instance $20284 m0 *1 176.13,158.2
X$20284 13115 12894 12895 77 109 12023 OR3_X1
* cell instance $20287 m0 *1 180.12,158.2
X$20287 13352 12894 12895 77 109 12898 OR3_X1
* cell instance $20289 m0 *1 182.59,158.2
X$20289 77 11327 13073 12731 13071 11676 109 DFFR_X2
* cell instance $20290 m0 *1 186.77,158.2
X$20290 77 11327 13346 3676 12972 12365 109 DFFR_X2
* cell instance $20293 m0 *1 194.75,158.2
X$20293 13075 12902 13106 109 77 10930 OAI21_X4
* cell instance $20294 m0 *1 197.22,158.2
X$20294 12899 13081 109 77 12963 AND2_X1
* cell instance $20295 m0 *1 197.98,158.2
X$20295 13076 12903 13081 77 13106 109 AOI21_X2
* cell instance $20297 r0 *1 176.32,158.2
X$20297 10086 13298 13113 13296 12365 109 77 13224 OAI221_X1
* cell instance $20300 r0 *1 180.69,158.2
X$20300 77 11327 13302 12731 12995 13187 109 DFFR_X2
* cell instance $20305 r0 *1 187.72,158.2
X$20305 77 3676 12731 109 BUF_X32
* cell instance $20307 r0 *1 197.41,158.2
X$20307 12986 12991 13221 109 77 13078 HA_X1
* cell instance $20308 r0 *1 199.31,158.2
X$20308 13221 77 109 13077 CLKBUF_X2
* cell instance $20309 m0 *1 199.88,158.2
X$20309 13078 13077 12763 77 13105 109 AOI21_X1
* cell instance $20311 m0 *1 200.64,158.2
X$20311 12765 12902 13077 77 109 13104 NAND3_X1
* cell instance $20312 m0 *1 201.4,158.2
X$20312 13078 12763 12902 77 109 13079 NOR3_X1
* cell instance $20313 m0 *1 202.16,158.2
X$20313 13078 77 109 13080 INV_X1
* cell instance $20315 m0 *1 202.73,158.2
X$20315 13080 12946 12905 109 77 13076 OAI21_X2
* cell instance $20316 m0 *1 204.06,158.2
X$20316 13081 12612 13100 77 109 13101 AND3_X4
* cell instance $20317 m0 *1 206.15,158.2
X$20317 77 12957 12952 12947 13101 9243 109 NOR4_X4
* cell instance $20320 m0 *1 210.52,158.2
X$20320 13099 77 109 13082 INV_X1
* cell instance $20321 m0 *1 210.9,158.2
X$20321 77 12134 13213 13214 13082 3676 109 DFFR_X1
* cell instance $20324 m0 *1 217.93,158.2
X$20324 4036 12909 77 109 12789 NAND2_X1
* cell instance $20328 r0 *1 201.78,158.2
X$20328 12902 13219 13080 77 13103 109 AOI21_X1
* cell instance $20329 r0 *1 202.54,158.2
X$20329 12765 12763 13077 109 13219 77 OAI21_X1
* cell instance $20332 r0 *1 204.25,158.2
X$20332 12905 12953 12946 77 109 12906 NAND3_X1
* cell instance $20333 r0 *1 205.01,158.2
X$20333 13077 77 109 12946 INV_X1
* cell instance $20335 r0 *1 205.58,158.2
X$20335 13490 77 109 13217 INV_X1
* cell instance $20338 r0 *1 207.67,158.2
X$20338 77 13305 13188 13216 13307 3676 109 DFFR_X1
* cell instance $20340 r0 *1 212.23,158.2
X$20340 13214 13309 13189 13190 77 109 13099 AOI22_X1
* cell instance $20342 r0 *1 213.56,158.2
X$20342 13308 13467 13213 109 13189 77 OAI21_X1
* cell instance $20345 r0 *1 215.46,158.2
X$20345 77 18444 13083 13210 13191 109 DFF_X1
* cell instance $20346 r0 *1 218.69,158.2
X$20346 13083 11506 13209 77 109 13210 MUX2_X1
* cell instance $20347 m0 *1 219.07,158.2
X$20347 13083 77 109 13084 INV_X1
* cell instance $20349 m0 *1 219.45,158.2
X$20349 9559 13084 4036 77 13097 109 AOI21_X2
* cell instance $20350 m0 *1 220.78,158.2
X$20350 77 18340 13094 13095 12302 109 DFF_X1
* cell instance $20353 m0 *1 224.96,158.2
X$20353 77 13093 9540 13094 4036 109 AOI21_X4
* cell instance $20354 m0 *1 227.43,158.2
X$20354 77 18348 12915 13203 12302 109 DFF_X1
* cell instance $20356 m0 *1 231.42,158.2
X$20356 13086 77 109 12305 CLKBUF_X3
* cell instance $20357 m0 *1 232.37,158.2
X$20357 13086 77 109 13201 CLKBUF_X3
* cell instance $20358 m0 *1 233.32,158.2
X$20358 13074 77 109 12920 BUF_X1
* cell instance $20360 m0 *1 234.08,158.2
X$20360 13086 77 109 10500 CLKBUF_X3
* cell instance $20361 m0 *1 235.03,158.2
X$20361 13090 12304 12156 109 12772 77 OAI21_X1
* cell instance $20362 m0 *1 235.79,158.2
X$20362 12918 77 109 13090 INV_X1
* cell instance $20364 r0 *1 220.02,158.2
X$20364 13097 13208 109 77 13209 XNOR2_X1
* cell instance $20365 r0 *1 221.16,158.2
X$20365 13192 13097 77 109 12912 NAND2_X1
* cell instance $20367 r0 *1 222.11,158.2
X$20367 13093 13207 13193 77 109 13192 NOR3_X1
* cell instance $20368 r0 *1 222.87,158.2
X$20368 13093 13311 109 77 13206 XNOR2_X1
* cell instance $20369 r0 *1 224.01,158.2
X$20369 13094 11506 13206 77 109 13095 MUX2_X1
* cell instance $20370 r0 *1 225.34,158.2
X$20370 11783 12297 13085 109 77 13312 AND3_X1
* cell instance $20372 r0 *1 226.48,158.2
X$20372 13092 13093 12304 77 13194 109 AOI21_X2
* cell instance $20376 r0 *1 227.81,158.2
X$20376 12915 13201 13194 77 109 13203 MUX2_X1
* cell instance $20379 r0 *1 230.85,158.2
X$20379 13202 12304 12297 77 109 13195 MUX2_X1
* cell instance $20382 r0 *1 232.75,158.2
X$20382 3822 77 109 13200 INV_X1
* cell instance $20383 r0 *1 233.13,158.2
X$20383 13200 77 109 10498 CLKBUF_X3
* cell instance $20384 r0 *1 234.08,158.2
X$20384 13200 77 109 12304 CLKBUF_X3
* cell instance $20385 r0 *1 235.03,158.2
X$20385 77 18392 13314 13313 12621 109 DFF_X1
* cell instance $20386 m0 *1 236.74,158.2
X$20386 12926 77 109 12773 BUF_X1
* cell instance $20388 m0 *1 237.31,158.2
X$20388 12924 10500 12919 77 109 13089 MUX2_X1
* cell instance $20390 r0 *1 238.26,158.2
X$20390 12919 77 109 12921 BUF_X1
* cell instance $20391 r0 *1 238.83,158.2
X$20391 12772 77 109 13087 BUF_X1
* cell instance $20393 m0 *1 239.02,158.2
X$20393 13088 77 109 12774 BUF_X1
* cell instance $20402 r0 *1 1.52,149.8
X$20402 77 11262 12239 12238 12471 4909 109 DFFR_X1
* cell instance $20406 r0 *1 5.32,149.8
X$20406 12238 10198 11979 77 109 12471 MUX2_X1
* cell instance $20407 m0 *1 6.84,149.8
X$20407 12239 12153 12393 77 109 12311 MUX2_X1
* cell instance $20408 m0 *1 5.51,149.8
X$20408 12152 5301 11979 77 109 12151 MUX2_X1
* cell instance $20410 r0 *1 6.65,149.8
X$20410 12239 12072 12393 77 109 11697 MUX2_X1
* cell instance $20413 m0 *1 8.55,149.8
X$20413 12311 12240 12063 77 109 12162 MUX2_X1
* cell instance $20417 m0 *1 11.02,149.8
X$20417 5726 109 12312 77 BUF_X4
* cell instance $20419 r0 *1 11.21,149.8
X$20419 77 12555 12244 12474 12475 9814 109 DFFR_X1
* cell instance $20420 m0 *1 14.82,149.8
X$20420 12241 11276 12242 77 109 12315 MUX2_X1
* cell instance $20421 m0 *1 13.49,149.8
X$20421 12241 11461 12242 77 109 12243 MUX2_X1
* cell instance $20424 m0 *1 17.1,149.8
X$20424 12315 11278 12246 77 109 12320 MUX2_X1
* cell instance $20428 m0 *1 20.9,149.8
X$20428 10273 109 12065 77 BUF_X4
* cell instance $20432 r0 *1 15.2,149.8
X$20432 12244 11461 12245 77 109 12478 MUX2_X1
* cell instance $20433 r0 *1 16.53,149.8
X$20433 12244 11276 12245 77 109 12246 MUX2_X1
* cell instance $20434 r0 *1 17.86,149.8
X$20434 12394 3594 12479 77 109 12395 MUX2_X1
* cell instance $20435 r0 *1 19.19,149.8
X$20435 77 11701 12067 12479 12395 9814 109 DFFR_X1
* cell instance $20436 r0 *1 22.99,149.8
X$20436 12557 7063 12162 77 109 12323 MUX2_X1
* cell instance $20437 m0 *1 23.56,149.8
X$20437 12319 7619 12320 77 109 12163 MUX2_X1
* cell instance $20439 m0 *1 24.89,149.8
X$20439 12068 11278 12321 77 109 12319 MUX2_X1
* cell instance $20440 m0 *1 26.22,149.8
X$20440 11859 11276 12397 77 109 12321 MUX2_X1
* cell instance $20442 m0 *1 30.59,149.8
X$20442 12324 5110 11980 77 109 12326 MUX2_X1
* cell instance $20443 m0 *1 31.92,149.8
X$20443 77 11704 12328 12324 12326 9814 109 DFFR_X1
* cell instance $20444 m0 *1 35.72,149.8
X$20444 12328 11276 12398 77 109 12070 MUX2_X1
* cell instance $20446 r0 *1 24.32,149.8
X$20446 2786 109 12481 77 BUF_X4
* cell instance $20449 r0 *1 26.22,149.8
X$20449 11859 11461 12397 77 109 12322 MUX2_X1
* cell instance $20450 r0 *1 27.55,149.8
X$20450 12165 4320 12322 77 109 12247 MUX2_X1
* cell instance $20451 r0 *1 28.88,149.8
X$20451 12247 7063 12396 77 109 12483 MUX2_X1
* cell instance $20453 r0 *1 30.4,149.8
X$20453 12483 6379 12323 77 109 12485 MUX2_X1
* cell instance $20454 r0 *1 31.73,149.8
X$20454 10273 109 11980 77 BUF_X4
* cell instance $20455 r0 *1 33.06,149.8
X$20455 6816 109 2931 77 BUF_X4
* cell instance $20458 r0 *1 34.96,149.8
X$20458 11704 77 109 19109 INV_X2
* cell instance $20459 r0 *1 35.53,149.8
X$20459 12328 5039 12398 77 109 12489 MUX2_X1
* cell instance $20460 r0 *1 36.86,149.8
X$20460 11865 5275 12489 77 109 12249 MUX2_X1
* cell instance $20461 m0 *1 37.62,149.8
X$20461 12248 7321 77 109 12250 NAND2_X1
* cell instance $20464 m0 *1 39.71,149.8
X$20464 77 6100 12072 109 BUF_X32
* cell instance $20466 m0 *1 49.78,149.8
X$20466 12073 6627 11868 77 109 12340 MUX2_X1
* cell instance $20469 r0 *1 38.19,149.8
X$20469 7703 12857 12071 7643 109 77 12493 OAI22_X1
* cell instance $20470 r0 *1 39.14,149.8
X$20470 7580 12493 12492 109 12642 77 OAI21_X1
* cell instance $20471 r0 *1 39.9,149.8
X$20471 5728 109 12066 77 BUF_X4
* cell instance $20474 r0 *1 41.8,149.8
X$20474 9834 12400 77 109 12495 NOR2_X1
* cell instance $20475 r0 *1 42.37,149.8
X$20475 12495 10583 9834 77 12333 109 AOI21_X1
* cell instance $20476 r0 *1 43.13,149.8
X$20476 12560 10952 12497 77 109 12401 MUX2_X1
* cell instance $20477 r0 *1 44.46,149.8
X$20477 77 11116 12497 12336 12399 9814 109 DFFR_X1
* cell instance $20479 r0 *1 48.45,149.8
X$20479 11280 7619 12498 77 109 12499 MUX2_X1
* cell instance $20481 r0 *1 50.16,149.8
X$20481 12499 7917 77 109 12500 NOR2_X1
* cell instance $20482 r0 *1 50.73,149.8
X$20482 12403 11449 7202 77 109 12506 NAND3_X2
* cell instance $20483 r0 *1 52.06,149.8
X$20483 12500 12404 7997 109 12251 77 NOR3_X2
* cell instance $20484 m0 *1 52.44,149.8
X$20484 12074 6091 12340 77 109 12501 MUX2_X1
* cell instance $20486 m0 *1 53.77,149.8
X$20486 12076 8407 12185 77 109 12252 MUX2_X1
* cell instance $20487 m0 *1 55.1,149.8
X$20487 12252 10368 12253 77 109 12077 MUX2_X1
* cell instance $20488 m0 *1 56.43,149.8
X$20488 12077 7197 11453 77 109 12341 MUX2_X1
* cell instance $20489 m0 *1 57.76,149.8
X$20489 77 11731 12251 7026 12341 109 AOI21_X4
* cell instance $20490 m0 *1 60.23,149.8
X$20490 9832 12345 77 109 12078 NOR2_X1
* cell instance $20493 r0 *1 53.39,149.8
X$20493 12501 5017 12503 77 109 12505 MUX2_X1
* cell instance $20496 r0 *1 55.86,149.8
X$20496 11872 6296 12505 77 109 12566 MUX2_X1
* cell instance $20497 r0 *1 57.19,149.8
X$20497 12078 10132 9832 77 12342 109 AOI21_X1
* cell instance $20499 r0 *1 58.14,149.8
X$20499 77 11708 12511 12345 12342 9814 109 DFFR_X1
* cell instance $20504 r0 *1 62.32,149.8
X$20504 77 11708 12406 12348 12405 9814 109 DFFR_X1
* cell instance $20505 m0 *1 62.89,149.8
X$20505 12347 10132 9830 77 12405 109 AOI21_X1
* cell instance $20509 m0 *1 64.03,149.8
X$20509 9830 12348 77 109 12347 NOR2_X1
* cell instance $20511 m0 *1 64.98,149.8
X$20511 12406 10957 12511 77 109 12349 MUX2_X1
* cell instance $20512 m0 *1 67.07,149.8
X$20512 12349 11125 12254 77 109 12255 MUX2_X1
* cell instance $20513 m0 *1 68.4,149.8
X$20513 12255 8671 12081 77 109 12082 MUX2_X1
* cell instance $20516 r0 *1 66.31,149.8
X$20516 12511 8349 12570 77 109 12513 MUX2_X1
* cell instance $20518 r0 *1 68.02,149.8
X$20518 12513 4643 12512 77 109 12514 MUX2_X1
* cell instance $20519 r0 *1 69.35,149.8
X$20519 12514 8672 77 109 11591 NOR2_X1
* cell instance $20521 m0 *1 70.3,149.8
X$20521 77 11593 12190 12354 12357 4086 109 DFFR_X1
* cell instance $20525 r0 *1 72.2,149.8
X$20525 12354 9985 11289 77 109 12357 MUX2_X1
* cell instance $20527 r0 *1 73.91,149.8
X$20527 9440 77 109 11593 CLKBUF_X3
* cell instance $20528 m0 *1 74.67,149.8
X$20528 12083 10065 12358 77 109 12084 MUX2_X1
* cell instance $20533 m0 *1 79.99,149.8
X$20533 7703 12256 12519 7643 109 77 12200 OAI22_X1
* cell instance $20535 m0 *1 81.13,149.8
X$20535 9440 77 109 11291 CLKBUF_X3
* cell instance $20536 m0 *1 82.08,149.8
X$20536 9570 7876 12257 77 12366 109 AOI21_X1
* cell instance $20538 m0 *1 84.36,149.8
X$20538 12258 6885 11293 77 109 12522 MUX2_X1
* cell instance $20541 m0 *1 86.64,149.8
X$20541 12258 4914 77 109 12209 NOR2_X1
* cell instance $20542 m0 *1 87.21,149.8
X$20542 12209 8421 12088 77 12368 109 AOI21_X1
* cell instance $20543 m0 *1 87.97,149.8
X$20543 7403 12258 12089 109 12526 77 OAI21_X1
* cell instance $20545 m0 *1 88.92,149.8
X$20545 12368 6459 8191 8369 12369 12371 109 77 AOI221_X2
* cell instance $20547 m0 *1 91.2,149.8
X$20547 12529 77 109 12369 INV_X1
* cell instance $20548 m0 *1 91.58,149.8
X$20548 9742 12374 12084 9801 12375 9272 77 109 OAI221_X2
* cell instance $20550 m0 *1 93.86,149.8
X$20550 12090 6379 12377 77 109 12374 MUX2_X1
* cell instance $20554 r0 *1 75.24,149.8
X$20554 11289 6716 12516 77 109 12517 MUX2_X1
* cell instance $20555 r0 *1 76.57,149.8
X$20555 77 11593 12519 12516 12517 8687 109 DFFR_X1
* cell instance $20558 r0 *1 80.94,149.8
X$20558 7580 12200 12366 109 12375 77 OAI21_X1
* cell instance $20561 r0 *1 82.27,149.8
X$20561 5415 12520 7618 12519 109 77 12672 OAI22_X2
* cell instance $20562 r0 *1 83.98,149.8
X$20562 77 11291 18850 12258 12522 8687 109 DFFR_X1
* cell instance $20564 r0 *1 87.97,149.8
X$20564 7020 12526 12529 8157 109 77 12408 OAI22_X1
* cell instance $20565 r0 *1 88.92,149.8
X$20565 77 12576 12529 12531 12409 8201 109 DFFR_X1
* cell instance $20567 r0 *1 92.91,149.8
X$20567 12532 7063 12382 77 109 12377 MUX2_X1
* cell instance $20569 r0 *1 94.62,149.8
X$20569 12534 4320 12829 77 109 12532 MUX2_X1
* cell instance $20570 r0 *1 95.95,149.8
X$20570 11880 11461 12577 77 109 12534 MUX2_X1
* cell instance $20572 m0 *1 96.33,149.8
X$20572 8080 8375 77 12218 109 NAND2_X4
* cell instance $20574 m0 *1 99.75,149.8
X$20574 12091 7936 12092 77 109 12260 MUX2_X1
* cell instance $20575 m0 *1 101.08,149.8
X$20575 12260 8375 12384 77 109 12381 MUX2_X1
* cell instance $20576 m0 *1 102.41,149.8
X$20576 12093 12240 12224 77 109 12382 MUX2_X1
* cell instance $20578 r0 *1 97.28,149.8
X$20578 12535 7877 11880 77 109 12537 MUX2_X1
* cell instance $20581 r0 *1 99.18,149.8
X$20581 12537 8421 12411 77 109 12683 MUX2_X1
* cell instance $20584 r0 *1 101.46,149.8
X$20584 12381 12413 77 109 12412 NOR2_X1
* cell instance $20586 r0 *1 102.41,149.8
X$20586 77 12225 12415 12410 12414 12236 109 NAND4_X4
* cell instance $20587 m0 *1 104.31,149.8
X$20587 77 12261 12092 12262 12386 8201 109 DFFR_X1
* cell instance $20589 m0 *1 108.11,149.8
X$20589 12262 9824 11573 77 109 12386 MUX2_X1
* cell instance $20594 r0 *1 108.11,149.8
X$20594 12542 9830 11293 77 109 12387 MUX2_X1
* cell instance $20596 r0 *1 109.63,149.8
X$20596 77 12261 12416 12542 12387 8201 109 DFFR_X1
* cell instance $20597 m0 *1 110.77,149.8
X$20597 77 9652 109 5967 BUF_X8
* cell instance $20601 r0 *1 113.62,149.8
X$20601 11885 9652 12390 77 109 12417 MUX2_X1
* cell instance $20602 m0 *1 113.81,149.8
X$20602 77 12263 12096 12259 12389 7038 109 NAND4_X4
* cell instance $20606 r0 *1 114.95,149.8
X$20606 77 12096 12263 12389 12259 7029 109 AND4_X4
* cell instance $20610 r0 *1 117.42,149.8
X$20610 12547 4774 12098 77 109 12390 MUX2_X1
* cell instance $20611 m0 *1 122.17,149.8
X$20611 11892 109 10787 77 BUF_X4
* cell instance $20612 m0 *1 118.37,149.8
X$20612 77 10982 12097 12231 12391 4086 109 DFFR_X1
* cell instance $20613 m0 *1 123.5,149.8
X$20613 10733 109 12264 77 BUF_X4
* cell instance $20614 m0 *1 124.83,149.8
X$20614 12265 109 12099 77 BUF_X4
* cell instance $20615 m0 *1 126.16,149.8
X$20615 77 11895 7996 12392 12099 11684 12266 11894 109 AOI222_X2
* cell instance $20616 m0 *1 128.82,149.8
X$20616 77 11895 8462 12422 12099 12388 12266 7053 109 AOI222_X2
* cell instance $20617 m0 *1 131.48,149.8
X$20617 77 11895 9805 12267 12099 8000 12266 12268 109 AOI222_X2
* cell instance $20618 m0 *1 134.14,149.8
X$20618 77 12154 12385 12100 12237 109 AOI21_X4
* cell instance $20619 m0 *1 136.61,149.8
X$20619 11036 12426 12102 12383 77 109 12543 OR4_X1
* cell instance $20624 r0 *1 119.7,149.8
X$20624 12548 9824 12095 77 109 12418 MUX2_X1
* cell instance $20629 r0 *1 125.21,149.8
X$20629 12419 109 11895 77 BUF_X4
* cell instance $20630 r0 *1 126.54,149.8
X$20630 12264 109 12266 77 BUF_X4
* cell instance $20631 r0 *1 127.87,149.8
X$20631 12419 12424 12099 11731 77 109 11893 AOI22_X1
* cell instance $20632 r0 *1 128.82,149.8
X$20632 77 12359 12551 12100 12422 109 AOI21_X4
* cell instance $20633 r0 *1 131.29,149.8
X$20633 7028 12421 77 109 12423 NOR2_X1
* cell instance $20634 r0 *1 131.86,149.8
X$20634 77 12313 12549 12100 12267 109 AOI21_X4
* cell instance $20635 r0 *1 134.33,149.8
X$20635 6564 11892 77 109 12549 NOR2_X1
* cell instance $20638 r0 *1 135.47,149.8
X$20638 5716 5472 8512 109 77 12546 OAI21_X2
* cell instance $20640 r0 *1 137.18,149.8
X$20640 8957 8718 12543 12545 77 109 12425 OR4_X1
* cell instance $20641 r0 *1 138.32,149.8
X$20641 11838 77 109 12268 BUF_X1
* cell instance $20643 m0 *1 139.84,149.8
X$20643 12103 12269 77 109 8111 XNOR2_X2
* cell instance $20644 m0 *1 138.89,149.8
X$20644 11201 9101 12277 77 109 12383 OR3_X1
* cell instance $20645 m0 *1 141.74,149.8
X$20645 12380 12104 109 6359 77 XOR2_X2
* cell instance $20646 m0 *1 143.45,149.8
X$20646 12111 12104 12232 77 11898 109 AOI21_X2
* cell instance $20647 m0 *1 144.78,149.8
X$20647 12111 12104 12379 77 12056 109 AOI21_X2
* cell instance $20648 m0 *1 146.11,149.8
X$20648 12372 12223 12431 109 77 12111 HA_X1
* cell instance $20650 r0 *1 139.08,149.8
X$20650 12426 77 109 12427 BUF_X1
* cell instance $20651 r0 *1 139.65,149.8
X$20651 8000 109 12541 77 BUF_X4
* cell instance $20653 r0 *1 141.17,149.8
X$20653 12428 12429 12686 77 12106 109 AOI21_X2
* cell instance $20654 r0 *1 142.5,149.8
X$20654 12277 77 109 12539 BUF_X1
* cell instance $20655 r0 *1 143.07,149.8
X$20655 12428 12429 12687 77 11900 109 AOI21_X2
* cell instance $20656 r0 *1 144.4,149.8
X$20656 12378 77 109 12103 BUF_X2
* cell instance $20657 r0 *1 145.16,149.8
X$20657 12431 109 12104 77 BUF_X4
* cell instance $20658 r0 *1 146.49,149.8
X$20658 12379 77 109 12107 INV_X1
* cell instance $20659 r0 *1 146.87,149.8
X$20659 12376 12530 12378 109 77 12379 HA_X1
* cell instance $20660 m0 *1 148.58,149.8
X$20660 11740 11908 12432 77 109 12376 MUX2_X1
* cell instance $20665 r0 *1 149.53,149.8
X$20665 12588 11084 109 77 12587 XNOR2_X1
* cell instance $20667 m0 *1 151.24,149.8
X$20667 11481 12270 12434 77 109 12192 MUX2_X1
* cell instance $20669 m0 *1 152.57,149.8
X$20669 11602 12270 12271 77 109 12208 MUX2_X1
* cell instance $20671 m0 *1 154.09,149.8
X$20671 11909 12273 77 109 12272 NOR2_X1
* cell instance $20673 r0 *1 151.43,149.8
X$20673 11741 11908 12538 77 109 12346 MUX2_X1
* cell instance $20676 r0 *1 153.33,149.8
X$20676 12272 12116 12536 77 12372 109 AOI21_X1
* cell instance $20677 r0 *1 154.09,149.8
X$20677 11604 12273 77 109 12834 NOR2_X1
* cell instance $20679 m0 *1 155.23,149.8
X$20679 12370 12273 77 109 12435 NOR2_X1
* cell instance $20682 m0 *1 156.56,149.8
X$20682 11914 11908 12590 77 109 12217 MUX2_X1
* cell instance $20683 m0 *1 157.89,149.8
X$20683 11303 10807 109 77 12367 XNOR2_X1
* cell instance $20685 m0 *1 159.22,149.8
X$20685 11919 12273 77 109 12113 NOR2_X1
* cell instance $20686 m0 *1 159.79,149.8
X$20686 12275 7230 12438 109 12223 77 OAI21_X1
* cell instance $20689 r0 *1 155.61,149.8
X$20689 12435 12116 12436 77 12274 109 AOI21_X2
* cell instance $20690 r0 *1 156.94,149.8
X$20690 12533 12433 12046 77 109 12527 MUX2_X1
* cell instance $20694 r0 *1 159.6,149.8
X$20694 12437 12433 11606 77 109 12363 MUX2_X1
* cell instance $20695 r0 *1 160.93,149.8
X$20695 12275 7804 12524 109 12530 77 OAI21_X1
* cell instance $20696 m0 *1 162.26,149.8
X$20696 11303 77 109 12588 CLKBUF_X3
* cell instance $20697 m0 *1 160.93,149.8
X$20697 11607 12270 12439 77 109 12114 MUX2_X1
* cell instance $20702 r0 *1 163.4,149.8
X$20702 11746 12270 12528 77 109 12521 MUX2_X1
* cell instance $20707 m0 *1 4.56,130.2
X$20707 10270 5726 10425 77 109 10349 MUX2_X1
* cell instance $20714 m0 *1 7.6,130.2
X$20714 10351 7477 10504 77 109 10839 MUX2_X1
* cell instance $20715 m0 *1 6.27,130.2
X$20715 10351 9178 10504 77 109 10426 MUX2_X1
* cell instance $20720 m0 *1 14.63,130.2
X$20720 10428 10508 10429 77 109 10507 MUX2_X1
* cell instance $20721 m0 *1 10.83,130.2
X$20721 77 9956 10430 10428 10507 4909 109 DFFR_X1
* cell instance $20725 r0 *1 11.59,130.2
X$20725 10666 2400 10429 77 109 10427 MUX2_X1
* cell instance $20726 r0 *1 12.92,130.2
X$20726 9961 77 109 9956 CLKBUF_X3
* cell instance $20728 r0 *1 14.63,130.2
X$20728 10669 2786 10429 77 109 10667 MUX2_X1
* cell instance $20729 r0 *1 15.96,130.2
X$20729 77 9956 10431 10669 10667 4909 109 DFFR_X1
* cell instance $20731 m0 *1 19.38,130.2
X$20731 10430 4138 10431 77 109 10511 MUX2_X1
* cell instance $20732 m0 *1 21.47,130.2
X$20732 10574 5951 10432 77 109 10576 MUX2_X1
* cell instance $20737 r0 *1 19.95,130.2
X$20737 10430 5522 10431 77 109 10671 MUX2_X1
* cell instance $20739 r0 *1 21.47,130.2
X$20739 10574 9178 10432 77 109 10575 MUX2_X1
* cell instance $20743 r0 *1 24.13,130.2
X$20743 9175 109 7619 77 BUF_X4
* cell instance $20744 m0 *1 25.65,130.2
X$20744 9175 109 5818 77 BUF_X4
* cell instance $20748 m0 *1 30.21,130.2
X$20748 77 5446 4322 109 BUF_X16
* cell instance $20749 m0 *1 34.96,130.2
X$20749 9968 77 109 19221 CLKBUF_X1
* cell instance $20752 r0 *1 25.46,130.2
X$20752 10258 77 109 10429 BUF_X2
* cell instance $20755 r0 *1 29.64,130.2
X$20755 10258 77 109 10425 BUF_X2
* cell instance $20758 r0 *1 33.82,130.2
X$20758 10679 5110 10131 77 109 10681 MUX2_X1
* cell instance $20759 r0 *1 35.15,130.2
X$20759 77 9968 10433 10679 10681 4909 109 DFFR_X1
* cell instance $20760 m0 *1 37.62,130.2
X$20760 3861 109 10435 77 BUF_X4
* cell instance $20762 m0 *1 38.95,130.2
X$20762 10433 8229 10434 77 109 10274 MUX2_X1
* cell instance $20763 m0 *1 40.28,130.2
X$20763 10433 10435 10434 77 109 10522 MUX2_X1
* cell instance $20764 m0 *1 41.61,130.2
X$20764 6717 77 109 10436 INV_X1
* cell instance $20767 m0 *1 45.79,130.2
X$20767 10279 77 109 19243 CLKBUF_X1
* cell instance $20768 m0 *1 46.36,130.2
X$20768 10132 7767 10579 109 10524 77 OAI21_X1
* cell instance $20770 m0 *1 48.64,130.2
X$20770 9972 7767 10525 109 10580 77 OAI21_X1
* cell instance $20771 m0 *1 49.4,130.2
X$20771 8345 109 10142 77 BUF_X4
* cell instance $20772 m0 *1 50.73,130.2
X$20772 7922 10437 77 109 10525 NAND2_X1
* cell instance $20777 r0 *1 40.28,130.2
X$20777 10436 8369 6866 5410 10692 10691 109 77 AOI221_X2
* cell instance $20779 r0 *1 42.56,130.2
X$20779 77 10279 10760 10698 10524 1663 109 DFFR_X1
* cell instance $20780 r0 *1 46.36,130.2
X$20780 10674 77 109 10279 CLKBUF_X3
* cell instance $20781 r0 *1 47.31,130.2
X$20781 7922 10698 77 109 10579 NAND2_X1
* cell instance $20782 r0 *1 47.88,130.2
X$20782 77 10279 10962 10437 10580 1663 109 DFFR_X1
* cell instance $20785 m0 *1 51.68,130.2
X$20785 6816 109 3619 77 BUF_X4
* cell instance $20786 m0 *1 53.77,130.2
X$20786 77 9974 10139 10376 10438 9814 109 DFFR_X1
* cell instance $20789 r0 *1 52.44,130.2
X$20789 6816 109 3613 77 BUF_X4
* cell instance $20792 r0 *1 55.48,130.2
X$20792 9972 3794 10700 109 10581 77 OAI21_X1
* cell instance $20795 r0 *1 57.38,130.2
X$20795 3709 10582 77 109 10700 NAND2_X1
* cell instance $20797 r0 *1 58.14,130.2
X$20797 77 10442 10703 10587 10439 9814 109 DFFR_X1
* cell instance $20802 m0 *1 60.99,130.2
X$20802 8986 4639 10527 109 10439 77 OAI21_X1
* cell instance $20803 m0 *1 63.27,130.2
X$20803 77 10442 10876 10589 10387 9814 109 DFFR_X1
* cell instance $20804 m0 *1 67.07,130.2
X$20804 77 10442 10443 10392 10288 9814 109 DFFR_X1
* cell instance $20807 r0 *1 61.94,130.2
X$20807 4505 10587 77 109 10527 NAND2_X1
* cell instance $20808 r0 *1 62.51,130.2
X$20808 4072 10588 77 109 10586 NAND2_X1
* cell instance $20811 r0 *1 64.03,130.2
X$20811 10442 77 109 19176 INV_X1
* cell instance $20814 r0 *1 66.31,130.2
X$20814 4505 10589 77 109 10441 NAND2_X1
* cell instance $20818 r0 *1 70.87,130.2
X$20818 77 9763 10591 10534 10445 9814 109 DFFR_X1
* cell instance $20819 m0 *1 72.77,130.2
X$20819 9945 10534 77 109 10444 NOR2_X1
* cell instance $20820 m0 *1 72.01,130.2
X$20820 10444 9492 9945 77 10445 109 AOI21_X1
* cell instance $20823 r0 *1 74.67,130.2
X$20823 10591 3861 10885 77 109 10536 MUX2_X1
* cell instance $20824 m0 *1 75.81,130.2
X$20824 10537 10446 3694 77 109 10538 NOR3_X1
* cell instance $20825 m0 *1 75.24,130.2
X$20825 10536 6231 77 109 10446 NOR2_X1
* cell instance $20827 m0 *1 77.33,130.2
X$20827 10770 10538 8672 109 10540 77 NOR3_X2
* cell instance $20832 r0 *1 76.57,130.2
X$20832 77 9763 10594 10596 10714 4086 109 DFFR_X1
* cell instance $20833 m0 *1 81.13,130.2
X$20833 10448 3978 10395 77 109 10550 MUX2_X1
* cell instance $20834 m0 *1 79.8,130.2
X$20834 10447 6584 10594 77 109 10448 MUX2_X1
* cell instance $20836 m0 *1 82.65,130.2
X$20836 10447 10449 9437 77 109 10541 MUX2_X1
* cell instance $20837 m0 *1 83.98,130.2
X$20837 9440 77 109 9924 CLKBUF_X3
* cell instance $20838 m0 *1 84.93,130.2
X$20838 9924 77 109 19252 CLKBUF_X1
* cell instance $20841 m0 *1 87.21,130.2
X$20841 77 8627 10540 10546 10544 109 NOR3_X4
* cell instance $20842 m0 *1 89.87,130.2
X$20842 10549 6236 77 109 10546 NOR2_X1
* cell instance $20843 m0 *1 90.44,130.2
X$20843 10550 3611 10401 77 109 10549 MUX2_X1
* cell instance $20846 r0 *1 80.37,130.2
X$20846 7922 10596 77 109 10593 NAND2_X1
* cell instance $20847 r0 *1 80.94,130.2
X$20847 7878 10597 77 109 10595 NAND2_X1
* cell instance $20848 r0 *1 81.51,130.2
X$20848 77 6451 109 10716 BUF_X8
* cell instance $20851 r0 *1 85.12,130.2
X$20851 10718 6276 10720 77 109 10548 MUX2_X1
* cell instance $20852 r0 *1 86.45,130.2
X$20852 77 9924 10292 10600 10599 8687 109 DFFR_X1
* cell instance $20854 r0 *1 90.44,130.2
X$20854 77 9924 10601 10724 10552 8687 109 DFFR_X1
* cell instance $20855 m0 *1 93.1,130.2
X$20855 10724 6820 10157 77 109 10552 MUX2_X1
* cell instance $20860 r0 *1 94.62,130.2
X$20860 5449 10603 6379 10554 5451 10740 109 77 AOI221_X2
* cell instance $20861 m0 *1 95.76,130.2
X$20861 10293 5275 10450 77 109 10554 MUX2_X1
* cell instance $20863 m0 *1 97.09,130.2
X$20863 7495 109 10451 77 BUF_X4
* cell instance $20865 m0 *1 98.61,130.2
X$20865 10452 7469 10157 77 109 10453 MUX2_X1
* cell instance $20869 r0 *1 97.09,130.2
X$20869 10730 6459 10604 77 109 10555 MUX2_X1
* cell instance $20871 r0 *1 98.8,130.2
X$20871 77 9986 10737 10452 10453 8201 109 DFFR_X1
* cell instance $20872 m0 *1 102.41,130.2
X$20872 10555 6318 77 109 10736 NAND2_X1
* cell instance $20873 m0 *1 101.08,130.2
X$20873 10407 8548 10157 77 109 10295 MUX2_X1
* cell instance $20875 m0 *1 103.17,130.2
X$20875 10561 7283 10563 77 109 10454 MUX2_X1
* cell instance $20876 m0 *1 104.5,130.2
X$20876 10156 9337 10296 77 109 10563 MUX2_X1
* cell instance $20878 r0 *1 102.6,130.2
X$20878 6694 10736 10734 109 77 10744 AND3_X1
* cell instance $20881 r0 *1 104.12,130.2
X$20881 10454 5455 77 109 10455 NAND2_X1
* cell instance $20882 r0 *1 104.69,130.2
X$20882 10455 10740 10570 109 77 10738 AND3_X1
* cell instance $20884 r0 *1 105.83,130.2
X$20884 10449 109 8209 77 BUF_X4
* cell instance $20885 m0 *1 107.54,130.2
X$20885 10565 6694 77 109 10456 NOR2_X1
* cell instance $20886 m0 *1 106.21,130.2
X$20886 10297 6130 10784 77 109 10565 MUX2_X1
* cell instance $20888 m0 *1 108.87,130.2
X$20888 77 9833 10458 10457 10566 8201 109 DFFR_X1
* cell instance $20889 m0 *1 112.67,130.2
X$20889 10608 7283 77 109 10568 NAND2_X1
* cell instance $20892 r0 *1 107.35,130.2
X$20892 10456 10744 6866 109 10613 77 NOR3_X2
* cell instance $20893 r0 *1 108.68,130.2
X$20893 6554 2931 10457 77 109 10566 MUX2_X1
* cell instance $20896 r0 *1 111.72,130.2
X$20896 10458 7283 77 109 10748 NAND2_X1
* cell instance $20897 r0 *1 112.29,130.2
X$20897 10608 10451 10458 77 109 10610 MUX2_X1
* cell instance $20898 r0 *1 113.62,130.2
X$20898 10749 10459 10461 7580 77 109 10570 NAND4_X1
* cell instance $20899 m0 *1 114.38,130.2
X$20899 10298 10462 6372 109 10461 77 OAI21_X1
* cell instance $20900 m0 *1 113.62,130.2
X$20900 10568 10460 10298 77 109 10459 NAND3_X1
* cell instance $20901 m0 *1 115.14,130.2
X$20901 9742 6389 10413 77 10462 109 AOI21_X1
* cell instance $20904 r0 *1 114.57,130.2
X$20904 10748 10746 10462 77 109 10749 NAND3_X1
* cell instance $20910 r0 *1 117.04,130.2
X$20910 10610 8984 10463 77 109 10464 MUX2_X1
* cell instance $20911 m0 *1 117.23,130.2
X$20911 10266 10299 10159 77 109 10463 MUX2_X1
* cell instance $20915 r0 *1 118.37,130.2
X$20915 10464 6130 10611 77 109 10465 MUX2_X1
* cell instance $20916 r0 *1 119.7,130.2
X$20916 10742 10743 6125 109 10466 77 NOR3_X2
* cell instance $20918 m0 *1 119.7,130.2
X$20918 10465 6902 77 109 10742 NOR2_X1
* cell instance $20922 r0 *1 121.6,130.2
X$20922 10544 9499 10741 77 109 NOR2_X4
* cell instance $20923 m0 *1 122.36,130.2
X$20923 77 6436 10466 10613 7090 109 NOR3_X4
* cell instance $20925 m0 *1 125.02,130.2
X$20925 5330 10573 9042 109 77 10503 MUX2_X2
* cell instance $20928 m0 *1 127.68,130.2
X$20928 9506 9841 9675 109 77 10303 AND3_X1
* cell instance $20930 m0 *1 128.82,130.2
X$20930 9172 9995 77 109 10467 XNOR2_X2
* cell instance $20931 m0 *1 130.72,130.2
X$20931 9674 10265 9841 10572 109 77 10731 OAI22_X1
* cell instance $20933 m0 *1 131.86,130.2
X$20933 9045 9841 77 109 10265 NAND2_X1
* cell instance $20935 r0 *1 123.31,130.2
X$20935 9499 10544 77 109 8961 OR2_X2
* cell instance $20937 r0 *1 124.45,130.2
X$20937 10733 6569 10735 77 109 10573 MUX2_X1
* cell instance $20938 r0 *1 125.78,130.2
X$20938 5002 5149 10732 109 77 10925 HA_X1
* cell instance $20940 r0 *1 127.87,130.2
X$20940 9042 10732 6569 77 109 10615 NAND3_X1
* cell instance $20942 r0 *1 128.82,130.2
X$20942 9639 9994 77 109 10989 NOR2_X2
* cell instance $20943 r0 *1 129.77,130.2
X$20943 9994 9639 77 109 10616 OR2_X1
* cell instance $20945 r0 *1 130.91,130.2
X$20945 9675 10731 109 77 10617 AND2_X1
* cell instance $20959 r0 *1 3.99,124.6
X$20959 4843 109 10198 77 BUF_X4
* cell instance $20960 r0 *1 5.32,124.6
X$20960 77 9790 9954 10199 10031 4909 109 DFFR_X1
* cell instance $20962 m0 *1 5.51,124.6
X$20962 9791 4843 9473 77 109 9885 MUX2_X1
* cell instance $20963 m0 *1 7.6,124.6
X$20963 9953 7477 9954 77 109 9793 MUX2_X1
* cell instance $20964 m0 *1 8.93,124.6
X$20964 9953 3048 9954 77 109 9955 MUX2_X1
* cell instance $20965 m0 *1 10.26,124.6
X$20965 9955 7156 10032 77 109 9892 MUX2_X1
* cell instance $20969 r0 *1 9.12,124.6
X$20969 9792 10200 9721 77 109 10032 MUX2_X1
* cell instance $20972 r0 *1 11.4,124.6
X$20972 77 9956 9959 10035 10033 4909 109 DFFR_X1
* cell instance $20974 m0 *1 14.25,124.6
X$20974 10035 2786 8837 77 109 10033 MUX2_X1
* cell instance $20976 r0 *1 15.2,124.6
X$20976 77 9957 9962 9958 10036 4909 109 DFFR_X1
* cell instance $20977 m0 *1 16.91,124.6
X$20977 9958 2631 8837 77 109 10036 MUX2_X1
* cell instance $20980 m0 *1 18.81,124.6
X$20980 10127 5310 9959 77 109 10038 MUX2_X1
* cell instance $20983 m0 *1 20.33,124.6
X$20983 9961 77 109 9957 CLKBUF_X3
* cell instance $20984 m0 *1 21.28,124.6
X$20984 10038 4393 9963 77 109 9730 MUX2_X1
* cell instance $20988 r0 *1 19.57,124.6
X$20988 9960 3048 9962 77 109 10202 MUX2_X1
* cell instance $20989 r0 *1 20.9,124.6
X$20989 9957 77 109 19182 INV_X1
* cell instance $20990 r0 *1 21.28,124.6
X$20990 9960 4287 9962 77 109 9963 MUX2_X1
* cell instance $20992 r0 *1 22.8,124.6
X$20992 9964 5577 9473 77 109 9965 MUX2_X1
* cell instance $20993 m0 *1 23.18,124.6
X$20993 10205 9652 9892 77 109 9891 MUX2_X1
* cell instance $20998 m0 *1 26.98,124.6
X$20998 77 9957 9796 10042 9966 4909 109 DFFR_X1
* cell instance $21000 r0 *1 24.13,124.6
X$21000 77 9957 9967 9964 9965 4909 109 DFFR_X1
* cell instance $21001 r0 *1 27.93,124.6
X$21001 10042 5805 9473 77 109 9966 MUX2_X1
* cell instance $21003 r0 *1 29.64,124.6
X$21003 9967 10129 9796 77 109 10043 MUX2_X1
* cell instance $21004 r0 *1 30.97,124.6
X$21004 10043 9895 10208 77 109 10044 MUX2_X1
* cell instance $21005 m0 *1 31.35,124.6
X$21005 9896 6379 10044 77 109 9804 MUX2_X1
* cell instance $21009 m0 *1 33.63,124.6
X$21009 10045 5577 10131 77 109 9800 MUX2_X1
* cell instance $21010 m0 *1 34.96,124.6
X$21010 77 9968 10047 10045 9800 4909 109 DFFR_X1
* cell instance $21014 r0 *1 32.49,124.6
X$21014 77 9968 9970 9969 10046 4909 109 DFFR_X1
* cell instance $21015 r0 *1 36.29,124.6
X$21015 9969 5805 10131 77 109 10046 MUX2_X1
* cell instance $21017 r0 *1 38,124.6
X$21017 10047 8666 9970 77 109 10213 MUX2_X1
* cell instance $21018 r0 *1 39.33,124.6
X$21018 10047 5318 9970 77 109 10048 MUX2_X1
* cell instance $21020 m0 *1 39.9,124.6
X$21020 77 6083 109 6100 BUF_X8
* cell instance $21021 r0 *1 40.66,124.6
X$21021 10048 3995 77 109 10217 NOR2_X1
* cell instance $21022 r0 *1 41.23,124.6
X$21022 9803 109 10006 77 BUF_X4
* cell instance $21025 m0 *1 42.75,124.6
X$21025 9175 109 8671 77 BUF_X4
* cell instance $21026 m0 *1 44.84,124.6
X$21026 10132 6972 10052 109 10051 77 OAI21_X1
* cell instance $21028 m0 *1 45.79,124.6
X$21028 7201 9971 77 109 10052 NAND2_X1
* cell instance $21031 m0 *1 47.31,124.6
X$21031 9972 6972 10055 109 9973 77 OAI21_X1
* cell instance $21032 m0 *1 48.07,124.6
X$21032 7201 10058 77 109 10055 NAND2_X1
* cell instance $21033 m0 *1 48.64,124.6
X$21033 6007 109 9326 77 BUF_X4
* cell instance $21034 m0 *1 49.97,124.6
X$21034 2786 109 9027 77 BUF_X4
* cell instance $21037 m0 *1 52.25,124.6
X$21037 5314 6890 10061 109 10060 77 OAI21_X1
* cell instance $21039 r0 *1 42.75,124.6
X$21039 77 8674 10133 9971 10051 1663 109 DFFR_X1
* cell instance $21041 r0 *1 46.74,124.6
X$21041 77 10279 10136 10058 9973 1663 109 DFFR_X1
* cell instance $21043 r0 *1 50.92,124.6
X$21043 77 9974 10063 10062 10060 1663 109 DFFR_X1
* cell instance $21045 m0 *1 53.39,124.6
X$21045 7160 10062 77 109 10061 NAND2_X1
* cell instance $21047 m0 *1 58.52,124.6
X$21047 9975 7020 77 109 9977 NOR2_X1
* cell instance $21048 m0 *1 59.09,124.6
X$21048 9755 9976 9659 77 109 10066 MUX2_X1
* cell instance $21049 m0 *1 60.42,124.6
X$21049 10066 3995 77 109 9978 NOR2_X1
* cell instance $21051 m0 *1 62.51,124.6
X$21051 9979 7338 9914 77 10068 109 AOI21_X1
* cell instance $21052 m0 *1 63.27,124.6
X$21052 8529 6655 7764 8670 10069 77 109 9979 AOI221_X1
* cell instance $21054 m0 *1 65.17,124.6
X$21054 10072 7561 9020 77 10069 109 AOI21_X1
* cell instance $21055 m0 *1 65.93,124.6
X$21055 8403 6655 8858 4627 10075 77 109 9980 AOI221_X1
* cell instance $21056 m0 *1 67.07,124.6
X$21056 10076 5169 9020 77 10075 109 AOI21_X1
* cell instance $21059 r0 *1 55.1,124.6
X$21059 9807 9812 10063 77 109 10064 MUX2_X1
* cell instance $21061 r0 *1 56.81,124.6
X$21061 10064 7020 77 109 10140 NOR2_X1
* cell instance $21063 r0 *1 57.76,124.6
X$21063 10140 10282 5017 77 109 10226 NOR3_X1
* cell instance $21069 r0 *1 60.8,124.6
X$21069 9977 9978 10065 77 109 10073 NOR3_X1
* cell instance $21073 r0 *1 62.89,124.6
X$21073 10141 6997 10068 77 10078 109 AOI21_X2
* cell instance $21074 r0 *1 64.22,124.6
X$21074 9813 77 109 10132 CLKBUF_X3
* cell instance $21075 r0 *1 65.17,124.6
X$21075 7776 10145 10226 9570 10073 9980 77 109 10080 OAI33_X1
* cell instance $21077 m0 *1 68.4,124.6
X$21077 2459 109 9829 77 BUF_X4
* cell instance $21079 m0 *1 69.73,124.6
X$21079 77 9763 9981 9816 9916 9814 109 DFFR_X1
* cell instance $21080 m0 *1 73.53,124.6
X$21080 77 9763 9818 9920 9817 9814 109 DFFR_X1
* cell instance $21083 r0 *1 70.3,124.6
X$21083 77 10230 6996 6726 10078 109 AOI21_X4
* cell instance $21084 r0 *1 72.77,124.6
X$21084 10080 5673 77 10228 109 OR2_X4
* cell instance $21085 r0 *1 74.48,124.6
X$21085 9632 10233 77 109 10146 NOR2_X1
* cell instance $21087 r0 *1 75.43,124.6
X$21087 3565 6890 10084 109 10232 77 OAI21_X1
* cell instance $21089 r0 *1 76.57,124.6
X$21089 7160 10234 77 109 10084 NAND2_X1
* cell instance $21090 r0 *1 77.14,124.6
X$21090 3565 6972 9982 109 9819 77 OAI21_X1
* cell instance $21091 m0 *1 78.28,124.6
X$21091 77 4086 9814 109 BUF_X32
* cell instance $21092 m0 *1 77.71,124.6
X$21092 7201 10087 77 109 9982 NAND2_X1
* cell instance $21093 m0 *1 87.59,124.6
X$21093 9821 7495 9770 77 109 10094 MUX2_X1
* cell instance $21097 r0 *1 78.85,124.6
X$21097 10235 7495 9983 77 109 10147 MUX2_X1
* cell instance $21099 r0 *1 80.94,124.6
X$21099 10090 3565 9667 77 9984 109 AOI21_X1
* cell instance $21101 r0 *1 82.46,124.6
X$21101 9667 10092 77 109 10090 NOR2_X1
* cell instance $21103 r0 *1 83.41,124.6
X$21103 10239 9029 9985 77 10237 109 AOI21_X1
* cell instance $21106 r0 *1 84.74,124.6
X$21106 9820 7495 9818 77 109 10095 MUX2_X1
* cell instance $21109 r0 *1 86.64,124.6
X$21109 10095 10149 10094 77 109 10096 MUX2_X1
* cell instance $21111 r0 *1 88.16,124.6
X$21111 10096 6130 10243 77 109 10100 MUX2_X1
* cell instance $21113 m0 *1 89.3,124.6
X$21113 9774 3603 9931 77 109 10099 MUX2_X1
* cell instance $21114 m0 *1 90.82,124.6
X$21114 7087 5415 77 109 10101 NAND2_X1
* cell instance $21115 m0 *1 91.39,124.6
X$21115 9825 6174 77 109 9826 NOR2_X1
* cell instance $21119 r0 *1 89.68,124.6
X$21119 77 10101 10548 10100 10152 9031 109 OAI22_X4
* cell instance $21121 m0 *1 94.43,124.6
X$21121 10103 3622 77 109 10155 NOR2_X1
* cell instance $21122 m0 *1 93.1,124.6
X$21122 9775 5589 9498 77 109 10103 MUX2_X1
* cell instance $21123 m0 *1 95,124.6
X$21123 77 9986 9498 10110 10106 8687 109 DFFR_X1
* cell instance $21125 m0 *1 98.99,124.6
X$21125 77 9986 9987 9937 9828 8201 109 DFFR_X1
* cell instance $21128 r0 *1 93.1,124.6
X$21128 6185 10153 9443 5479 10104 10154 77 109 10250 OAI33_X1
* cell instance $21130 r0 *1 94.81,124.6
X$21130 9827 10155 6130 77 109 10104 NOR3_X1
* cell instance $21133 r0 *1 96.52,124.6
X$21133 6524 10110 77 109 10105 NOR2_X1
* cell instance $21136 r0 *1 98.8,124.6
X$21136 9341 77 109 9986 CLKBUF_X3
* cell instance $21140 r0 *1 102.22,124.6
X$21140 9987 9337 9988 77 109 10561 MUX2_X1
* cell instance $21145 m0 *1 5.13,147
X$21145 11966 5726 11979 77 109 11965 MUX2_X1
* cell instance $21155 r0 *1 4.18,147
X$21155 77 11262 11854 12152 12151 4909 109 DFFR_X1
* cell instance $21157 m0 *1 6.84,147
X$21157 11853 8005 11854 77 109 11698 MUX2_X1
* cell instance $21160 r0 *1 7.98,147
X$21160 11853 12153 11854 77 109 12063 MUX2_X1
* cell instance $21161 r0 *1 9.31,147
X$21161 77 11262 12242 12064 12155 9814 109 DFFR_X1
* cell instance $21162 m0 *1 14.63,147
X$21162 11856 10508 12065 77 109 11971 MUX2_X1
* cell instance $21163 m0 *1 10.83,147
X$21163 77 11028 12241 11856 11971 9814 109 DFFR_X1
* cell instance $21166 r0 *1 13.11,147
X$21166 12064 2786 12065 77 109 12155 MUX2_X1
* cell instance $21169 r0 *1 16.34,147
X$21169 3445 77 109 9961 CLKBUF_X3
* cell instance $21170 r0 *1 17.29,147
X$21170 9961 77 109 19190 CLKBUF_X3
* cell instance $21171 m0 *1 18.24,147
X$21171 12394 3784 11974 77 109 11972 MUX2_X1
* cell instance $21172 m0 *1 17.86,147
X$21172 11701 77 109 19152 INV_X1
* cell instance $21174 m0 *1 19.76,147
X$21174 77 11701 12160 11974 11972 9814 109 DFFR_X1
* cell instance $21175 m0 *1 23.56,147
X$21175 77 11701 11859 11978 11973 9814 109 DFFR_X1
* cell instance $21177 m0 *1 27.55,147
X$21177 10273 6816 11978 77 109 11973 MUX2_X1
* cell instance $21178 m0 *1 28.88,147
X$21178 10273 109 11979 77 BUF_X4
* cell instance $21179 m0 *1 30.21,147
X$21179 11981 5577 11980 77 109 11860 MUX2_X1
* cell instance $21185 r0 *1 23.75,147
X$21185 12160 12066 12067 77 109 12068 MUX2_X1
* cell instance $21186 r0 *1 25.08,147
X$21186 12160 3896 12067 77 109 12165 MUX2_X1
* cell instance $21188 r0 *1 27.17,147
X$21188 12170 4631 12065 77 109 12169 MUX2_X1
* cell instance $21189 r0 *1 28.5,147
X$21189 77 12069 12071 12170 12169 9814 109 DFFR_X1
* cell instance $21191 m0 *1 31.92,147
X$21191 11983 5805 11980 77 109 11861 MUX2_X1
* cell instance $21194 m0 *1 34.58,147
X$21194 11862 11276 11863 77 109 11864 MUX2_X1
* cell instance $21196 m0 *1 35.91,147
X$21196 11862 10952 11863 77 109 11865 MUX2_X1
* cell instance $21197 m0 *1 37.24,147
X$21197 6694 12172 11986 109 77 11985 AND3_X1
* cell instance $21198 m0 *1 38.19,147
X$21198 6902 109 7620 77 BUF_X4
* cell instance $21201 r0 *1 35.72,147
X$21201 11864 11278 12070 77 109 12173 MUX2_X1
* cell instance $21202 r0 *1 37.05,147
X$21202 12173 7764 77 109 12172 NAND2_X1
* cell instance $21203 r0 *1 37.62,147
X$21203 7618 12071 6704 6902 12178 109 77 11986 OAI221_X1
* cell instance $21204 r0 *1 38.76,147
X$21204 12072 109 8229 77 BUF_X4
* cell instance $21205 m0 *1 41.23,147
X$21205 6100 109 11276 77 BUF_X4
* cell instance $21206 m0 *1 39.9,147
X$21206 9742 109 7631 77 BUF_X4
* cell instance $21207 m0 *1 42.56,147
X$21207 5726 109 9834 77 BUF_X4
* cell instance $21208 m0 *1 43.89,147
X$21208 5301 109 9503 77 BUF_X4
* cell instance $21214 r0 *1 42.56,147
X$21214 10674 77 109 11116 CLKBUF_X3
* cell instance $21215 r0 *1 43.51,147
X$21215 11116 77 109 19178 INV_X1
* cell instance $21216 r0 *1 43.89,147
X$21216 12180 10583 9503 77 12399 109 AOI21_X1
* cell instance $21218 r0 *1 45.03,147
X$21218 9503 12336 77 109 12180 NOR2_X1
* cell instance $21220 r0 *1 45.79,147
X$21220 77 11116 12073 11867 12181 9814 109 DFFR_X1
* cell instance $21221 m0 *1 47.31,147
X$21221 11992 9972 9985 77 12181 109 AOI21_X1
* cell instance $21224 m0 *1 48.26,147
X$21224 9985 11867 77 109 11992 NOR2_X1
* cell instance $21226 m0 *1 50.35,147
X$21226 77 11283 11870 11869 11993 9814 109 DFFR_X1
* cell instance $21227 m0 *1 54.15,147
X$21227 77 11283 12075 11996 11995 9814 109 DFFR_X1
* cell instance $21228 m0 *1 57.95,147
X$21228 11997 9972 9830 77 11995 109 AOI21_X1
* cell instance $21230 m0 *1 58.9,147
X$21230 9830 11996 77 109 11997 NOR2_X1
* cell instance $21233 m0 *1 60.42,147
X$21233 11999 10969 6820 77 11998 109 AOI21_X1
* cell instance $21235 m0 *1 61.37,147
X$21235 6820 11873 77 109 11999 NOR2_X1
* cell instance $21236 m0 *1 61.94,147
X$21236 12001 10969 6975 77 12186 109 AOI21_X1
* cell instance $21237 m0 *1 62.7,147
X$21237 77 11708 12003 11709 12186 9814 109 DFFR_X1
* cell instance $21238 m0 *1 66.5,147
X$21238 12002 10957 11711 77 109 12079 MUX2_X1
* cell instance $21240 m0 *1 68.59,147
X$21240 12002 5734 12003 77 109 12004 MUX2_X1
* cell instance $21242 m0 *1 70.11,147
X$21242 77 11571 11713 12006 7026 109 AOI21_X4
* cell instance $21246 r0 *1 49.78,147
X$21246 12073 10966 11868 77 109 12185 MUX2_X1
* cell instance $21249 r0 *1 51.68,147
X$21249 12075 6627 11870 77 109 12074 MUX2_X1
* cell instance $21250 r0 *1 53.01,147
X$21250 12075 10966 11870 77 109 12076 MUX2_X1
* cell instance $21253 r0 *1 57.76,147
X$21253 10674 77 109 11283 CLKBUF_X3
* cell instance $21254 r0 *1 58.71,147
X$21254 11283 77 109 19300 CLKBUF_X1
* cell instance $21262 r0 *1 67.83,147
X$21262 12079 11125 12080 77 109 12081 MUX2_X1
* cell instance $21265 r0 *1 72.58,147
X$21265 12190 12189 12086 77 109 12194 MUX2_X1
* cell instance $21267 m0 *1 73.72,147
X$21267 11874 9976 11458 77 109 12193 MUX2_X1
* cell instance $21271 r0 *1 73.91,147
X$21271 12193 5513 12194 77 109 12083 MUX2_X1
* cell instance $21272 r0 *1 75.24,147
X$21272 77 11593 12086 12087 12085 8687 109 DFFR_X1
* cell instance $21273 r0 *1 79.04,147
X$21273 12087 9667 11289 77 109 12085 MUX2_X1
* cell instance $21274 r0 *1 80.37,147
X$21274 12086 10451 11597 77 109 12202 MUX2_X1
* cell instance $21276 m0 *1 80.75,147
X$21276 12190 10451 11835 77 109 12203 MUX2_X1
* cell instance $21278 r0 *1 81.7,147
X$21278 12203 8984 12202 77 109 12216 MUX2_X1
* cell instance $21279 r0 *1 83.03,147
X$21279 11291 77 109 19262 CLKBUF_X1
* cell instance $21284 m0 *1 5.13,166.6
X$21284 13544 6214 13858 77 109 13801 MUX2_X1
* cell instance $21285 m0 *1 6.46,166.6
X$21285 77 13800 13802 13858 13801 9814 109 DFFR_X1
* cell instance $21286 m0 *1 10.26,166.6
X$21286 13671 10200 13802 77 109 13919 MUX2_X1
* cell instance $21288 m0 *1 11.78,166.6
X$21288 13671 13257 13802 77 109 13803 MUX2_X1
* cell instance $21291 m0 *1 14.82,166.6
X$21291 13544 3043 13859 77 109 13738 MUX2_X1
* cell instance $21303 r0 *1 3.42,166.6
X$21303 13544 6876 14101 77 109 13974 MUX2_X1
* cell instance $21307 r0 *1 7.22,166.6
X$21307 13544 7054 13977 77 109 14102 MUX2_X1
* cell instance $21310 r0 *1 9.5,166.6
X$21310 13916 10200 13917 77 109 13918 MUX2_X1
* cell instance $21312 r0 *1 11.02,166.6
X$21312 13918 10860 13919 77 109 13987 MUX2_X1
* cell instance $21315 r0 *1 13.3,166.6
X$21315 9961 77 109 13672 CLKBUF_X3
* cell instance $21316 r0 *1 14.25,166.6
X$21316 13672 77 109 19302 CLKBUF_X1
* cell instance $21321 r0 *1 17.67,166.6
X$21321 77 13672 13860 14107 13981 9814 109 DFFR_X1
* cell instance $21326 m0 *1 4.56,177.8
X$21326 77 13800 14702 14587 14632 9814 109 DFFR_X1
* cell instance $21327 m0 *1 8.36,177.8
X$21327 14828 6083 14702 77 109 14761 MUX2_X1
* cell instance $21328 m0 *1 9.69,177.8
X$21328 14828 4309 14702 77 109 14765 MUX2_X1
* cell instance $21329 m0 *1 11.02,177.8
X$21329 14761 9326 14763 77 109 14762 MUX2_X1
* cell instance $21331 m0 *1 12.54,177.8
X$21331 14830 4309 14831 77 109 14703 MUX2_X1
* cell instance $21334 m0 *1 14.82,177.8
X$21334 14766 10508 14043 77 109 14767 MUX2_X1
* cell instance $21335 m0 *1 16.15,177.8
X$21335 77 14168 14704 14766 14767 9814 109 DFFR_X1
* cell instance $21344 r0 *1 3.42,177.8
X$21344 77 15031 14828 14869 14868 9814 109 DFFR_X1
* cell instance $21345 r0 *1 7.22,177.8
X$21345 14869 10198 14043 77 109 14868 MUX2_X1
* cell instance $21348 r0 *1 10.83,177.8
X$21348 14982 12312 14043 77 109 14829 MUX2_X1
* cell instance $21350 r0 *1 12.35,177.8
X$21350 14830 6083 14831 77 109 14763 MUX2_X1
* cell instance $21354 r0 *1 15.77,177.8
X$21354 14832 13145 14043 77 109 14874 MUX2_X1
* cell instance $21355 r0 *1 17.1,177.8
X$21355 14461 77 109 14168 CLKBUF_X3
* cell instance $21358 r0 *1 19.95,177.8
X$21358 14877 13682 14043 77 109 14876 MUX2_X1
* cell instance $21359 m0 *1 20.52,177.8
X$21359 14704 9976 14589 77 109 14769 MUX2_X1
* cell instance $21365 r0 *1 22.23,177.8
X$21365 14833 13257 14834 77 109 14591 MUX2_X1
* cell instance $21367 m0 *1 23.94,177.8
X$21367 14769 5461 14835 77 109 14114 MUX2_X1
* cell instance $21372 r0 *1 23.94,177.8
X$21372 14833 9976 14834 77 109 14835 MUX2_X1
* cell instance $21375 r0 *1 25.84,177.8
X$21375 77 13984 14593 14836 14881 9814 109 DFFR_X1
* cell instance $21376 m0 *1 29.64,177.8
X$21376 14593 4784 14706 77 109 14705 MUX2_X1
* cell instance $21378 m0 *1 30.97,177.8
X$21378 14705 5410 14774 77 109 14773 MUX2_X1
* cell instance $21379 m0 *1 32.3,177.8
X$21379 14594 13257 14775 77 109 14774 MUX2_X1
* cell instance $21381 m0 *1 34.39,177.8
X$21381 14706 6231 14775 77 109 14319 MUX2_X1
* cell instance $21382 m0 *1 35.72,177.8
X$21382 77 11838 14777 14646 7026 109 AOI21_X4
* cell instance $21385 m0 *1 39.14,177.8
X$21385 14779 13926 13675 77 109 14778 MUX2_X1
* cell instance $21388 m0 *1 42.18,177.8
X$21388 14783 9812 14707 77 109 14650 MUX2_X1
* cell instance $21389 m0 *1 43.51,177.8
X$21389 14783 9810 14707 77 109 14539 MUX2_X1
* cell instance $21391 m0 *1 45.03,177.8
X$21391 14785 13767 14043 77 109 14709 MUX2_X1
* cell instance $21392 m0 *1 46.36,177.8
X$21392 77 14708 14597 14785 14709 4086 109 DFFR_X1
* cell instance $21395 m0 *1 51.11,177.8
X$21395 77 14710 14323 14711 14787 4086 109 DFFR_X1
* cell instance $21396 m0 *1 54.91,177.8
X$21396 14711 13548 14712 77 109 14787 MUX2_X1
* cell instance $21399 r0 *1 29.83,177.8
X$21399 14836 13149 14118 77 109 14881 MUX2_X1
* cell instance $21402 r0 *1 31.73,177.8
X$21402 77 14318 14706 14884 14882 4086 109 DFFR_X1
* cell instance $21405 r0 *1 36.48,177.8
X$21405 77 14318 14467 14779 14778 4086 109 DFFR_X1
* cell instance $21408 r0 *1 40.85,177.8
X$21408 77 14708 14783 14837 14889 4086 109 DFFR_X1
* cell instance $21409 r0 *1 44.65,177.8
X$21409 14837 14047 13675 77 109 14889 MUX2_X1
* cell instance $21410 r0 *1 45.98,177.8
X$21410 14135 77 109 14708 CLKBUF_X3
* cell instance $21413 r0 *1 49.21,177.8
X$21413 14842 6371 77 109 14891 NAND2_X1
* cell instance $21414 r0 *1 49.78,177.8
X$21414 6383 14838 14891 109 14894 77 OAI21_X1
* cell instance $21415 r0 *1 50.54,177.8
X$21415 7618 14839 3482 7620 14840 109 77 14841 OAI221_X1
* cell instance $21416 r0 *1 51.68,177.8
X$21416 7561 14838 14895 109 14840 77 OAI21_X1
* cell instance $21417 r0 *1 52.44,177.8
X$21417 14842 9810 77 109 14895 NAND2_X1
* cell instance $21420 r0 *1 54.15,177.8
X$21420 77 14710 14546 14843 14896 8687 109 DFFR_X1
* cell instance $21421 m0 *1 56.81,177.8
X$21421 14048 7330 14792 77 109 14790 MUX2_X1
* cell instance $21423 m0 *1 58.14,177.8
X$21423 77 14710 14713 14792 14790 8687 109 DFFR_X1
* cell instance $21425 m0 *1 62.13,177.8
X$21425 14713 6180 77 109 14714 NAND2_X1
* cell instance $21427 m0 *1 62.89,177.8
X$21427 14712 6888 14795 77 109 14794 MUX2_X1
* cell instance $21431 r0 *1 57.95,177.8
X$21431 14843 13408 14712 77 109 14896 MUX2_X1
* cell instance $21437 r0 *1 61.18,177.8
X$21437 6371 14795 14714 109 14844 77 OAI21_X1
* cell instance $21438 r0 *1 61.94,177.8
X$21438 14999 7561 14713 77 15001 109 AOI21_X1
* cell instance $21439 r0 *1 62.7,177.8
X$21439 77 13553 18739 14795 14794 8687 109 DFFR_X1
* cell instance $21440 r0 *1 66.5,177.8
X$21440 77 15126 14901 14897 14715 8687 109 DFFR_X1
* cell instance $21441 m0 *1 68.59,177.8
X$21441 14717 5178 14897 77 109 14715 MUX2_X1
* cell instance $21443 m0 *1 69.92,177.8
X$21443 14717 5252 14898 77 109 14716 MUX2_X1
* cell instance $21446 r0 *1 70.3,177.8
X$21446 77 14475 14900 14898 14716 8687 109 DFFR_X1
* cell instance $21447 m0 *1 73.34,177.8
X$21447 14717 7330 14798 77 109 14797 MUX2_X1
* cell instance $21449 m0 *1 74.67,177.8
X$21449 77 14475 14718 14798 14797 8687 109 DFFR_X1
* cell instance $21450 m0 *1 78.47,177.8
X$21450 14717 6888 14600 77 109 14801 MUX2_X1
* cell instance $21451 m0 *1 79.8,177.8
X$21451 77 14803 18553 14600 14801 8687 109 DFFR_X1
* cell instance $21452 m0 *1 83.6,177.8
X$21452 14600 8421 77 109 14802 NOR2_X1
* cell instance $21455 m0 *1 86.45,177.8
X$21455 14719 12312 14193 77 109 14804 MUX2_X1
* cell instance $21456 m0 *1 87.78,177.8
X$21456 14805 13145 14193 77 109 14720 MUX2_X1
* cell instance $21458 m0 *1 89.87,177.8
X$21458 14721 5740 14601 77 109 14722 MUX2_X1
* cell instance $21459 m0 *1 91.2,177.8
X$21459 14669 6174 14722 77 109 14808 MUX2_X1
* cell instance $21461 r0 *1 74.1,177.8
X$21461 14901 6308 14900 77 109 14905 MUX2_X1
* cell instance $21465 r0 *1 77.52,177.8
X$21465 14903 10142 14718 77 14904 109 AOI21_X1
* cell instance $21466 r0 *1 78.28,177.8
X$21466 14940 8403 8858 3978 14904 15053 109 77 AOI221_X2
* cell instance $21470 r0 *1 81.7,177.8
X$21470 6308 14718 109 77 14906 AND2_X1
* cell instance $21471 r0 *1 82.46,177.8
X$21471 14906 14802 5415 77 109 15008 NOR3_X1
* cell instance $21472 r0 *1 83.22,177.8
X$21472 14905 8249 77 109 14845 NOR2_X1
* cell instance $21474 r0 *1 83.98,177.8
X$21474 77 14803 14721 14719 14804 8687 109 DFFR_X1
* cell instance $21475 r0 *1 87.78,177.8
X$21475 77 14803 14601 14805 14720 8687 109 DFFR_X1
* cell instance $21478 r0 *1 92.72,177.8
X$21478 77 14428 14602 14807 14846 8201 109 DFFR_X1
* cell instance $21479 m0 *1 93.1,177.8
X$21479 14140 8166 14807 77 109 14846 MUX2_X1
* cell instance $21482 m0 *1 98.04,177.8
X$21482 14673 4914 14676 77 109 14811 MUX2_X1
* cell instance $21483 m0 *1 94.81,177.8
X$21483 77 12413 14808 15017 14812 8499 109 OAI22_X4
* cell instance $21484 m0 *1 99.37,177.8
X$21484 77 13687 14603 14912 14911 8201 109 DFFR_X1
* cell instance $21485 m0 *1 103.17,177.8
X$21485 6180 109 6383 77 BUF_X4
* cell instance $21489 r0 *1 98.23,177.8
X$21489 14910 3611 14946 77 109 14568 MUX2_X1
* cell instance $21492 r0 *1 100.13,177.8
X$21492 14140 8235 14912 77 109 14911 MUX2_X1
* cell instance $21494 r0 *1 101.84,177.8
X$21494 9146 77 109 14193 BUF_X2
* cell instance $21498 r0 *1 103.93,177.8
X$21498 14606 6584 14913 77 109 14914 MUX2_X1
* cell instance $21499 m0 *1 105.07,177.8
X$21499 6276 5415 7087 77 14723 109 NAND3_X4
* cell instance $21502 m0 *1 107.73,177.8
X$21502 77 14481 14724 14723 14814 14725 109 OAI22_X4
* cell instance $21505 r0 *1 105.45,177.8
X$21505 77 15255 14811 15147 14847 12218 109 OAI22_X4
* cell instance $21506 r0 *1 108.68,177.8
X$21506 77 14814 14812 14847 14335 6476 109 NOR4_X4
* cell instance $21508 m0 *1 111.34,177.8
X$21508 14140 8008 14818 77 109 14813 MUX2_X1
* cell instance $21510 r0 *1 112.1,177.8
X$21510 77 13249 14335 14847 14812 14814 109 OR4_X4
* cell instance $21511 m0 *1 114,177.8
X$21511 14440 6993 14817 77 109 14819 MUX2_X1
* cell instance $21513 m0 *1 115.33,177.8
X$21513 77 14198 14913 14817 14819 12731 109 DFFR_X1
* cell instance $21519 m0 *1 119.7,177.8
X$21519 77 14726 14950 14917 14916 12731 109 DFFR_X1
* cell instance $21521 m0 *1 123.5,177.8
X$21521 77 14726 14919 14822 14821 12731 109 DFFR_X1
* cell instance $21522 m0 *1 127.3,177.8
X$21522 14822 14206 14691 77 109 14821 MUX2_X1
* cell instance $21525 m0 *1 130.91,177.8
X$21525 14824 14485 14727 77 109 14609 MUX2_X1
* cell instance $21526 m0 *1 132.24,177.8
X$21526 77 14205 14695 14728 14827 12731 109 DFFR_X1
* cell instance $21527 m0 *1 136.04,177.8
X$21527 14728 13939 14848 77 109 14827 MUX2_X1
* cell instance $21528 m0 *1 137.37,177.8
X$21528 12640 77 109 14729 BUF_X1
* cell instance $21530 m0 *1 138.13,177.8
X$21530 11228 13797 12420 77 109 14730 MUX2_X1
* cell instance $21531 m0 *1 139.46,177.8
X$21531 14730 14063 14823 77 109 14925 MUX2_X1
* cell instance $21535 m0 *1 143.26,177.8
X$21535 14731 13797 8462 77 109 14732 MUX2_X1
* cell instance $21536 m0 *1 144.59,177.8
X$21536 14732 14063 14850 77 109 14733 MUX2_X1
* cell instance $21543 r0 *1 123.12,177.8
X$21543 14917 13822 14685 77 109 14916 MUX2_X1
* cell instance $21544 r0 *1 124.45,177.8
X$21544 12420 77 109 14918 BUF_X1
* cell instance $21545 r0 *1 125.02,177.8
X$21545 12265 109 12728 77 BUF_X4
* cell instance $21547 r0 *1 126.54,177.8
X$21547 14919 14200 15066 77 109 14824 MUX2_X1
* cell instance $21550 r0 *1 128.44,177.8
X$21550 77 14580 15029 14923 14921 12731 109 DFFR_X1
* cell instance $21553 r0 *1 133.38,177.8
X$21553 14923 14206 14486 77 109 14921 MUX2_X1
* cell instance $21556 r0 *1 135.85,177.8
X$21556 10741 14061 8718 77 109 14848 MUX2_X1
* cell instance $21559 r0 *1 138.13,177.8
X$21559 11406 14338 11150 77 109 14924 MUX2_X1
* cell instance $21560 r0 *1 139.46,177.8
X$21560 77 14205 18866 14823 14925 12731 109 DFFR_X1
* cell instance $21562 r0 *1 144.02,177.8
X$21562 14776 77 109 14949 CLKBUF_X3
* cell instance $21563 r0 *1 144.97,177.8
X$21563 77 14849 18869 14850 14733 12731 109 DFFR_X1
* cell instance $21564 m0 *1 148.01,177.8
X$21564 77 14493 18686 14614 14701 12731 109 DFFR_X1
* cell instance $21566 m0 *1 151.81,177.8
X$21566 77 9162 14208 14850 12996 13700 14815 13442 109 OAI222_X2
* cell instance $21567 m0 *1 154.47,177.8
X$21567 14543 77 109 14929 BUF_X1
* cell instance $21571 r0 *1 149.72,177.8
X$21571 11118 77 109 14851 BUF_X1
* cell instance $21572 r0 *1 150.29,177.8
X$21572 77 11118 13176 14823 13287 14210 14791 13907 109 OAI222_X2
* cell instance $21573 r0 *1 152.95,177.8
X$21573 77 14543 14208 14820 12996 14210 14739 13531 109 OAI222_X2
* cell instance $21574 m0 *1 158.08,177.8
X$21574 14735 13447 14736 109 77 14816 OAI21_X4
* cell instance $21575 m0 *1 155.42,177.8
X$21575 77 12999 14928 14690 7212 109 NOR3_X4
* cell instance $21577 r0 *1 155.61,177.8
X$21577 14560 77 109 18286 INV_X8
* cell instance $21578 r0 *1 157.32,177.8
X$21578 14926 14927 14852 77 14928 109 AOI21_X2
* cell instance $21579 r0 *1 158.65,177.8
X$21579 14737 14852 11829 109 14926 77 OAI21_X1
* cell instance $21581 r0 *1 159.6,177.8
X$21581 13702 14550 77 109 14213 NOR2_X2
* cell instance $21582 r0 *1 160.55,177.8
X$21582 14306 14347 14213 109 15156 77 OAI21_X1
* cell instance $21583 m0 *1 162.26,177.8
X$21583 14435 14495 77 109 14347 NAND2_X2
* cell instance $21584 m0 *1 160.93,177.8
X$21584 14781 109 13292 77 BUF_X4
* cell instance $21585 m0 *1 163.21,177.8
X$21585 14738 14067 14439 77 109 14810 MUX2_X1
* cell instance $21586 m0 *1 164.54,177.8
X$21586 10242 13447 13234 77 14683 109 AOI21_X1
* cell instance $21587 m0 *1 165.3,177.8
X$21587 14616 77 109 14854 INV_X1
* cell instance $21588 m0 *1 165.68,177.8
X$21588 77 14446 14809 12731 13521 14739 109 DFFR_X2
* cell instance $21590 m0 *1 170.05,177.8
X$21590 12983 13232 14740 77 109 14806 MUX2_X1
* cell instance $21591 m0 *1 171.38,177.8
X$21591 14806 10242 77 109 8631 NOR2_X2
* cell instance $21592 m0 *1 172.33,177.8
X$21592 14446 77 109 19147 INV_X1
* cell instance $21593 m0 *1 172.71,177.8
X$21593 12640 13359 14018 14677 109 77 14800 OAI22_X2
* cell instance $21596 r0 *1 161.31,177.8
X$21596 9469 14347 14213 109 15250 77 OAI21_X1
* cell instance $21597 r0 *1 162.07,177.8
X$21597 13361 11829 14067 77 109 NOR2_X4
* cell instance $21598 r0 *1 163.78,177.8
X$21598 10242 14922 77 109 9617 OR2_X1
* cell instance $21599 r0 *1 164.54,177.8
X$21599 13702 14853 77 109 14920 OR2_X1
* cell instance $21601 r0 *1 165.49,177.8
X$21601 14680 14854 14496 13951 14855 109 77 14809 OAI221_X1
* cell instance $21602 r0 *1 166.63,177.8
X$21602 14543 14347 77 109 14681 OR2_X1
* cell instance $21603 r0 *1 167.39,177.8
X$21603 14739 77 109 14855 INV_X1
* cell instance $21604 r0 *1 167.77,177.8
X$21604 14915 77 109 13359 CLKBUF_X3
* cell instance $21605 r0 *1 168.72,177.8
X$21605 14345 14213 77 109 14915 NAND2_X1
* cell instance $21607 r0 *1 169.48,177.8
X$21607 14963 13300 11829 77 109 13893 NAND3_X1
* cell instance $21608 r0 *1 170.24,177.8
X$21608 14550 8831 14345 77 14856 109 AOI21_X1
* cell instance $21613 r0 *1 171.38,177.8
X$21613 12816 14852 14737 77 109 14498 MUX2_X1
* cell instance $21614 r0 *1 172.71,177.8
X$21614 11541 13359 14028 14018 109 77 14741 OAI22_X1
* cell instance $21615 r0 *1 173.66,177.8
X$21615 13718 77 109 14446 CLKBUF_X3
* cell instance $21616 r0 *1 174.61,177.8
X$21616 14018 77 109 13296 CLKBUF_X3
* cell instance $21617 r0 *1 175.56,177.8
X$21617 14967 13300 11829 77 109 14282 NAND3_X1
* cell instance $21618 m0 *1 176.51,177.8
X$21618 13300 14857 77 109 14909 NAND2_X1
* cell instance $21620 m0 *1 177.08,177.8
X$21620 14619 4660 77 109 14799 NOR2_X1
* cell instance $21621 m0 *1 177.65,177.8
X$21621 13794 8623 109 77 14907 AND2_X1
* cell instance $21623 r0 *1 176.32,177.8
X$21623 11118 13359 14909 13070 14791 109 77 14899 OAI221_X1
* cell instance $21624 r0 *1 177.46,177.8
X$21624 13457 14907 14087 14495 77 109 14908 AOI22_X2
* cell instance $21625 m0 *1 180.88,177.8
X$21625 14662 12985 13841 77 14743 109 AOI21_X2
* cell instance $21626 m0 *1 178.79,177.8
X$21626 14664 14796 14800 14799 13296 14742 109 77 AOI221_X2
* cell instance $21627 m0 *1 182.21,177.8
X$21627 14745 14353 77 109 14796 NAND2_X1
* cell instance $21629 m0 *1 182.97,177.8
X$21629 14754 14435 14744 77 109 14745 MUX2_X1
* cell instance $21630 m0 *1 184.3,177.8
X$21630 13457 14744 13451 11228 13452 77 109 14746 AOI221_X1
* cell instance $21631 m0 *1 185.44,177.8
X$21631 14788 13454 77 109 14789 NAND2_X1
* cell instance $21633 m0 *1 186.77,177.8
X$21633 14784 14353 77 109 14747 NAND2_X1
* cell instance $21634 m0 *1 187.34,177.8
X$21634 14747 14786 77 109 14553 NAND2_X1
* cell instance $21637 r0 *1 179.17,177.8
X$21637 14678 77 109 14968 INV_X1
* cell instance $21639 r0 *1 179.74,177.8
X$21639 13883 14902 14351 14731 14079 77 109 14858 AOI221_X1
* cell instance $21640 r0 *1 180.88,177.8
X$21640 14743 14081 14495 12691 14079 15000 109 77 AOI221_X2
* cell instance $21643 r0 *1 183.92,177.8
X$21643 14899 14789 14746 77 14859 109 AOI21_X1
* cell instance $21645 r0 *1 184.87,177.8
X$21645 14756 13345 14973 77 109 14788 MUX2_X1
* cell instance $21647 r0 *1 186.58,177.8
X$21647 14861 13352 13959 77 14860 109 AOI21_X1
* cell instance $21648 r0 *1 187.34,177.8
X$21648 14223 9245 77 109 14861 NOR2_X1
* cell instance $21650 r0 *1 188.1,177.8
X$21650 14081 14860 14495 11775 14079 77 109 14786 AOI221_X1
* cell instance $21651 m0 *1 190.38,177.8
X$21651 14628 14435 14656 77 109 14784 MUX2_X1
* cell instance $21652 m0 *1 189.05,177.8
X$21652 13883 109 14081 77 BUF_X4
* cell instance $21655 r0 *1 189.24,177.8
X$21655 14864 14435 14860 77 109 14892 MUX2_X1
* cell instance $21657 r0 *1 190.76,177.8
X$21657 14892 13842 14890 14081 14977 14893 109 77 AOI221_X2
* cell instance $21658 m0 *1 193.04,177.8
X$21658 14495 14226 10528 77 14749 109 AOI21_X1
* cell instance $21661 m0 *1 193.99,177.8
X$21661 77 14358 14781 14780 14782 3676 109 DFFR_X1
* cell instance $21662 m0 *1 197.79,177.8
X$21662 14780 77 109 14502 BUF_X2
* cell instance $21664 m0 *1 198.74,177.8
X$21664 14698 14211 14457 14502 77 109 14750 NOR4_X1
* cell instance $21667 r0 *1 193.04,177.8
X$21667 14749 77 109 14890 INV_X1
* cell instance $21670 r0 *1 195.13,177.8
X$21670 14081 109 13457 77 BUF_X4
* cell instance $21674 r0 *1 197.79,177.8
X$21674 14263 13996 77 109 14862 NAND2_X1
* cell instance $21675 r0 *1 198.36,177.8
X$21675 14263 14750 14862 109 14888 77 OAI21_X1
* cell instance $21677 r0 *1 199.31,177.8
X$21677 77 14358 14236 14887 14888 3676 109 DFFR_X1
* cell instance $21678 m0 *1 201.97,177.8
X$21678 77 14506 14626 3676 14751 14627 109 DFFR_X2
* cell instance $21679 m0 *1 200.07,177.8
X$21679 14886 14236 77 109 14698 XNOR2_X2
* cell instance $21680 m0 *1 206.15,177.8
X$21680 14752 14751 14776 109 77 14394 HA_X1
* cell instance $21681 m0 *1 208.05,177.8
X$21681 77 14506 14770 14772 14771 3676 109 DFFR_X1
* cell instance $21682 m0 *1 211.85,177.8
X$21682 14772 14109 14754 13967 77 109 14755 AOI22_X1
* cell instance $21683 m0 *1 212.8,177.8
X$21683 14755 77 109 14771 INV_X1
* cell instance $21685 m0 *1 213.94,177.8
X$21685 77 14506 14757 14764 14768 3676 109 DFFR_X1
* cell instance $21686 m0 *1 217.74,177.8
X$21686 14509 13633 14760 109 14628 77 OAI21_X1
* cell instance $21688 m0 *1 218.69,177.8
X$21688 14865 77 109 14759 INV_X1
* cell instance $21695 r0 *1 203.11,177.8
X$21695 14887 77 109 13996 CLKBUF_X3
* cell instance $21698 r0 *1 205.01,177.8
X$21698 14752 14751 19068 109 77 14886 HA_X1
* cell instance $21701 r0 *1 208.81,177.8
X$21701 14885 77 109 14863 INV_X1
* cell instance $21702 r0 *1 209.19,177.8
X$21702 14506 77 109 19290 CLKBUF_X1
* cell instance $21703 r0 *1 209.76,177.8
X$21703 10855 77 109 14506 CLKBUF_X3
* cell instance $21704 r0 *1 210.71,177.8
X$21704 14978 14109 14883 13605 77 109 14885 AOI22_X1
* cell instance $21705 r0 *1 211.66,177.8
X$21705 14753 13308 14770 109 14754 77 OAI21_X1
* cell instance $21707 r0 *1 213.18,177.8
X$21707 14880 77 109 14980 INV_X1
* cell instance $21709 r0 *1 213.94,177.8
X$21709 14879 13309 14878 13605 77 109 14880 AOI22_X1
* cell instance $21711 r0 *1 215.08,177.8
X$21711 14981 14397 14090 109 77 14878 OAI21_X2
* cell instance $21712 r0 *1 216.41,177.8
X$21712 14875 77 109 14768 INV_X1
* cell instance $21713 r0 *1 216.79,177.8
X$21713 14764 14109 14756 13967 77 109 14875 AOI22_X1
* cell instance $21714 r0 *1 217.74,177.8
X$21714 14873 13309 14864 13605 77 109 14865 AOI22_X1
* cell instance $21715 r0 *1 218.69,177.8
X$21715 77 14758 14872 14873 14759 3676 109 DFFR_X1
* cell instance $21724 r0 *1 232.94,177.8
X$21724 8718 77 109 14871 BUF_X1
* cell instance $21725 r0 *1 233.51,177.8
X$21725 14224 77 109 14870 BUF_X1
* cell instance $21728 r0 *1 235.98,177.8
X$21728 14870 77 109 14866 BUF_X1
* cell instance $21731 r0 *1 237.5,177.8
X$21731 14871 77 109 14867 BUF_X1
* cell instance $21736 r0 *1 190.19,1.4
X$21736 113 77 109 105 BUF_X2
* cell instance $21738 r0 *1 192.47,1.4
X$21738 107 77 109 190 BUF_X2
* cell instance $21787 m0 *1 236.36,127.4
X$21787 77 18368 10345 10350 10196 109 DFF_X1
* cell instance $21789 r0 *1 236.55,127.4
X$21789 10345 10498 10344 77 109 10346 MUX2_X1
* cell instance $21790 r0 *1 237.88,127.4
X$21790 10345 10500 10346 77 109 10350 MUX2_X1
* cell instance $21836 m0 *1 92.34,35
X$21836 1717 332 117 77 109 1790 MUX2_X1
* cell instance $21841 r0 *1 93.1,35
X$21841 1931 332 248 77 109 1967 MUX2_X1
* cell instance $21843 m0 *1 94.05,35
X$21843 77 18316 1681 1745 1487 109 DFF_X1
* cell instance $21844 m0 *1 98.04,35
X$21844 77 18318 1747 1746 1487 109 DFF_X1
* cell instance $21849 r0 *1 95,35
X$21849 77 18416 1932 1876 1487 109 DFF_X1
* cell instance $21850 r0 *1 98.23,35
X$21850 1793 442 1969 77 109 1877 MUX2_X1
* cell instance $21851 r0 *1 99.56,35
X$21851 77 18418 1793 1877 1682 109 DFF_X1
* cell instance $21852 m0 *1 103.74,35
X$21852 1748 887 1793 77 109 1337 MUX2_X1
* cell instance $21853 m0 *1 102.41,35
X$21853 1748 642 1380 77 109 1878 MUX2_X1
* cell instance $21854 m0 *1 105.07,35
X$21854 117 958 77 109 1828 NAND2_X1
* cell instance $21856 m0 *1 105.83,35
X$21856 881 1828 1794 77 1749 109 AOI21_X1
* cell instance $21861 r0 *1 104.5,35
X$21861 248 803 1793 77 109 1933 MUX2_X1
* cell instance $21863 r0 *1 106.02,35
X$21863 1380 1003 1933 77 109 1936 MUX2_X1
* cell instance $21864 r0 *1 107.35,35
X$21864 1882 1829 1934 1880 1973 1971 77 109 OAI221_X2
* cell instance $21866 m0 *1 107.73,35
X$21866 1432 77 109 1767 CLKBUF_X3
* cell instance $21868 m0 *1 109.06,35
X$21868 1750 1497 1798 77 1882 109 AOI21_X1
* cell instance $21869 m0 *1 110.58,35
X$21869 1695 1582 1687 109 1798 77 OAI21_X1
* cell instance $21870 m0 *1 111.34,35
X$21870 1497 1751 77 109 1883 NAND2_X1
* cell instance $21871 m0 *1 111.91,35
X$21871 1752 1481 1432 109 1980 77 OAI21_X1
* cell instance $21872 m0 *1 112.67,35
X$21872 1687 77 109 1885 INV_X1
* cell instance $21873 m0 *1 113.05,35
X$21873 1432 1339 77 109 1755 NOR2_X1
* cell instance $21875 m0 *1 113.81,35
X$21875 1885 1755 1767 1341 77 109 1756 AOI22_X1
* cell instance $21876 m0 *1 114.76,35
X$21876 1756 1754 77 109 1801 NOR2_X1
* cell instance $21878 r0 *1 109.44,35
X$21878 1121 1831 1832 77 1880 109 AOI21_X1
* cell instance $21880 r0 *1 110.39,35
X$21880 1339 1390 1830 109 1935 77 OAI21_X1
* cell instance $21881 r0 *1 111.15,35
X$21881 1883 1310 1582 77 1974 109 AOI21_X1
* cell instance $21882 r0 *1 111.91,35
X$21882 1436 1833 1227 77 1834 109 AOI21_X1
* cell instance $21883 r0 *1 112.67,35
X$21883 1834 1481 1339 109 2016 77 OAI21_X1
* cell instance $21885 r0 *1 113.62,35
X$21885 1755 77 109 1979 INV_X1
* cell instance $21887 r0 *1 114.19,35
X$21887 77 1984 1396 1837 1170 1829 1886 1986 109 OAI222_X2
* cell instance $21891 m0 *1 116.66,35
X$21891 1581 1388 1685 77 1887 109 AOI21_X1
* cell instance $21892 m0 *1 115.71,35
X$21892 1801 1802 1689 1758 77 109 1886 NOR4_X1
* cell instance $21893 m0 *1 117.42,35
X$21893 1887 1835 1579 77 1836 109 AOI21_X1
* cell instance $21894 m0 *1 118.18,35
X$21894 1497 1582 109 77 1765 AND2_X2
* cell instance $21895 m0 *1 119.13,35
X$21895 1388 1503 1807 1577 1761 1889 77 109 OAI221_X2
* cell instance $21896 m0 *1 121.22,35
X$21896 1808 1757 1835 77 1891 109 AOI21_X1
* cell instance $21897 m0 *1 121.98,35
X$21897 1587 1889 1694 1753 1691 1808 109 77 AOI221_X2
* cell instance $21898 m0 *1 124.07,35
X$21898 1400 1175 77 109 1764 NOR2_X2
* cell instance $21899 m0 *1 125.02,35
X$21899 1577 1765 109 77 1766 AND2_X1
* cell instance $21900 m0 *1 125.78,35
X$21900 1577 77 109 1835 CLKBUF_X3
* cell instance $21901 m0 *1 126.73,35
X$21901 1766 1499 1816 77 1896 109 AOI21_X1
* cell instance $21904 r0 *1 117.04,35
X$21904 1829 1836 1685 1837 109 77 1988 OAI22_X2
* cell instance $21906 r0 *1 118.94,35
X$21906 1937 1396 77 109 1833 NAND2_X2
* cell instance $21908 r0 *1 120.27,35
X$21908 1755 1227 1587 77 1991 109 AOI21_X1
* cell instance $21910 r0 *1 121.22,35
X$21910 1829 1891 1726 1837 109 77 1993 OAI22_X2
* cell instance $21912 r0 *1 123.12,35
X$21912 1764 77 109 1762 INV_X1
* cell instance $21913 r0 *1 123.5,35
X$21913 1764 1692 109 77 1994 AND2_X1
* cell instance $21914 r0 *1 124.26,35
X$21914 1692 1764 77 109 1937 NAND2_X2
* cell instance $21915 r0 *1 125.21,35
X$21915 1764 1835 1696 109 2021 77 OAI21_X1
* cell instance $21917 r0 *1 126.35,35
X$21917 1590 1766 1751 109 1996 77 OAI21_X1
* cell instance $21918 r0 *1 127.11,35
X$21918 1651 1841 77 109 1830 NOR2_X1
* cell instance $21920 m0 *1 128.63,35
X$21920 1814 1901 1751 77 109 NOR2_X4
* cell instance $21921 m0 *1 127.87,35
X$21921 1400 1396 1696 109 1838 77 OAI21_X1
* cell instance $21922 m0 *1 130.34,35
X$21922 1344 1694 1767 77 109 1840 NOR3_X1
* cell instance $21925 r0 *1 128.25,35
X$21925 1995 1838 1754 77 1839 109 AOI21_X1
* cell instance $21927 r0 *1 129.2,35
X$21927 1477 1589 1757 77 2002 109 AOI21_X1
* cell instance $21929 r0 *1 130.15,35
X$21929 1840 1767 1340 77 1899 109 AOI21_X1
* cell instance $21931 m0 *1 131.67,35
X$21931 1593 109 1841 77 BUF_X4
* cell instance $21933 m0 *1 133,35
X$21933 209 77 109 1903 INV_X1
* cell instance $21935 m0 *1 134.14,35
X$21935 1903 352 958 77 109 1904 NOR3_X1
* cell instance $21936 m0 *1 134.9,35
X$21936 1904 352 654 77 1842 109 AOI21_X1
* cell instance $21937 m0 *1 135.66,35
X$21937 345 77 109 1819 CLKBUF_X3
* cell instance $21938 m0 *1 136.61,35
X$21938 1819 77 109 19085 INV_X4
* cell instance $21939 m0 *1 137.56,35
X$21939 1941 1820 1908 109 1907 77 OAI21_X1
* cell instance $21940 m0 *1 138.32,35
X$21940 885 1910 77 109 1908 OR2_X1
* cell instance $21941 m0 *1 139.08,35
X$21941 1654 2029 209 109 1910 77 OAI21_X1
* cell instance $21947 r0 *1 133,35
X$21947 881 109 1126 77 BUF_X4
* cell instance $21949 r0 *1 134.71,35
X$21949 1903 1126 959 77 109 1905 NOR3_X1
* cell instance $21950 r0 *1 135.47,35
X$21950 1842 1347 1003 77 109 1906 NOR3_X1
* cell instance $21951 r0 *1 136.23,35
X$21951 1907 1126 1905 1347 959 1909 109 77 AOI221_X2
* cell instance $21952 r0 *1 138.32,35
X$21952 1843 109 1122 77 BUF_X4
* cell instance $21955 r0 *1 141.36,35
X$21955 77 1844 18896 1913 1911 1663 109 DFFR_X1
* cell instance $21956 m0 *1 146.49,35
X$21956 1914 77 109 1596 CLKBUF_X2
* cell instance $21957 m0 *1 144.78,35
X$21957 1845 1699 1700 1768 77 1770 109 NAND4_X2
* cell instance $21959 m0 *1 148.01,35
X$21959 1845 1915 1263 77 1919 109 AOI21_X1
* cell instance $21960 m0 *1 148.77,35
X$21960 1919 1275 1769 77 1911 109 AOI21_X1
* cell instance $21962 r0 *1 145.16,35
X$21962 1913 77 109 1845 BUF_X2
* cell instance $21964 r0 *1 146.11,35
X$21964 1699 1845 1943 109 77 1846 AND3_X1
* cell instance $21965 r0 *1 147.06,35
X$21965 1596 1845 1699 77 109 1945 NAND3_X1
* cell instance $21966 r0 *1 147.82,35
X$21966 1846 1596 1847 77 109 1703 NAND3_X2
* cell instance $21967 r0 *1 149.15,35
X$21967 1846 1179 1596 77 109 1946 NAND3_X1
* cell instance $21968 m0 *1 150.1,35
X$21968 1847 77 109 1848 INV_X1
* cell instance $21970 m0 *1 150.48,35
X$21970 1770 1848 1771 109 1572 77 NOR3_X2
* cell instance $21971 m0 *1 151.81,35
X$21971 1848 1921 1259 1826 77 109 1850 AOI22_X1
* cell instance $21972 m0 *1 152.76,35
X$21972 1701 1847 77 109 1671 NAND2_X2
* cell instance $21975 r0 *1 150.29,35
X$21975 1945 1848 1771 109 1454 77 NOR3_X2
* cell instance $21976 r0 *1 151.62,35
X$21976 1572 373 1849 1851 77 109 1947 NAND4_X1
* cell instance $21977 r0 *1 152.57,35
X$21977 1852 1671 1179 109 1948 77 OAI21_X1
* cell instance $21978 r0 *1 153.33,35
X$21978 1851 77 109 1852 INV_X1
* cell instance $21979 r0 *1 153.71,35
X$21979 1852 1922 1259 1923 77 109 1949 AOI22_X1
* cell instance $21980 m0 *1 154.28,35
X$21980 1852 1853 872 109 1923 77 OAI21_X1
* cell instance $21982 m0 *1 155.04,35
X$21982 1454 373 77 109 1853 NAND2_X1
* cell instance $21984 r0 *1 154.66,35
X$21984 1854 1853 787 109 2086 77 OAI21_X1
* cell instance $21985 r0 *1 155.42,35
X$21985 1867 1322 77 109 703 NAND2_X1
* cell instance $21986 m0 *1 156.18,35
X$21986 973 1454 1447 109 1922 77 OAI21_X1
* cell instance $21990 r0 *1 156.37,35
X$21990 1854 1671 77 109 1950 OR2_X1
* cell instance $21991 r0 *1 157.13,35
X$21991 1855 1854 77 109 1600 OR2_X1
* cell instance $21993 m0 *1 157.32,35
X$21993 1893 1322 77 109 872 NAND2_X1
* cell instance $21994 m0 *1 158.65,35
X$21994 1600 1671 77 109 1515 OR2_X2
* cell instance $21996 m0 *1 159.79,35
X$21996 1925 1322 77 109 575 NAND2_X1
* cell instance $21998 m0 *1 161.12,35
X$21998 1856 1602 724 109 1857 77 OAI21_X1
* cell instance $22001 m0 *1 164.16,35
X$22001 1331 501 1602 77 1928 109 AOI21_X1
* cell instance $22002 m0 *1 164.92,35
X$22002 1608 1515 501 109 1825 77 OAI21_X1
* cell instance $22003 m0 *1 165.68,35
X$22003 1602 1058 1859 77 109 1929 NOR3_X1
* cell instance $22007 r0 *1 158.08,35
X$22007 1924 973 77 109 1015 NAND2_X1
* cell instance $22010 r0 *1 159.79,35
X$22010 820 1515 1856 77 109 1951 OR3_X1
* cell instance $22011 r0 *1 160.74,35
X$22011 1927 1259 1827 77 1952 109 AOI21_X1
* cell instance $22012 r0 *1 161.5,35
X$22012 1926 1857 1263 77 1927 109 AOI21_X1
* cell instance $22015 r0 *1 163.21,35
X$22015 1859 1515 1179 109 1953 77 OAI21_X1
* cell instance $22016 r0 *1 163.97,35
X$22016 1858 1954 77 109 1856 NAND2_X1
* cell instance $22017 r0 *1 164.54,35
X$22017 1858 1954 1926 77 109 1608 NAND3_X2
* cell instance $22018 r0 *1 165.87,35
X$22018 1858 77 109 1859 INV_X1
* cell instance $22020 r0 *1 166.44,35
X$22020 1929 973 759 77 1955 109 AOI21_X1
* cell instance $22022 m0 *1 171.38,35
X$22022 349 77 109 1523 CLKBUF_X3
* cell instance $22023 m0 *1 167.58,35
X$22023 77 1523 18510 1824 1930 1663 109 DFFR_X1
* cell instance $22025 m0 *1 172.52,35
X$22025 1809 1322 77 109 580 NAND2_X1
* cell instance $22026 m0 *1 173.09,35
X$22026 1772 1818 1821 109 1861 77 OAI21_X1
* cell instance $22029 r0 *1 168.15,35
X$22029 1273 77 109 458 CLKBUF_X3
* cell instance $22030 r0 *1 169.1,35
X$22030 1860 820 77 109 513 NAND2_X1
* cell instance $22033 r0 *1 170.62,35
X$22033 1860 109 503 77 BUF_X4
* cell instance $22038 r0 *1 172.33,35
X$22038 77 1523 18804 1862 2001 1146 109 DFFR_X1
* cell instance $22040 m0 *1 174.23,35
X$22040 1416 1862 77 109 1821 NOR2_X1
* cell instance $22041 m0 *1 174.99,35
X$22041 1862 733 1355 737 77 109 1998 AOI22_X1
* cell instance $22043 m0 *1 176.13,35
X$22043 1773 1361 77 109 1774 NOR2_X1
* cell instance $22044 m0 *1 176.7,35
X$22044 1677 1862 1775 1357 77 109 1773 NAND4_X1
* cell instance $22045 m0 *1 177.65,35
X$22045 1677 1672 1775 1357 77 109 1818 NAND4_X1
* cell instance $22046 m0 *1 178.6,35
X$22046 1920 1863 1813 1777 1775 77 109 1918 AOI221_X1
* cell instance $22049 r0 *1 176.32,35
X$22049 1775 608 609 1354 77 109 1956 AOI22_X2
* cell instance $22050 r0 *1 178.03,35
X$22050 77 2115 18781 1916 1918 1146 109 DFFR_X1
* cell instance $22052 m0 *1 180.12,35
X$22052 1917 1708 77 109 1815 NAND2_X1
* cell instance $22053 m0 *1 180.88,35
X$22053 1775 1776 77 109 1811 OR2_X1
* cell instance $22054 m0 *1 181.64,35
X$22054 1811 1279 1912 77 1813 109 AOI21_X1
* cell instance $22055 m0 *1 182.4,35
X$22055 1865 1912 109 77 1777 AND2_X1
* cell instance $22056 m0 *1 183.16,35
X$22056 1865 1418 1284 77 109 1864 NOR3_X1
* cell instance $22057 m0 *1 183.92,35
X$22057 1809 1863 1864 1279 1284 77 109 1778 AOI221_X1
* cell instance $22059 m0 *1 185.25,35
X$22059 1613 1776 77 109 1900 OR2_X1
* cell instance $22060 m0 *1 186.01,35
X$22060 1900 1279 1529 77 1898 109 AOI21_X1
* cell instance $22062 r0 *1 181.83,35
X$22062 1916 77 109 1775 CLKBUF_X2
* cell instance $22063 r0 *1 182.59,35
X$22063 1357 1711 109 77 1912 AND2_X1
* cell instance $22065 r0 *1 183.54,35
X$22065 1357 1775 1862 1711 109 77 1866 AND4_X1
* cell instance $22067 r0 *1 185.44,35
X$22067 1902 1776 77 109 2047 OR2_X1
* cell instance $22068 r0 *1 186.2,35
X$22068 1902 1866 109 77 1712 AND2_X1
* cell instance $22069 r0 *1 186.96,35
X$22069 1865 1866 109 77 1957 AND2_X1
* cell instance $22070 m0 *1 187.91,35
X$22070 1398 1863 1898 1779 1613 77 109 1897 AOI221_X1
* cell instance $22071 m0 *1 187.15,35
X$22071 1865 1529 109 77 1779 AND2_X1
* cell instance $22073 m0 *1 189.24,35
X$22073 77 1364 18546 1895 1897 1146 109 DFFR_X1
* cell instance $22077 m0 *1 193.42,35
X$22077 1895 77 109 1613 BUF_X2
* cell instance $22080 r0 *1 194.18,35
X$22080 77 1713 18803 1958 1894 1146 109 DFFR_X1
* cell instance $22082 m0 *1 196.08,35
X$22082 1402 1892 1958 77 109 1894 MUX2_X1
* cell instance $22083 m0 *1 197.6,35
X$22083 1893 77 109 1402 INV_X1
* cell instance $22087 m0 *1 198.36,35
X$22087 77 1713 18560 1868 1987 1146 109 DFFR_X1
* cell instance $22088 m0 *1 202.92,35
X$22088 1463 1892 1985 77 109 1890 MUX2_X1
* cell instance $22091 r0 *1 199.5,35
X$22091 903 1892 1868 77 109 1987 MUX2_X1
* cell instance $22094 r0 *1 201.4,35
X$22094 77 1553 18852 1985 1890 1146 109 DFFR_X1
* cell instance $22096 m0 *1 205.58,35
X$22096 1553 77 109 19244 CLKBUF_X1
* cell instance $22098 m0 *1 206.15,35
X$22098 1867 77 109 1087 INV_X1
* cell instance $22101 r0 *1 205.39,35
X$22101 999 77 109 1553 CLKBUF_X3
* cell instance $22102 r0 *1 206.34,35
X$22102 1087 1892 1982 77 109 1960 MUX2_X1
* cell instance $22104 m0 *1 208.62,35
X$22104 77 1367 18507 1714 1888 1146 109 DFFR_X1
* cell instance $22110 r0 *1 210.52,35
X$22110 1822 77 109 903 INV_X2
* cell instance $22114 m0 *1 212.8,35
X$22114 77 1367 18557 1870 1782 992 109 DFFR_X1
* cell instance $22115 m0 *1 216.79,35
X$22115 1783 1629 77 109 1305 NAND2_X2
* cell instance $22116 m0 *1 217.74,35
X$22116 1463 1470 1881 77 109 1884 MUX2_X1
* cell instance $22117 m0 *1 219.07,35
X$22117 1783 1542 77 109 912 NAND2_X2
* cell instance $22121 r0 *1 213.18,35
X$22121 1869 77 109 1540 CLKBUF_X3
* cell instance $22123 r0 *1 214.51,35
X$22123 1539 1870 77 109 1715 NAND2_X1
* cell instance $22125 r0 *1 216.6,35
X$22125 1869 77 109 1539 CLKBUF_X3
* cell instance $22127 r0 *1 218.31,35
X$22127 77 1721 1884 992 18995 1881 109 DFFR_X2
* cell instance $22128 m0 *1 222.3,35
X$22128 999 77 109 1721 CLKBUF_X3
* cell instance $22129 m0 *1 221.92,35
X$22129 1721 77 109 19143 INV_X1
* cell instance $22130 m0 *1 223.25,35
X$22130 77 1721 18490 1879 1784 992 109 DFFR_X1
* cell instance $22132 r0 *1 222.49,35
X$22132 548 1630 1871 77 109 1963 MUX2_X1
* cell instance $22133 r0 *1 223.82,35
X$22133 996 1540 1964 109 1784 77 OAI21_X1
* cell instance $22134 r0 *1 224.58,35
X$22134 1539 1879 77 109 1964 NAND2_X1
* cell instance $22141 r0 *1 227.24,35
X$22141 772 1470 1970 77 109 1965 MUX2_X1
* cell instance $22142 m0 *1 231.23,35
X$22142 77 1546 18568 1791 1788 992 109 DFFR_X1
* cell instance $22143 m0 *1 227.43,35
X$22143 77 1546 18549 1787 1786 992 109 DFFR_X1
* cell instance $22149 r0 *1 234.08,35
X$22149 413 1470 1872 77 109 1875 MUX2_X1
* cell instance $22150 r0 *1 235.41,35
X$22150 77 1873 1875 992 18970 1872 109 DFFR_X2
* cell instance $22152 m0 *1 235.41,35
X$22152 77 1873 1874 992 18912 1789 109 DFFR_X2
* cell instance $22167 r0 *1 9.5,186.2
X$22167 15167 6280 15507 77 109 15460 MUX2_X1
* cell instance $22169 r0 *1 11.02,186.2
X$22169 77 15031 15267 15507 15460 9814 109 DFFR_X1
* cell instance $22170 m0 *1 11.78,186.2
X$22170 77 15031 15268 15406 15315 9814 109 DFFR_X1
* cell instance $22172 m0 *1 15.58,186.2
X$22172 15267 12066 15268 77 109 15269 MUX2_X1
* cell instance $22179 r0 *1 17.67,186.2
X$22179 77 15461 15411 15462 15511 9814 109 DFFR_X1
* cell instance $22181 m0 *1 18.05,186.2
X$22181 15318 14187 15368 77 109 15409 MUX2_X1
* cell instance $22182 m0 *1 19.95,186.2
X$22182 15411 12066 15410 77 109 15270 MUX2_X1
* cell instance $22184 m0 *1 21.28,186.2
X$22184 15411 10129 15410 77 109 15412 MUX2_X1
* cell instance $22186 r0 *1 21.47,186.2
X$22186 15462 10198 15368 77 109 15511 MUX2_X1
* cell instance $22189 m0 *1 22.99,186.2
X$22189 15412 9895 15603 77 109 15168 MUX2_X1
* cell instance $22192 m0 *1 25.46,186.2
X$22192 77 14930 15271 15363 15512 9814 109 DFFR_X1
* cell instance $22193 m0 *1 30.02,186.2
X$22193 15364 13257 15272 77 109 15273 MUX2_X1
* cell instance $22194 m0 *1 31.35,186.2
X$22194 14461 77 109 14930 CLKBUF_X3
* cell instance $22200 r0 *1 27.55,186.2
X$22200 14461 77 109 19115 INV_X2
* cell instance $22201 r0 *1 28.12,186.2
X$22201 15363 10198 13675 77 109 15512 MUX2_X1
* cell instance $22202 r0 *1 29.45,186.2
X$22202 77 14930 15272 15463 15515 4086 109 DFFR_X1
* cell instance $22203 r0 *1 33.25,186.2
X$22203 15463 13145 13675 77 109 15515 MUX2_X1
* cell instance $22207 m0 *1 36.48,186.2
X$22207 77 11685 15365 15464 7026 109 AOI21_X4
* cell instance $22208 m0 *1 39.71,186.2
X$22208 15420 12189 15421 77 109 15274 MUX2_X1
* cell instance $22209 m0 *1 41.04,186.2
X$22209 15420 13355 15421 77 109 15275 MUX2_X1
* cell instance $22211 m0 *1 42.56,186.2
X$22211 15366 3624 15367 77 109 15332 MUX2_X1
* cell instance $22212 m0 *1 43.89,186.2
X$22212 15366 13355 15367 77 109 15174 MUX2_X1
* cell instance $22213 m0 *1 45.22,186.2
X$22213 14989 11129 15368 77 109 15370 MUX2_X1
* cell instance $22214 m0 *1 46.55,186.2
X$22214 77 15369 18502 14989 15370 4086 109 DFFR_X1
* cell instance $22215 m0 *1 50.35,186.2
X$22215 8627 6296 77 9801 109 NAND2_X4
* cell instance $22217 m0 *1 52.25,186.2
X$22217 77 9742 109 6296 BUF_X8
* cell instance $22218 m0 *1 54.72,186.2
X$22218 15371 9976 15276 77 109 15426 MUX2_X1
* cell instance $22219 m0 *1 56.05,186.2
X$22219 15372 9810 15424 77 109 15423 MUX2_X1
* cell instance $22220 m0 *1 57.38,186.2
X$22220 15372 12189 15424 77 109 15425 MUX2_X1
* cell instance $22223 r0 *1 36.86,186.2
X$22223 77 14930 15420 15465 15525 4086 109 DFFR_X1
* cell instance $22226 r0 *1 41.8,186.2
X$22226 77 14708 15366 15466 15527 4086 109 DFFR_X1
* cell instance $22227 r0 *1 45.6,186.2
X$22227 15466 14047 15368 77 109 15527 MUX2_X1
* cell instance $22229 r0 *1 49.97,186.2
X$22229 9742 15468 15530 7742 15334 11052 77 109 OAI221_X2
* cell instance $22234 r0 *1 57.19,186.2
X$22234 77 14710 15470 15469 15427 8687 109 DFFR_X1
* cell instance $22239 m0 *1 59.85,186.2
X$22239 14048 7636 15469 77 109 15427 MUX2_X1
* cell instance $22240 m0 *1 61.94,186.2
X$22240 15470 4287 15373 77 109 15374 MUX2_X1
* cell instance $22242 m0 *1 63.46,186.2
X$22242 77 3624 109 15375 BUF_X8
* cell instance $22243 m0 *1 65.93,186.2
X$22243 77 15126 15376 15429 15338 8687 109 DFFR_X1
* cell instance $22244 m0 *1 69.73,186.2
X$22244 77 15126 15377 15280 15281 8687 109 DFFR_X1
* cell instance $22246 r0 *1 60.99,186.2
X$22246 6686 77 109 14712 BUF_X2
* cell instance $22248 r0 *1 61.94,186.2
X$22248 15470 11128 15373 77 109 15471 MUX2_X1
* cell instance $22249 r0 *1 63.27,186.2
X$22249 15374 4322 15627 77 109 15531 MUX2_X1
* cell instance $22251 r0 *1 64.79,186.2
X$22251 15531 4284 15472 77 109 15278 MUX2_X1
* cell instance $22255 r0 *1 68.21,186.2
X$22255 14135 77 109 15126 CLKBUF_X3
* cell instance $22258 r0 *1 70.3,186.2
X$22258 15375 109 12189 77 BUF_X4
* cell instance $22261 r0 *1 72.77,186.2
X$22261 15376 12153 15377 77 109 15474 MUX2_X1
* cell instance $22262 m0 *1 75.24,186.2
X$22262 15378 8359 15430 77 109 15052 MUX2_X1
* cell instance $22263 m0 *1 73.91,186.2
X$22263 15376 6451 15377 77 109 15378 MUX2_X1
* cell instance $22265 r0 *1 74.1,186.2
X$22265 15473 13272 15565 77 109 15430 MUX2_X1
* cell instance $22269 r0 *1 76.76,186.2
X$22269 77 14475 15046 15633 15536 8687 109 DFFR_X1
* cell instance $22270 m0 *1 80.75,186.2
X$22270 15436 4631 15434 77 109 15342 MUX2_X1
* cell instance $22271 m0 *1 76.95,186.2
X$22271 77 14475 18513 15182 15341 8687 109 DFFR_X1
* cell instance $22276 m0 *1 82.46,186.2
X$22276 4914 109 8984 77 BUF_X4
* cell instance $22277 m0 *1 85.31,186.2
X$22277 8359 109 3622 77 BUF_X4
* cell instance $22278 m0 *1 86.64,186.2
X$22278 15476 3694 15431 77 109 15438 MUX2_X1
* cell instance $22282 r0 *1 83.41,186.2
X$22282 15539 7468 15339 77 109 15537 MUX2_X1
* cell instance $22283 r0 *1 84.74,186.2
X$22283 77 14803 15248 15539 15537 8687 109 DFFR_X1
* cell instance $22284 m0 *1 88.92,186.2
X$22284 15053 15439 6294 77 109 15379 NOR3_X1
* cell instance $22285 m0 *1 88.35,186.2
X$22285 15438 6294 77 109 15668 NOR2_X1
* cell instance $22286 m0 *1 89.68,186.2
X$22286 15441 8028 15440 14194 15666 15186 109 77 AOI221_X2
* cell instance $22287 m0 *1 91.77,186.2
X$22287 15381 7292 77 109 15442 NOR2_X1
* cell instance $22293 r0 *1 89.87,186.2
X$22293 15442 15540 3599 77 109 15439 NOR3_X1
* cell instance $22294 r0 *1 90.63,186.2
X$22294 15567 10860 77 109 15540 NOR2_X1
* cell instance $22297 r0 *1 91.77,186.2
X$22297 77 13272 8067 109 BUF_X32
* cell instance $22298 m0 *1 93.67,186.2
X$22298 15825 15379 8627 109 15380 77 NOR3_X2
* cell instance $22300 m0 *1 95,186.2
X$22300 77 14428 15055 15285 15352 8201 109 DFFR_X1
* cell instance $22301 m0 *1 98.8,186.2
X$22301 15284 15380 77 109 9127 OR2_X2
* cell instance $22304 r0 *1 101.08,186.2
X$22304 77 15149 15382 15640 15547 8201 109 DFFR_X1
* cell instance $22305 m0 *1 102.6,186.2
X$22305 15382 12153 15477 77 109 15381 MUX2_X1
* cell instance $22306 m0 *1 101.65,186.2
X$22306 14026 77 109 15149 CLKBUF_X3
* cell instance $22307 m0 *1 103.93,186.2
X$22307 15382 10451 15478 77 109 15446 MUX2_X1
* cell instance $22310 r0 *1 105.07,186.2
X$22310 15446 8984 5415 109 15569 77 NOR3_X2
* cell instance $22312 m0 *1 105.64,186.2
X$22312 77 14723 15548 16099 15447 14724 109 OAI22_X4
* cell instance $22313 r0 *1 106.4,186.2
X$22313 6745 15479 15642 7590 109 77 15480 OAI22_X2
* cell instance $22315 r0 *1 108.3,186.2
X$22315 77 15255 15740 15871 15449 12218 109 OAI22_X4
* cell instance $22317 m0 *1 109.25,186.2
X$22317 77 6869 15151 15449 15358 15447 109 OR4_X4
* cell instance $22318 r0 *1 111.53,186.2
X$22318 77 6742 109 10451 BUF_X8
* cell instance $22319 m0 *1 112.29,186.2
X$22319 77 12236 12875 15188 12728 8168 15065 14918 109 AOI222_X2
* cell instance $22322 m0 *1 115.14,186.2
X$22322 77 12264 8168 15452 15063 13060 15064 12236 109 AOI222_X2
* cell instance $22323 m0 *1 117.8,186.2
X$22323 77 12875 15191 15557 12728 6869 15065 7028 109 AOI222_X2
* cell instance $22324 m0 *1 120.46,186.2
X$22324 77 6599 15063 15482 15064 15383 15065 11474 109 AOI222_X2
* cell instance $22325 m0 *1 123.12,186.2
X$22325 77 14726 15459 15384 15458 12731 109 DFFR_X1
* cell instance $22326 m0 *1 126.92,186.2
X$22326 15384 13822 15266 77 109 15458 MUX2_X1
* cell instance $22328 m0 *1 129.01,186.2
X$22328 14580 77 109 19217 CLKBUF_X1
* cell instance $22329 m0 *1 129.58,186.2
X$22329 13437 77 109 14580 CLKBUF_X3
* cell instance $22330 m0 *1 130.53,186.2
X$22330 15357 13822 15456 77 109 15457 MUX2_X1
* cell instance $22331 m0 *1 131.86,186.2
X$22331 14303 14949 15288 77 109 15551 MUX2_X1
* cell instance $22335 r0 *1 114.38,186.2
X$22335 15153 13141 15452 77 15553 109 AOI21_X2
* cell instance $22340 r0 *1 115.9,186.2
X$22340 77 12264 15383 15571 15063 15187 15064 6599 109 AOI222_X2
* cell instance $22341 r0 *1 118.56,186.2
X$22341 11474 15185 77 109 15481 NOR2_X1
* cell instance $22342 r0 *1 119.13,186.2
X$22342 15554 13141 15557 77 15555 109 AOI21_X2
* cell instance $22343 r0 *1 120.46,186.2
X$22343 15189 12421 77 109 15554 NOR2_X1
* cell instance $22345 r0 *1 121.22,186.2
X$22345 15287 10787 15482 77 15556 109 AOI21_X2
* cell instance $22346 r0 *1 122.55,186.2
X$22346 13437 77 109 12828 CLKBUF_X3
* cell instance $22349 r0 *1 125.4,186.2
X$22349 14955 13823 12427 77 109 15842 MUX2_X1
* cell instance $22350 r0 *1 126.73,186.2
X$22350 15646 14200 15459 77 109 15552 MUX2_X1
* cell instance $22351 r0 *1 128.06,186.2
X$22351 9263 13823 9556 77 109 15647 MUX2_X1
* cell instance $22355 r0 *1 131.48,186.2
X$22355 11474 109 13668 77 BUF_X4
* cell instance $22356 r0 *1 132.81,186.2
X$22356 15551 14485 15552 77 109 15550 MUX2_X1
* cell instance $22357 r0 *1 134.14,186.2
X$22357 15845 14608 15550 77 109 15549 MUX2_X1
* cell instance $22358 m0 *1 135.28,186.2
X$22358 9469 13823 12691 77 109 15456 MUX2_X1
* cell instance $22361 m0 *1 136.8,186.2
X$22361 77 15455 15453 15354 15355 12731 109 DFFR_X1
* cell instance $22365 m0 *1 143.07,186.2
X$22365 9552 13281 7996 77 109 15451 MUX2_X1
* cell instance $22367 m0 *1 144.59,186.2
X$22367 15351 14063 15261 77 109 15291 MUX2_X1
* cell instance $22368 m0 *1 145.92,186.2
X$22368 15451 14063 15194 77 109 15450 MUX2_X1
* cell instance $22372 r0 *1 136.23,186.2
X$22372 15674 14698 15549 77 109 14826 MUX2_X1
* cell instance $22373 r0 *1 137.56,186.2
X$22373 11052 15069 14825 77 109 15483 MUX2_X1
* cell instance $22374 r0 *1 138.89,186.2
X$22374 12427 13281 15189 77 109 15574 MUX2_X1
* cell instance $22375 r0 *1 140.22,186.2
X$22375 77 15455 18745 15022 15649 12731 109 DFFR_X1
* cell instance $22377 r0 *1 144.21,186.2
X$22377 15575 14063 14820 77 109 15645 MUX2_X1
* cell instance $22379 r0 *1 145.73,186.2
X$22379 77 14849 18791 15194 15450 12731 109 DFFR_X1
* cell instance $22381 m0 *1 148.39,186.2
X$22381 13060 15448 109 77 15546 AND2_X1
* cell instance $22383 m0 *1 150.1,186.2
X$22383 11894 15448 109 77 15544 AND2_X1
* cell instance $22384 m0 *1 150.86,186.2
X$22384 12236 12420 15072 109 77 15445 MUX2_X2
* cell instance $22385 m0 *1 152.57,186.2
X$22385 9912 8047 15082 109 77 15385 MUX2_X2
* cell instance $22386 m0 *1 154.28,186.2
X$22386 10892 9469 15082 109 77 15444 MUX2_X2
* cell instance $22387 m0 *1 155.99,186.2
X$22387 15486 5472 77 109 15293 NOR2_X2
* cell instance $22389 r0 *1 149.53,186.2
X$22389 15546 8168 15348 77 15545 109 AOI21_X2
* cell instance $22390 r0 *1 150.86,186.2
X$22390 15484 6693 77 109 15485 NOR2_X1
* cell instance $22391 r0 *1 151.43,186.2
X$22391 15544 7996 15072 77 15543 109 AOI21_X2
* cell instance $22392 r0 *1 152.76,186.2
X$22392 15484 14564 77 109 15542 NOR2_X1
* cell instance $22393 r0 *1 153.33,186.2
X$22393 77 15541 15542 9902 15072 109 AOI21_X4
* cell instance $22394 r0 *1 155.8,186.2
X$22394 9902 77 109 15189 BUF_X1
* cell instance $22395 r0 *1 156.37,186.2
X$22395 15486 77 109 15386 CLKBUF_X3
* cell instance $22396 r0 *1 157.32,186.2
X$22396 77 15749 15443 15538 15076 12731 109 DFFR_X1
* cell instance $22397 m0 *1 162.07,186.2
X$22397 15443 77 109 13286 CLKBUF_X3
* cell instance $22398 m0 *1 157.32,186.2
X$22398 77 5472 14615 109 BUF_X16
* cell instance $22400 r0 *1 161.12,186.2
X$22400 15538 77 109 13794 CLKBUF_X3
* cell instance $22403 r0 *1 162.64,186.2
X$22403 13297 15201 9162 77 109 15487 MUX2_X1
* cell instance $22404 m0 *1 163.59,186.2
X$22404 8264 109 13232 77 BUF_X4
* cell instance $22406 m0 *1 164.92,186.2
X$22406 15387 14296 77 109 13445 NOR2_X2
* cell instance $22409 r0 *1 164.16,186.2
X$22409 14615 109 14296 77 BUF_X4
* cell instance $22410 r0 *1 165.49,186.2
X$22410 15535 13236 15386 77 12751 109 AOI21_X2
* cell instance $22412 m0 *1 166.25,186.2
X$22412 15388 13232 77 109 14152 NAND2_X1
* cell instance $22413 r0 *1 166.82,186.2
X$22413 15386 15489 77 109 15535 NOR2_X1
* cell instance $22414 m0 *1 167.39,186.2
X$22414 15300 77 109 15294 CLKBUF_X3
* cell instance $22416 m0 *1 168.34,186.2
X$22416 15437 15389 13232 77 109 10912 NAND3_X2
* cell instance $22419 r0 *1 167.39,186.2
X$22419 13520 15488 77 109 15389 OR2_X1
* cell instance $22420 r0 *1 168.15,186.2
X$22420 77 5472 15534 15533 11485 109 NOR3_X4
* cell instance $22421 r0 *1 170.81,186.2
X$22421 15488 15393 77 109 15437 NAND2_X1
* cell instance $22422 m0 *1 171,186.2
X$22422 13232 15390 15435 109 77 15297 OAI21_X2
* cell instance $22424 m0 *1 172.33,186.2
X$22424 15391 77 109 15435 INV_X1
* cell instance $22429 r0 *1 171.38,186.2
X$22429 77 11058 15297 14852 15532 109 AOI21_X4
* cell instance $22430 m0 *1 173.28,186.2
X$22430 15386 15391 77 109 15432 NOR2_X1
* cell instance $22432 m0 *1 173.85,186.2
X$22432 15493 15299 77 109 15433 NOR2_X1
* cell instance $22433 m0 *1 174.42,186.2
X$22433 15392 12972 15386 77 15335 109 AOI21_X1
* cell instance $22434 m0 *1 175.18,186.2
X$22434 15386 15223 77 109 15392 NOR2_X1
* cell instance $22436 r0 *1 173.85,186.2
X$22436 14296 15493 15294 77 15634 109 AOI21_X1
* cell instance $22438 r0 *1 174.8,186.2
X$22438 5472 15300 15489 77 15631 109 AOI21_X1
* cell instance $22440 r0 *1 175.75,186.2
X$22440 14615 15529 15492 77 11239 109 AOI21_X2
* cell instance $22442 m0 *1 176.13,186.2
X$22442 15223 15390 15428 77 109 14619 MUX2_X1
* cell instance $22443 m0 *1 177.65,186.2
X$22443 8333 10228 15082 109 77 15526 MUX2_X2
* cell instance $22444 m0 *1 179.36,186.2
X$22444 77 15302 14742 12731 15394 14677 109 DFFR_X2
* cell instance $22445 m0 *1 183.54,186.2
X$22445 12979 77 109 15422 INV_X1
* cell instance $22446 m0 *1 183.92,186.2
X$22446 77 14358 14859 12731 12979 14791 109 DFFR_X2
* cell instance $22449 r0 *1 177.08,186.2
X$22449 9127 9314 15201 109 77 15528 MUX2_X2
* cell instance $22451 r0 *1 178.98,186.2
X$22451 77 14296 15491 15494 14544 109 NOR3_X4
* cell instance $22452 r0 *1 181.64,186.2
X$22452 13520 15524 77 109 15623 OR2_X1
* cell instance $22453 r0 *1 182.4,186.2
X$22453 15394 77 109 12989 BUF_X2
* cell instance $22455 r0 *1 183.92,186.2
X$22455 12995 15524 77 109 15495 OR2_X1
* cell instance $22456 r0 *1 184.68,186.2
X$22456 12816 15524 77 109 15621 OR2_X1
* cell instance $22459 r0 *1 186.01,186.2
X$22459 15706 15523 15489 109 77 15521 HA_X1
* cell instance $22462 r0 *1 189.05,186.2
X$22462 15521 15619 15522 109 77 15520 HA_X1
* cell instance $22463 r0 *1 190.95,186.2
X$22463 15705 15522 15393 109 77 15419 HA_X1
* cell instance $22464 m0 *1 191.71,186.2
X$22464 15419 15418 15391 109 77 15417 HA_X1
* cell instance $22466 m0 *1 193.61,186.2
X$22466 15395 15517 15418 109 77 15303 HA_X1
* cell instance $22467 m0 *1 195.51,186.2
X$22467 77 15396 15415 15305 15304 15416 109 FA_X1
* cell instance $22470 r0 *1 192.85,186.2
X$22470 15520 15519 15517 109 77 15325 HA_X1
* cell instance $22474 r0 *1 197.41,186.2
X$22474 15518 77 109 15396 INV_X1
* cell instance $22475 r0 *1 197.79,186.2
X$22475 15496 16266 15518 109 77 15516 HA_X1
* cell instance $22477 r0 *1 199.88,186.2
X$22477 15516 77 109 15497 INV_X1
* cell instance $22478 r0 *1 200.26,186.2
X$22478 77 15397 15514 15498 15513 15497 109 FA_X1
* cell instance $22479 m0 *1 200.64,186.2
X$22479 15584 77 109 15513 INV_X1
* cell instance $22482 m0 *1 201.78,186.2
X$22482 15514 77 109 15320 INV_X1
* cell instance $22483 m0 *1 202.16,186.2
X$22483 15498 77 109 15306 INV_X1
* cell instance $22484 m0 *1 202.54,186.2
X$22484 15415 77 109 15413 INV_X1
* cell instance $22487 m0 *1 203.3,186.2
X$22487 15306 15413 15319 109 77 15307 HA_X1
* cell instance $22488 m0 *1 205.96,186.2
X$22488 15398 15399 77 109 15414 XNOR2_X2
* cell instance $22490 r0 *1 203.3,186.2
X$22490 15585 77 109 15397 INV_X1
* cell instance $22493 r0 *1 207.1,186.2
X$22493 15611 77 109 15308 INV_X1
* cell instance $22495 m0 *1 208.62,186.2
X$22495 15309 15398 15399 77 15408 109 AOI21_X1
* cell instance $22496 m0 *1 208.24,186.2
X$22496 15309 77 109 15499 INV_X1
* cell instance $22498 r0 *1 209,186.2
X$22498 15499 15400 15317 109 77 15500 OAI21_X4
* cell instance $22500 m0 *1 209.76,186.2
X$22500 15399 77 109 15400 INV_X1
* cell instance $22504 r0 *1 211.66,186.2
X$22504 15401 15500 77 109 15493 XNOR2_X2
* cell instance $22505 m0 *1 212.99,186.2
X$22505 15407 15401 15408 109 77 15588 OAI21_X2
* cell instance $22509 r0 *1 213.75,186.2
X$22509 15510 15501 15509 109 77 15402 HA_X1
* cell instance $22510 m0 *1 214.89,186.2
X$22510 15402 77 109 15407 INV_X1
* cell instance $22516 m0 *1 233.7,186.2
X$22516 12691 77 109 15504 BUF_X1
* cell instance $22517 m0 *1 234.27,186.2
X$22517 15405 77 109 15312 BUF_X1
* cell instance $22518 m0 *1 234.84,186.2
X$22518 9393 77 109 15404 BUF_X1
* cell instance $22519 m0 *1 235.41,186.2
X$22519 15404 77 109 15403 BUF_X1
* cell instance $22523 r0 *1 215.84,186.2
X$22523 77 15508 15402 15509 15500 109 AOI21_X4
* cell instance $22526 r0 *1 218.88,186.2
X$22526 15503 15594 77 109 15502 NOR2_X1
* cell instance $22528 r0 *1 219.83,186.2
X$22528 15508 15602 77 109 15503 NOR2_X1
* cell instance $22536 r0 *1 234.46,186.2
X$22536 15504 77 109 15597 BUF_X1
* cell instance $22539 r0 *1 238.83,186.2
X$22539 15505 77 109 15506 BUF_X1
* cell instance $22549 m0 *1 9.88,163.8
X$22549 13544 3594 13618 77 109 13543 MUX2_X1
* cell instance $22550 m0 *1 11.21,163.8
X$22550 77 13672 13399 13619 13620 9814 109 DFFR_X1
* cell instance $22551 m0 *1 15.01,163.8
X$22551 13544 3784 13619 77 109 13620 MUX2_X1
* cell instance $22554 m0 *1 19.57,163.8
X$22554 2400 109 13682 77 BUF_X4
* cell instance $22555 m0 *1 20.9,163.8
X$22555 13740 12481 13096 77 109 13621 MUX2_X1
* cell instance $22558 m0 *1 26.03,163.8
X$22558 9142 77 109 13544 BUF_X2
* cell instance $22560 m0 *1 27.55,163.8
X$22560 9142 77 109 13675 BUF_X2
* cell instance $22569 r0 *1 5.51,163.8
X$22569 13544 6280 13735 77 109 13670 MUX2_X1
* cell instance $22570 r0 *1 6.84,163.8
X$22570 77 13672 13671 13735 13670 9814 109 DFFR_X1
* cell instance $22572 r0 *1 13.68,163.8
X$22572 77 13672 13401 13859 13738 9814 109 DFFR_X1
* cell instance $22573 r0 *1 17.48,163.8
X$22573 77 13672 13673 13740 13621 9814 109 DFFR_X1
* cell instance $22575 r0 *1 21.47,163.8
X$22575 13860 7059 13673 77 109 13742 MUX2_X1
* cell instance $22577 r0 *1 22.99,163.8
X$22577 13742 11278 13743 77 109 13402 MUX2_X1
* cell instance $22578 r0 *1 24.32,163.8
X$22578 13804 7059 13674 77 109 13743 MUX2_X1
* cell instance $22580 m0 *1 28.88,163.8
X$22580 13403 4627 13261 77 109 13623 MUX2_X1
* cell instance $22584 r0 *1 30.21,163.8
X$22584 13746 5455 77 109 13748 NAND2_X1
* cell instance $22585 m0 *1 30.78,163.8
X$22585 6299 13623 5449 77 13545 109 AOI21_X1
* cell instance $22589 m0 *1 33.25,163.8
X$22589 13625 13548 13544 77 109 13488 MUX2_X1
* cell instance $22590 m0 *1 34.58,163.8
X$22590 10674 77 109 12856 CLKBUF_X3
* cell instance $22596 r0 *1 31.16,163.8
X$22596 13406 13545 13748 77 109 13752 NAND3_X1
* cell instance $22598 r0 *1 34.96,163.8
X$22598 13749 7468 13544 77 109 13676 MUX2_X1
* cell instance $22599 r0 *1 36.29,163.8
X$22599 77 12856 13808 13749 13676 9814 109 DFFR_X1
* cell instance $22601 r0 *1 40.28,163.8
X$22601 77 13751 7776 13752 13546 9570 13754 10900 109 OAI222_X2
* cell instance $22602 m0 *1 42.56,163.8
X$22602 3995 13875 13809 8403 77 109 13547 AOI22_X1
* cell instance $22603 m0 *1 41.23,163.8
X$22603 13631 10065 13547 77 109 13754 MUX2_X1
* cell instance $22606 r0 *1 43.32,163.8
X$22606 13757 6885 13675 77 109 13677 MUX2_X1
* cell instance $22608 m0 *1 43.89,163.8
X$22608 3782 109 13548 77 BUF_X4
* cell instance $22609 m0 *1 45.41,163.8
X$22609 5020 109 13767 77 BUF_X4
* cell instance $22611 r0 *1 44.65,163.8
X$22611 77 13551 18834 13757 13677 4086 109 DFFR_X1
* cell instance $22612 m0 *1 50.92,163.8
X$22612 13678 13355 13636 77 109 13637 MUX2_X1
* cell instance $22613 m0 *1 47.12,163.8
X$22613 77 12860 13636 13411 13498 4086 109 DFFR_X1
* cell instance $22614 m0 *1 52.25,163.8
X$22614 13637 7620 77 109 13500 NOR2_X1
* cell instance $22616 r0 *1 48.45,163.8
X$22616 5110 109 9632 77 BUF_X4
* cell instance $22619 r0 *1 50.92,163.8
X$22619 13678 3624 13636 77 109 13759 MUX2_X1
* cell instance $22622 m0 *1 53.39,163.8
X$22622 13549 3624 13412 77 109 13760 MUX2_X1
* cell instance $22624 m0 *1 54.72,163.8
X$22624 77 13551 13412 13417 13415 4086 109 DFFR_X1
* cell instance $22627 m0 *1 60.8,163.8
X$22627 13552 10969 9815 77 13762 109 AOI21_X1
* cell instance $22628 m0 *1 61.56,163.8
X$22628 9815 13763 77 109 13552 NOR2_X1
* cell instance $22631 m0 *1 63.84,163.8
X$22631 77 13553 13554 13513 13645 4086 109 DFFR_X1
* cell instance $22632 m0 *1 67.64,163.8
X$22632 9976 109 6591 77 BUF_X4
* cell instance $22635 m0 *1 70.68,163.8
X$22635 13646 7468 12717 77 109 13647 MUX2_X1
* cell instance $22637 m0 *1 72.77,163.8
X$22637 77 13555 13556 13646 13647 8687 109 DFFR_X1
* cell instance $22640 r0 *1 53.58,163.8
X$22640 13760 3995 13759 77 109 13550 MUX2_X1
* cell instance $22644 r0 *1 57,163.8
X$22644 5805 109 14046 77 BUF_X4
* cell instance $22645 r0 *1 58.33,163.8
X$22645 77 13553 13679 13763 13762 4086 109 DFFR_X1
* cell instance $22650 r0 *1 62.51,163.8
X$22650 13680 13681 8671 109 13761 77 NOR3_X2
* cell instance $22651 r0 *1 63.84,163.8
X$22651 13764 6120 77 109 13681 NOR2_X1
* cell instance $22652 r0 *1 64.41,163.8
X$22652 13765 10200 13554 77 109 13884 MUX2_X1
* cell instance $22653 r0 *1 65.74,163.8
X$22653 13765 8463 13554 77 109 13764 MUX2_X1
* cell instance $22657 r0 *1 71.82,163.8
X$22657 13768 13767 13164 77 109 13885 MUX2_X1
* cell instance $22660 r0 *1 74.29,163.8
X$22660 13814 9023 13887 77 109 13770 MUX2_X1
* cell instance $22661 r0 *1 75.62,163.8
X$22661 13770 7292 77 109 13888 NOR2_X1
* cell instance $22663 r0 *1 76.38,163.8
X$22663 77 5589 109 7926 BUF_X8
* cell instance $22664 m0 *1 77.14,163.8
X$22664 13648 4138 13556 77 13650 109 AOI21_X1
* cell instance $22666 m0 *1 77.9,163.8
X$22666 13649 7290 8070 3791 13650 13420 109 77 AOI221_X2
* cell instance $22669 r0 *1 79.04,163.8
X$22669 7926 13556 109 77 13772 AND2_X1
* cell instance $22671 m0 *1 80.56,163.8
X$22671 77 13559 13165 13652 13653 8687 109 DFFR_X1
* cell instance $22674 m0 *1 84.55,163.8
X$22674 77 13559 13561 13775 13560 8687 109 DFFR_X1
* cell instance $22675 m0 *1 88.35,163.8
X$22675 13655 13421 77 109 13563 NOR2_X1
* cell instance $22676 m0 *1 88.92,163.8
X$22676 10449 8359 77 109 13656 NAND2_X1
* cell instance $22677 m0 *1 89.49,163.8
X$22677 13564 11132 5887 109 13657 77 NOR3_X2
* cell instance $22678 m0 *1 90.82,163.8
X$22678 8079 7342 13684 13656 13777 77 109 OAI211_X2
* cell instance $22679 m0 *1 92.53,163.8
X$22679 11132 7342 10451 77 109 13566 NAND3_X1
* cell instance $22681 m0 *1 93.48,163.8
X$22681 13660 13523 6901 109 13662 77 NOR3_X2
* cell instance $22682 m0 *1 94.81,163.8
X$22682 6593 7168 77 109 13421 OR2_X1
* cell instance $22686 r0 *1 82.46,163.8
X$22686 13652 13682 12717 77 109 13653 MUX2_X1
* cell instance $22688 r0 *1 84.17,163.8
X$22688 13775 13149 12717 77 109 13560 MUX2_X1
* cell instance $22691 r0 *1 86.64,163.8
X$22691 6276 8359 77 6184 109 NAND2_X4
* cell instance $22692 r0 *1 88.35,163.8
X$22692 77 13563 13777 13776 13657 13683 109 NOR4_X4
* cell instance $22695 r0 *1 92.34,163.8
X$22695 13685 13272 13686 77 109 13684 MUX2_X1
* cell instance $22696 r0 *1 93.67,163.8
X$22696 13896 8349 13780 77 109 13525 MUX2_X1
* cell instance $22697 r0 *1 95,163.8
X$22697 13685 8847 13686 77 109 13780 MUX2_X1
* cell instance $22698 m0 *1 97.28,163.8
X$22698 13384 13040 13526 77 109 13816 MUX2_X1
* cell instance $22699 m0 *1 95.95,163.8
X$22699 13422 109 6564 77 BUF_X4
* cell instance $22701 m0 *1 100.13,163.8
X$22701 13276 7279 13424 77 109 13529 MUX2_X1
* cell instance $22702 m0 *1 101.46,163.8
X$22702 11132 109 6130 77 BUF_X4
* cell instance $22706 r0 *1 96.71,163.8
X$22706 77 13687 13685 13688 13782 8201 109 DFFR_X1
* cell instance $22707 r0 *1 100.51,163.8
X$22707 13688 13098 13276 77 109 13782 MUX2_X1
* cell instance $22711 r0 *1 103.93,163.8
X$22711 13784 13548 13276 77 109 13689 MUX2_X1
* cell instance $22713 m0 *1 103.93,163.8
X$22713 13276 7636 13425 77 109 13532 MUX2_X1
* cell instance $22716 r0 *1 105.26,163.8
X$22716 77 13819 13818 13784 13689 8201 109 DFFR_X1
* cell instance $22718 m0 *1 114,163.8
X$22718 77 7087 109 7342 BUF_X8
* cell instance $22719 m0 *1 110.2,163.8
X$22719 77 13819 13427 13536 13664 8201 109 DFFR_X1
* cell instance $22720 m0 *1 116.47,163.8
X$22720 14058 4774 13789 77 109 13397 MUX2_X1
* cell instance $22722 m0 *1 117.99,163.8
X$22722 77 13053 13691 13537 13665 4086 109 DFFR_X1
* cell instance $22725 m0 *1 125.59,163.8
X$22725 12419 109 12875 77 BUF_X4
* cell instance $22726 m0 *1 126.92,163.8
X$22726 77 13430 18582 13283 13666 12731 109 DFFR_X1
* cell instance $22729 r0 *1 112.48,163.8
X$22729 13906 9632 12095 77 109 13786 MUX2_X1
* cell instance $22730 r0 *1 113.81,163.8
X$22730 8367 13690 13820 77 109 12389 OR3_X2
* cell instance $22731 r0 *1 114.95,163.8
X$22731 13788 10142 13691 77 109 13567 MUX2_X1
* cell instance $22737 r0 *1 117.23,163.8
X$22737 77 13053 13935 13692 13792 4086 109 DFFR_X1
* cell instance $22739 r0 *1 121.22,163.8
X$22739 13692 9815 12095 77 109 13792 MUX2_X1
* cell instance $22743 r0 *1 127.3,163.8
X$22743 10086 13823 7968 77 109 13914 MUX2_X1
* cell instance $22745 r0 *1 129.39,163.8
X$22745 9556 13281 9805 77 109 13693 MUX2_X1
* cell instance $22746 r0 *1 130.72,163.8
X$22746 13693 13056 13826 77 109 13915 MUX2_X1
* cell instance $22747 m0 *1 131.29,163.8
X$22747 13429 77 109 11732 BUF_X1
* cell instance $22752 r0 *1 132.05,163.8
X$22752 13437 77 109 13430 CLKBUF_X3
* cell instance $22754 r0 *1 133.19,163.8
X$22754 77 13430 13796 12731 19008 13695 109 DFFR_X2
* cell instance $22755 m0 *1 136.99,163.8
X$22755 12734 8623 12550 109 13568 77 OAI21_X1
* cell instance $22757 m0 *1 137.75,163.8
X$22757 77 13022 18579 13434 13669 12731 109 DFFR_X1
* cell instance $22758 m0 *1 141.55,163.8
X$22758 13022 77 109 19150 INV_X1
* cell instance $22760 m0 *1 142.12,163.8
X$22760 77 13022 18575 13569 13436 12731 109 DFFR_X1
* cell instance $22762 m0 *1 146.11,163.8
X$22762 8383 13439 13569 13068 109 77 13570 OAI22_X1
* cell instance $22765 m0 *1 148.77,163.8
X$22765 77 8360 13176 13798 13287 13178 13572 13388 109 OAI222_X2
* cell instance $22766 m0 *1 151.43,163.8
X$22766 11684 13441 13699 109 12681 77 OAI21_X1
* cell instance $22768 m0 *1 152.38,163.8
X$22768 13668 13441 13905 109 12373 77 OAI21_X1
* cell instance $22770 m0 *1 153.33,163.8
X$22770 13570 13441 13667 77 12744 109 AOI21_X1
* cell instance $22773 m0 *1 155.04,163.8
X$22773 13374 9170 12750 13700 109 77 13667 OAI22_X1
* cell instance $22774 m0 *1 155.99,163.8
X$22774 13793 13441 13701 77 12436 109 AOI21_X1
* cell instance $22777 m0 *1 157.7,163.8
X$22777 13292 13444 13285 77 13181 109 NAND3_X4
* cell instance $22778 m0 *1 160.17,163.8
X$22778 13182 77 109 13068 CLKBUF_X3
* cell instance $22780 r0 *1 137.37,163.8
X$22780 12738 13568 13694 109 13796 77 OAI21_X1
* cell instance $22781 r0 *1 138.13,163.8
X$22781 12738 13695 77 109 13694 NAND2_X1
* cell instance $22782 r0 *1 138.7,163.8
X$22782 11165 13797 11685 77 109 13696 MUX2_X1
* cell instance $22783 r0 *1 140.03,163.8
X$22783 13696 13432 13799 77 109 13911 MUX2_X1
* cell instance $22787 r0 *1 142.69,163.8
X$22787 11685 13439 13799 13068 109 77 13793 OAI22_X1
* cell instance $22790 r0 *1 144.78,163.8
X$22790 77 13901 18875 13697 13827 12731 109 DFFR_X1
* cell instance $22791 r0 *1 148.58,163.8
X$22791 11731 13439 13068 13697 109 77 13698 OAI22_X2
* cell instance $22793 r0 *1 150.67,163.8
X$22793 13181 77 109 13439 CLKBUF_X3
* cell instance $22795 r0 *1 152,163.8
X$22795 13429 13441 13904 109 12538 77 OAI21_X1
* cell instance $22796 r0 *1 152.76,163.8
X$22796 8360 77 109 13795 BUF_X1
* cell instance $22798 r0 *1 153.52,163.8
X$22798 12541 13441 13903 109 12833 77 OAI21_X1
* cell instance $22799 r0 *1 154.28,163.8
X$22799 13285 109 13182 77 BUF_X4
* cell instance $22801 r0 *1 155.99,163.8
X$22801 13794 13373 13285 13695 13181 13246 77 109 OAI221_X2
* cell instance $22802 r0 *1 158.08,163.8
X$22802 13698 13441 13831 77 12748 109 AOI21_X2
* cell instance $22803 r0 *1 159.41,163.8
X$22803 13373 109 13178 77 BUF_X4
* cell instance $22807 m0 *1 161.5,163.8
X$22807 11309 5472 13293 77 13573 109 AOI21_X1
* cell instance $22808 m0 *1 162.45,163.8
X$22808 13702 13293 77 109 13576 NAND2_X1
* cell instance $22810 m0 *1 163.21,163.8
X$22810 13574 13575 13576 13298 12990 109 77 13783 OAI221_X1
* cell instance $22813 r0 *1 161.88,163.8
X$22813 13702 77 109 13575 CLKBUF_X3
* cell instance $22814 r0 *1 162.83,163.8
X$22814 11261 13298 13791 13367 13951 109 77 13790 OAI221_X1
* cell instance $22815 r0 *1 163.97,163.8
X$22815 13070 13445 77 109 13791 NAND2_X1
* cell instance $22816 r0 *1 164.54,163.8
X$22816 77 13118 13787 12731 13236 12750 109 DFFR_X2
* cell instance $22817 m0 *1 165.68,163.8
X$22817 13575 12750 77 109 13895 NAND2_X1
* cell instance $22819 m0 *1 166.25,163.8
X$22819 10912 13575 13785 13298 8360 109 77 13577 OAI221_X1
* cell instance $22820 m0 *1 167.39,163.8
X$22820 13361 13295 13352 77 13446 109 AOI21_X1
* cell instance $22822 m0 *1 168.34,163.8
X$22822 77 13118 13663 12731 13520 13572 109 DFFR_X2
* cell instance $22824 m0 *1 172.71,163.8
X$22824 13577 13661 13658 77 13663 109 AOI21_X1
* cell instance $22827 r0 *1 168.72,163.8
X$22827 13702 13578 77 109 13785 NAND2_X1
* cell instance $22828 r0 *1 169.29,163.8
X$22828 13572 77 109 13578 INV_X1
* cell instance $22830 r0 *1 169.86,163.8
X$22830 13783 13779 13707 77 13365 109 AOI21_X1
* cell instance $22836 r0 *1 171.57,163.8
X$22836 13118 77 109 19292 CLKBUF_X1
* cell instance $22837 r0 *1 172.14,163.8
X$22837 11301 13769 13066 77 109 13703 MUX2_X1
* cell instance $22838 r0 *1 173.47,163.8
X$22838 13718 77 109 13118 CLKBUF_X3
* cell instance $22839 r0 *1 174.42,163.8
X$22839 13771 13705 13454 109 13704 77 OAI21_X1
* cell instance $22840 m0 *1 175.56,163.8
X$22840 13579 13580 13451 8111 13461 13661 109 77 AOI221_X2
* cell instance $22841 m0 *1 174.61,163.8
X$22841 13359 77 109 13298 CLKBUF_X3
* cell instance $22843 m0 *1 177.84,163.8
X$22843 8333 77 109 13581 BUF_X1
* cell instance $22845 r0 *1 175.18,163.8
X$22845 13703 13706 77 109 13705 NOR2_X1
* cell instance $22846 r0 *1 175.75,163.8
X$22846 13579 13706 77 109 13708 NOR2_X1
* cell instance $22848 r0 *1 176.7,163.8
X$22848 13710 13580 13709 8925 13452 13779 109 77 AOI221_X2
* cell instance $22849 m0 *1 178.98,163.8
X$22849 13582 13303 77 109 13659 NAND2_X1
* cell instance $22851 m0 *1 179.55,163.8
X$22851 13654 13303 77 109 13658 NAND2_X1
* cell instance $22852 m0 *1 180.12,163.8
X$22852 13778 12593 13584 77 13583 109 AOI21_X1
* cell instance $22854 m0 *1 181.07,163.8
X$22854 13458 13585 13583 77 109 13450 MUX2_X1
* cell instance $22856 r0 *1 178.79,163.8
X$22856 13710 13706 77 109 13711 NOR2_X1
* cell instance $22857 r0 *1 179.36,163.8
X$22857 13711 13706 13715 77 13582 109 AOI21_X1
* cell instance $22859 r0 *1 180.5,163.8
X$22859 13712 8718 77 109 13778 NOR2_X1
* cell instance $22861 r0 *1 181.45,163.8
X$22861 13714 13585 13713 77 109 13654 MUX2_X1
* cell instance $22863 m0 *1 182.78,163.8
X$22863 13580 13713 13451 6359 13461 77 109 13453 AOI221_X1
* cell instance $22864 r0 *1 182.78,163.8
X$22864 13774 13520 13584 77 13713 109 AOI21_X1
* cell instance $22865 r0 *1 183.54,163.8
X$22865 8925 77 109 13716 BUF_X1
* cell instance $22866 r0 *1 184.11,163.8
X$22866 13773 12995 13584 77 13455 109 AOI21_X1
* cell instance $22867 m0 *1 184.49,163.8
X$22867 13651 13303 77 109 13504 NAND2_X1
* cell instance $22870 m0 *1 185.25,163.8
X$22870 13628 13585 13456 77 109 13651 MUX2_X1
* cell instance $22871 m0 *1 186.58,163.8
X$22871 13717 13071 13584 77 13456 109 AOI21_X1
* cell instance $22873 r0 *1 184.87,163.8
X$22873 13712 8111 77 109 13774 NOR2_X1
* cell instance $22874 r0 *1 185.44,163.8
X$22874 13712 8719 77 109 13773 NOR2_X1
* cell instance $22876 r0 *1 186.77,163.8
X$22876 13769 6359 77 109 13717 NOR2_X1
* cell instance $22884 m0 *1 20.52,49
X$22884 77 2930 2781 2782 2686 2157 109 DFFR_X1
* cell instance $22885 m0 *1 24.32,49
X$22885 2782 2631 2779 77 109 2686 MUX2_X1
* cell instance $22898 r0 *1 15.96,49
X$22898 3245 2786 2779 77 109 3247 MUX2_X1
* cell instance $22900 r0 *1 17.48,49
X$22900 2993 2459 2779 77 109 2929 MUX2_X1
* cell instance $22901 r0 *1 18.81,49
X$22901 77 2930 3103 2780 2994 2157 109 DFFR_X1
* cell instance $22902 r0 *1 22.61,49
X$22902 2780 2400 2779 77 109 2994 MUX2_X1
* cell instance $22905 r0 *1 27.74,49
X$22905 77 2397 2934 2783 2688 2157 109 DFFR_X1
* cell instance $22906 m0 *1 30.02,49
X$22906 2783 2633 2539 77 109 2688 MUX2_X1
* cell instance $22909 r0 *1 31.54,49
X$22909 77 2397 3045 2784 2857 2157 109 DFFR_X1
* cell instance $22910 m0 *1 35.53,49
X$22910 2785 2631 2539 77 109 2858 MUX2_X1
* cell instance $22911 m0 *1 31.73,49
X$22911 77 2397 2935 2785 2858 2157 109 DFFR_X1
* cell instance $22913 r0 *1 35.34,49
X$22913 2784 2786 2539 77 109 2857 MUX2_X1
* cell instance $22915 m0 *1 37.43,49
X$22915 77 2403 2937 2636 2635 2157 109 DFFR_X1
* cell instance $22917 m0 *1 41.23,49
X$22917 2636 2633 2787 77 109 2635 MUX2_X1
* cell instance $22918 m0 *1 42.56,49
X$22918 2403 77 109 19148 INV_X1
* cell instance $22922 r0 *1 40.28,49
X$22922 77 2403 3259 2788 2859 2157 109 DFFR_X1
* cell instance $22924 m0 *1 43.32,49
X$22924 2698 2631 2787 77 109 2694 MUX2_X1
* cell instance $22927 r0 *1 44.08,49
X$22927 2788 2786 2787 77 109 2859 MUX2_X1
* cell instance $22929 r0 *1 45.79,49
X$22929 77 2542 3179 2861 2862 2157 109 DFFR_X1
* cell instance $22930 m0 *1 49.02,49
X$22930 2789 2861 77 109 2860 NAND2_X1
* cell instance $22932 m0 *1 49.59,49
X$22932 77 2220 2704 2706 2863 2157 109 DFFR_X1
* cell instance $22934 m0 *1 54.15,49
X$22934 77 2220 2639 2792 2708 2157 109 DFFR_X1
* cell instance $22935 m0 *1 57.95,49
X$22935 2222 2544 2866 109 2708 77 OAI21_X1
* cell instance $22937 m0 *1 58.9,49
X$22937 2158 2544 2640 109 2793 77 OAI21_X1
* cell instance $22938 m0 *1 59.66,49
X$22938 2796 2867 77 109 2640 NAND2_X1
* cell instance $22940 m0 *1 60.99,49
X$22940 2543 77 109 2224 CLKBUF_X3
* cell instance $22941 m0 *1 61.94,49
X$22941 77 2224 2941 2716 2712 2157 109 DFFR_X1
* cell instance $22942 m0 *1 65.74,49
X$22942 77 2411 2718 2719 2869 2157 109 DFFR_X1
* cell instance $22943 m0 *1 69.54,49
X$22943 77 2411 2641 2545 2721 2157 109 DFFR_X1
* cell instance $22944 m0 *1 73.34,49
X$22944 77 2229 3273 2725 2871 2157 109 DFFR_X1
* cell instance $22945 m0 *1 77.14,49
X$22945 2229 77 109 19211 CLKBUF_X1
* cell instance $22948 r0 *1 49.59,49
X$22948 2860 2939 2700 109 77 2862 OAI21_X4
* cell instance $22949 r0 *1 52.06,49
X$22949 2158 2407 2998 109 2863 77 OAI21_X1
* cell instance $22951 r0 *1 53.01,49
X$22951 2222 2939 2790 109 3114 77 OAI21_X1
* cell instance $22952 r0 *1 53.77,49
X$22952 2789 2791 77 109 2790 NAND2_X1
* cell instance $22953 r0 *1 54.34,49
X$22953 2322 2706 77 109 2998 NAND2_X1
* cell instance $22955 r0 *1 55.29,49
X$22955 3000 2794 77 109 2322 NAND2_X2
* cell instance $22959 r0 *1 57.57,49
X$22959 2796 2792 77 109 2866 NAND2_X1
* cell instance $22960 r0 *1 58.14,49
X$22960 77 2224 2940 2867 2793 2157 109 DFFR_X1
* cell instance $22964 r0 *1 61.94,49
X$22964 3000 2795 77 109 2156 NAND2_X2
* cell instance $22967 r0 *1 66.31,49
X$22967 2795 2797 2945 77 109 2796 NAND3_X2
* cell instance $22969 r0 *1 68.02,49
X$22969 2943 3053 77 109 2944 NAND2_X1
* cell instance $22972 r0 *1 70.3,49
X$22972 2794 2797 2945 77 109 2326 NAND3_X2
* cell instance $22975 r0 *1 73.91,49
X$22975 2796 77 109 2544 CLKBUF_X3
* cell instance $22977 r0 *1 75.24,49
X$22977 2873 2544 2548 109 77 3123 OAI21_X4
* cell instance $22978 r0 *1 77.71,49
X$22978 2796 2946 77 109 2873 NAND2_X1
* cell instance $22980 m0 *1 79.8,49
X$22980 77 2378 3129 2875 2798 2157 109 DFFR_X1
* cell instance $22981 m0 *1 78.85,49
X$22981 166 77 109 2378 CLKBUF_X3
* cell instance $22985 r0 *1 79.61,49
X$22985 2939 3010 77 109 2799 NAND2_X1
* cell instance $22986 r0 *1 80.18,49
X$22986 2417 2939 2799 109 3009 77 OAI21_X1
* cell instance $22987 r0 *1 80.94,49
X$22987 2417 2407 2947 109 2798 77 OAI21_X1
* cell instance $22988 r0 *1 81.7,49
X$22988 2407 2875 77 109 2947 NAND2_X1
* cell instance $22991 r0 *1 83.41,49
X$22991 77 2551 2948 2801 2800 1663 109 DFFR_X1
* cell instance $22993 m0 *1 83.98,49
X$22993 2232 2544 2877 109 2800 77 OAI21_X1
* cell instance $22994 m0 *1 86.26,49
X$22994 2544 2801 77 109 2877 NAND2_X1
* cell instance $22995 m0 *1 86.83,49
X$22995 2417 2544 2642 109 2729 77 OAI21_X1
* cell instance $22997 m0 *1 87.78,49
X$22997 77 2551 3385 2733 2730 1663 109 DFFR_X1
* cell instance $22998 m0 *1 91.58,49
X$22998 77 2234 18674 2645 2879 1663 109 DFFR_X1
* cell instance $22999 m0 *1 95.38,49
X$22999 2646 2647 77 109 2738 NOR2_X1
* cell instance $23000 m0 *1 95.95,49
X$23000 2806 77 109 2647 CLKBUF_X3
* cell instance $23002 m0 *1 97.09,49
X$23002 112 2649 77 109 2802 NAND2_X1
* cell instance $23003 m0 *1 97.66,49
X$23003 2648 2656 2652 77 109 2651 MUX2_X1
* cell instance $23006 r0 *1 87.21,49
X$23006 166 77 109 2551 CLKBUF_X3
* cell instance $23007 r0 *1 88.16,49
X$23007 2544 3011 77 109 2642 NAND2_X1
* cell instance $23010 r0 *1 89.3,49
X$23010 3445 77 109 166 CLKBUF_X3
* cell instance $23014 r0 *1 93.86,49
X$23014 213 2090 2645 77 109 2879 MUX2_X1
* cell instance $23017 r0 *1 97.09,49
X$23017 276 2952 77 109 2951 NAND2_X1
* cell instance $23018 r0 *1 97.66,49
X$23018 2656 2802 3015 109 2880 77 OAI21_X1
* cell instance $23019 r0 *1 98.42,49
X$23019 2738 2647 2880 77 2953 109 AOI21_X1
* cell instance $23022 r0 *1 100.32,49
X$23022 2805 2647 2882 77 2954 109 AOI21_X1
* cell instance $23023 m0 *1 101.46,49
X$23023 84 2649 77 109 2807 NAND2_X1
* cell instance $23024 m0 *1 100.89,49
X$23024 2653 2806 77 109 2805 NOR2_X1
* cell instance $23027 r0 *1 101.08,49
X$23027 2656 2807 2955 109 2882 77 OAI21_X1
* cell instance $23028 r0 *1 101.84,49
X$23028 250 2808 2804 77 109 2955 NAND3_X1
* cell instance $23029 r0 *1 102.6,49
X$23029 250 2649 2091 77 109 2958 MUX2_X1
* cell instance $23031 m0 *1 104.12,49
X$23031 84 2655 2330 77 109 2809 MUX2_X1
* cell instance $23033 m0 *1 105.45,49
X$23033 2091 2655 252 77 109 2810 MUX2_X1
* cell instance $23034 m0 *1 106.78,49
X$23034 2743 2656 2887 77 109 2744 MUX2_X1
* cell instance $23036 m0 *1 108.3,49
X$23036 2745 3018 2888 2025 2657 2746 77 109 OAI221_X2
* cell instance $23038 r0 *1 104.12,49
X$23038 2655 77 109 2649 CLKBUF_X3
* cell instance $23040 r0 *1 105.45,49
X$23040 2809 2804 2810 77 109 3196 MUX2_X1
* cell instance $23041 r0 *1 106.78,49
X$23041 84 2655 250 77 109 3198 MUX2_X1
* cell instance $23045 r0 *1 110.58,49
X$23045 2237 2811 109 77 2959 AND2_X1
* cell instance $23047 m0 *1 110.77,49
X$23047 1390 2022 77 109 2811 NAND2_X1
* cell instance $23048 r0 *1 111.34,49
X$23048 1767 2011 1227 77 109 3020 MUX2_X1
* cell instance $23050 m0 *1 111.72,49
X$23050 1831 1390 2396 1586 2561 3019 77 109 OAI221_X2
* cell instance $23051 m0 *1 114,49
X$23051 2011 1554 2098 77 109 NOR2_X4
* cell instance $23052 m0 *1 115.71,49
X$23052 2560 2093 2565 77 2813 109 AOI21_X1
* cell instance $23055 r0 *1 113.43,49
X$23055 2889 2561 2303 77 2960 109 AOI21_X1
* cell instance $23056 r0 *1 114.19,49
X$23056 2421 2424 77 109 2889 NOR2_X1
* cell instance $23058 r0 *1 114.95,49
X$23058 1754 1094 2011 1341 77 109 3023 AOI22_X1
* cell instance $23062 r0 *1 115.9,49
X$23062 1995 3023 2335 109 2961 77 OAI21_X1
* cell instance $23063 r0 *1 116.66,49
X$23063 2098 109 2303 77 BUF_X4
* cell instance $23065 m0 *1 116.85,49
X$23065 2754 2424 2755 2025 2893 2756 77 109 OAI221_X2
* cell instance $23066 m0 *1 119.13,49
X$23066 1939 1175 2892 109 2893 77 OAI21_X1
* cell instance $23067 m0 *1 119.89,49
X$23067 1585 1440 1995 1175 77 109 2814 AOI22_X1
* cell instance $23068 m0 *1 120.84,49
X$23068 2093 2209 1996 77 2895 109 AOI21_X1
* cell instance $23069 m0 *1 121.6,49
X$23069 2895 1440 77 109 2896 NOR2_X1
* cell instance $23071 m0 *1 122.36,49
X$23071 1341 77 109 2565 INV_X1
* cell instance $23075 r0 *1 118.75,49
X$23075 1995 2421 77 109 2764 NOR2_X1
* cell instance $23076 r0 *1 119.32,49
X$23076 1939 2814 2963 109 2962 77 OAI21_X1
* cell instance $23078 r0 *1 120.27,49
X$23078 2209 1172 2012 109 3028 77 OAI21_X1
* cell instance $23080 r0 *1 121.22,49
X$23080 2896 1996 3028 77 2965 109 AOI21_X1
* cell instance $23082 r0 *1 122.17,49
X$23082 2565 1589 1983 109 2815 77 OAI21_X1
* cell instance $23084 r0 *1 123.12,49
X$23084 1227 2815 2567 77 2966 109 AOI21_X1
* cell instance $23086 m0 *1 124.07,49
X$23086 1691 2766 2659 2025 2769 109 77 2767 OAI221_X1
* cell instance $23088 m0 *1 125.21,49
X$23088 1554 1344 2303 1586 77 109 2769 AOI22_X1
* cell instance $23089 m0 *1 126.16,49
X$23089 2561 2660 2774 109 2771 77 OAI21_X1
* cell instance $23090 m0 *1 126.92,49
X$23090 2570 1831 2561 1939 2776 109 77 2774 OAI221_X1
* cell instance $23091 m0 *1 128.06,49
X$23091 1175 1585 1995 1440 77 109 2776 AOI22_X1
* cell instance $23093 m0 *1 129.2,49
X$23093 2396 1589 77 109 1831 NAND2_X2
* cell instance $23095 r0 *1 124.07,49
X$23095 2303 2815 2567 2172 109 77 3156 OAI22_X1
* cell instance $23097 r0 *1 125.21,49
X$23097 1754 2967 1835 2572 77 109 3031 AOI22_X2
* cell instance $23099 r0 *1 127.11,49
X$23099 2243 2561 2303 77 2968 109 AOI21_X1
* cell instance $23101 r0 *1 128.06,49
X$23101 1589 1841 77 109 2967 NOR2_X1
* cell instance $23102 r0 *1 128.63,49
X$23102 1939 2421 1754 77 2969 109 AOI21_X1
* cell instance $23104 r0 *1 129.58,49
X$23104 1983 109 2561 77 BUF_X4
* cell instance $23105 m0 *1 130.72,49
X$23105 1841 77 109 2572 CLKBUF_X3
* cell instance $23108 m0 *1 131.86,49
X$23108 2900 2775 2901 109 77 3035 AND3_X1
* cell instance $23111 m0 *1 133.76,49
X$23111 2903 2428 1440 77 109 2906 MUX2_X1
* cell instance $23112 m0 *1 135.09,49
X$23112 77 2907 2903 2906 2343 109 DFF_X1
* cell instance $23114 m0 *1 141.36,49
X$23114 2911 2661 77 109 2106 NOR2_X1
* cell instance $23115 m0 *1 141.93,49
X$23115 2661 77 109 2971 INV_X1
* cell instance $23118 r0 *1 131.1,49
X$23118 2905 2428 1400 77 109 2902 MUX2_X1
* cell instance $23119 r0 *1 132.43,49
X$23119 77 3208 2905 2902 2343 109 DFF_X1
* cell instance $23122 r0 *1 136.61,49
X$23122 3037 2428 1227 77 109 3038 MUX2_X1
* cell instance $23124 r0 *1 138.32,49
X$23124 77 1844 18762 2661 2910 1663 109 DFFR_X1
* cell instance $23125 r0 *1 142.12,49
X$23125 2816 2971 77 109 1942 NAND2_X2
* cell instance $23127 m0 *1 142.69,49
X$23127 2911 77 109 2816 INV_X1
* cell instance $23129 r0 *1 143.07,49
X$23129 133 2817 77 109 2911 NAND2_X1
* cell instance $23131 r0 *1 144.4,49
X$23131 2900 109 2428 77 BUF_X4
* cell instance $23132 m0 *1 149.15,49
X$23132 2818 77 109 2821 INV_X1
* cell instance $23133 m0 *1 144.97,49
X$23133 77 2109 2768 1663 18943 2154 109 DFFR_X2
* cell instance $23134 m0 *1 149.53,49
X$23134 2915 77 109 2916 INV_X1
* cell instance $23135 m0 *1 149.91,49
X$23135 2916 2179 1059 1416 77 109 2574 AOI22_X1
* cell instance $23137 m0 *1 151.05,49
X$23137 2821 2179 1156 1416 77 109 2820 AOI22_X1
* cell instance $23142 r0 *1 148.39,49
X$23142 2819 2154 2915 109 77 2918 HA_X1
* cell instance $23143 r0 *1 150.29,49
X$23143 3040 2820 109 77 2917 AND2_X1
* cell instance $23145 r0 *1 151.43,49
X$23145 2973 2918 2824 109 77 2822 AND3_X1
* cell instance $23146 r0 *1 152.38,49
X$23146 2154 2973 2819 109 77 2823 AND3_X1
* cell instance $23147 m0 *1 152.57,49
X$23147 2822 77 109 2351 BUF_X2
* cell instance $23150 m0 *1 153.52,49
X$23150 2824 1776 77 109 2919 OR2_X1
* cell instance $23151 m0 *1 154.28,49
X$23151 2821 1189 1134 2765 77 109 2921 AOI22_X2
* cell instance $23154 r0 *1 153.52,49
X$23154 2919 2826 2823 77 2974 109 AOI21_X1
* cell instance $23156 r0 *1 154.47,49
X$23156 2824 2823 109 77 2388 AND2_X1
* cell instance $23159 r0 *1 155.8,49
X$23159 2388 77 109 2433 BUF_X2
* cell instance $23161 m0 *1 156.37,49
X$23161 2433 2435 77 109 2825 NAND2_X1
* cell instance $23164 r0 *1 156.94,49
X$23164 2973 1110 980 1699 77 109 2666 AOI22_X2
* cell instance $23166 m0 *1 159.03,49
X$23166 2663 2826 2827 77 2662 109 AOI21_X1
* cell instance $23168 m0 *1 159.79,49
X$23168 2351 2435 109 77 2827 AND2_X1
* cell instance $23170 r0 *1 159.03,49
X$23170 2665 2576 2435 2388 109 77 3036 AND4_X1
* cell instance $23172 r0 *1 160.55,49
X$23172 2828 2665 2576 2827 109 77 2923 AND4_X1
* cell instance $23174 m0 *1 160.93,49
X$23174 2576 2827 109 77 2763 AND2_X1
* cell instance $23175 m0 *1 161.88,49
X$23175 2922 2179 2351 2577 109 77 2829 AND4_X1
* cell instance $23176 m0 *1 163.02,49
X$23176 2621 2622 2829 77 109 3164 OR3_X1
* cell instance $23177 m0 *1 163.97,49
X$23177 2760 2826 2923 77 2578 109 AOI21_X1
* cell instance $23179 r0 *1 161.69,49
X$23179 2665 77 109 2922 INV_X1
* cell instance $23183 r0 *1 164.54,49
X$23183 2665 605 1858 606 77 109 2975 AOI22_X1
* cell instance $23184 m0 *1 165.3,49
X$23184 2079 2828 2665 2577 109 77 2354 AND4_X1
* cell instance $23188 m0 *1 168.15,49
X$23188 2667 1110 980 1422 77 109 2925 AOI22_X2
* cell instance $23190 m0 *1 170.62,49
X$23190 2667 2830 109 77 2305 AND2_X1
* cell instance $23193 r0 *1 165.49,49
X$23193 3034 77 109 2665 BUF_X1
* cell instance $23195 r0 *1 166.44,49
X$23195 2433 2354 2830 109 77 3163 AND3_X1
* cell instance $23196 r0 *1 167.39,49
X$23196 2667 2433 2354 2830 109 77 3033 AND4_X1
* cell instance $23200 r0 *1 170.62,49
X$23200 2438 2831 109 77 2830 AND2_X1
* cell instance $23204 r0 *1 171.38,49
X$23204 2831 1418 77 109 2928 OR2_X1
* cell instance $23205 r0 *1 172.14,49
X$23205 2928 2438 2355 77 3029 109 AOI21_X1
* cell instance $23206 m0 *1 172.71,49
X$23206 2921 2441 77 109 2927 NOR2_X1
* cell instance $23209 m0 *1 174.8,49
X$23209 77 2924 2748 2909 2927 2580 109 OR4_X4
* cell instance $23210 m0 *1 177.27,49
X$23210 2925 2581 697 2443 2668 2747 77 109 OAI221_X2
* cell instance $23211 m0 *1 179.36,49
X$23211 1034 109 996 77 BUF_X4
* cell instance $23212 m0 *1 180.69,49
X$23212 1524 2581 692 2443 2608 2742 77 109 OAI221_X2
* cell instance $23214 r0 *1 172.9,49
X$23214 2438 2355 109 77 2832 AND2_X1
* cell instance $23215 r0 *1 173.66,49
X$23215 2831 1110 1518 980 77 109 3026 AOI22_X1
* cell instance $23216 r0 *1 174.61,49
X$23216 120 2872 3027 2709 2514 77 109 2926 AOI221_X1
* cell instance $23217 r0 *1 175.75,49
X$23217 1324 2443 77 109 3079 NOR2_X1
* cell instance $23218 r0 *1 176.32,49
X$23218 2837 2926 3080 77 109 2748 NAND3_X1
* cell instance $23220 r0 *1 177.27,49
X$23220 2666 2581 1107 2443 3021 3025 77 109 OAI221_X2
* cell instance $23221 r0 *1 179.36,49
X$23221 1564 2581 868 2443 2839 3024 77 109 OAI221_X2
* cell instance $23222 r0 *1 181.45,49
X$23222 2836 2834 2607 77 109 3149 OR3_X2
* cell instance $23223 r0 *1 182.59,49
X$23223 2607 2834 2836 109 2920 77 NOR3_X2
* cell instance $23224 m0 *1 187.34,49
X$23224 1783 2838 77 109 2185 NAND2_X1
* cell instance $23225 m0 *1 183.16,49
X$23225 77 1731 2914 1146 3352 2583 109 DFFR_X2
* cell instance $23227 m0 *1 188.67,49
X$23227 2890 2732 3145 109 77 2294 AND3_X1
* cell instance $23229 r0 *1 183.92,49
X$23229 1809 109 625 77 BUF_X4
* cell instance $23231 r0 *1 185.63,49
X$23231 552 1630 2976 77 109 3022 MUX2_X1
* cell instance $23233 m0 *1 190.76,49
X$23233 2736 2588 2671 77 109 2735 MUX2_X1
* cell instance $23234 m0 *1 190,49
X$23234 1156 2728 2913 109 2736 77 OAI21_X1
* cell instance $23235 m0 *1 192.09,49
X$23235 2734 2670 77 109 2909 NAND2_X1
* cell instance $23236 m0 *1 192.66,49
X$23236 77 2593 1714 2732 2908 2904 2977 2598 109 AOI222_X2
* cell instance $23237 m0 *1 195.32,49
X$23237 2710 2899 2584 2713 77 2616 109 NAND4_X2
* cell instance $23241 r0 *1 190.76,49
X$23241 2912 2512 2978 77 2837 109 AOI21_X1
* cell instance $23242 r0 *1 191.52,49
X$23242 77 2447 18707 2977 3017 1146 109 DFFR_X1
* cell instance $23245 r0 *1 196.27,49
X$23245 552 1722 2979 77 109 2840 MUX2_X1
* cell instance $23246 r0 *1 197.6,49
X$23246 77 2120 18847 2979 2840 1146 109 DFFR_X1
* cell instance $23247 m0 *1 198.36,49
X$23247 2586 109 2605 77 BUF_X4
* cell instance $23249 m0 *1 199.69,49
X$23249 2254 2841 2898 2709 2136 77 109 2842 AOI221_X1
* cell instance $23250 m0 *1 200.83,49
X$23250 2586 77 109 2585 CLKBUF_X3
* cell instance $23255 r0 *1 201.97,49
X$23255 2364 2844 2838 2847 2256 77 109 2897 AOI221_X1
* cell instance $23258 m0 *1 203.68,49
X$23258 3090 2674 2838 2841 2257 2723 109 77 AOI221_X2
* cell instance $23261 r0 *1 204.06,49
X$23261 77 2360 3014 1146 19010 2980 109 DFFR_X2
* cell instance $23262 m0 *1 207.1,49
X$23262 2894 77 109 2360 CLKBUF_X3
* cell instance $23264 m0 *1 208.05,49
X$23264 77 2360 18517 2677 2891 1146 109 DFFR_X1
* cell instance $23266 r0 *1 208.24,49
X$23266 3012 2585 2677 77 109 2891 MUX2_X1
* cell instance $23269 m0 *1 212.23,49
X$23269 2841 1366 2711 2843 1070 2890 109 77 AOI221_X2
* cell instance $23270 m0 *1 215.08,49
X$23270 77 1080 2843 2710 2886 2681 1222 1629 109 AOI222_X2
* cell instance $23273 r0 *1 212.8,49
X$23273 77 1961 18787 2982 3008 992 109 DFFR_X1
* cell instance $23274 r0 *1 216.6,49
X$23274 77 1977 2843 3006 2885 2681 2203 1629 109 AOI222_X2
* cell instance $23276 m0 *1 218.12,49
X$23276 2678 3005 2884 2883 77 2607 109 NAND4_X2
* cell instance $23278 r0 *1 220.02,49
X$23278 2844 2881 3004 2593 2130 2713 109 77 AOI221_X2
* cell instance $23279 m0 *1 221.92,49
X$23279 77 2276 2450 2703 2676 2598 2876 2453 109 AOI222_X2
* cell instance $23280 m0 *1 220.21,49
X$23280 2707 2681 2123 1294 77 109 2679 AOI22_X2
* cell instance $23281 m0 *1 224.58,49
X$23281 913 2843 2123 1145 77 109 3282 AOI22_X2
* cell instance $23284 r0 *1 222.11,49
X$23284 693 2258 2878 77 109 2845 MUX2_X1
* cell instance $23285 r0 *1 223.44,49
X$23285 77 2051 18887 2878 2845 992 109 DFFR_X1
* cell instance $23289 r0 *1 227.24,49
X$23289 2872 109 2844 77 BUF_X4
* cell instance $23290 m0 *1 228,49
X$23290 77 2051 18589 2682 2680 992 109 DFFR_X1
* cell instance $23291 m0 *1 227.43,49
X$23291 2992 77 109 2874 BUF_X1
* cell instance $23292 m0 *1 231.8,49
X$23292 2868 2683 2846 109 2690 77 OAI21_X1
* cell instance $23294 m0 *1 232.75,49
X$23294 2865 2681 1372 2123 77 109 2848 AOI22_X1
* cell instance $23295 m0 *1 233.7,49
X$23295 2864 2605 2684 77 109 2691 MUX2_X1
* cell instance $23296 m0 *1 235.03,49
X$23296 77 1873 18550 2684 2691 992 109 DFFR_X1
* cell instance $23297 m0 *1 238.83,49
X$23297 2854 77 109 2852 CLKBUF_X2
* cell instance $23299 r0 *1 228.57,49
X$23299 2870 1970 2123 77 2985 109 AOI21_X1
* cell instance $23300 r0 *1 229.33,49
X$23300 2999 2681 1629 2201 77 109 3110 AOI22_X2
* cell instance $23301 r0 *1 231.04,49
X$23301 2847 109 2593 77 BUF_X4
* cell instance $23302 r0 *1 232.37,49
X$23302 1633 2847 2987 2978 988 77 109 2849 AOI221_X1
* cell instance $23303 r0 *1 233.51,49
X$23303 2848 2986 2594 2849 109 77 2486 AND4_X1
* cell instance $23304 r0 *1 234.65,49
X$23304 471 1892 2988 77 109 2990 MUX2_X1
* cell instance $23306 r0 *1 236.17,49
X$23306 2989 2122 77 109 2997 NAND2_X1
* cell instance $23307 r0 *1 236.74,49
X$23307 2991 1299 2455 77 2856 109 AOI21_X1
* cell instance $23308 r0 *1 237.5,49
X$23308 3102 1209 2365 77 2991 109 AOI21_X1
* cell instance $23309 r0 *1 238.26,49
X$23309 2851 77 109 2995 BUF_X1
* cell instance $23310 r0 *1 238.83,49
X$23310 2855 77 109 2850 BUF_X2
* cell instance $23316 m0 *1 16.53,54.6
X$23316 77 2930 3362 3248 3246 2157 109 DFFR_X1
* cell instance $23317 m0 *1 20.33,54.6
X$23317 3361 2931 3248 77 109 3246 MUX2_X1
* cell instance $23318 m0 *1 21.66,54.6
X$23318 2930 77 109 19151 INV_X1
* cell instance $23329 r0 *1 17.1,54.6
X$23329 3361 3043 3540 77 109 3360 MUX2_X1
* cell instance $23332 r0 *1 20.33,54.6
X$23332 3362 3041 3363 77 109 3480 MUX2_X1
* cell instance $23333 r0 *1 21.66,54.6
X$23333 3362 3042 3363 77 109 3481 MUX2_X1
* cell instance $23335 m0 *1 22.42,54.6
X$23335 3251 3364 3169 77 109 3365 MUX2_X1
* cell instance $23337 m0 *1 24.32,54.6
X$23337 3250 3541 3170 77 109 3366 MUX2_X1
* cell instance $23343 r0 *1 25.27,54.6
X$23343 77 2930 3367 3684 3429 2157 109 DFFR_X1
* cell instance $23345 m0 *1 31.92,54.6
X$23345 3171 3106 3172 77 109 3544 MUX2_X1
* cell instance $23346 m0 *1 30.59,54.6
X$23346 3171 3042 3172 77 109 3686 MUX2_X1
* cell instance $23348 m0 *1 34.01,54.6
X$23348 3256 3173 3175 77 109 3689 MUX2_X1
* cell instance $23355 r0 *1 34.2,54.6
X$23355 3174 3370 3176 77 109 3605 MUX2_X1
* cell instance $23356 r0 *1 35.53,54.6
X$23356 2541 77 109 3368 CLKBUF_X3
* cell instance $23357 r0 *1 36.48,54.6
X$23357 77 3368 3486 3690 3369 2157 109 DFFR_X1
* cell instance $23358 m0 *1 40.85,54.6
X$23358 2936 3042 3258 77 109 3372 MUX2_X1
* cell instance $23359 m0 *1 39.52,54.6
X$23359 2936 3048 3258 77 109 3371 MUX2_X1
* cell instance $23362 m0 *1 43.13,54.6
X$23362 3177 3173 3261 77 109 3374 MUX2_X1
* cell instance $23366 m0 *1 49.78,54.6
X$23366 2158 3377 3262 109 3432 77 OAI21_X1
* cell instance $23369 m0 *1 54.34,54.6
X$23369 3000 3380 109 77 3264 AND2_X1
* cell instance $23371 m0 *1 55.29,54.6
X$23371 3264 109 2633 77 BUF_X4
* cell instance $23372 m0 *1 56.62,54.6
X$23372 2372 3042 2408 77 109 3378 MUX2_X1
* cell instance $23374 m0 *1 58.14,54.6
X$23374 2372 3106 2408 77 109 3379 MUX2_X1
* cell instance $23377 m0 *1 63.27,54.6
X$23377 2225 2938 2410 77 109 3381 MUX2_X1
* cell instance $23378 m0 *1 64.6,54.6
X$23378 3052 3183 2941 77 109 3707 MUX2_X1
* cell instance $23382 r0 *1 41.42,54.6
X$23382 3431 3173 3372 77 109 3488 MUX2_X1
* cell instance $23385 r0 *1 43.7,54.6
X$23385 3178 3373 3375 77 109 3693 MUX2_X1
* cell instance $23388 r0 *1 47.31,54.6
X$23388 77 2542 3489 3490 3432 2157 109 DFFR_X1
* cell instance $23389 r0 *1 51.11,54.6
X$23389 3376 3490 77 109 3262 NAND2_X1
* cell instance $23391 r0 *1 51.87,54.6
X$23391 2222 3377 3491 109 3551 77 OAI21_X1
* cell instance $23394 r0 *1 53.2,54.6
X$23394 3376 3552 77 109 3491 NAND2_X1
* cell instance $23398 r0 *1 56.24,54.6
X$23398 3181 3106 2639 77 109 3433 MUX2_X1
* cell instance $23401 r0 *1 58.71,54.6
X$23401 3433 3370 3379 77 109 3494 MUX2_X1
* cell instance $23405 r0 *1 60.04,54.6
X$23405 3380 3000 77 109 3376 NAND2_X2
* cell instance $23409 r0 *1 63.08,54.6
X$23409 3269 3541 3381 77 109 3706 MUX2_X1
* cell instance $23410 r0 *1 64.41,54.6
X$23410 2225 3183 2410 77 109 3554 MUX2_X1
* cell instance $23412 m0 *1 66.5,54.6
X$23412 2797 2945 3380 77 2943 109 NAND3_X4
* cell instance $23418 r0 *1 67.07,54.6
X$23418 2543 77 109 19121 INV_X2
* cell instance $23419 r0 *1 67.64,54.6
X$23419 3445 77 109 2543 CLKBUF_X3
* cell instance $23420 r0 *1 68.59,54.6
X$23420 77 2411 3495 3496 3556 2157 109 DFFR_X1
* cell instance $23421 m0 *1 71.06,54.6
X$23421 77 2411 3383 3185 3272 2157 109 DFFR_X1
* cell instance $23424 m0 *1 75.62,54.6
X$23424 77 2229 3276 3275 3382 2157 109 DFFR_X1
* cell instance $23425 m0 *1 79.42,54.6
X$23425 77 2378 3278 3277 3186 2157 109 DFFR_X1
* cell instance $23427 m0 *1 83.41,54.6
X$23427 77 2551 3502 3279 3187 1663 109 DFFR_X1
* cell instance $23431 r0 *1 72.58,54.6
X$23431 3559 3377 2415 109 77 3497 OAI21_X2
* cell instance $23432 r0 *1 73.91,54.6
X$23432 3376 3560 77 109 3559 NAND2_X1
* cell instance $23434 r0 *1 74.86,54.6
X$23434 3274 3003 2415 109 77 3382 OAI21_X2
* cell instance $23436 r0 *1 76.95,54.6
X$23436 3383 3498 3273 77 109 3499 MUX2_X1
* cell instance $23437 r0 *1 78.28,54.6
X$23437 3383 3500 3273 77 109 3501 MUX2_X1
* cell instance $23440 r0 *1 81.89,54.6
X$23440 3565 3003 3566 109 3716 77 OAI21_X1
* cell instance $23442 r0 *1 82.84,54.6
X$23442 2943 3568 77 109 3566 NAND2_X1
* cell instance $23444 m0 *1 88.54,54.6
X$23444 77 3058 18696 3190 3444 1663 109 DFFR_X1
* cell instance $23449 r0 *1 91.01,54.6
X$23449 3571 2090 3190 77 109 3444 MUX2_X1
* cell instance $23450 r0 *1 92.34,54.6
X$23450 3998 77 109 3058 CLKBUF_X3
* cell instance $23452 m0 *1 93.67,54.6
X$23452 3386 2235 3191 77 109 3283 MUX2_X1
* cell instance $23455 m0 *1 96.52,54.6
X$23455 3288 2647 3448 77 3449 109 AOI21_X1
* cell instance $23456 m0 *1 97.28,54.6
X$23456 3386 2952 3016 77 109 3450 NAND3_X1
* cell instance $23459 m0 *1 100.32,54.6
X$23459 2803 3302 3061 77 109 3452 MUX2_X1
* cell instance $23460 m0 *1 101.65,54.6
X$23460 3016 109 3136 77 BUF_X4
* cell instance $23462 m0 *1 103.17,54.6
X$23462 2808 3141 2654 3193 109 77 3300 OAI22_X2
* cell instance $23463 m0 *1 104.88,54.6
X$23463 3297 77 109 3454 INV_X1
* cell instance $23464 m0 *1 105.26,54.6
X$23464 2649 2656 77 109 3195 NOR2_X1
* cell instance $23465 m0 *1 105.83,54.6
X$23465 3195 126 3194 3300 3016 3457 109 77 AOI221_X2
* cell instance $23466 m0 *1 107.92,54.6
X$23466 3198 3302 3064 77 109 3459 MUX2_X1
* cell instance $23467 m0 *1 109.25,54.6
X$23467 79 2655 254 77 109 3390 MUX2_X1
* cell instance $23470 m0 *1 113.81,54.6
X$23470 3306 3200 3309 77 109 3391 OR3_X1
* cell instance $23471 m0 *1 114.76,54.6
X$23471 3310 1503 3308 77 3309 109 AOI21_X1
* cell instance $23472 m0 *1 115.52,54.6
X$23472 2563 2572 77 109 3018 NAND2_X1
* cell instance $23476 r0 *1 95,54.6
X$23476 3386 3387 3190 77 109 3503 MUX2_X1
* cell instance $23477 r0 *1 96.33,54.6
X$23477 3132 3387 77 109 3388 NAND2_X1
* cell instance $23479 r0 *1 97.28,54.6
X$23479 3016 3388 3450 109 3448 77 OAI21_X1
* cell instance $23480 r0 *1 98.04,54.6
X$23480 3387 2656 77 109 3295 NAND2_X2
* cell instance $23484 r0 *1 100.32,54.6
X$23484 3456 2651 3192 3389 77 109 3579 AOI22_X2
* cell instance $23485 r0 *1 102.03,54.6
X$23485 2650 77 109 3387 CLKBUF_X3
* cell instance $23487 r0 *1 103.74,54.6
X$23487 2808 254 109 77 3582 AND2_X1
* cell instance $23488 r0 *1 104.5,54.6
X$23488 126 2650 79 77 109 3504 MUX2_X1
* cell instance $23489 r0 *1 105.83,54.6
X$23489 3456 3196 3197 3389 77 109 3587 AOI22_X2
* cell instance $23491 r0 *1 107.92,54.6
X$23491 3390 2656 3199 77 109 3505 MUX2_X1
* cell instance $23492 r0 *1 109.25,54.6
X$23492 3199 3302 77 109 3506 NAND2_X1
* cell instance $23493 r0 *1 109.82,54.6
X$23493 3390 3136 77 109 3507 NAND2_X1
* cell instance $23497 r0 *1 114.38,54.6
X$23497 3460 3205 1503 77 109 3737 MUX2_X1
* cell instance $23502 r0 *1 116.09,54.6
X$23502 3461 3205 1388 77 109 3508 MUX2_X1
* cell instance $23505 m0 *1 117.99,54.6
X$23505 77 3201 2563 3463 1939 3312 1494 3202 109 AOI222_X2
* cell instance $23509 r0 *1 119.7,54.6
X$23509 3743 3205 1835 77 109 3509 MUX2_X1
* cell instance $23512 m0 *1 123.5,54.6
X$23512 2572 1757 1939 77 3464 109 AOI21_X1
* cell instance $23514 m0 *1 124.26,54.6
X$23514 2141 3464 3204 77 109 3392 NOR3_X1
* cell instance $23516 m0 *1 126.54,54.6
X$23516 3466 3205 1757 77 109 3393 MUX2_X1
* cell instance $23518 m0 *1 128.63,54.6
X$23518 77 3756 3206 3318 2343 109 DFF_X1
* cell instance $23519 m0 *1 131.86,54.6
X$23519 3206 3205 2563 77 109 3318 MUX2_X1
* cell instance $23522 r0 *1 124.64,54.6
X$23522 3465 3205 1939 77 109 3749 MUX2_X1
* cell instance $23523 r0 *1 125.97,54.6
X$23523 77 3469 3466 3393 3510 109 DFF_X1
* cell instance $23526 r0 *1 130.91,54.6
X$23526 3635 3205 2572 77 109 3511 MUX2_X1
* cell instance $23528 r0 *1 132.43,54.6
X$23528 2900 77 109 3205 CLKBUF_X3
* cell instance $23530 m0 *1 134.9,54.6
X$23530 77 3472 3207 3323 3325 109 DFF_X1
* cell instance $23531 m0 *1 133.57,54.6
X$23531 3207 3205 1767 77 109 3323 MUX2_X1
* cell instance $23532 m0 *1 138.13,54.6
X$23532 2346 2174 77 109 3473 NAND2_X1
* cell instance $23533 m0 *1 138.7,54.6
X$23533 77 3325 18668 3331 3328 1663 109 DFFR_X1
* cell instance $23534 m0 *1 142.5,54.6
X$23534 3331 3395 3210 77 2972 109 AOI21_X1
* cell instance $23537 m0 *1 144.21,54.6
X$23537 133 3211 77 109 3212 NAND2_X1
* cell instance $23538 m0 *1 144.78,54.6
X$23538 3212 2817 77 109 3213 NAND2_X1
* cell instance $23539 m0 *1 145.35,54.6
X$23539 3213 3215 77 109 3214 NAND2_X1
* cell instance $23543 r0 *1 134.33,54.6
X$23543 3758 3205 1344 77 109 3757 MUX2_X1
* cell instance $23546 r0 *1 136.23,54.6
X$23546 206 77 109 19090 INV_X4
* cell instance $23547 r0 *1 137.18,54.6
X$23547 166 77 109 206 CLKBUF_X3
* cell instance $23548 r0 *1 138.13,54.6
X$23548 3473 2174 2319 109 77 3593 OAI21_X4
* cell instance $23551 r0 *1 142.5,54.6
X$23551 2816 3211 3394 77 3762 109 AOI21_X1
* cell instance $23552 r0 *1 143.26,54.6
X$23552 3395 885 2817 216 3592 3591 77 109 OAI221_X2
* cell instance $23553 r0 *1 145.35,54.6
X$23553 3215 3763 77 109 3069 NOR2_X1
* cell instance $23555 r0 *1 146.3,54.6
X$23555 100 3512 77 109 3215 NAND2_X1
* cell instance $23556 r0 *1 146.87,54.6
X$23556 100 3512 2817 77 109 3394 NAND3_X1
* cell instance $23558 r0 *1 148.01,54.6
X$23558 3514 3513 77 109 100 NAND2_X2
* cell instance $23560 m0 *1 150.67,54.6
X$23560 3334 3335 3336 77 109 3396 MUX2_X1
* cell instance $23561 m0 *1 149.34,54.6
X$23561 2973 2043 1311 77 109 3336 MUX2_X1
* cell instance $23562 m0 *1 152,54.6
X$23562 77 3070 18562 2575 3340 1146 109 DFFR_X1
* cell instance $23563 m0 *1 155.8,54.6
X$23563 2430 77 109 3070 CLKBUF_X3
* cell instance $23564 m0 *1 156.75,54.6
X$23564 3341 1867 1416 77 3340 109 AOI21_X1
* cell instance $23565 m0 *1 157.51,54.6
X$23565 3217 1665 2973 109 3334 77 OAI21_X1
* cell instance $23567 r0 *1 152,54.6
X$23567 77 3070 3396 1146 18998 2973 109 DFFR_X2
* cell instance $23570 r0 *1 156.75,54.6
X$23570 1418 2575 77 109 3071 NOR2_X1
* cell instance $23572 r0 *1 157.51,54.6
X$23572 3218 3342 109 77 3072 AND2_X1
* cell instance $23573 r0 *1 158.27,54.6
X$23573 3342 3218 77 109 3217 NAND2_X1
* cell instance $23575 m0 *1 158.65,54.6
X$23575 1603 1704 779 77 109 3074 OR3_X2
* cell instance $23577 r0 *1 159.22,54.6
X$23577 77 3070 18764 3219 3397 1146 109 DFFR_X1
* cell instance $23578 m0 *1 160.93,54.6
X$23578 3343 1989 1416 77 3397 109 AOI21_X1
* cell instance $23579 m0 *1 160.17,54.6
X$23579 3218 3220 109 77 1603 AND2_X1
* cell instance $23582 m0 *1 162.64,54.6
X$23582 3219 77 109 2828 BUF_X1
* cell instance $23585 m0 *1 163.78,54.6
X$23585 1027 3218 2310 3220 3345 3344 77 109 OAI221_X2
* cell instance $23587 m0 *1 165.87,54.6
X$23587 3350 2040 3304 3346 3476 3477 109 77 AOI221_X2
* cell instance $23588 m0 *1 167.96,54.6
X$23588 2828 605 1954 606 77 109 3402 AOI22_X1
* cell instance $23590 m0 *1 169.1,54.6
X$23590 3400 3401 2040 77 109 NOR2_X4
* cell instance $23593 r0 *1 164.16,54.6
X$23593 3398 3399 77 109 2110 NAND2_X2
* cell instance $23595 r0 *1 165.3,54.6
X$23595 3398 3399 3475 77 109 3478 NAND3_X1
* cell instance $23597 r0 *1 166.25,54.6
X$23597 3478 77 109 1273 CLKBUF_X3
* cell instance $23599 r0 *1 167.58,54.6
X$23599 3221 3400 3401 109 77 3475 OAI21_X2
* cell instance $23601 r0 *1 169.1,54.6
X$23601 3402 3220 77 109 3585 NOR2_X1
* cell instance $23603 r0 *1 170.05,54.6
X$23603 3585 3474 3468 77 109 3583 OR3_X4
* cell instance $23607 m0 *1 171.38,54.6
X$23607 3221 77 109 2441 CLKBUF_X3
* cell instance $23609 m0 *1 172.33,54.6
X$23609 2080 3221 1114 3222 3354 3353 77 109 OAI221_X2
* cell instance $23610 m0 *1 174.42,54.6
X$23610 1679 2441 77 109 3471 NOR2_X1
* cell instance $23611 m0 *1 174.99,54.6
X$23611 77 3157 3223 3292 3291 3470 109 NOR4_X4
* cell instance $23612 m0 *1 178.41,54.6
X$23612 1425 3220 77 109 3403 NOR2_X1
* cell instance $23613 m0 *1 178.98,54.6
X$23613 3218 1157 3349 109 3575 77 OAI21_X1
* cell instance $23616 r0 *1 172.14,54.6
X$23616 3218 702 3573 109 3474 77 OAI21_X1
* cell instance $23618 r0 *1 173.09,54.6
X$23618 3401 3400 77 109 3222 OR2_X1
* cell instance $23619 r0 *1 173.85,54.6
X$23619 701 3400 3401 77 109 3520 NOR3_X1
* cell instance $23620 r0 *1 174.61,54.6
X$23620 77 3578 3467 3557 3471 3520 109 OR4_X4
* cell instance $23621 r0 *1 177.08,54.6
X$23621 2441 2759 3405 109 3522 77 OAI21_X1
* cell instance $23623 r0 *1 178.22,54.6
X$23623 3403 3462 3438 77 109 3523 OR3_X4
* cell instance $23624 r0 *1 180.31,54.6
X$23624 3218 694 3564 109 3462 77 OAI21_X1
* cell instance $23625 m0 *1 184.68,54.6
X$23625 3224 3092 552 77 109 3355 MUX2_X1
* cell instance $23626 m0 *1 180.88,54.6
X$23626 77 3404 18526 3224 3355 1146 109 DFFR_X1
* cell instance $23628 m0 *1 186.2,54.6
X$23628 77 3147 3455 1146 18944 3320 109 DFFR_X2
* cell instance $23629 m0 *1 190.38,54.6
X$23629 77 2447 18515 3225 3451 1146 109 DFFR_X1
* cell instance $23630 m0 *1 194.18,54.6
X$23630 77 2447 18603 3226 3088 1146 109 DFFR_X1
* cell instance $23631 m0 *1 197.98,54.6
X$23631 77 2447 18588 3228 3227 1146 109 DFFR_X1
* cell instance $23634 m0 *1 202.73,54.6
X$23634 77 2276 2187 3332 3333 3094 3134 2261 109 AOI222_X2
* cell instance $23635 m0 *1 205.39,54.6
X$23635 3228 2984 1626 2593 77 109 3412 AOI22_X1
* cell instance $23637 m0 *1 206.53,54.6
X$23637 3329 2981 1624 2978 77 109 3229 AOI22_X1
* cell instance $23638 m0 *1 207.48,54.6
X$23638 3233 3555 77 109 3230 NAND2_X1
* cell instance $23639 m0 *1 208.05,54.6
X$23639 3231 3529 77 109 3324 NAND2_X1
* cell instance $23642 r0 *1 181.07,54.6
X$23642 77 3574 3443 3324 3359 3083 109 OR4_X4
* cell instance $23643 r0 *1 183.54,54.6
X$23643 3332 77 109 3082 INV_X1
* cell instance $23644 r0 *1 183.92,54.6
X$23644 3755 3224 3572 3546 2976 3573 109 77 AOI221_X2
* cell instance $23646 r0 *1 186.2,54.6
X$23646 772 3406 3320 77 109 3455 MUX2_X1
* cell instance $23647 r0 *1 187.53,54.6
X$23647 1783 3407 77 109 3406 NAND2_X2
* cell instance $23649 r0 *1 191.52,54.6
X$23649 3453 2605 3225 77 109 3451 MUX2_X1
* cell instance $23650 r0 *1 192.85,54.6
X$23650 77 3086 3525 3349 3408 3409 3225 3664 109 AOI222_X2
* cell instance $23653 r0 *1 196.46,54.6
X$23653 1537 3525 1958 3531 77 109 3567 AOI22_X1
* cell instance $23655 r0 *1 198.17,54.6
X$23655 2979 3525 3409 3562 77 109 3563 AOI22_X2
* cell instance $23656 r0 *1 199.88,54.6
X$23656 3447 2605 3446 77 109 3561 MUX2_X1
* cell instance $23657 r0 *1 201.21,54.6
X$23657 77 3411 18811 3446 3561 1146 109 DFFR_X1
* cell instance $23660 r0 *1 205.58,54.6
X$23660 3412 3442 77 109 3557 NAND2_X1
* cell instance $23662 r0 *1 206.91,54.6
X$23662 3230 3441 3229 3413 77 3443 109 NAND4_X2
* cell instance $23663 r0 *1 208.62,54.6
X$23663 3946 3090 3118 3422 77 109 3442 AOI22_X1
* cell instance $23665 m0 *1 210.52,54.6
X$23665 77 3407 3320 3234 2121 2843 2260 2978 109 AOI222_X2
* cell instance $23666 m0 *1 209.76,54.6
X$23666 2838 1552 2843 77 3441 109 AOI21_X1
* cell instance $23671 r0 *1 211.47,54.6
X$23671 77 3440 18750 3530 3439 992 109 DFFR_X1
* cell instance $23674 r0 *1 215.84,54.6
X$23674 554 1630 3414 77 109 3534 MUX2_X1
* cell instance $23675 m0 *1 216.03,54.6
X$23675 3307 3127 3533 3298 77 3304 109 NAND4_X2
* cell instance $23677 m0 *1 217.74,54.6
X$23677 3301 109 3233 77 BUF_X4
* cell instance $23678 m0 *1 219.07,54.6
X$23678 3437 3235 3285 77 109 3299 NAND3_X2
* cell instance $23679 m0 *1 220.4,54.6
X$23679 552 2258 3236 77 109 3294 MUX2_X1
* cell instance $23680 m0 *1 221.73,54.6
X$23680 3284 3435 77 109 3292 NAND2_X2
* cell instance $23681 m0 *1 222.68,54.6
X$23681 77 3281 3239 2591 3282 3291 109 NAND4_X4
* cell instance $23682 m0 *1 226.1,54.6
X$23682 77 2850 1297 3417 3099 2057 109 AOI22_X4
* cell instance $23683 m0 *1 229.33,54.6
X$23683 77 2989 2122 3418 2452 1544 109 AOI22_X4
* cell instance $23684 m0 *1 232.56,54.6
X$23684 2452 1544 77 109 2846 NAND2_X1
* cell instance $23686 m0 *1 233.32,54.6
X$23686 3267 3105 3260 3430 109 77 2839 AND4_X1
* cell instance $23687 m0 *1 234.46,54.6
X$23687 77 2847 1634 3260 3428 2984 2455 3422 109 AOI222_X2
* cell instance $23688 m0 *1 237.12,54.6
X$23688 2455 1299 2365 1209 77 109 3426 AOI22_X2
* cell instance $23689 m0 *1 238.83,54.6
X$23689 3253 77 109 2989 BUF_X2
* cell instance $23692 r0 *1 217.36,54.6
X$23692 3550 3532 3436 77 109 3438 NAND3_X2
* cell instance $23694 r0 *1 218.88,54.6
X$23694 3415 2989 3535 3536 2995 3437 109 77 AOI221_X2
* cell instance $23695 r0 *1 220.97,54.6
X$23695 3415 2850 3535 3536 2265 3550 109 77 AOI221_X2
* cell instance $23697 r0 *1 223.44,54.6
X$23697 3546 853 3548 3537 1297 3436 109 77 AOI221_X2
* cell instance $23698 r0 *1 225.53,54.6
X$23698 3417 3418 3098 3416 77 3545 109 NAND4_X2
* cell instance $23702 r0 *1 227.24,54.6
X$23702 3240 3417 3418 109 3674 77 OAI21_X1
* cell instance $23703 r0 *1 228,54.6
X$23703 2850 1297 77 109 3420 NAND2_X1
* cell instance $23704 r0 *1 228.57,54.6
X$23704 3538 3420 1370 3427 77 109 2683 AOI22_X1
* cell instance $23705 r0 *1 229.52,54.6
X$23705 3542 3543 109 77 3241 AND2_X1
* cell instance $23706 r0 *1 230.28,54.6
X$23706 77 2852 1970 3098 3427 1370 109 AOI22_X4
* cell instance $23707 r0 *1 233.51,54.6
X$23707 77 2847 3425 3849 3268 2984 3100 3422 109 AOI222_X2
* cell instance $23708 r0 *1 236.17,54.6
X$23708 413 1892 3425 77 109 3681 MUX2_X1
* cell instance $23710 r0 *1 237.88,54.6
X$23710 3423 1789 3100 1872 77 109 3424 AOI22_X2
* cell instance $23722 m0 *1 47.69,43.4
X$23722 77 2403 2367 2266 2195 2157 109 DFFR_X1
* cell instance $23723 m0 *1 51.49,43.4
X$23723 77 2220 2602 2221 2267 2157 109 DFFR_X1
* cell instance $23724 m0 *1 55.29,43.4
X$23724 2156 2221 77 109 2269 NAND2_X1
* cell instance $23726 m0 *1 56.62,43.4
X$23726 2222 2159 2371 109 2270 77 OAI21_X1
* cell instance $23727 m0 *1 57.38,43.4
X$23727 77 2220 2474 2272 2271 2157 109 DFFR_X1
* cell instance $23728 m0 *1 61.18,43.4
X$23728 77 2224 2225 2274 2273 2157 109 DFFR_X1
* cell instance $23729 m0 *1 64.98,43.4
X$23729 77 2224 2606 2227 2275 2157 109 DFFR_X1
* cell instance $23730 m0 *1 68.78,43.4
X$23730 77 2229 2228 2277 2278 2157 109 DFFR_X1
* cell instance $23731 m0 *1 72.58,43.4
X$23731 2414 2155 2415 109 77 2483 OAI21_X2
* cell instance $23732 m0 *1 73.91,43.4
X$23732 2125 77 109 2159 CLKBUF_X3
* cell instance $23734 m0 *1 75.05,43.4
X$23734 77 2229 2379 2089 2281 2157 109 DFFR_X1
* cell instance $23736 m0 *1 80.37,43.4
X$23736 2155 2230 77 109 2488 NAND2_X1
* cell instance $23748 r0 *1 37.81,43.4
X$23748 77 2403 2634 2460 2402 2157 109 DFFR_X1
* cell instance $23752 r0 *1 49.4,43.4
X$23752 2467 2155 2700 109 77 2464 OAI21_X2
* cell instance $23753 r0 *1 50.73,43.4
X$23753 2156 2466 77 109 2467 NAND2_X1
* cell instance $23755 r0 *1 52.06,43.4
X$23755 2222 2407 2321 109 2469 77 OAI21_X1
* cell instance $23757 r0 *1 53.01,43.4
X$23757 2322 2471 77 109 2321 NAND2_X1
* cell instance $23761 r0 *1 57.19,43.4
X$23761 2222 2325 2323 109 2472 77 OAI21_X1
* cell instance $23763 r0 *1 58.14,43.4
X$23763 2326 2324 77 109 2323 NAND2_X1
* cell instance $23765 r0 *1 58.9,43.4
X$23765 2125 2223 77 109 2371 NAND2_X1
* cell instance $23770 r0 *1 59.66,43.4
X$23770 2158 2325 2475 109 2473 77 OAI21_X1
* cell instance $23773 r0 *1 61.56,43.4
X$23773 2326 2409 77 109 2475 NAND2_X1
* cell instance $23776 r0 *1 63.27,43.4
X$23776 2478 2325 2226 109 77 2476 OAI21_X4
* cell instance $23777 r0 *1 65.74,43.4
X$23777 2326 2412 77 109 2478 NAND2_X1
* cell instance $23781 r0 *1 68.78,43.4
X$23781 2161 2325 2327 109 2479 77 OAI21_X1
* cell instance $23782 r0 *1 69.54,43.4
X$23782 2325 2481 77 109 2327 NAND2_X1
* cell instance $23786 r0 *1 72.2,43.4
X$23786 77 2229 2547 2482 2483 2157 109 DFFR_X1
* cell instance $23790 r0 *1 79.99,43.4
X$23790 2417 2155 2488 109 2377 77 OAI21_X1
* cell instance $23791 r0 *1 80.75,43.4
X$23791 77 2378 2493 2490 2328 2157 109 DFFR_X1
* cell instance $23792 m0 *1 82.08,43.4
X$23792 2155 2490 77 109 2231 NAND2_X1
* cell instance $23793 m0 *1 81.32,43.4
X$23793 2232 2155 2231 109 2328 77 OAI21_X1
* cell instance $23794 m0 *1 82.65,43.4
X$23794 2232 2159 2381 109 2285 77 OAI21_X1
* cell instance $23795 m0 *1 83.41,43.4
X$23795 77 2378 2615 2233 2285 2157 109 DFFR_X1
* cell instance $23796 m0 *1 87.21,43.4
X$23796 2159 2233 77 109 2381 NAND2_X1
* cell instance $23802 r0 *1 86.45,43.4
X$23802 2159 2496 77 109 2382 NAND2_X1
* cell instance $23803 r0 *1 87.02,43.4
X$23803 2417 2159 2382 109 2494 77 OAI21_X1
* cell instance $23804 r0 *1 87.78,43.4
X$23804 77 2551 2418 2496 2494 2157 109 DFFR_X1
* cell instance $23807 r0 *1 92.72,43.4
X$23807 77 2234 18753 2329 2383 1663 109 DFFR_X1
* cell instance $23808 m0 *1 96.33,43.4
X$23808 409 77 109 2234 CLKBUF_X3
* cell instance $23810 m0 *1 98.04,43.4
X$23810 77 2234 18677 2236 2288 1663 109 DFFR_X1
* cell instance $23811 m0 *1 101.84,43.4
X$23811 79 2235 2236 77 109 2288 MUX2_X1
* cell instance $23814 r0 *1 96.52,43.4
X$23814 2234 77 109 19167 INV_X1
* cell instance $23815 r0 *1 96.9,43.4
X$23815 77 2234 18758 2330 2497 1663 109 DFFR_X1
* cell instance $23816 r0 *1 100.7,43.4
X$23816 250 2235 2330 77 109 2497 MUX2_X1
* cell instance $23819 r0 *1 103.74,43.4
X$23819 254 2552 2555 77 109 2498 MUX2_X1
* cell instance $23821 m0 *1 105.26,43.4
X$23821 125 2235 2291 77 109 2289 MUX2_X1
* cell instance $23825 m0 *1 108.3,43.4
X$23825 1729 1829 2165 2025 2292 2293 77 109 OAI221_X2
* cell instance $23826 m0 *1 107.73,43.4
X$23826 880 2105 77 109 2292 NAND2_X1
* cell instance $23828 m0 *1 110.58,43.4
X$23828 2096 1833 1499 77 2332 109 AOI21_X1
* cell instance $23830 m0 *1 111.53,43.4
X$23830 2096 109 2093 77 BUF_X4
* cell instance $23831 m0 *1 112.86,43.4
X$23831 2058 2238 1938 109 2297 77 OAI21_X1
* cell instance $23833 m0 *1 113.81,43.4
X$23833 2239 2096 77 109 2333 NOR2_X2
* cell instance $23834 m0 *1 114.76,43.4
X$23834 2240 1396 77 109 2239 NOR2_X1
* cell instance $23835 m0 *1 115.33,43.4
X$23835 1094 1431 77 109 2335 NAND2_X1
* cell instance $23836 m0 *1 115.9,43.4
X$23836 1737 2069 2335 1501 2337 109 77 2336 OAI221_X1
* cell instance $23837 m0 *1 117.04,43.4
X$23837 1341 1436 1339 109 2337 77 OAI21_X1
* cell instance $23840 r0 *1 108.49,43.4
X$23840 1307 1753 77 109 2386 NAND2_X1
* cell instance $23842 r0 *1 109.25,43.4
X$23842 2331 2332 2386 77 2419 109 AOI21_X1
* cell instance $23844 r0 *1 110.2,43.4
X$23844 1339 1154 1494 2332 109 77 2420 OAI22_X1
* cell instance $23845 r0 *1 111.15,43.4
X$23845 2167 1307 2058 1124 77 109 2502 AOI22_X2
* cell instance $23846 r0 *1 112.86,43.4
X$23846 2026 2502 2333 77 2500 109 AOI21_X2
* cell instance $23847 r0 *1 114.19,43.4
X$23847 1499 1340 109 77 2167 AND2_X1
* cell instance $23848 r0 *1 114.95,43.4
X$23848 1753 1557 2333 109 2334 77 OAI21_X1
* cell instance $23852 r0 *1 115.71,43.4
X$23852 1938 2334 2012 2336 77 109 2560 AOI22_X1
* cell instance $23854 r0 *1 117.04,43.4
X$23854 1476 2209 1757 1589 2338 2504 77 109 OAI221_X2
* cell instance $23856 m0 *1 118.18,43.4
X$23856 1833 1584 77 109 2338 NAND2_X1
* cell instance $23857 m0 *1 119.51,43.4
X$23857 1339 77 109 2209 CLKBUF_X3
* cell instance $23858 m0 *1 120.46,43.4
X$23858 2241 1835 2063 77 2390 109 AOI21_X1
* cell instance $23859 m0 *1 121.22,43.4
X$23859 2026 2390 2242 2302 2025 109 77 2511 OAI221_X1
* cell instance $23860 m0 *1 122.36,43.4
X$23860 2019 1835 1585 77 2513 109 AOI21_X1
* cell instance $23861 m0 *1 123.12,43.4
X$23861 1737 77 109 2340 INV_X1
* cell instance $23863 m0 *1 124.26,43.4
X$23863 1691 1436 1477 77 109 2341 MUX2_X1
* cell instance $23864 m0 *1 125.59,43.4
X$23864 1340 1499 77 109 2169 NAND2_X2
* cell instance $23865 m0 *1 126.54,43.4
X$23865 2173 2304 77 109 2427 NAND2_X1
* cell instance $23866 m0 *1 127.11,43.4
X$23866 2243 2105 1312 109 2306 77 OAI21_X1
* cell instance $23867 m0 *1 127.87,43.4
X$23867 2517 2304 2244 77 2342 109 AOI21_X1
* cell instance $23868 m0 *1 128.63,43.4
X$23868 2244 1496 1344 77 109 2245 NAND3_X1
* cell instance $23869 m0 *1 129.39,43.4
X$23869 1477 2396 1995 77 109 2309 NOR3_X1
* cell instance $23870 m0 *1 130.15,43.4
X$23870 2246 2309 2561 109 2215 77 OAI21_X1
* cell instance $23871 m0 *1 130.91,43.4
X$23871 2331 1753 77 109 2244 NOR2_X1
* cell instance $23873 m0 *1 137.56,43.4
X$23873 2318 2315 77 109 2217 NOR2_X1
* cell instance $23874 m0 *1 138.13,43.4
X$23874 2345 2347 2395 109 2315 77 NOR3_X2
* cell instance $23875 m0 *1 139.46,43.4
X$23875 2395 2347 77 109 2108 OR2_X2
* cell instance $23876 m0 *1 140.41,43.4
X$23876 2394 2247 2320 109 77 2078 AND3_X1
* cell instance $23877 m0 *1 141.36,43.4
X$23877 2430 77 109 1844 CLKBUF_X3
* cell instance $23878 m0 *1 142.31,43.4
X$23878 2108 2346 77 109 2320 NAND2_X1
* cell instance $23882 r0 *1 119.13,43.4
X$23882 2209 858 2507 109 2423 77 OAI21_X1
* cell instance $23884 r0 *1 120.27,43.4
X$23884 2169 2137 77 109 2339 OR2_X1
* cell instance $23886 r0 *1 121.22,43.4
X$23886 1837 2339 109 77 2426 AND2_X1
* cell instance $23887 r0 *1 121.98,43.4
X$23887 1694 2209 77 109 2396 NAND2_X2
* cell instance $23889 r0 *1 123.12,43.4
X$23889 1937 2340 1835 77 2566 109 AOI21_X1
* cell instance $23891 r0 *1 124.07,43.4
X$23891 2069 2340 77 109 2516 NOR2_X1
* cell instance $23893 r0 *1 124.83,43.4
X$23893 1754 2341 2173 109 2507 77 OAI21_X1
* cell instance $23894 r0 *1 125.59,43.4
X$23894 1753 77 109 1939 CLKBUF_X3
* cell instance $23897 r0 *1 127.49,43.4
X$23897 77 1995 2342 2426 1310 2026 2101 2519 109 OAI222_X2
* cell instance $23898 r0 *1 130.15,43.4
X$23898 1901 77 109 2424 CLKBUF_X3
* cell instance $23899 r0 *1 131.1,43.4
X$23899 2022 1901 77 109 2331 NAND2_X1
* cell instance $23902 r0 *1 132.24,43.4
X$23902 2524 2428 1586 77 109 2521 MUX2_X1
* cell instance $23903 r0 *1 133.57,43.4
X$23903 77 3209 2524 2521 2343 109 DFF_X1
* cell instance $23905 r0 *1 137.56,43.4
X$23905 216 885 2106 77 2344 109 AOI21_X1
* cell instance $23906 r0 *1 138.32,43.4
X$23906 2344 77 109 2345 INV_X1
* cell instance $23907 r0 *1 138.7,43.4
X$23907 2028 2429 2348 109 2318 77 OAI21_X1
* cell instance $23911 r0 *1 140.79,43.4
X$23911 2347 2395 77 109 2429 NOR2_X1
* cell instance $23913 r0 *1 142.12,43.4
X$23913 2348 109 2394 77 BUF_X4
* cell instance $23916 r0 *1 145.73,43.4
X$23916 77 1507 18818 2349 2393 1663 109 DFFR_X1
* cell instance $23917 m0 *1 147.25,43.4
X$23917 77 2109 18576 2317 2391 1663 109 DFFR_X1
* cell instance $23920 m0 *1 151.81,43.4
X$23920 2317 77 109 2312 BUF_X1
* cell instance $23922 m0 *1 153.14,43.4
X$23922 2312 2179 2351 109 77 2316 AND3_X1
* cell instance $23923 m0 *1 154.09,43.4
X$23923 2316 2314 2311 77 109 2391 NOR3_X1
* cell instance $23924 m0 *1 154.85,43.4
X$23924 2313 2042 2351 77 2314 109 AOI21_X1
* cell instance $23925 m0 *1 155.61,43.4
X$23925 2312 1418 77 109 2313 OR2_X1
* cell instance $23929 r0 *1 150.48,43.4
X$23929 1416 2349 77 109 2431 NOR2_X1
* cell instance $23930 r0 *1 151.05,43.4
X$23930 2530 2431 2529 77 2393 109 AOI21_X1
* cell instance $23931 r0 *1 151.81,43.4
X$23931 2433 2179 2312 77 109 2529 NAND3_X1
* cell instance $23932 r0 *1 152.57,43.4
X$23932 1416 788 77 109 2392 NAND2_X1
* cell instance $23933 r0 *1 153.14,43.4
X$23933 345 77 109 2109 CLKBUF_X3
* cell instance $23934 r0 *1 154.09,43.4
X$23934 2179 2433 2434 109 77 2533 AND3_X1
* cell instance $23935 r0 *1 155.04,43.4
X$23935 2109 77 109 19180 INV_X1
* cell instance $23938 r0 *1 155.99,43.4
X$23938 2312 2349 109 77 2435 AND2_X1
* cell instance $23940 m0 *1 156.94,43.4
X$23940 2312 1110 980 1943 77 109 2389 AOI22_X2
* cell instance $23944 m0 *1 160.36,43.4
X$23944 77 2109 18607 2249 2248 1146 109 DFFR_X1
* cell instance $23946 m0 *1 165.68,43.4
X$23946 77 2115 18512 2079 2307 1146 109 DFFR_X1
* cell instance $23948 m0 *1 171,43.4
X$23948 2219 77 109 2041 INV_X1
* cell instance $23949 m0 *1 171.38,43.4
X$23949 2111 2250 2305 109 77 1672 AND3_X1
* cell instance $23951 m0 *1 172.52,43.4
X$23951 2250 2111 2305 77 1361 109 NAND3_X4
* cell instance $23952 m0 *1 174.99,43.4
X$23952 77 2144 2113 2251 2387 109 NOR3_X4
* cell instance $23953 m0 *1 177.65,43.4
X$23953 1565 2114 1109 2184 2282 2299 77 109 OAI221_X2
* cell instance $23954 m0 *1 179.74,43.4
X$23954 1201 2177 77 109 1917 NAND2_X2
* cell instance $23955 m0 *1 180.69,43.4
X$23955 1160 2184 77 109 2298 NOR2_X1
* cell instance $23957 m0 *1 181.45,43.4
X$23957 77 1201 2252 2356 1361 1412 109 NOR4_X4
* cell instance $23959 r0 *1 156.94,43.4
X$23959 2249 2350 109 77 2434 AND2_X1
* cell instance $23961 r0 *1 157.89,43.4
X$23961 2432 1189 2037 1134 77 109 2436 AOI22_X1
* cell instance $23963 r0 *1 159.22,43.4
X$23963 2249 2437 2351 2350 109 77 2537 AND4_X1
* cell instance $23964 r0 *1 160.36,43.4
X$23964 2350 2351 2179 77 109 2538 NAND3_X1
* cell instance $23965 r0 *1 161.12,43.4
X$23965 2537 2352 2353 2538 2248 109 77 AOI211_X2
* cell instance $23966 r0 *1 162.83,43.4
X$23966 1863 2249 77 109 2353 NOR2_X1
* cell instance $23967 r0 *1 163.4,43.4
X$23967 1917 77 109 1158 CLKBUF_X3
* cell instance $23969 r0 *1 164.73,43.4
X$23969 2042 2250 2578 484 2043 77 109 2307 AOI221_X1
* cell instance $23972 r0 *1 166.82,43.4
X$23972 2351 2354 109 77 2250 AND2_X1
* cell instance $23974 r0 *1 167.77,43.4
X$23974 2356 2439 1201 109 2437 77 NOR3_X2
* cell instance $23975 r0 *1 169.1,43.4
X$23975 2354 2351 77 109 2535 NAND2_X1
* cell instance $23976 r0 *1 169.67,43.4
X$23976 2356 2252 1201 2535 109 2355 77 NOR4_X2
* cell instance $23980 r0 *1 171.38,43.4
X$23980 2111 2388 2354 2305 109 77 1616 AND4_X1
* cell instance $23982 r0 *1 172.71,43.4
X$23982 2531 2355 2305 77 2180 109 AOI21_X1
* cell instance $23984 r0 *1 173.66,43.4
X$23984 2111 1776 77 109 2531 OR2_X1
* cell instance $23986 r0 *1 174.61,43.4
X$23986 685 77 109 2181 INV_X1
* cell instance $23988 r0 *1 176.51,43.4
X$23988 515 2184 77 109 2444 NOR2_X2
* cell instance $23989 r0 *1 177.46,43.4
X$23989 1956 2114 937 2177 2486 2525 77 109 OAI221_X2
* cell instance $23990 r0 *1 179.55,43.4
X$23990 1817 2114 582 2184 2465 2523 77 109 OAI221_X2
* cell instance $23991 r0 *1 181.64,43.4
X$23991 77 1201 2445 2356 2385 1865 109 NOR4_X4
* cell instance $23992 r0 *1 185.06,43.4
X$23992 1616 77 109 2385 INV_X1
* cell instance $23994 m0 *1 185.25,43.4
X$23994 77 1731 2219 2295 2296 1146 109 DFFR_X1
* cell instance $23999 r0 *1 186.77,43.4
X$23999 1731 77 109 19287 CLKBUF_X1
* cell instance $24000 r0 *1 187.34,43.4
X$24000 1198 1722 2514 77 109 2515 MUX2_X1
* cell instance $24001 r0 *1 188.67,43.4
X$24001 349 77 109 1731 CLKBUF_X3
* cell instance $24003 r0 *1 189.81,43.4
X$24003 77 1731 18837 2512 2384 1146 109 DFFR_X1
* cell instance $24005 m0 *1 190.19,43.4
X$24005 1198 1630 2512 77 109 2384 MUX2_X1
* cell instance $24008 m0 *1 193.99,43.4
X$24008 1198 2258 2357 77 109 2358 MUX2_X1
* cell instance $24011 r0 *1 193.61,43.4
X$24011 77 2120 18817 2357 2358 1146 109 DFFR_X1
* cell instance $24012 m0 *1 201.02,43.4
X$24012 77 2120 18538 2256 2255 1146 109 DFFR_X1
* cell instance $24013 m0 *1 197.22,43.4
X$24013 77 1713 18569 2254 2290 1146 109 DFFR_X1
* cell instance $24016 m0 *1 205.77,43.4
X$24016 399 2258 2259 77 109 2505 MUX2_X1
* cell instance $24024 r0 *1 201.78,43.4
X$24024 2509 2585 2376 77 109 2359 MUX2_X1
* cell instance $24025 r0 *1 203.11,43.4
X$24025 999 77 109 2120 CLKBUF_X3
* cell instance $24026 r0 *1 204.06,43.4
X$24026 2587 2261 2062 2276 77 109 2610 AOI22_X1
* cell instance $24028 r0 *1 205.77,43.4
X$24028 77 2120 18872 2259 2505 1146 109 DFFR_X1
* cell instance $24030 r0 *1 209.95,43.4
X$24030 77 2360 18830 2260 2380 1146 109 DFFR_X1
* cell instance $24031 m0 *1 211.47,43.4
X$24031 772 1630 2260 77 109 2380 MUX2_X1
* cell instance $24035 m0 *1 213.75,43.4
X$24035 77 1961 18535 2283 2286 992 109 DFFR_X1
* cell instance $24037 m0 *1 217.74,43.4
X$24037 77 2051 18593 2203 2284 992 109 DFFR_X1
* cell instance $24041 m0 *1 226.29,43.4
X$24041 2376 2261 1642 2276 77 109 2280 AOI22_X1
* cell instance $24042 m0 *1 227.24,43.4
X$24042 77 2051 18540 2201 2279 992 109 DFFR_X1
* cell instance $24043 m0 *1 231.04,43.4
X$24043 1544 2123 850 1629 77 109 2373 AOI22_X1
* cell instance $24045 m0 *1 232.75,43.4
X$24045 1209 2123 1298 1629 77 109 2370 AOI22_X1
* cell instance $24047 m0 *1 233.89,43.4
X$24047 2194 1542 2123 1373 77 109 2369 AOI22_X2
* cell instance $24050 m0 *1 237.31,43.4
X$24050 2262 77 109 2265 BUF_X1
* cell instance $24052 r0 *1 213.75,43.4
X$24052 1869 109 2258 77 BUF_X4
* cell instance $24055 r0 *1 215.65,43.4
X$24055 1961 77 109 19174 INV_X1
* cell instance $24057 r0 *1 216.22,43.4
X$24057 1783 2276 77 109 1869 NAND2_X2
* cell instance $24058 r0 *1 217.17,43.4
X$24058 999 77 109 1961 CLKBUF_X3
* cell instance $24059 r0 *1 218.12,43.4
X$24059 554 1722 2361 77 109 2449 MUX2_X1
* cell instance $24062 r0 *1 221.73,43.4
X$24062 77 2051 18711 2450 2362 992 109 DFFR_X1
* cell instance $24064 r0 *1 225.72,43.4
X$24064 999 77 109 2051 CLKBUF_X3
* cell instance $24070 r0 *1 227.24,43.4
X$24070 2451 2375 2487 109 2186 77 NOR3_X2
* cell instance $24071 r0 *1 228.57,43.4
X$24071 2489 2190 77 109 2375 NAND2_X1
* cell instance $24074 r0 *1 230.85,43.4
X$24074 2373 2480 2477 2374 109 77 2188 AND4_X1
* cell instance $24075 r0 *1 231.99,43.4
X$24075 752 1542 2263 2363 77 109 2477 AOI22_X1
* cell instance $24077 r0 *1 233.13,43.4
X$24077 989 1542 2368 2363 77 109 2594 AOI22_X1
* cell instance $24078 r0 *1 234.08,43.4
X$24078 2370 2468 2366 2470 109 77 2465 AND4_X1
* cell instance $24079 r0 *1 235.22,43.4
X$24079 847 1542 2268 2363 77 109 2366 AOI22_X1
* cell instance $24080 r0 *1 236.17,43.4
X$24080 1063 1892 2454 77 109 2462 MUX2_X1
* cell instance $24081 r0 *1 237.5,43.4
X$24081 2458 77 109 2461 BUF_X1
* cell instance $24083 m0 *1 238.45,43.4
X$24083 2264 77 109 2365 BUF_X1
* cell instance $24086 r0 *1 238.45,43.4
X$24086 2687 77 109 2455 BUF_X1
* cell instance $24087 r0 *1 239.02,43.4
X$24087 2596 77 109 2364 BUF_X1
* cell instance $24132 r0 *1 90.06,32.2
X$24132 77 18398 1717 1790 1487 109 DFF_X1
* cell instance $24133 m0 *1 93.1,32.2
X$24133 117 216 1717 77 109 1637 MUX2_X1
* cell instance $24137 m0 *1 96.71,32.2
X$24137 324 352 1488 77 109 1574 MUX2_X1
* cell instance $24138 m0 *1 98.04,32.2
X$24138 77 18317 1489 1575 955 109 DFF_X1
* cell instance $24141 m0 *1 102.98,32.2
X$24141 1683 642 1303 77 109 1723 MUX2_X1
* cell instance $24142 m0 *1 104.31,32.2
X$24142 324 958 77 109 1684 NAND2_X1
* cell instance $24143 m0 *1 104.88,32.2
X$24143 1126 1684 1576 77 1725 109 AOI21_X1
* cell instance $24144 m0 *1 105.64,32.2
X$24144 1725 1126 1492 77 1685 109 AOI21_X2
* cell instance $24148 r0 *1 93.67,32.2
X$24148 1487 77 109 19291 CLKBUF_X1
* cell instance $24149 r0 *1 94.24,32.2
X$24149 1681 418 1637 77 109 1745 MUX2_X1
* cell instance $24150 r0 *1 95.57,32.2
X$24150 409 77 109 1487 CLKBUF_X3
* cell instance $24151 r0 *1 96.52,32.2
X$24151 117 352 1681 77 109 1720 MUX2_X1
* cell instance $24152 r0 *1 97.85,32.2
X$24152 1747 442 1720 77 109 1746 MUX2_X1
* cell instance $24155 r0 *1 101.08,32.2
X$24155 77 18415 1683 1723 1682 109 DFF_X1
* cell instance $24156 r0 *1 104.31,32.2
X$24156 1683 887 1747 77 109 1335 MUX2_X1
* cell instance $24157 r0 *1 105.64,32.2
X$24157 1747 803 77 109 1794 NAND2_X1
* cell instance $24158 r0 *1 106.21,32.2
X$24158 1749 1126 1303 77 1726 109 AOI21_X2
* cell instance $24160 m0 *1 108.87,32.2
X$24160 1640 1686 1641 1497 1643 1729 109 77 AOI221_X2
* cell instance $24161 m0 *1 108.11,32.2
X$24161 1494 880 77 109 1640 OR2_X1
* cell instance $24162 m0 *1 110.96,32.2
X$24162 1481 1124 1496 109 1498 77 OAI21_X1
* cell instance $24163 m0 *1 111.72,32.2
X$24163 1581 77 109 1686 INV_X1
* cell instance $24166 r0 *1 108.68,32.2
X$24166 1494 1121 1686 109 1796 77 OAI21_X1
* cell instance $24168 r0 *1 109.82,32.2
X$24168 1796 1734 1797 77 109 1750 NAND3_X1
* cell instance $24169 r0 *1 110.58,32.2
X$24169 1227 1754 1753 77 109 1797 NAND3_X1
* cell instance $24170 r0 *1 111.34,32.2
X$24170 1431 1154 1340 77 1752 109 AOI21_X1
* cell instance $24171 r0 *1 112.1,32.2
X$24171 1730 1582 1687 109 1643 77 OAI21_X1
* cell instance $24172 m0 *1 112.67,32.2
X$24172 1169 77 109 1577 CLKBUF_X3
* cell instance $24176 r0 *1 113.05,32.2
X$24176 1431 77 109 1753 CLKBUF_X3
* cell instance $24178 m0 *1 114.19,32.2
X$24178 1582 1577 77 109 1687 NAND2_X2
* cell instance $24180 m0 *1 115.14,32.2
X$24180 1578 1339 77 109 1579 NAND2_X2
* cell instance $24182 r0 *1 114.76,32.2
X$24182 1581 1388 1170 77 1802 109 AOI21_X1
* cell instance $24186 r0 *1 115.52,32.2
X$24186 1341 1753 77 109 1688 NAND2_X1
* cell instance $24187 r0 *1 116.09,32.2
X$24187 1688 1757 1582 77 1758 109 AOI21_X1
* cell instance $24188 m0 *1 116.66,32.2
X$24188 1577 1435 1554 109 1580 77 OAI21_X1
* cell instance $24190 m0 *1 117.42,32.2
X$24190 1580 77 109 1689 INV_X1
* cell instance $24191 m0 *1 117.8,32.2
X$24191 1647 1581 1580 1310 1690 109 77 1804 OAI221_X1
* cell instance $24192 m0 *1 118.94,32.2
X$24192 1310 1582 1687 109 1583 77 OAI21_X1
* cell instance $24193 m0 *1 119.7,32.2
X$24193 1584 1577 77 109 1581 NAND2_X2
* cell instance $24194 m0 *1 120.65,32.2
X$24194 1343 1586 77 1582 109 NAND2_X4
* cell instance $24195 m0 *1 122.36,32.2
X$24195 1343 1691 77 109 1737 NAND2_X1
* cell instance $24196 m0 *1 122.93,32.2
X$24196 1586 77 109 1691 INV_X1
* cell instance $24197 m0 *1 123.31,32.2
X$24197 1587 1588 1589 1577 77 109 1693 AOI22_X1
* cell instance $24199 m0 *1 125.78,32.2
X$24199 1435 1436 1585 77 109 NOR2_X4
* cell instance $24202 r0 *1 117.23,32.2
X$24202 1689 1400 1585 77 1734 109 AOI21_X1
* cell instance $24203 r0 *1 117.99,32.2
X$24203 1804 1497 1760 77 1759 109 AOI21_X1
* cell instance $24205 r0 *1 119.13,32.2
X$24205 1477 1582 1687 109 1760 77 OAI21_X1
* cell instance $24208 r0 *1 120.46,32.2
X$24208 1726 1340 77 109 1761 NAND2_X1
* cell instance $24211 r0 *1 121.6,32.2
X$24211 1494 1762 1503 77 1807 109 AOI21_X1
* cell instance $24212 r0 *1 122.36,32.2
X$24212 1503 1388 109 77 1696 AND2_X1
* cell instance $24213 r0 *1 123.12,32.2
X$24213 1481 77 109 1694 CLKBUF_X3
* cell instance $24214 r0 *1 124.07,32.2
X$24214 1693 1694 77 109 1763 NOR2_X1
* cell instance $24215 r0 *1 124.64,32.2
X$24215 1765 1341 1763 1585 1753 1810 109 77 AOI221_X2
* cell instance $24216 r0 *1 126.73,32.2
X$24216 1435 77 109 1754 CLKBUF_X3
* cell instance $24217 r0 *1 127.68,32.2
X$24217 1440 77 109 1730 INV_X1
* cell instance $24218 m0 *1 128.25,32.2
X$24218 1396 1591 1696 109 1697 77 OAI21_X1
* cell instance $24219 m0 *1 127.87,32.2
X$24219 1400 77 109 1695 INV_X1
* cell instance $24221 m0 *1 129.2,32.2
X$24221 1336 109 958 77 BUF_X4
* cell instance $24223 m0 *1 130.72,32.2
X$24223 1345 1047 1594 77 109 1593 MUX2_X1
* cell instance $24225 m0 *1 132.24,32.2
X$24225 1592 1336 1594 109 77 1901 OAI21_X4
* cell instance $24226 m0 *1 134.71,32.2
X$24226 1251 77 109 1336 INV_X4
* cell instance $24229 m0 *1 137.94,32.2
X$24229 77 1819 18661 1595 1742 1663 109 DFFR_X1
* cell instance $24230 m0 *1 141.74,32.2
X$24230 77 1507 1661 1663 18907 1700 109 DFFR_X2
* cell instance $24231 m0 *1 145.92,32.2
X$24231 1447 77 109 1259 CLKBUF_X3
* cell instance $24232 m0 *1 146.87,32.2
X$24232 1700 1447 1741 77 109 1661 MUX2_X1
* cell instance $24233 m0 *1 148.2,32.2
X$24233 1699 77 109 1666 INV_X1
* cell instance $24234 m0 *1 148.58,32.2
X$24234 1744 1666 1668 77 1742 109 AOI21_X1
* cell instance $24235 m0 *1 149.34,32.2
X$24235 1596 722 1185 109 1668 77 OAI21_X1
* cell instance $24236 m0 *1 150.1,32.2
X$24236 458 1596 1699 77 109 1597 NAND3_X1
* cell instance $24237 m0 *1 150.86,32.2
X$24237 1331 1597 1166 77 1744 109 AOI21_X1
* cell instance $24238 m0 *1 151.62,32.2
X$24238 461 1598 77 109 1743 NAND2_X1
* cell instance $24240 m0 *1 152.38,32.2
X$24240 373 1059 1743 109 1741 77 OAI21_X1
* cell instance $24241 m0 *1 153.14,32.2
X$24241 1447 77 109 1275 CLKBUF_X3
* cell instance $24242 m0 *1 154.09,32.2
X$24242 1572 1179 77 109 1702 NAND2_X1
* cell instance $24243 m0 *1 154.66,32.2
X$24243 1447 77 109 1185 CLKBUF_X3
* cell instance $24244 m0 *1 155.61,32.2
X$24244 820 1665 77 109 1166 NAND2_X1
* cell instance $24246 r0 *1 128.06,32.2
X$24246 1695 1696 1697 109 1816 77 OAI21_X1
* cell instance $24247 r0 *1 128.82,32.2
X$24247 1694 77 109 1757 CLKBUF_X3
* cell instance $24250 r0 *1 130.34,32.2
X$24250 77 642 109 1122 BUF_X8
* cell instance $24251 r0 *1 132.81,32.2
X$24251 1163 109 1586 77 BUF_X4
* cell instance $24252 r0 *1 134.14,32.2
X$24252 1698 77 109 887 CLKBUF_X3
* cell instance $24253 r0 *1 135.09,32.2
X$24253 1698 77 109 878 CLKBUF_X3
* cell instance $24254 r0 *1 136.04,32.2
X$24254 1347 1654 654 77 1820 109 AOI21_X1
* cell instance $24255 r0 *1 136.8,32.2
X$24255 1940 77 109 1251 BUF_X2
* cell instance $24259 r0 *1 144.78,32.2
X$24259 1768 1700 1598 109 77 1914 HA_X1
* cell instance $24260 r0 *1 146.68,32.2
X$24260 1768 1699 1700 77 109 1823 NAND3_X1
* cell instance $24262 r0 *1 147.82,32.2
X$24262 1823 348 77 109 1915 NAND2_X1
* cell instance $24265 r0 *1 149.34,32.2
X$24265 530 1770 1235 109 1769 77 OAI21_X1
* cell instance $24268 r0 *1 151.24,32.2
X$24268 1770 1771 77 109 1701 NOR2_X1
* cell instance $24269 r0 *1 151.81,32.2
X$24269 530 1701 1447 109 1921 77 OAI21_X1
* cell instance $24272 r0 *1 154.28,32.2
X$24272 602 969 1702 109 1826 77 OAI21_X1
* cell instance $24274 r0 *1 155.23,32.2
X$24274 1799 1322 77 109 1235 NAND2_X1
* cell instance $24276 m0 *1 156.75,32.2
X$24276 1671 1601 77 109 1269 OR2_X2
* cell instance $24278 m0 *1 157.7,32.2
X$24278 1601 1703 77 109 1606 NOR2_X2
* cell instance $24279 m0 *1 158.65,32.2
X$24279 1705 1704 1603 109 1453 77 NOR3_X2
* cell instance $24280 m0 *1 159.98,32.2
X$24280 1610 1601 1671 1603 1704 1705 77 109 1604 OAI33_X1
* cell instance $24281 m0 *1 161.31,32.2
X$24281 1739 1259 1605 77 1740 109 AOI21_X1
* cell instance $24283 r0 *1 157.32,32.2
X$24283 1703 1600 77 109 1602 OR2_X2
* cell instance $24285 r0 *1 159.03,32.2
X$24285 1058 77 109 1322 CLKBUF_X3
* cell instance $24287 r0 *1 160.36,32.2
X$24287 77 1130 1740 1663 19016 1518 109 DFFR_X2
* cell instance $24288 m0 *1 163.21,32.2
X$24288 1518 1738 1263 77 1739 109 AOI21_X1
* cell instance $24289 m0 *1 162.45,32.2
X$24289 722 1606 1185 109 1675 77 OAI21_X1
* cell instance $24291 m0 *1 164.16,32.2
X$24291 1607 1058 1515 1608 77 109 1674 OR4_X1
* cell instance $24292 m0 *1 165.3,32.2
X$24292 1186 1674 638 77 1706 109 AOI21_X1
* cell instance $24293 m0 *1 166.06,32.2
X$24293 1273 77 109 348 CLKBUF_X3
* cell instance $24294 m0 *1 167.01,32.2
X$24294 1456 77 109 1610 INV_X1
* cell instance $24295 m0 *1 167.39,32.2
X$24295 1707 1610 1675 77 1735 109 AOI21_X1
* cell instance $24296 m0 *1 168.15,32.2
X$24296 1331 1611 513 77 1707 109 AOI21_X1
* cell instance $24297 m0 *1 168.91,32.2
X$24297 77 1523 18511 1678 1735 1663 109 DFFR_X1
* cell instance $24298 m0 *1 172.71,32.2
X$24298 1678 77 109 1456 BUF_X2
* cell instance $24300 m0 *1 173.66,32.2
X$24300 1284 605 606 1448 77 109 1679 AOI22_X2
* cell instance $24303 r0 *1 164.73,32.2
X$24303 1607 1608 1602 778 777 1705 77 109 1738 OAI33_X1
* cell instance $24304 r0 *1 166.06,32.2
X$24304 1824 77 109 1607 INV_X1
* cell instance $24305 r0 *1 166.44,32.2
X$24305 1824 1825 1275 77 1736 109 AOI21_X1
* cell instance $24306 r0 *1 167.2,32.2
X$24306 1706 1736 77 109 1930 NOR2_X1
* cell instance $24310 r0 *1 170.24,32.2
X$24310 1523 77 109 19162 INV_X1
* cell instance $24316 r0 *1 172.33,32.2
X$24316 1822 1322 77 109 974 NAND2_X1
* cell instance $24320 r0 *1 174.99,32.2
X$24320 77 977 18846 1612 1709 1146 109 DFFR_X1
* cell instance $24321 m0 *1 175.94,32.2
X$24321 1613 1189 1134 1258 77 109 1733 AOI22_X2
* cell instance $24325 r0 *1 178.79,32.2
X$24325 1612 608 609 1456 77 109 1817 AOI22_X2
* cell instance $24326 m0 *1 179.93,32.2
X$24326 1614 1708 1615 109 1527 77 NOR3_X2
* cell instance $24327 m0 *1 179.55,32.2
X$24327 1612 77 109 1708 INV_X1
* cell instance $24328 m0 *1 181.26,32.2
X$24328 1614 1615 77 109 1710 NOR2_X1
* cell instance $24329 m0 *1 181.83,32.2
X$24329 1528 1708 1615 1614 109 1711 77 NOR4_X2
* cell instance $24330 m0 *1 183.54,32.2
X$24330 1461 1525 1613 1617 77 1614 109 NAND4_X2
* cell instance $24333 m0 *1 186.2,32.2
X$24333 1712 1672 77 109 1199 NAND2_X1
* cell instance $24334 m0 *1 186.77,32.2
X$24334 1712 1616 77 109 1099 NAND2_X1
* cell instance $24336 m0 *1 188.86,32.2
X$24336 1711 77 109 1618 INV_X1
* cell instance $24337 m0 *1 189.24,32.2
X$24337 1412 1711 109 77 1727 AND2_X1
* cell instance $24338 m0 *1 190,32.2
X$24338 1283 1619 1728 1727 109 77 1805 OAI22_X1
* cell instance $24340 m0 *1 191.14,32.2
X$24340 1158 1357 77 109 1728 NAND2_X1
* cell instance $24342 m0 *1 192.47,32.2
X$24342 1364 77 109 19124 INV_X1
* cell instance $24344 m0 *1 193.61,32.2
X$24344 1620 77 109 1357 BUF_X2
* cell instance $24346 r0 *1 180.5,32.2
X$24346 1815 1412 1710 77 1812 109 AOI21_X1
* cell instance $24347 r0 *1 181.26,32.2
X$24347 1412 1527 1812 503 1416 77 109 1709 AOI221_X1
* cell instance $24349 r0 *1 183.16,32.2
X$24349 1461 1617 109 77 1529 AND2_X1
* cell instance $24350 r0 *1 183.92,32.2
X$24350 77 1731 18824 1806 1778 1146 109 DFFR_X1
* cell instance $24351 r0 *1 187.72,32.2
X$24351 1806 77 109 1284 BUF_X2
* cell instance $24355 r0 *1 189.81,32.2
X$24355 77 1364 18857 1620 1805 1146 109 DFFR_X1
* cell instance $24356 r0 *1 193.61,32.2
X$24356 349 77 109 1364 CLKBUF_X3
* cell instance $24357 r0 *1 194.56,32.2
X$24357 1402 1621 1780 77 109 1803 MUX2_X1
* cell instance $24358 m0 *1 194.94,32.2
X$24358 1665 77 109 1311 INV_X2
* cell instance $24364 r0 *1 195.89,32.2
X$24364 77 1713 18735 1780 1803 1146 109 DFFR_X1
* cell instance $24366 r0 *1 200.07,32.2
X$24366 77 1713 18854 1800 1724 1146 109 DFFR_X1
* cell instance $24367 m0 *1 201.4,32.2
X$24367 1463 1621 1800 77 109 1724 MUX2_X1
* cell instance $24372 m0 *1 204.82,32.2
X$24372 77 1553 18542 1624 1625 1146 109 DFFR_X1
* cell instance $24374 m0 *1 208.62,32.2
X$24374 77 1367 18519 1626 1653 1146 109 DFFR_X1
* cell instance $24375 m0 *1 212.42,32.2
X$24375 77 1367 18555 1628 1627 1146 109 DFFR_X1
* cell instance $24376 m0 *1 216.22,32.2
X$24376 912 109 1722 77 BUF_X4
* cell instance $24377 m0 *1 217.55,32.2
X$24377 77 1721 18590 1716 1648 1146 109 DFFR_X1
* cell instance $24378 m0 *1 221.35,32.2
X$24378 77 1721 18559 1644 1645 992 109 DFFR_X1
* cell instance $24380 m0 *1 225.34,32.2
X$24380 77 1546 18491 1642 1631 992 109 DFFR_X1
* cell instance $24381 m0 *1 229.14,32.2
X$24381 77 1546 18548 1633 1632 992 109 DFFR_X1
* cell instance $24382 m0 *1 232.94,32.2
X$24382 77 1546 18567 1634 1639 992 109 DFFR_X1
* cell instance $24388 r0 *1 206.34,32.2
X$24388 1799 77 109 1463 INV_X1
* cell instance $24391 r0 *1 209.95,32.2
X$24391 1059 1540 1781 109 1888 77 OAI21_X1
* cell instance $24392 r0 *1 210.71,32.2
X$24392 1539 1714 77 109 1781 NAND2_X1
* cell instance $24395 r0 *1 213.18,32.2
X$24395 1367 77 109 19301 CLKBUF_X1
* cell instance $24396 r0 *1 213.75,32.2
X$24396 759 1540 1715 109 1782 77 OAI21_X1
* cell instance $24398 r0 *1 214.7,32.2
X$24398 77 1367 18701 1975 1978 992 109 DFFR_X1
* cell instance $24399 r0 *1 218.5,32.2
X$24399 685 1722 1716 77 109 1648 MUX2_X1
* cell instance $24402 r0 *1 221.54,32.2
X$24402 77 1716 1542 1795 1629 1644 109 AOI22_X4
* cell instance $24408 r0 *1 227.05,32.2
X$24408 1539 1642 77 109 1719 NAND2_X1
* cell instance $24411 r0 *1 228.19,32.2
X$24411 578 1540 1718 109 1786 77 OAI21_X1
* cell instance $24413 r0 *1 229.14,32.2
X$24413 1539 1787 77 109 1718 NAND2_X1
* cell instance $24417 r0 *1 231.8,32.2
X$24417 503 1540 1792 109 1788 77 OAI21_X1
* cell instance $24418 r0 *1 232.56,32.2
X$24418 1546 77 109 19258 CLKBUF_X1
* cell instance $24419 r0 *1 233.13,32.2
X$24419 1539 1791 77 109 1792 NAND2_X1
* cell instance $24422 r0 *1 234.84,32.2
X$24422 471 1470 1789 77 109 1874 MUX2_X1
* cell instance $24441 r0 *1 10.07,57.4
X$24441 4193 3594 3680 77 109 3595 MUX2_X1
* cell instance $24442 r0 *1 11.4,57.4
X$24442 77 3596 3598 3680 3595 2157 109 DFFR_X1
* cell instance $24443 m0 *1 14.82,57.4
X$24443 77 3596 3363 3540 3360 2157 109 DFFR_X1
* cell instance $24447 m0 *1 19.57,57.4
X$24447 3597 3479 3598 77 109 3683 MUX2_X1
* cell instance $24449 m0 *1 22.42,57.4
X$24449 3683 3600 3481 77 109 3602 MUX2_X1
* cell instance $24452 r0 *1 15.39,57.4
X$24452 77 3596 3597 3850 3848 2157 109 DFFR_X1
* cell instance $24454 r0 *1 19.38,57.4
X$24454 3597 3041 3598 77 109 3682 MUX2_X1
* cell instance $24456 r0 *1 20.9,57.4
X$24456 3682 3364 3480 77 109 3601 MUX2_X1
* cell instance $24458 r0 *1 22.42,57.4
X$24458 3601 3599 3365 77 109 4200 MUX2_X1
* cell instance $24460 m0 *1 24.32,57.4
X$24460 3602 3482 3366 77 109 3483 MUX2_X1
* cell instance $24464 m0 *1 26.22,57.4
X$24464 2932 3594 3684 77 109 3429 MUX2_X1
* cell instance $24467 m0 *1 28.31,57.4
X$24467 3485 3607 3367 77 109 3685 MUX2_X1
* cell instance $24468 m0 *1 29.64,57.4
X$24468 3485 3603 3367 77 109 3687 MUX2_X1
* cell instance $24469 m0 *1 30.97,57.4
X$24469 3685 3173 3686 77 109 3688 MUX2_X1
* cell instance $24471 r0 *1 26.03,57.4
X$24471 77 3968 3485 3785 3852 2157 109 DFFR_X1
* cell instance $24473 m0 *1 32.87,57.4
X$24473 3687 3370 3544 77 109 3604 MUX2_X1
* cell instance $24476 m0 *1 34.39,57.4
X$24476 3688 3482 3689 77 109 3606 MUX2_X1
* cell instance $24477 m0 *1 35.72,57.4
X$24477 3368 77 109 19100 INV_X2
* cell instance $24478 m0 *1 36.29,57.4
X$24478 2787 3594 3690 77 109 3369 MUX2_X1
* cell instance $24482 r0 *1 34.39,57.4
X$24482 3604 3611 3605 77 109 3855 MUX2_X1
* cell instance $24485 r0 *1 36.67,57.4
X$24485 77 3368 3487 3857 3691 2157 109 DFFR_X1
* cell instance $24486 m0 *1 40.85,57.4
X$24486 3487 3048 3486 77 109 3692 MUX2_X1
* cell instance $24487 m0 *1 39.52,57.4
X$24487 3487 3607 3486 77 109 3431 MUX2_X1
* cell instance $24488 m0 *1 42.18,57.4
X$24488 3488 3482 3374 77 109 4136 MUX2_X1
* cell instance $24489 m0 *1 43.51,57.4
X$24489 3692 3373 3371 77 109 3608 MUX2_X1
* cell instance $24490 m0 *1 44.84,57.4
X$24490 77 2542 3609 3549 3858 2157 109 DFFR_X1
* cell instance $24491 m0 *1 48.64,57.4
X$24491 3376 3549 77 109 3610 NAND2_X1
* cell instance $24497 r0 *1 44.08,57.4
X$24497 3608 3694 3693 77 109 3859 MUX2_X1
* cell instance $24500 r0 *1 46.55,57.4
X$24500 3179 3861 2637 77 109 3862 MUX2_X1
* cell instance $24501 r0 *1 47.88,57.4
X$24501 3179 3607 2637 77 109 3787 MUX2_X1
* cell instance $24502 r0 *1 49.21,57.4
X$24502 3610 3377 2226 109 77 3858 OAI21_X4
* cell instance $24504 m0 *1 50.35,57.4
X$24504 77 3698 3612 3552 3551 2157 109 DFFR_X1
* cell instance $24508 r0 *1 52.82,57.4
X$24508 3619 3788 3697 109 3864 77 OAI21_X1
* cell instance $24509 r0 *1 53.58,57.4
X$24509 77 3698 3789 3790 3699 2157 109 DFFR_X1
* cell instance $24510 m0 *1 56.62,57.4
X$24510 3492 3600 3378 77 109 3493 MUX2_X1
* cell instance $24511 m0 *1 55.29,57.4
X$24511 3181 3479 2639 77 109 3492 MUX2_X1
* cell instance $24514 m0 *1 59.66,57.4
X$24514 77 3618 3615 3704 3702 2157 109 DFFR_X1
* cell instance $24515 m0 *1 63.46,57.4
X$24515 3614 3482 3706 77 109 3616 MUX2_X1
* cell instance $24517 m0 *1 65.55,57.4
X$24517 3707 3791 3554 77 109 4073 MUX2_X1
* cell instance $24519 m0 *1 68.4,57.4
X$24519 3498 109 3106 77 BUF_X4
* cell instance $24520 m0 *1 69.73,57.4
X$24520 2161 3377 3711 109 3556 77 OAI21_X1
* cell instance $24521 m0 *1 70.49,57.4
X$24521 3376 77 109 3377 CLKBUF_X3
* cell instance $24523 m0 *1 71.63,57.4
X$24523 3377 3496 77 109 3711 NAND2_X1
* cell instance $24525 r0 *1 57.38,57.4
X$24525 77 2700 109 3701 BUF_X8
* cell instance $24530 r0 *1 60.61,57.4
X$24530 3619 3793 3703 109 3702 77 OAI21_X1
* cell instance $24532 r0 *1 61.56,57.4
X$24532 3613 3704 77 109 3703 NAND2_X1
* cell instance $24534 r0 *1 62.32,57.4
X$24534 3867 3541 3705 77 109 3614 MUX2_X1
* cell instance $24535 r0 *1 63.65,57.4
X$24535 3615 2938 3617 77 109 3705 MUX2_X1
* cell instance $24536 r0 *1 64.98,57.4
X$24536 3615 3183 3617 77 109 3792 MUX2_X1
* cell instance $24537 r0 *1 66.31,57.4
X$24537 77 3618 3617 3620 3708 2157 109 DFFR_X1
* cell instance $24538 r0 *1 70.11,57.4
X$24538 3709 3620 77 109 3868 NAND2_X1
* cell instance $24540 r0 *1 70.87,57.4
X$24540 3619 3710 3869 109 3870 77 OAI21_X1
* cell instance $24542 r0 *1 71.82,57.4
X$24542 3613 3872 77 109 3869 NAND2_X1
* cell instance $24545 m0 *1 72.58,57.4
X$24545 77 3618 3713 3560 3497 2157 109 DFFR_X1
* cell instance $24547 r0 *1 72.96,57.4
X$24547 3498 109 3603 77 BUF_X4
* cell instance $24549 r0 *1 75.05,57.4
X$24549 77 2415 109 3621 BUF_X8
* cell instance $24550 m0 *1 76.95,57.4
X$24550 3713 3500 2547 77 109 3714 MUX2_X1
* cell instance $24554 r0 *1 77.52,57.4
X$24554 3713 3498 2547 77 109 3796 MUX2_X1
* cell instance $24555 r0 *1 78.85,57.4
X$24555 3714 3622 3501 77 109 3873 MUX2_X1
* cell instance $24558 r0 *1 81.13,57.4
X$24558 2232 3377 3717 109 3797 77 OAI21_X1
* cell instance $24560 m0 *1 81.7,57.4
X$24560 77 3623 3569 3568 3716 1663 109 DFFR_X1
* cell instance $24562 m0 *1 86.45,57.4
X$24562 2615 3500 2643 77 109 3720 MUX2_X1
* cell instance $24563 m0 *1 87.78,57.4
X$24563 2615 3624 2643 77 109 3570 MUX2_X1
* cell instance $24566 r0 *1 81.89,57.4
X$24566 3377 3719 77 109 3717 NAND2_X1
* cell instance $24570 r0 *1 84.93,57.4
X$24570 3502 3624 2948 77 109 3800 MUX2_X1
* cell instance $24571 r0 *1 86.26,57.4
X$24571 3502 3500 2948 77 109 3625 MUX2_X1
* cell instance $24572 r0 *1 87.59,57.4
X$24572 3625 3622 3720 77 109 3875 MUX2_X1
* cell instance $24574 m0 *1 90.44,57.4
X$24574 77 3058 18697 3722 3721 1663 109 DFFR_X1
* cell instance $24577 r0 *1 91.96,57.4
X$24577 3058 77 109 19169 INV_X1
* cell instance $24579 r0 *1 92.53,57.4
X$24579 3907 2552 3722 77 109 3721 MUX2_X1
* cell instance $24581 m0 *1 94.81,57.4
X$24581 3132 3626 3191 77 109 3723 MUX2_X1
* cell instance $24583 m0 *1 96.14,57.4
X$24583 3190 3060 3571 3062 77 109 3728 AOI22_X2
* cell instance $24584 m0 *1 97.85,57.4
X$24584 3727 3388 3059 77 109 3576 NAND3_X1
* cell instance $24586 r0 *1 94.62,57.4
X$24586 3723 2804 3726 77 109 3878 MUX2_X1
* cell instance $24588 r0 *1 96.14,57.4
X$24588 3190 3627 3801 77 109 3726 MUX2_X1
* cell instance $24589 r0 *1 97.47,57.4
X$24589 3801 2952 77 109 3727 NAND2_X1
* cell instance $24590 r0 *1 98.04,57.4
X$24590 3136 3727 3728 3295 3449 3877 77 109 OAI221_X2
* cell instance $24591 m0 *1 99.75,57.4
X$24591 2808 77 109 2952 CLKBUF_X3
* cell instance $24592 m0 *1 98.99,57.4
X$24592 3136 3503 3576 109 3580 77 OAI21_X1
* cell instance $24594 r0 *1 100.13,57.4
X$24594 3628 77 109 2804 CLKBUF_X3
* cell instance $24595 r0 *1 101.08,57.4
X$24595 3626 77 109 2650 CLKBUF_X3
* cell instance $24597 m0 *1 101.08,57.4
X$24597 3628 77 109 3016 CLKBUF_X3
* cell instance $24601 r0 *1 102.6,57.4
X$24601 3581 109 3456 77 BUF_X4
* cell instance $24602 m0 *1 105.26,57.4
X$24602 3582 3387 2291 77 3731 109 AOI21_X1
* cell instance $24603 m0 *1 103.17,57.4
X$24603 2554 79 3581 3628 3582 3193 109 77 AOI221_X2
* cell instance $24604 m0 *1 106.02,57.4
X$24604 3059 3731 3733 109 3584 77 OAI21_X1
* cell instance $24605 m0 *1 106.78,57.4
X$24605 3504 3016 77 109 3733 NAND2_X1
* cell instance $24606 m0 *1 107.35,57.4
X$24606 3456 2744 3505 3389 77 109 4085 AOI22_X2
* cell instance $24607 m0 *1 109.06,57.4
X$24607 3628 77 109 2656 CLKBUF_X3
* cell instance $24608 m0 *1 110.01,57.4
X$24608 2647 3506 3507 77 3809 109 AOI21_X2
* cell instance $24611 r0 *1 103.93,57.4
X$24611 3626 77 109 2655 CLKBUF_X3
* cell instance $24612 r0 *1 104.88,57.4
X$24612 2650 2806 3804 77 3629 109 AOI21_X1
* cell instance $24613 r0 *1 105.64,57.4
X$24613 3629 3806 3062 3732 109 77 3807 OAI22_X1
* cell instance $24614 r0 *1 106.59,57.4
X$24614 3734 3808 2650 3803 77 109 3732 AOI22_X1
* cell instance $24616 r0 *1 107.92,57.4
X$24616 3805 2655 77 109 3734 NOR2_X1
* cell instance $24619 r0 *1 110.2,57.4
X$24619 3805 77 109 3389 CLKBUF_X3
* cell instance $24621 m0 *1 112.67,57.4
X$24621 77 3738 3460 3737 3739 109 DFF_X1
* cell instance $24623 m0 *1 115.9,57.4
X$24623 77 3742 3461 3508 3739 109 DFF_X1
* cell instance $24625 m0 *1 119.32,57.4
X$24625 77 3746 3743 3509 3510 109 DFF_X1
* cell instance $24626 m0 *1 122.55,57.4
X$24626 77 3748 3465 3749 3510 109 DFF_X1
* cell instance $24634 r0 *1 115.71,57.4
X$24634 3810 109 3916 77 BUF_X4
* cell instance $24636 r0 *1 117.23,57.4
X$24636 3811 3630 3463 77 109 3883 MUX2_X1
* cell instance $24638 r0 *1 119.32,57.4
X$24638 3812 3742 3632 109 77 3744 MUX2_X2
* cell instance $24640 r0 *1 121.22,57.4
X$24640 3815 3630 2511 77 109 3814 MUX2_X1
* cell instance $24644 r0 *1 123.88,57.4
X$24644 3631 3813 2767 77 109 4023 MUX2_X1
* cell instance $24646 r0 *1 125.59,57.4
X$24646 3634 3630 3066 77 109 3633 MUX2_X1
* cell instance $24647 r0 *1 126.92,57.4
X$24647 77 18413 3752 3633 3510 109 DFF_X1
* cell instance $24648 r0 *1 130.15,57.4
X$24648 3752 77 109 3634 BUF_X2
* cell instance $24650 m0 *1 130.72,57.4
X$24650 77 18381 3635 3511 2343 109 DFF_X1
* cell instance $24651 m0 *1 134.71,57.4
X$24651 77 3817 3758 3757 3325 109 DFF_X1
* cell instance $24657 r0 *1 133.76,57.4
X$24657 3636 3322 3632 109 77 3759 MUX2_X2
* cell instance $24659 r0 *1 136.23,57.4
X$24659 2900 109 3630 77 BUF_X4
* cell instance $24660 r0 *1 137.56,57.4
X$24660 3637 3630 1906 77 109 3638 MUX2_X1
* cell instance $24661 m0 *1 141.55,57.4
X$24661 77 3325 3762 1146 3211 3395 109 DFFR_X2
* cell instance $24662 m0 *1 138.32,57.4
X$24662 77 18306 3639 3638 3325 109 DFF_X1
* cell instance $24664 m0 *1 145.92,57.4
X$24664 3590 3591 3211 77 109 3514 NAND3_X2
* cell instance $24666 r0 *1 138.89,57.4
X$24666 2430 77 109 3325 CLKBUF_X3
* cell instance $24667 r0 *1 139.84,57.4
X$24667 3325 77 109 19267 CLKBUF_X1
* cell instance $24669 r0 *1 141.17,57.4
X$24669 3639 109 3637 77 BUF_X4
* cell instance $24672 r0 *1 143.07,57.4
X$24672 3210 109 2526 77 BUF_X4
* cell instance $24673 r0 *1 144.4,57.4
X$24673 3763 77 109 3820 INV_X1
* cell instance $24674 r0 *1 144.78,57.4
X$24674 77 3818 3764 1146 3513 3821 109 DFFR_X2
* cell instance $24675 m0 *1 148.39,57.4
X$24675 3514 77 109 3765 INV_X1
* cell instance $24676 m0 *1 147.63,57.4
X$24676 3512 3513 3514 77 3764 109 AOI21_X1
* cell instance $24680 m0 *1 153.52,57.4
X$24680 77 3642 3515 3643 3641 1705 109 NAND4_X4
* cell instance $24682 m0 *1 157.13,57.4
X$24682 3643 3641 3642 3515 109 77 3398 AND4_X1
* cell instance $24685 r0 *1 148.96,57.4
X$24685 3765 3513 77 3884 109 NAND2_X4
* cell instance $24687 r0 *1 150.86,57.4
X$24687 3640 3922 19069 109 77 4040 HA_X1
* cell instance $24690 r0 *1 153.33,57.4
X$24690 3640 3823 19064 109 77 3644 HA_X1
* cell instance $24691 r0 *1 155.23,57.4
X$24691 77 779 3766 3882 3641 3643 109 OR4_X4
* cell instance $24692 r0 *1 157.7,57.4
X$24692 3644 109 3646 77 BUF_X4
* cell instance $24693 r0 *1 159.03,57.4
X$24693 3644 77 109 3826 INV_X2
* cell instance $24694 m0 *1 161.31,57.4
X$24694 3650 3644 77 109 3589 NOR2_X1
* cell instance $24695 m0 *1 159.41,57.4
X$24695 3645 3586 3643 109 77 3769 HA_X1
* cell instance $24696 m0 *1 161.88,57.4
X$24696 3769 3519 3646 3516 109 3827 77 OR4_X2
* cell instance $24698 m0 *1 163.4,57.4
X$24698 3770 3656 3517 77 3771 109 AOI21_X2
* cell instance $24699 m0 *1 164.73,57.4
X$24699 3517 3648 77 109 3774 NAND2_X1
* cell instance $24700 m0 *1 165.3,57.4
X$24700 3649 3588 77 109 3476 NOR2_X2
* cell instance $24701 m0 *1 166.25,57.4
X$24701 3651 3773 3652 109 3588 77 OAI21_X1
* cell instance $24702 m0 *1 167.01,57.4
X$24702 3774 3652 77 109 3770 NAND2_X1
* cell instance $24704 m0 *1 167.77,57.4
X$24704 77 3475 3655 3778 3780 3880 109 NOR4_X4
* cell instance $24705 m0 *1 171.19,57.4
X$24705 3646 3648 3656 109 77 3518 OAI21_X2
* cell instance $24707 m0 *1 173.28,57.4
X$24707 3519 3656 3647 109 77 3524 OAI21_X4
* cell instance $24708 m0 *1 175.75,57.4
X$24708 3518 3660 77 109 3525 NOR2_X2
* cell instance $24709 m0 *1 176.7,57.4
X$24709 1733 3220 77 109 3521 NOR2_X1
* cell instance $24710 m0 *1 177.27,57.4
X$24710 3521 3575 3299 77 109 3577 OR3_X4
* cell instance $24711 m0 *1 179.36,57.4
X$24711 77 3404 18679 3659 3768 1146 109 DFFR_X1
* cell instance $24712 m0 *1 183.16,57.4
X$24712 3406 3659 77 109 3767 NAND2_X1
* cell instance $24713 m0 *1 183.73,57.4
X$24713 625 3406 3767 109 3768 77 OAI21_X1
* cell instance $24715 m0 *1 184.68,57.4
X$24715 3524 3660 3527 77 109 NOR2_X4
* cell instance $24717 m0 *1 186.58,57.4
X$24717 115 2844 3661 2838 3663 77 109 3662 AOI221_X1
* cell instance $24718 m0 *1 187.72,57.4
X$24718 3352 77 109 3663 INV_X1
* cell instance $24721 r0 *1 159.6,57.4
X$24721 3926 3647 77 109 3645 NOR2_X1
* cell instance $24723 r0 *1 160.55,57.4
X$24723 3401 4048 77 109 3218 OR2_X2
* cell instance $24725 r0 *1 161.88,57.4
X$24725 3824 3775 3647 109 77 3654 OAI21_X4
* cell instance $24726 r0 *1 164.35,57.4
X$24726 3881 3651 77 109 3772 NAND2_X1
* cell instance $24727 r0 *1 164.92,57.4
X$24727 3650 3646 3773 3651 3653 3221 77 109 OAI221_X2
* cell instance $24728 r0 *1 167.01,57.4
X$24728 3775 109 3656 77 BUF_X4
* cell instance $24729 r0 *1 168.34,57.4
X$24729 3934 3776 109 77 3828 AND2_X1
* cell instance $24730 r0 *1 169.1,57.4
X$24730 3654 77 109 3586 INV_X1
* cell instance $24732 r0 *1 169.67,57.4
X$24732 3779 3658 3518 77 3778 109 AOI21_X2
* cell instance $24733 r0 *1 171,57.4
X$24733 3516 3648 3656 109 77 3830 OAI21_X2
* cell instance $24738 r0 *1 173.09,57.4
X$24738 3648 3656 77 109 3777 NOR2_X1
* cell instance $24739 r0 *1 173.66,57.4
X$24739 77 3826 3777 3657 3664 109 NOR3_X4
* cell instance $24742 r0 *1 178.03,57.4
X$24742 3876 3658 3537 77 109 NOR2_X4
* cell instance $24743 r0 *1 179.74,57.4
X$24743 3779 3658 3422 77 109 NOR2_X4
* cell instance $24744 r0 *1 181.45,57.4
X$24744 3657 3658 3415 77 109 NOR2_X4
* cell instance $24745 r0 *1 183.16,57.4
X$24745 3659 77 109 3833 INV_X1
* cell instance $24747 r0 *1 183.92,57.4
X$24747 3830 3660 3546 77 109 NOR2_X4
* cell instance $24749 r0 *1 185.82,57.4
X$24749 3657 3524 77 109 3409 NOR2_X2
* cell instance $24750 r0 *1 186.77,57.4
X$24750 3524 3834 2253 3761 109 77 3661 OAI22_X1
* cell instance $24751 r0 *1 187.72,57.4
X$24751 3836 3871 3760 3662 109 77 3021 AND4_X1
* cell instance $24752 r0 *1 188.86,57.4
X$24752 77 2447 18717 3838 3754 1146 109 DFFR_X1
* cell instance $24753 m0 *1 189.43,57.4
X$24753 3837 3755 4551 3527 77 109 3751 AOI22_X1
* cell instance $24759 r0 *1 193.23,57.4
X$24759 3747 3536 3535 3664 3838 77 109 3526 AOI221_X1
* cell instance $24761 m0 *1 193.8,57.4
X$24761 3526 3567 3751 3750 109 77 3345 AND4_X1
* cell instance $24763 r0 *1 194.75,57.4
X$24763 3839 2585 3740 77 109 3665 MUX2_X1
* cell instance $24765 m0 *1 195.32,57.4
X$24765 3741 3409 1780 3546 77 109 3750 AOI22_X1
* cell instance $24766 r0 *1 196.08,57.4
X$24766 77 3411 18798 3740 3665 1146 109 DFFR_X1
* cell instance $24767 m0 *1 196.84,57.4
X$24767 625 2728 3745 109 3528 77 OAI21_X1
* cell instance $24770 m0 *1 197.79,57.4
X$24770 77 749 3525 3564 3666 3409 3740 3664 109 AOI222_X2
* cell instance $24772 r0 *1 199.88,57.4
X$24772 3667 3664 3527 3736 77 109 3735 AOI22_X2
* cell instance $24773 m0 *1 201.02,57.4
X$24773 3563 3712 3715 3735 77 3468 109 NAND4_X2
* cell instance $24778 r0 *1 202.73,57.4
X$24778 4015 2585 3669 77 109 3668 MUX2_X1
* cell instance $24779 m0 *1 205.77,57.4
X$24779 3730 2585 3553 77 109 3729 MUX2_X1
* cell instance $24780 m0 *1 203.11,57.4
X$24780 77 2847 1985 3405 3446 2984 3672 3422 109 AOI222_X2
* cell instance $24781 m0 *1 207.1,57.4
X$24781 77 2360 18518 3553 3729 992 109 DFFR_X1
* cell instance $24784 r0 *1 204.25,57.4
X$24784 77 3411 18810 3669 3668 992 109 DFFR_X1
* cell instance $24785 r0 *1 208.05,57.4
X$24785 2984 3669 77 109 3866 NAND2_X1
* cell instance $24789 r0 *1 210.71,57.4
X$24789 3670 2258 3671 77 109 3725 MUX2_X1
* cell instance $24790 m0 *1 211.47,57.4
X$24790 484 77 109 3670 INV_X1
* cell instance $24793 m0 *1 212.61,57.4
X$24793 3670 1722 3530 77 109 3439 MUX2_X1
* cell instance $24795 r0 *1 212.04,57.4
X$24795 77 3440 18749 3671 3725 992 109 DFFR_X1
* cell instance $24796 m0 *1 216.03,57.4
X$24796 77 3440 18554 3414 3534 992 109 DFFR_X1
* cell instance $24797 m0 *1 214.32,57.4
X$24797 1628 3531 3527 3724 77 109 3532 AOI22_X2
* cell instance $24801 r0 *1 219.07,57.4
X$24801 3989 3531 3527 3718 77 109 3235 AOI22_X2
* cell instance $24802 m0 *1 220.4,57.4
X$24802 3537 1220 3535 3536 2874 3712 109 77 AOI221_X2
* cell instance $24804 m0 *1 222.49,57.4
X$24804 77 3672 1881 3547 1220 2689 109 AOI22_X4
* cell instance $24805 m0 *1 225.72,57.4
X$24805 3098 3418 3417 3416 109 77 3673 AND4_X2
* cell instance $24807 r0 *1 220.78,57.4
X$24807 3531 3236 4559 3415 2689 3715 109 77 AOI221_X2
* cell instance $24808 r0 *1 222.87,57.4
X$24808 3546 1871 4268 3537 2122 3285 109 77 AOI221_X2
* cell instance $24809 r0 *1 224.96,57.4
X$24809 3673 1220 2689 77 109 3957 NAND3_X2
* cell instance $24810 r0 *1 226.29,57.4
X$24810 3418 3098 77 109 3842 NAND2_X1
* cell instance $24811 r0 *1 226.86,57.4
X$24811 1543 2983 109 77 3856 AND2_X1
* cell instance $24815 m0 *1 227.62,57.4
X$24815 3419 3118 1543 77 109 3538 NAND3_X1
* cell instance $24818 m0 *1 228.57,57.4
X$24818 3553 2984 2852 3422 77 109 3543 AOI22_X1
* cell instance $24819 m0 *1 229.52,57.4
X$24819 77 3675 18501 3268 3696 3676 109 DFFR_X1
* cell instance $24820 m0 *1 233.32,57.4
X$24820 3422 109 2453 77 BUF_X4
* cell instance $24822 r0 *1 227.62,57.4
X$24822 3700 3094 3427 2453 77 109 2491 AOI22_X1
* cell instance $24823 r0 *1 228.57,57.4
X$24823 3854 3242 2588 77 3696 109 AOI21_X1
* cell instance $24824 r0 *1 229.33,57.4
X$24824 3695 3233 2052 2978 77 109 3853 AOI22_X1
* cell instance $24825 r0 *1 230.28,57.4
X$24825 77 992 3676 109 BUF_X32
* cell instance $24826 m0 *1 235.79,57.4
X$24826 77 3677 18500 3425 3681 992 109 DFFR_X1
* cell instance $24827 m0 *1 235.03,57.4
X$24827 3679 77 109 3672 BUF_X2
* cell instance $24870 m0 *1 90.82,37.8
X$24870 77 18309 1931 1967 1487 109 DFF_X1
* cell instance $24874 m0 *1 95,37.8
X$24874 1932 418 2010 77 109 1876 MUX2_X1
* cell instance $24879 r0 *1 93.86,37.8
X$24879 248 216 1931 77 109 2010 MUX2_X1
* cell instance $24881 m0 *1 96.9,37.8
X$24881 248 352 1932 77 109 1969 MUX2_X1
* cell instance $24885 m0 *1 101.46,37.8
X$24885 77 18310 1748 1878 1682 109 DFF_X1
* cell instance $24886 m0 *1 104.69,37.8
X$24886 409 77 109 1682 CLKBUF_X3
* cell instance $24887 m0 *1 105.64,37.8
X$24887 1682 77 109 19106 INV_X2
* cell instance $24889 m0 *1 106.97,37.8
X$24889 1341 1767 1227 77 109 1972 MUX2_X1
* cell instance $24890 m0 *1 108.3,37.8
X$24890 1972 2012 2011 77 109 1973 NAND3_X1
* cell instance $24893 r0 *1 101.46,37.8
X$24893 77 1682 18772 2091 2053 1663 109 DFFR_X1
* cell instance $24896 r0 *1 108.68,37.8
X$24896 1832 2105 77 109 1934 NOR2_X1
* cell instance $24898 m0 *1 110.39,37.8
X$24898 1974 1976 77 109 2014 NOR2_X1
* cell instance $24899 m0 *1 109.44,37.8
X$24899 1830 77 109 2012 CLKBUF_X3
* cell instance $24901 m0 *1 111.15,37.8
X$24901 1935 2056 77 109 1976 NOR2_X1
* cell instance $24902 m0 *1 111.72,37.8
X$24902 1579 1586 1833 77 2056 109 AOI21_X1
* cell instance $24903 m0 *1 112.48,37.8
X$24903 1979 2016 1830 77 109 1981 NAND3_X1
* cell instance $24905 m0 *1 113.43,37.8
X$24905 2011 2012 1831 1983 77 109 1984 AOI22_X2
* cell instance $24907 m0 *1 115.33,37.8
X$24907 1751 109 1938 77 BUF_X4
* cell instance $24908 m0 *1 116.66,37.8
X$24908 1936 1494 77 109 2061 NOR2_X1
* cell instance $24912 r0 *1 110.58,37.8
X$24912 2093 2092 2014 77 2013 109 AOI21_X1
* cell instance $24913 r0 *1 111.34,37.8
X$24913 2095 2058 1751 109 2015 77 OAI21_X1
* cell instance $24914 r0 *1 112.1,37.8
X$24914 2015 2014 77 109 2094 NAND2_X1
* cell instance $24916 r0 *1 112.86,37.8
X$24916 2018 2096 77 109 2097 NOR2_X1
* cell instance $24917 r0 *1 113.43,37.8
X$24917 1435 1431 2011 77 109 NOR2_X4
* cell instance $24921 r0 *1 115.14,37.8
X$24921 1435 1554 77 109 2099 NAND2_X2
* cell instance $24922 r0 *1 116.09,37.8
X$24922 1751 2099 77 109 2137 NAND2_X2
* cell instance $24924 r0 *1 117.42,37.8
X$24924 1494 2101 2061 1581 2017 2134 77 109 OAI221_X2
* cell instance $24925 m0 *1 118.37,37.8
X$24925 1759 1829 77 109 2170 NOR2_X1
* cell instance $24926 m0 *1 117.61,37.8
X$24926 1579 1503 1494 77 2063 109 AOI21_X1
* cell instance $24928 m0 *1 119.51,37.8
X$24928 1554 1694 1835 109 2017 77 OAI21_X1
* cell instance $24932 r0 *1 119.89,37.8
X$24932 1435 1431 77 109 2101 NAND2_X2
* cell instance $24933 m0 *1 121.22,37.8
X$24933 1992 77 109 2018 INV_X1
* cell instance $24934 m0 *1 120.65,37.8
X$24934 1392 1577 77 109 1992 NAND2_X1
* cell instance $24935 m0 *1 121.6,37.8
X$24935 1310 1577 1388 109 2065 77 OAI21_X1
* cell instance $24936 m0 *1 122.36,37.8
X$24936 1991 1694 77 109 2019 NOR2_X1
* cell instance $24938 m0 *1 123.12,37.8
X$24938 1992 1751 77 109 2066 NAND2_X1
* cell instance $24939 m0 *1 123.69,37.8
X$24939 1994 1499 1577 77 109 2069 NAND3_X1
* cell instance $24940 m0 *1 124.45,37.8
X$24940 1694 1994 1587 109 2020 77 OAI21_X1
* cell instance $24941 m0 *1 125.21,37.8
X$24941 1436 77 109 1995 CLKBUF_X3
* cell instance $24943 m0 *1 126.35,37.8
X$24943 1582 1496 1938 1939 1839 109 77 1997 OAI221_X1
* cell instance $24945 m0 *1 127.68,37.8
X$24945 1591 1831 77 109 1999 NOR2_X1
* cell instance $24949 r0 *1 121.22,37.8
X$24949 1584 2065 2018 1344 1765 2211 109 77 AOI221_X2
* cell instance $24950 r0 *1 123.31,37.8
X$24950 1765 1440 2066 2021 1499 2141 109 77 AOI221_X2
* cell instance $24951 r0 *1 125.4,37.8
X$24951 1841 2020 2022 77 2104 109 AOI21_X1
* cell instance $24952 r0 *1 126.16,37.8
X$24952 1695 1694 1494 77 109 2071 MUX2_X1
* cell instance $24953 r0 *1 127.49,37.8
X$24953 2024 2105 1591 77 2023 109 AOI21_X1
* cell instance $24954 r0 *1 128.25,37.8
X$24954 2025 2071 1554 77 2024 109 AOI21_X1
* cell instance $24956 m0 *1 128.63,37.8
X$24956 1939 1899 1766 2002 1938 2075 77 109 OAI221_X2
* cell instance $24957 m0 *1 130.91,37.8
X$24957 1814 1841 1983 77 109 NOR2_X4
* cell instance $24960 r0 *1 129.01,37.8
X$24960 2026 1589 2101 77 2027 109 AOI21_X1
* cell instance $24961 r0 *1 129.77,37.8
X$24961 2027 2244 1400 109 2143 77 OAI21_X1
* cell instance $24963 r0 *1 130.72,37.8
X$24963 1814 77 109 2022 CLKBUF_X3
* cell instance $24966 r0 *1 132.62,37.8
X$24966 77 1819 2029 1940 2078 1663 109 DFFR_X1
* cell instance $24967 m0 *1 136.23,37.8
X$24967 885 77 109 1941 INV_X2
* cell instance $24969 m0 *1 136.8,37.8
X$24969 77 1941 216 1942 332 109 NOR3_X4
* cell instance $24971 m0 *1 140.98,37.8
X$24971 77 1844 2005 1663 2030 1768 109 DFFR_X2
* cell instance $24973 m0 *1 145.35,37.8
X$24973 1768 1447 1944 77 109 2005 MUX2_X1
* cell instance $24974 m0 *1 146.68,37.8
X$24974 345 77 109 1507 CLKBUF_X3
* cell instance $24975 m0 *1 147.63,37.8
X$24975 1156 1179 2007 109 1944 77 OAI21_X1
* cell instance $24976 m0 *1 148.39,37.8
X$24976 458 2030 77 109 2007 NAND2_X1
* cell instance $24978 r0 *1 136.42,37.8
X$24978 2106 1941 959 77 109 2107 NAND3_X2
* cell instance $24979 r0 *1 137.75,37.8
X$24979 2028 2108 2077 77 109 1843 MUX2_X1
* cell instance $24980 r0 *1 139.08,37.8
X$24980 1942 959 77 109 2077 NOR2_X1
* cell instance $24983 r0 *1 143.07,37.8
X$24983 77 1507 18882 2083 1949 1663 109 DFFR_X1
* cell instance $24984 r0 *1 146.87,37.8
X$24984 1507 77 109 19308 CLKBUF_X1
* cell instance $24987 r0 *1 148.58,37.8
X$24987 2081 2082 77 109 2147 NOR2_X1
* cell instance $24990 m0 *1 149.34,37.8
X$24990 1945 501 77 109 2031 NAND2_X1
* cell instance $24991 m0 *1 150.1,37.8
X$24991 1186 1946 1015 77 2081 109 AOI21_X1
* cell instance $24992 m0 *1 150.86,37.8
X$24992 1943 77 109 1771 INV_X1
* cell instance $24994 m0 *1 152,37.8
X$24994 1186 1947 703 77 2084 109 AOI21_X1
* cell instance $24995 m0 *1 152.76,37.8
X$24995 1849 1948 1185 77 2085 109 AOI21_X1
* cell instance $24996 m0 *1 153.52,37.8
X$24996 1454 1849 1851 77 109 2009 NAND3_X1
* cell instance $24997 m0 *1 154.28,37.8
X$24997 2009 373 77 109 2033 NAND2_X1
* cell instance $25000 r0 *1 149.34,37.8
X$25000 1943 2031 1275 77 2082 109 AOI21_X1
* cell instance $25003 r0 *1 150.67,37.8
X$25003 2083 77 109 1851 CLKBUF_X2
* cell instance $25006 r0 *1 152,37.8
X$25006 2085 2084 77 109 2148 NOR2_X1
* cell instance $25008 r0 *1 153.33,37.8
X$25008 2032 1275 2086 77 2218 109 AOI21_X1
* cell instance $25009 r0 *1 154.09,37.8
X$25009 2034 2033 1447 77 2032 109 AOI21_X1
* cell instance $25011 r0 *1 155.04,37.8
X$25011 2034 1849 1851 77 109 1854 NAND3_X1
* cell instance $25013 m0 *1 156.18,37.8
X$25013 1950 373 77 109 2036 NAND2_X1
* cell instance $25015 m0 *1 156.75,37.8
X$25015 1855 1058 1950 77 109 2008 OR3_X1
* cell instance $25016 m0 *1 157.7,37.8
X$25016 2037 77 109 1855 INV_X1
* cell instance $25018 r0 *1 156.18,37.8
X$25018 2088 1275 2035 77 2153 109 AOI21_X1
* cell instance $25020 r0 *1 157.32,37.8
X$25020 2037 2036 1447 77 2088 109 AOI21_X1
* cell instance $25037 m0 *1 76,40.6
X$25037 2125 2089 77 109 2199 NAND2_X1
* cell instance $25059 r0 *1 49.59,40.6
X$25059 2158 2155 2196 109 2195 77 OAI21_X1
* cell instance $25062 r0 *1 50.92,40.6
X$25062 2156 2266 77 109 2196 NAND2_X1
* cell instance $25064 r0 *1 51.87,40.6
X$25064 2222 2155 2269 109 2267 77 OAI21_X1
* cell instance $25068 r0 *1 55.1,40.6
X$25068 77 2220 2372 2223 2270 2157 109 DFFR_X1
* cell instance $25073 r0 *1 59.28,40.6
X$25073 2158 2159 2197 109 2271 77 OAI21_X1
* cell instance $25076 r0 *1 60.61,40.6
X$25076 2125 2272 77 109 2197 NAND2_X1
* cell instance $25080 r0 *1 63.27,40.6
X$25080 2198 2159 2226 109 77 2273 OAI21_X4
* cell instance $25081 r0 *1 65.74,40.6
X$25081 2125 2274 77 109 2198 NAND2_X1
* cell instance $25084 r0 *1 66.88,40.6
X$25084 2161 2159 2160 109 2275 77 OAI21_X1
* cell instance $25086 r0 *1 67.83,40.6
X$25086 2159 2227 77 109 2160 NAND2_X1
* cell instance $25088 r0 *1 69.16,40.6
X$25088 2161 2155 2162 109 2278 77 OAI21_X1
* cell instance $25091 r0 *1 70.49,40.6
X$25091 2155 2277 77 109 2162 NAND2_X1
* cell instance $25093 r0 *1 71.82,40.6
X$25093 2156 77 109 2155 CLKBUF_X3
* cell instance $25097 r0 *1 74.86,40.6
X$25097 2199 2159 2548 109 77 2281 OAI21_X4
* cell instance $25098 r0 *1 77.33,40.6
X$25098 77 2378 2163 2230 2377 2157 109 DFFR_X1
* cell instance $25103 r0 *1 93.86,40.6
X$25103 77 2234 18752 2287 2200 1663 109 DFFR_X1
* cell instance $25104 m0 *1 94.62,40.6
X$25104 112 2090 2287 77 109 2200 MUX2_X1
* cell instance $25108 m0 *1 97.66,40.6
X$25108 77 2234 18682 2164 2127 1663 109 DFFR_X1
* cell instance $25110 m0 *1 102.22,40.6
X$25110 325 2090 2091 77 109 2053 MUX2_X1
* cell instance $25115 r0 *1 100.7,40.6
X$25115 84 2090 2164 77 109 2127 MUX2_X1
* cell instance $25118 r0 *1 103.74,40.6
X$25118 77 1682 18773 2291 2289 1663 109 DFFR_X1
* cell instance $25120 m0 *1 107.92,40.6
X$25120 2011 1695 2025 2093 2166 1832 109 77 AOI221_X2
* cell instance $25123 m0 *1 110.2,40.6
X$25123 1227 77 109 2166 INV_X1
* cell instance $25124 m0 *1 110.58,40.6
X$25124 2092 77 109 2095 INV_X1
* cell instance $25126 r0 *1 108.3,40.6
X$25126 2303 880 2093 1124 77 109 2165 AOI22_X2
* cell instance $25129 r0 *1 110.58,40.6
X$25129 1586 2013 2094 109 2237 77 OAI21_X1
* cell instance $25130 r0 *1 111.34,40.6
X$25130 1981 2297 2206 2166 77 109 2204 AOI22_X2
* cell instance $25131 m0 *1 113.43,40.6
X$25131 2097 2168 1981 2169 77 109 2207 NAND4_X1
* cell instance $25132 m0 *1 111.34,40.6
X$25132 2167 1390 2096 1169 1392 2092 109 77 AOI221_X2
* cell instance $25133 m0 *1 114.38,40.6
X$25133 2098 1936 1388 2093 77 109 2133 AOI22_X1
* cell instance $25134 m0 *1 115.33,40.6
X$25134 2133 2025 77 109 2100 NOR2_X1
* cell instance $25135 m0 *1 115.9,40.6
X$25135 1936 2105 2100 2134 1938 2208 109 77 AOI221_X2
* cell instance $25136 m0 *1 117.99,40.6
X$25136 1765 1400 77 109 2168 NAND2_X1
* cell instance $25139 r0 *1 113.24,40.6
X$25139 2097 2168 2169 77 109 2238 NAND3_X1
* cell instance $25140 r0 *1 114,40.6
X$25140 2207 2099 77 109 2206 NAND2_X1
* cell instance $25142 r0 *1 114.76,40.6
X$25142 1481 1589 2096 77 109 NOR2_X4
* cell instance $25147 r0 *1 117.23,40.6
X$25147 77 1837 2105 1983 2098 109 AOI21_X4
* cell instance $25148 m0 *1 119.13,40.6
X$25148 1392 1765 77 109 2240 NOR2_X1
* cell instance $25150 m0 *1 119.7,40.6
X$25150 1938 2102 77 1829 109 NAND2_X4
* cell instance $25151 m0 *1 121.41,40.6
X$25151 2093 1396 77 109 2102 NAND2_X2
* cell instance $25153 r0 *1 119.7,40.6
X$25153 1496 1937 1835 2209 77 109 2241 NOR4_X1
* cell instance $25156 r0 *1 121.22,40.6
X$25156 2012 2301 2102 77 109 2242 NAND3_X1
* cell instance $25157 r0 *1 121.98,40.6
X$25157 1757 1767 2209 2212 1737 109 77 2301 OAI221_X1
* cell instance $25159 m0 *1 122.74,40.6
X$25159 2102 1737 1762 77 109 2171 NOR3_X1
* cell instance $25160 r0 *1 123.12,40.6
X$25160 2171 2303 77 109 2302 NOR2_X1
* cell instance $25162 m0 *1 124.07,40.6
X$25162 2022 2101 1436 77 2103 109 AOI21_X1
* cell instance $25165 m0 *1 125.02,40.6
X$25165 2103 2104 77 109 2172 NOR2_X1
* cell instance $25167 r0 *1 123.88,40.6
X$25167 1937 1481 77 109 2304 NOR2_X1
* cell instance $25169 r0 *1 124.64,40.6
X$25169 1436 2304 1396 77 2212 109 AOI21_X1
* cell instance $25170 r0 *1 125.4,40.6
X$25170 1431 1841 77 109 2173 NOR2_X2
* cell instance $25171 m0 *1 126.16,40.6
X$25171 2137 1896 2023 1999 2143 2142 77 109 OAI221_X2
* cell instance $25173 m0 *1 128.25,40.6
X$25173 1651 1841 77 2026 109 NAND2_X4
* cell instance $25175 r0 *1 126.35,40.6
X$25175 2169 2026 77 109 2243 NOR2_X1
* cell instance $25176 r0 *1 126.92,40.6
X$25176 2173 1651 2105 77 109 NOR2_X4
* cell instance $25177 r0 *1 128.63,40.6
X$25177 2245 2215 2075 2306 77 2213 109 NAND4_X2
* cell instance $25180 m0 *1 130.34,40.6
X$25180 1651 1901 77 2025 109 NAND2_X4
* cell instance $25182 r0 *1 130.72,40.6
X$25182 2303 1312 109 77 2246 AND2_X1
* cell instance $25184 r0 *1 133,40.6
X$25184 77 1844 2217 1663 2216 1174 109 DFFR_X2
* cell instance $25186 m0 *1 133.19,40.6
X$25186 1654 881 77 109 2174 NAND2_X2
* cell instance $25188 m0 *1 136.23,40.6
X$25188 2107 2216 77 109 2028 NAND2_X1
* cell instance $25190 m0 *1 136.8,40.6
X$25190 77 418 2315 2108 2107 109 AOI21_X4
* cell instance $25194 m0 *1 144.02,40.6
X$25194 77 1844 1850 1663 18957 1847 109 DFFR_X2
* cell instance $25195 m0 *1 148.2,40.6
X$25195 77 1507 18544 2150 2148 1663 109 DFFR_X1
* cell instance $25196 m0 *1 152,40.6
X$25196 2150 77 109 1849 CLKBUF_X2
* cell instance $25200 r0 *1 137.37,40.6
X$25200 2216 2029 1942 109 77 2319 OAI21_X2
* cell instance $25201 r0 *1 138.7,40.6
X$25201 2029 1942 109 77 2346 AND2_X1
* cell instance $25203 r0 *1 139.65,40.6
X$25203 2108 2028 77 109 2247 OR2_X1
* cell instance $25208 r0 *1 143.26,40.6
X$25208 77 1844 2147 1663 18980 1943 109 DFFR_X2
* cell instance $25211 r0 *1 150.86,40.6
X$25211 77 1507 18733 2034 2218 1663 109 DFFR_X1
* cell instance $25213 m0 *1 154.66,40.6
X$25213 77 2109 18587 2037 2153 1663 109 DFFR_X1
* cell instance $25216 r0 *1 156.37,40.6
X$25216 1776 77 109 1418 CLKBUF_X3
* cell instance $25218 r0 *1 157.51,40.6
X$25218 1158 1622 77 109 2311 NOR2_X1
* cell instance $25221 m0 *1 158.84,40.6
X$25221 1418 77 109 1863 CLKBUF_X3
* cell instance $25222 m0 *1 160.55,40.6
X$25222 2154 608 609 1700 77 109 2178 AOI22_X2
* cell instance $25223 m0 *1 162.26,40.6
X$25223 77 2109 2038 1663 18953 1954 109 DFFR_X2
* cell instance $25224 m0 *1 166.44,40.6
X$25224 2110 778 77 109 1058 NOR2_X2
* cell instance $25225 m0 *1 167.39,40.6
X$25225 2151 2177 2110 109 77 895 OAI21_X2
* cell instance $25231 r0 *1 160.93,40.6
X$25231 2175 608 609 1851 77 109 2310 AOI22_X2
* cell instance $25233 r0 *1 163.4,40.6
X$25233 2349 733 1847 737 77 109 2176 AOI22_X1
* cell instance $25234 r0 *1 164.35,40.6
X$25234 2249 733 737 2034 77 109 2308 AOI22_X2
* cell instance $25238 r0 *1 167.39,40.6
X$25238 2177 1273 2219 77 109 2152 MUX2_X1
* cell instance $25239 r0 *1 168.72,40.6
X$25239 2110 2114 2219 109 2151 77 OAI21_X1
* cell instance $25255 r0 *1 16.53,51.8
X$25255 77 2930 3168 3245 3247 2157 109 DFFR_X1
* cell instance $25256 m0 *1 21.47,51.8
X$25256 3101 77 109 2930 CLKBUF_X3
* cell instance $25257 m0 *1 17.67,51.8
X$25257 77 2930 3249 2993 2929 2157 109 DFFR_X1
* cell instance $25261 m0 *1 24.89,51.8
X$25261 2932 2931 2996 77 109 2933 MUX2_X1
* cell instance $25262 m0 *1 26.22,51.8
X$25262 77 2930 3171 2996 2933 2157 109 DFFR_X1
* cell instance $25263 m0 *1 30.02,51.8
X$25263 2541 77 109 2397 CLKBUF_X3
* cell instance $25264 m0 *1 30.97,51.8
X$25264 2397 77 109 19144 INV_X1
* cell instance $25268 r0 *1 20.33,51.8
X$25268 3249 3041 3168 77 109 3251 MUX2_X1
* cell instance $25269 r0 *1 21.66,51.8
X$25269 3249 3042 3168 77 109 3250 MUX2_X1
* cell instance $25270 r0 *1 22.99,51.8
X$25270 3103 3041 2781 77 109 3169 MUX2_X1
* cell instance $25271 r0 *1 24.32,51.8
X$25271 3103 2938 2781 77 109 3170 MUX2_X1
* cell instance $25274 r0 *1 26.22,51.8
X$25274 3484 3043 3255 77 109 3044 MUX2_X1
* cell instance $25275 r0 *1 27.55,51.8
X$25275 77 2397 3172 3255 3044 2157 109 DFFR_X1
* cell instance $25277 r0 *1 31.73,51.8
X$25277 2632 3042 3045 77 109 3256 MUX2_X1
* cell instance $25278 r0 *1 33.06,51.8
X$25278 2632 3106 3045 77 109 3174 MUX2_X1
* cell instance $25279 m0 *1 34.2,51.8
X$25279 2399 2938 2935 77 109 3175 MUX2_X1
* cell instance $25281 m0 *1 35.53,51.8
X$25281 2787 2931 3107 77 109 3046 MUX2_X1
* cell instance $25282 m0 *1 36.86,51.8
X$25282 77 2403 2936 3107 3046 2157 109 DFFR_X1
* cell instance $25286 r0 *1 34.39,51.8
X$25286 2399 3106 2935 77 109 3176 MUX2_X1
* cell instance $25287 r0 *1 35.72,51.8
X$25287 2787 3043 3257 77 109 3047 MUX2_X1
* cell instance $25288 r0 *1 37.05,51.8
X$25288 77 3368 3258 3257 3047 2157 109 DFFR_X1
* cell instance $25290 r0 *1 41.23,51.8
X$25290 2634 3042 3259 77 109 3177 MUX2_X1
* cell instance $25292 r0 *1 42.75,51.8
X$25292 2634 3048 3259 77 109 3178 MUX2_X1
* cell instance $25294 r0 *1 44.46,51.8
X$25294 2405 3048 2697 77 109 3375 MUX2_X1
* cell instance $25296 m0 *1 44.84,51.8
X$25296 2405 2938 2697 77 109 3261 MUX2_X1
* cell instance $25300 m0 *1 47.31,51.8
X$25300 2543 77 109 2542 CLKBUF_X3
* cell instance $25303 r0 *1 47.69,51.8
X$25303 77 2542 3180 3111 3113 2157 109 DFFR_X1
* cell instance $25304 m0 *1 49.97,51.8
X$25304 2158 2939 3112 109 3113 77 OAI21_X1
* cell instance $25305 m0 *1 49.4,51.8
X$25305 2789 3111 77 109 3112 NAND2_X1
* cell instance $25306 m0 *1 50.73,51.8
X$25306 77 2220 3049 2791 3114 2157 109 DFFR_X1
* cell instance $25311 r0 *1 53.01,51.8
X$25311 77 2220 3181 3265 3263 2157 109 DFFR_X1
* cell instance $25312 r0 *1 56.81,51.8
X$25312 2222 3003 3050 109 3263 77 OAI21_X1
* cell instance $25313 m0 *1 57.38,51.8
X$25313 3000 3054 77 109 2789 NAND2_X2
* cell instance $25316 r0 *1 57.57,51.8
X$25316 2943 3265 77 109 3050 NAND2_X1
* cell instance $25317 r0 *1 58.14,51.8
X$25317 77 2224 3266 3182 3051 2157 109 DFFR_X1
* cell instance $25318 m0 *1 59.47,51.8
X$25318 2942 3003 2700 109 77 3116 OAI21_X4
* cell instance $25319 m0 *1 58.71,51.8
X$25319 2158 3003 3115 109 3051 77 OAI21_X1
* cell instance $25320 m0 *1 61.94,51.8
X$25320 77 2224 3052 3001 3116 2157 109 DFFR_X1
* cell instance $25321 m0 *1 65.74,51.8
X$25321 2943 3001 77 109 2942 NAND2_X1
* cell instance $25323 m0 *1 67.07,51.8
X$25323 2161 3003 2944 109 3002 77 OAI21_X1
* cell instance $25325 m0 *1 68.02,51.8
X$25325 2411 77 109 19249 CLKBUF_X1
* cell instance $25326 m0 *1 68.59,51.8
X$25326 2797 3054 2945 77 109 2125 NAND3_X2
* cell instance $25327 m0 *1 69.92,51.8
X$25327 2543 77 109 2411 CLKBUF_X3
* cell instance $25328 m0 *1 70.87,51.8
X$25328 2161 2939 3121 109 3120 77 OAI21_X1
* cell instance $25331 m0 *1 72.58,51.8
X$25331 2939 3122 77 109 3121 NAND2_X1
* cell instance $25332 m0 *1 73.15,51.8
X$25332 2789 77 109 2939 CLKBUF_X3
* cell instance $25333 m0 *1 74.1,51.8
X$25333 2789 3185 77 109 3055 NAND2_X1
* cell instance $25335 m0 *1 75.43,51.8
X$25335 77 2229 3126 2946 3123 2157 109 DFFR_X1
* cell instance $25336 m0 *1 79.23,51.8
X$25336 77 2378 3384 3010 3009 2157 109 DFFR_X1
* cell instance $25338 m0 *1 86.07,51.8
X$25338 3003 3131 77 109 3280 NAND2_X1
* cell instance $25339 m0 *1 86.64,51.8
X$25339 77 2551 3057 3011 2729 1663 109 DFFR_X1
* cell instance $25340 m0 *1 90.44,51.8
X$25340 3132 2090 2949 77 109 3013 MUX2_X1
* cell instance $25341 m0 *1 91.77,51.8
X$25341 77 3058 18695 2949 3013 1663 109 DFFR_X1
* cell instance $25342 m0 *1 95.57,51.8
X$25342 2645 3060 213 3062 77 109 3287 AOI22_X2
* cell instance $25343 m0 *1 97.28,51.8
X$25343 2951 2802 3016 77 109 2950 NAND3_X1
* cell instance $25348 r0 *1 61.94,51.8
X$25348 2943 3182 77 109 3115 NAND2_X1
* cell instance $25350 r0 *1 64.03,51.8
X$25350 3052 2938 2941 77 109 3269 MUX2_X1
* cell instance $25352 r0 *1 65.55,51.8
X$25352 77 2411 3184 3053 3002 2157 109 DFFR_X1
* cell instance $25353 r0 *1 69.35,51.8
X$25353 77 2411 3271 3122 3120 2157 109 DFFR_X1
* cell instance $25354 r0 *1 73.15,51.8
X$25354 3055 2939 2548 109 77 3272 OAI21_X4
* cell instance $25357 r0 *1 77.52,51.8
X$25357 2943 3275 77 109 3274 NAND2_X1
* cell instance $25361 r0 *1 80.56,51.8
X$25361 2232 2939 3056 109 3186 77 OAI21_X1
* cell instance $25362 r0 *1 81.32,51.8
X$25362 2939 3277 77 109 3056 NAND2_X1
* cell instance $25364 r0 *1 82.65,51.8
X$25364 2943 77 109 3003 CLKBUF_X3
* cell instance $25367 r0 *1 84.55,51.8
X$25367 2232 3003 3130 109 3187 77 OAI21_X1
* cell instance $25368 r0 *1 85.31,51.8
X$25368 3003 3279 77 109 3130 NAND2_X1
* cell instance $25369 r0 *1 85.88,51.8
X$25369 2417 3003 3280 109 3188 77 OAI21_X1
* cell instance $25370 r0 *1 86.64,51.8
X$25370 77 2551 3189 3131 3188 1663 109 DFFR_X1
* cell instance $25372 r0 *1 91.2,51.8
X$25372 77 3058 18759 3191 3283 1663 109 DFFR_X1
* cell instance $25373 r0 *1 95,51.8
X$25373 3191 2553 2949 2554 77 109 3286 AOI22_X1
* cell instance $25374 r0 *1 95.95,51.8
X$25374 3286 2647 77 109 3288 NOR2_X1
* cell instance $25375 r0 *1 96.52,51.8
X$25375 3059 3289 2950 109 3290 77 OAI21_X1
* cell instance $25376 r0 *1 97.28,51.8
X$25376 3136 2951 3287 3295 2953 3296 77 109 OAI221_X2
* cell instance $25378 m0 *1 98.42,51.8
X$25378 2656 77 109 3059 CLKBUF_X3
* cell instance $25396 m0 *1 28.12,46.2
X$25396 77 2397 2632 2456 2398 2157 109 DFFR_X1
* cell instance $25397 m0 *1 26.79,46.2
X$25397 2456 2459 2539 77 109 2398 MUX2_X1
* cell instance $25398 m0 *1 31.92,46.2
X$25398 77 2397 2399 2401 2457 2157 109 DFFR_X1
* cell instance $25399 m0 *1 35.72,46.2
X$25399 2401 2400 2539 77 109 2457 MUX2_X1
* cell instance $25401 m0 *1 38.57,46.2
X$25401 2460 2459 2540 77 109 2402 MUX2_X1
* cell instance $25409 r0 *1 40.66,46.2
X$25409 2541 77 109 2403 CLKBUF_X3
* cell instance $25410 m0 *1 41.23,46.2
X$25410 2463 2400 2540 77 109 2404 MUX2_X1
* cell instance $25412 m0 *1 42.56,46.2
X$25412 77 2403 2405 2463 2404 2157 109 DFFR_X1
* cell instance $25413 m0 *1 46.36,46.2
X$25413 77 2542 2406 2466 2464 2157 109 DFFR_X1
* cell instance $25415 m0 *1 50.92,46.2
X$25415 77 2542 2601 2471 2469 2157 109 DFFR_X1
* cell instance $25416 m0 *1 54.72,46.2
X$25416 77 2220 2408 2324 2472 2157 109 DFFR_X1
* cell instance $25417 m0 *1 58.52,46.2
X$25417 77 2224 2603 2409 2473 2157 109 DFFR_X1
* cell instance $25418 m0 *1 62.32,46.2
X$25418 77 2224 2410 2412 2476 2157 109 DFFR_X1
* cell instance $25420 m0 *1 66.31,46.2
X$25420 77 2411 2413 2481 2479 2157 109 DFFR_X1
* cell instance $25422 m0 *1 71.63,46.2
X$25422 2326 77 109 2325 CLKBUF_X3
* cell instance $25426 r0 *1 43.32,46.2
X$25426 77 2542 2697 2698 2694 2157 109 DFFR_X1
* cell instance $25427 r0 *1 47.12,46.2
X$25427 77 2542 2637 2638 2702 2157 109 DFFR_X1
* cell instance $25428 r0 *1 50.92,46.2
X$25428 2322 2638 77 109 2600 NAND2_X1
* cell instance $25429 r0 *1 51.49,46.2
X$25429 2600 2407 2226 109 77 2702 OAI21_X4
* cell instance $25430 r0 *1 53.96,46.2
X$25430 2543 77 109 2220 CLKBUF_X3
* cell instance $25437 r0 *1 62.89,46.2
X$25437 2226 2544 2715 109 2712 77 OAI21_X1
* cell instance $25439 r0 *1 63.84,46.2
X$25439 2796 2716 77 109 2715 NAND2_X1
* cell instance $25443 r0 *1 66.88,46.2
X$25443 2161 2544 2717 109 2869 77 OAI21_X1
* cell instance $25445 r0 *1 68.02,46.2
X$25445 2544 2719 77 109 2717 NAND2_X1
* cell instance $25448 r0 *1 70.49,46.2
X$25448 2161 2407 2722 109 2721 77 OAI21_X1
* cell instance $25449 r0 *1 71.25,46.2
X$25449 2322 77 109 2407 CLKBUF_X3
* cell instance $25450 r0 *1 72.2,46.2
X$25450 2407 2545 77 109 2722 NAND2_X1
* cell instance $25453 m0 *1 72.96,46.2
X$25453 2156 2482 77 109 2414 NAND2_X1
* cell instance $25466 m0 *1 8.55,180.6
X$25466 77 15031 14830 14982 14829 9814 109 DFFR_X1
* cell instance $25467 r0 *1 8.93,180.6
X$25467 15031 77 109 19187 INV_X1
* cell instance $25470 r0 *1 11.02,180.6
X$25470 77 15031 15104 15103 15101 9814 109 DFFR_X1
* cell instance $25472 m0 *1 12.73,180.6
X$25472 77 14168 14831 14832 14874 9814 109 DFFR_X1
* cell instance $25473 m0 *1 18.05,180.6
X$25473 77 14168 14833 14877 14876 9814 109 DFFR_X1
* cell instance $25478 m0 *1 27.36,180.6
X$25478 77 14930 14594 14931 14984 9814 109 DFFR_X1
* cell instance $25479 m0 *1 31.16,180.6
X$25479 14931 13098 14118 77 109 14984 MUX2_X1
* cell instance $25483 r0 *1 15.2,180.6
X$25483 15032 10129 15104 77 109 15107 MUX2_X1
* cell instance $25485 r0 *1 17.29,180.6
X$25485 77 14168 14589 15213 15109 9814 109 DFFR_X1
* cell instance $25486 r0 *1 21.09,180.6
X$25486 77 13984 14834 15033 15110 9814 109 DFFR_X1
* cell instance $25487 r0 *1 24.89,180.6
X$25487 15033 13146 14118 77 109 15110 MUX2_X1
* cell instance $25488 r0 *1 26.22,180.6
X$25488 15112 14187 13675 77 109 15111 MUX2_X1
* cell instance $25491 r0 *1 32.11,180.6
X$25491 77 14930 14775 15034 15114 4086 109 DFFR_X1
* cell instance $25493 m0 *1 34.39,180.6
X$25493 14884 13548 14118 77 109 14882 MUX2_X1
* cell instance $25495 r0 *1 35.91,180.6
X$25495 15034 13408 14118 77 109 15114 MUX2_X1
* cell instance $25496 m0 *1 39.33,180.6
X$25496 8529 14988 7764 11125 14932 77 109 15115 AOI221_X1
* cell instance $25497 m0 *1 36.86,180.6
X$25497 77 7338 109 7764 BUF_X8
* cell instance $25498 m0 *1 40.47,180.6
X$25498 14933 7321 15038 77 14932 109 AOI21_X1
* cell instance $25500 m0 *1 41.42,180.6
X$25500 14989 13355 77 109 14933 NOR2_X1
* cell instance $25501 m0 *1 41.99,180.6
X$25501 77 14708 14707 14934 14992 4086 109 DFFR_X1
* cell instance $25502 m0 *1 45.79,180.6
X$25502 14934 13767 13675 77 109 14992 MUX2_X1
* cell instance $25503 m0 *1 47.12,180.6
X$25503 7020 109 7703 77 BUF_X4
* cell instance $25505 m0 *1 48.64,180.6
X$25505 14838 6885 15467 77 109 14993 MUX2_X1
* cell instance $25506 m0 *1 49.97,180.6
X$25506 8157 14839 6379 7703 14894 109 77 14935 OAI221_X1
* cell instance $25508 m0 *1 51.3,180.6
X$25508 7617 15122 14841 109 77 14936 AND3_X1
* cell instance $25511 m0 *1 53.2,180.6
X$25511 8369 109 8529 77 BUF_X4
* cell instance $25512 m0 *1 54.53,180.6
X$25512 14997 13098 14712 77 109 14995 MUX2_X1
* cell instance $25513 m0 *1 55.86,180.6
X$25513 14710 77 109 19224 CLKBUF_X1
* cell instance $25514 m0 *1 56.43,180.6
X$25514 14048 6716 14998 77 109 14937 MUX2_X1
* cell instance $25515 m0 *1 57.76,180.6
X$25515 77 14710 14938 14998 14937 8687 109 DFFR_X1
* cell instance $25516 m0 *1 61.56,180.6
X$25516 14938 77 109 15042 INV_X1
* cell instance $25517 m0 *1 61.94,180.6
X$25517 15042 8529 7764 8670 15001 15043 109 77 AOI221_X2
* cell instance $25518 m0 *1 64.03,180.6
X$25518 14795 7321 77 109 14999 NOR2_X1
* cell instance $25521 r0 *1 37.62,180.6
X$25521 15035 77 109 14988 INV_X1
* cell instance $25523 r0 *1 38.76,180.6
X$25523 15115 15118 4210 77 109 15036 NOR3_X1
* cell instance $25525 r0 *1 39.71,180.6
X$25525 6369 15171 15116 77 15037 109 AOI21_X2
* cell instance $25526 r0 *1 41.04,180.6
X$25526 15038 7403 77 109 15120 NAND2_X1
* cell instance $25527 r0 *1 41.61,180.6
X$25527 9337 14989 15120 109 15039 77 OAI21_X1
* cell instance $25532 r0 *1 45.22,180.6
X$25532 6083 109 13355 77 BUF_X4
* cell instance $25533 r0 *1 46.55,180.6
X$25533 14708 77 109 19303 CLKBUF_X1
* cell instance $25534 r0 *1 47.12,180.6
X$25534 77 14708 18799 14838 14993 4086 109 DFFR_X1
* cell instance $25538 r0 *1 53.01,180.6
X$25538 77 14708 14472 14997 14995 8687 109 DFFR_X1
* cell instance $25539 r0 *1 56.81,180.6
X$25539 77 6652 109 6369 BUF_X8
* cell instance $25543 r0 *1 59.28,180.6
X$25543 8157 109 7643 77 BUF_X4
* cell instance $25545 r0 *1 60.99,180.6
X$25545 8157 14938 6719 7020 14844 109 77 15040 OAI221_X1
* cell instance $25547 r0 *1 62.32,180.6
X$25547 15043 7338 15041 77 15232 109 AOI21_X1
* cell instance $25549 r0 *1 63.27,180.6
X$25549 15124 6997 77 109 15233 NOR2_X1
* cell instance $25552 m0 *1 64.98,180.6
X$25552 14793 7197 77 109 14939 NOR2_X2
* cell instance $25554 m0 *1 69.16,180.6
X$25554 14717 4905 15004 77 109 15127 MUX2_X1
* cell instance $25558 r0 *1 65.36,180.6
X$25558 15279 14939 6726 109 15235 77 NOR3_X2
* cell instance $25561 r0 *1 68.4,180.6
X$25561 14717 5656 15129 77 109 15238 MUX2_X1
* cell instance $25562 r0 *1 69.73,180.6
X$25562 77 15126 15130 15004 15127 8687 109 DFFR_X1
* cell instance $25563 m0 *1 74.48,180.6
X$25563 14049 77 109 14475 CLKBUF_X3
* cell instance $25564 m0 *1 73.15,180.6
X$25564 14901 11563 14900 77 109 15045 MUX2_X1
* cell instance $25566 r0 *1 73.53,180.6
X$25566 15044 6308 15130 77 109 15133 MUX2_X1
* cell instance $25568 r0 *1 75.62,180.6
X$25568 77 14475 15006 15007 15131 8687 109 DFFR_X1
* cell instance $25570 m0 *1 75.81,180.6
X$25570 14717 6716 15007 77 109 15131 MUX2_X1
* cell instance $25571 m0 *1 78.66,180.6
X$25571 15006 77 109 14940 INV_X1
* cell instance $25573 m0 *1 79.61,180.6
X$25573 15182 3500 77 109 14941 NOR2_X1
* cell instance $25577 r0 *1 79.42,180.6
X$25577 14941 7936 15046 77 15139 109 AOI21_X1
* cell instance $25578 r0 *1 80.18,180.6
X$25578 15046 7403 77 109 15047 NAND2_X1
* cell instance $25581 m0 *1 81.32,180.6
X$25581 3500 109 6308 77 BUF_X4
* cell instance $25582 m0 *1 82.84,180.6
X$25582 8191 15008 15011 13044 14845 15009 77 109 14942 OAI33_X1
* cell instance $25583 m0 *1 84.17,180.6
X$25583 15006 6276 6459 77 109 15011 NOR3_X1
* cell instance $25587 r0 *1 82.27,180.6
X$25587 15133 5415 77 109 15009 NOR2_X1
* cell instance $25588 r0 *1 82.84,180.6
X$25588 13558 109 9570 77 BUF_X4
* cell instance $25589 r0 *1 84.17,180.6
X$25589 14049 77 109 14803 CLKBUF_X3
* cell instance $25590 r0 *1 85.12,180.6
X$25590 15241 77 109 15142 INV_X1
* cell instance $25592 r0 *1 85.88,180.6
X$25592 15050 10198 14193 77 109 15049 MUX2_X1
* cell instance $25593 r0 *1 87.21,180.6
X$25593 8157 15136 10065 7020 15051 109 77 15137 OAI221_X1
* cell instance $25594 r0 *1 88.35,180.6
X$25594 5479 6318 15052 77 15140 109 AOI21_X1
* cell instance $25595 r0 *1 89.11,180.6
X$25595 15139 6174 8191 8369 15142 15440 109 77 AOI221_X2
* cell instance $25596 m0 *1 91.2,180.6
X$25596 77 14428 14944 15015 14943 8201 109 DFFR_X1
* cell instance $25597 m0 *1 89.87,180.6
X$25597 15015 10508 14193 77 109 14943 MUX2_X1
* cell instance $25598 m0 *1 95,180.6
X$25598 14944 6584 15054 77 109 15018 MUX2_X1
* cell instance $25600 m0 *1 96.52,180.6
X$25600 14945 6174 15144 77 109 15017 MUX2_X1
* cell instance $25601 m0 *1 97.85,180.6
X$25601 14428 77 109 19141 INV_X1
* cell instance $25603 m0 *1 98.42,180.6
X$25603 15018 3978 14947 77 109 14946 MUX2_X1
* cell instance $25606 m0 *1 102.03,180.6
X$25606 9146 12709 15019 77 109 15145 MUX2_X1
* cell instance $25608 m0 *1 103.55,180.6
X$25608 14914 3978 15020 77 109 14910 MUX2_X1
* cell instance $25610 m0 *1 105.07,180.6
X$25610 15146 3603 15027 77 109 15020 MUX2_X1
* cell instance $25612 r0 *1 91.2,180.6
X$25612 15141 15140 109 77 15151 AND2_X2
* cell instance $25616 r0 *1 94.24,180.6
X$25616 14026 77 109 14428 CLKBUF_X3
* cell instance $25617 r0 *1 95.19,180.6
X$25617 14944 5589 15054 77 109 14945 MUX2_X1
* cell instance $25620 r0 *1 97.47,180.6
X$25620 15056 5589 15055 77 109 15144 MUX2_X1
* cell instance $25621 r0 *1 98.8,180.6
X$25621 15056 3603 15055 77 109 14947 MUX2_X1
* cell instance $25623 r0 *1 100.51,180.6
X$25623 77 14428 15146 15019 15145 8201 109 DFFR_X1
* cell instance $25625 r0 *1 104.69,180.6
X$25625 15057 7335 15146 77 109 15148 MUX2_X1
* cell instance $25628 r0 *1 106.59,180.6
X$25628 15148 6308 15058 77 109 15147 MUX2_X1
* cell instance $25630 m0 *1 106.78,180.6
X$25630 77 15149 14606 15025 15023 8201 109 DFFR_X1
* cell instance $25631 m0 *1 110.77,180.6
X$25631 14140 7636 15025 77 109 15023 MUX2_X1
* cell instance $25634 r0 *1 108.11,180.6
X$25634 6174 109 8689 77 BUF_X4
* cell instance $25637 r0 *1 110.01,180.6
X$25637 77 15149 15027 15061 15152 8201 109 DFFR_X1
* cell instance $25639 m0 *1 112.48,180.6
X$25639 77 6174 6459 109 BUF_X16
* cell instance $25641 r0 *1 113.81,180.6
X$25641 14440 7279 15061 77 109 15152 MUX2_X1
* cell instance $25647 r0 *1 115.71,180.6
X$25647 77 7029 15063 15262 15064 7996 15065 11684 109 AOI222_X2
* cell instance $25648 r0 *1 118.37,180.6
X$25648 77 12264 7996 15154 15063 13396 15064 7029 109 AOI222_X2
* cell instance $25650 m0 *1 119.13,180.6
X$25650 12419 109 15063 77 BUF_X4
* cell instance $25652 m0 *1 121.41,180.6
X$25652 11846 77 109 12421 CLKBUF_X3
* cell instance $25654 m0 *1 122.55,180.6
X$25654 77 12875 14059 13054 12728 13249 15065 13541 109 AOI222_X2
* cell instance $25657 r0 *1 121.22,180.6
X$25657 77 12100 109 11846 BUF_X8
* cell instance $25658 r0 *1 123.69,180.6
X$25658 14726 77 109 19298 CLKBUF_X1
* cell instance $25659 r0 *1 124.26,180.6
X$25659 77 14726 15066 15159 15157 12731 109 DFFR_X1
* cell instance $25660 m0 *1 125.78,180.6
X$25660 14950 14949 14951 77 109 15030 MUX2_X1
* cell instance $25663 m0 *1 127.68,180.6
X$25663 15159 14206 15028 77 109 15157 MUX2_X1
* cell instance $25668 r0 *1 128.44,180.6
X$25668 77 14580 15067 15068 15158 12731 109 DFFR_X1
* cell instance $25670 m0 *1 130.91,180.6
X$25670 15067 14200 15029 77 109 14727 MUX2_X1
* cell instance $25673 m0 *1 136.23,180.6
X$25673 10892 14338 11201 77 109 15028 MUX2_X1
* cell instance $25675 r0 *1 132.24,180.6
X$25675 15068 14206 15160 77 109 15158 MUX2_X1
* cell instance $25676 r0 *1 133.57,180.6
X$25676 11409 14338 12690 77 109 15160 MUX2_X1
* cell instance $25678 r0 *1 135.09,180.6
X$25678 9170 15069 12585 77 109 15161 MUX2_X1
* cell instance $25680 r0 *1 136.8,180.6
X$25680 14729 15069 10556 77 109 15162 MUX2_X1
* cell instance $25681 m0 *1 139.27,180.6
X$25681 9862 13281 15024 77 109 14952 MUX2_X1
* cell instance $25682 m0 *1 137.94,180.6
X$25682 14061 109 14338 77 BUF_X4
* cell instance $25683 m0 *1 140.6,180.6
X$25683 14952 14063 15164 77 109 15070 MUX2_X1
* cell instance $25689 r0 *1 140.6,180.6
X$25689 77 14849 18795 15164 15070 12731 109 DFFR_X1
* cell instance $25690 m0 *1 144.4,180.6
X$25690 14953 14063 14954 77 109 15026 MUX2_X1
* cell instance $25691 m0 *1 143.07,180.6
X$25691 12691 13281 8168 77 109 14953 MUX2_X1
* cell instance $25693 m0 *1 146.49,180.6
X$25693 77 14849 18623 14954 15026 12731 109 DFFR_X1
* cell instance $25694 m0 *1 150.29,180.6
X$25694 77 9469 14208 14954 12996 14210 14959 13390 109 OAI222_X2
* cell instance $25696 m0 *1 153.14,180.6
X$25696 77 14960 14208 15022 12996 14210 15165 13378 109 OAI222_X2
* cell instance $25697 m0 *1 155.8,180.6
X$25697 1236 77 109 14560 CLKBUF_X3
* cell instance $25698 m0 *1 156.75,180.6
X$25698 14852 14737 14956 109 15021 77 OAI21_X1
* cell instance $25699 m0 *1 157.51,180.6
X$25699 13127 13447 77 109 14735 NAND2_X1
* cell instance $25700 m0 *1 158.08,180.6
X$25700 15021 14616 13794 13575 77 109 14957 AOI22_X1
* cell instance $25701 m0 *1 159.03,180.6
X$25701 14736 14616 14959 13575 77 109 14958 AOI22_X1
* cell instance $25702 m0 *1 159.98,180.6
X$25702 14960 77 109 14955 BUF_X1
* cell instance $25703 m0 *1 160.55,180.6
X$25703 77 14493 14961 12731 12988 13908 109 DFFR_X2
* cell instance $25705 m0 *1 164.92,180.6
X$25705 14018 77 109 13951 CLKBUF_X3
* cell instance $25706 m0 *1 165.87,180.6
X$25706 9263 14347 14067 109 14853 77 OAI21_X1
* cell instance $25707 m0 *1 166.63,180.6
X$25707 15016 14893 14213 109 14962 77 OAI21_X1
* cell instance $25708 m0 *1 167.39,180.6
X$25708 14347 10526 77 109 15016 NOR2_X1
* cell instance $25710 m0 *1 168.15,180.6
X$25710 9162 14915 14815 14018 109 77 15003 OAI22_X1
* cell instance $25715 r0 *1 148.01,180.6
X$25715 15072 11731 77 15166 109 NAND2_X4
* cell instance $25716 r0 *1 149.72,180.6
X$25716 77 10526 13176 15261 13287 14210 15075 13387 109 OAI222_X2
* cell instance $25717 r0 *1 152.38,180.6
X$25717 77 8828 13176 15164 13287 14210 15014 13382 109 OAI222_X2
* cell instance $25719 r0 *1 155.23,180.6
X$25719 15073 15074 109 5350 77 AND2_X4
* cell instance $25721 r0 *1 157.13,180.6
X$25721 11541 14306 15082 109 77 15163 MUX2_X2
* cell instance $25722 r0 *1 158.84,180.6
X$25722 15156 15005 14957 109 15076 77 OAI21_X1
* cell instance $25723 r0 *1 159.6,180.6
X$25723 15077 13361 77 109 9452 NOR2_X2
* cell instance $25724 r0 *1 160.55,180.6
X$25724 14920 15132 15155 14561 14854 109 77 14961 OAI221_X1
* cell instance $25727 r0 *1 162.26,180.6
X$25727 13361 15080 77 109 11247 OR2_X2
* cell instance $25728 r0 *1 163.21,180.6
X$25728 11309 109 13361 77 BUF_X4
* cell instance $25729 r0 *1 164.54,180.6
X$25729 13070 14067 77 109 15081 NAND2_X1
* cell instance $25730 r0 *1 165.11,180.6
X$25730 15075 14018 13522 77 109 15150 MUX2_X1
* cell instance $25732 r0 *1 166.63,180.6
X$25732 14962 15150 109 77 15243 AND2_X1
* cell instance $25734 r0 *1 167.77,180.6
X$25734 12811 15198 13232 109 77 10107 MUX2_X2
* cell instance $25735 m0 *1 170.05,180.6
X$25735 15012 14964 15013 14740 14854 109 77 14965 OAI221_X1
* cell instance $25736 m0 *1 169.48,180.6
X$25736 13575 15014 77 109 15013 NAND2_X1
* cell instance $25737 m0 *1 171.19,180.6
X$25737 14856 13296 77 109 15012 NAND2_X1
* cell instance $25739 r0 *1 169.48,180.6
X$25739 13575 14699 77 109 15083 NAND2_X1
* cell instance $25741 r0 *1 170.43,180.6
X$25741 15082 9130 77 109 15200 NOR2_X1
* cell instance $25742 r0 *1 171,180.6
X$25742 77 14446 14965 12731 14966 15014 109 DFFR_X2
* cell instance $25747 m0 *1 172.14,180.6
X$25747 8961 8831 15201 109 77 15010 MUX2_X2
* cell instance $25748 m0 *1 174.99,180.6
X$25748 12988 77 109 15143 INV_X1
* cell instance $25749 m0 *1 174.23,180.6
X$25749 14966 77 109 12983 BUF_X2
* cell instance $25750 m0 *1 175.37,180.6
X$25750 10006 77 109 14960 BUF_X1
* cell instance $25751 m0 *1 175.94,180.6
X$25751 15002 13842 14154 13457 15084 15005 109 77 AOI221_X2
* cell instance $25752 m0 *1 178.03,180.6
X$25752 14878 14435 14907 77 109 15002 MUX2_X1
* cell instance $25754 m0 *1 179.55,180.6
X$25754 14994 14858 15003 14968 13296 77 109 14970 AOI221_X1
* cell instance $25757 r0 *1 175.56,180.6
X$25757 9556 13841 15143 77 109 15084 MUX2_X1
* cell instance $25758 r0 *1 176.89,180.6
X$25758 10086 15201 12640 77 109 15085 MUX2_X1
* cell instance $25761 r0 *1 180.12,180.6
X$25761 14969 14353 15135 77 15138 109 AOI21_X1
* cell instance $25763 m0 *1 181.83,180.6
X$25763 15000 77 109 14971 INV_X1
* cell instance $25764 m0 *1 181.07,180.6
X$25764 14996 9165 14345 77 14969 109 AOI21_X1
* cell instance $25766 m0 *1 182.4,180.6
X$25766 14972 12811 13959 77 14902 109 AOI21_X1
* cell instance $25767 m0 *1 183.16,180.6
X$25767 14223 10702 77 109 14972 NOR2_X1
* cell instance $25769 r0 *1 181.07,180.6
X$25769 14971 14353 15128 77 15229 109 AOI21_X1
* cell instance $25771 r0 *1 182.02,180.6
X$25771 15098 13345 14902 77 109 15135 MUX2_X1
* cell instance $25773 r0 *1 183.54,180.6
X$25773 14223 77 109 13841 CLKBUF_X3
* cell instance $25774 m0 *1 186.2,180.6
X$25774 15123 14353 77 109 14994 NAND2_X1
* cell instance $25775 m0 *1 184.11,180.6
X$25775 14973 13883 14495 10702 14226 14996 109 77 AOI221_X2
* cell instance $25776 m0 *1 186.77,180.6
X$25776 14976 77 109 14974 INV_X1
* cell instance $25777 m0 *1 187.15,180.6
X$25777 13883 14975 14495 9556 14226 77 109 14976 AOI221_X1
* cell instance $25778 m0 *1 188.29,180.6
X$25778 14987 13842 14991 13457 15088 14964 109 77 AOI221_X2
* cell instance $25779 m0 *1 190.38,180.6
X$25779 14990 77 109 14991 INV_X1
* cell instance $25780 m0 *1 190.76,180.6
X$25780 14495 14226 9862 77 14990 109 AOI21_X1
* cell instance $25783 r0 *1 184.87,180.6
X$25783 15086 13119 13841 77 15088 109 AOI21_X2
* cell instance $25784 r0 *1 186.2,180.6
X$25784 14974 14353 15125 77 15132 109 AOI21_X1
* cell instance $25785 r0 *1 186.96,180.6
X$25785 15089 13345 14975 77 109 15128 MUX2_X1
* cell instance $25786 r0 *1 188.29,180.6
X$25786 15087 13345 15084 77 109 15125 MUX2_X1
* cell instance $25788 r0 *1 189.81,180.6
X$25788 15090 14435 15088 77 109 15123 MUX2_X1
* cell instance $25790 m0 *1 193.23,180.6
X$25790 14070 77 109 14263 CLKBUF_X3
* cell instance $25791 m0 *1 191.9,180.6
X$25791 14883 14435 14977 77 109 14987 MUX2_X1
* cell instance $25792 m0 *1 194.18,180.6
X$25792 14502 14070 14211 77 109 14986 MUX2_X1
* cell instance $25793 m0 *1 195.51,180.6
X$25793 77 14358 18624 14985 14986 3676 109 DFFR_X1
* cell instance $25795 m0 *1 199.5,180.6
X$25795 14985 109 14211 77 BUF_X4
* cell instance $25797 m0 *1 201.02,180.6
X$25797 14752 14211 14457 14502 77 109 15121 NOR4_X1
* cell instance $25800 r0 *1 191.9,180.6
X$25800 14435 77 109 13345 CLKBUF_X3
* cell instance $25802 r0 *1 193.23,180.6
X$25802 14263 14622 15091 109 15222 77 OAI21_X1
* cell instance $25803 r0 *1 193.99,180.6
X$25803 14263 15092 77 109 15091 NAND2_X1
* cell instance $25804 r0 *1 194.56,180.6
X$25804 14358 77 109 19306 CLKBUF_X1
* cell instance $25805 r0 *1 195.13,180.6
X$25805 13718 77 109 14358 CLKBUF_X3
* cell instance $25806 r0 *1 196.08,180.6
X$25806 15092 14070 14457 77 109 15219 MUX2_X1
* cell instance $25811 r0 *1 200.26,180.6
X$25811 14263 14485 77 109 15093 NAND2_X1
* cell instance $25812 r0 *1 200.83,180.6
X$25812 14263 15121 15093 109 15117 77 OAI21_X1
* cell instance $25813 r0 *1 201.59,180.6
X$25813 77 14758 15117 3676 14752 14530 109 DFFR_X2
* cell instance $25815 m0 *1 203.11,180.6
X$25815 14530 109 14485 77 BUF_X4
* cell instance $25820 r0 *1 207.86,180.6
X$25820 14397 13308 15094 109 15090 77 OAI21_X1
* cell instance $25821 m0 *1 208.05,180.6
X$25821 77 14506 14979 14978 14863 3676 109 DFFR_X1
* cell instance $25826 r0 *1 209.57,180.6
X$25826 15095 14109 15090 13605 77 109 15216 AOI22_X1
* cell instance $25827 r0 *1 210.52,180.6
X$25827 14753 13633 14979 109 14883 77 OAI21_X1
* cell instance $25830 r0 *1 212.23,180.6
X$25830 14365 14090 15096 109 15089 77 OAI21_X1
* cell instance $25832 m0 *1 212.23,180.6
X$25832 77 14506 14981 14879 14980 3676 109 DFFR_X1
* cell instance $25834 r0 *1 213.75,180.6
X$25834 10855 77 109 14758 CLKBUF_X3
* cell instance $25835 r0 *1 214.7,180.6
X$25835 14758 77 109 19275 CLKBUF_X1
* cell instance $25837 r0 *1 215.46,180.6
X$25837 14509 14090 15097 109 15087 77 OAI21_X1
* cell instance $25838 r0 *1 216.22,180.6
X$25838 14509 13308 15106 109 15098 77 OAI21_X1
* cell instance $25839 m0 *1 217.36,180.6
X$25839 14983 77 109 15108 INV_X1
* cell instance $25840 m0 *1 216.41,180.6
X$25840 15105 14109 15098 13605 77 109 14983 AOI22_X1
* cell instance $25843 m0 *1 218.69,180.6
X$25843 14365 13633 14872 109 14864 77 OAI21_X1
* cell instance $25849 r0 *1 216.98,180.6
X$25849 77 14758 15106 15105 15108 3676 109 DFFR_X1
* cell instance $25857 r0 *1 228.19,180.6
X$25857 11201 77 109 15102 BUF_X1
* cell instance $25860 r0 *1 233.32,180.6
X$25860 12199 77 109 15100 BUF_X1
* cell instance $25863 r0 *1 234.84,180.6
X$25863 15100 77 109 15099 BUF_X1
* cell instance $25907 m0 *1 88.54,21
X$25907 86 486 797 77 109 991 MUX2_X1
* cell instance $25909 m0 *1 89.87,21
X$25909 953 629 991 77 109 990 MUX2_X1
* cell instance $25913 r0 *1 88.92,21
X$25913 1038 394 320 77 109 1210 MUX2_X1
* cell instance $25914 r0 *1 90.25,21
X$25914 409 77 109 877 CLKBUF_X3
* cell instance $25915 r0 *1 91.2,21
X$25915 877 77 109 19186 INV_X1
* cell instance $25919 r0 *1 92.91,21
X$25919 1167 394 83 77 109 1212 MUX2_X1
* cell instance $25921 m0 *1 93.1,21
X$25921 77 18312 1039 993 955 109 DFF_X1
* cell instance $25922 m0 *1 97.09,21
X$25922 956 629 1076 77 109 954 MUX2_X1
* cell instance $25925 m0 *1 100.7,21
X$25925 119 645 956 77 109 1040 MUX2_X1
* cell instance $25929 r0 *1 94.81,21
X$25929 119 486 1039 77 109 1076 MUX2_X1
* cell instance $25930 r0 *1 96.14,21
X$25930 1117 394 139 77 109 1213 MUX2_X1
* cell instance $25933 r0 *1 99.37,21
X$25933 1118 642 957 77 109 1152 MUX2_X1
* cell instance $25936 r0 *1 101.84,21
X$25936 885 109 352 77 BUF_X4
* cell instance $25937 m0 *1 103.74,21
X$25937 119 878 156 77 109 1041 MUX2_X1
* cell instance $25938 m0 *1 102.41,21
X$25938 86 885 953 77 109 1123 MUX2_X1
* cell instance $25942 r0 *1 103.74,21
X$25942 1120 642 1040 77 109 1153 MUX2_X1
* cell instance $25944 m0 *1 106.78,21
X$25944 803 109 959 77 BUF_X4
* cell instance $25945 m0 *1 105.45,21
X$25945 156 803 355 77 109 1082 MUX2_X1
* cell instance $25949 r0 *1 106.21,21
X$25949 1040 1003 1082 77 109 1121 MUX2_X1
* cell instance $25953 r0 *1 109.63,21
X$25953 1168 887 493 77 109 1088 MUX2_X1
* cell instance $25955 m0 *1 110.01,21
X$25955 86 878 167 77 109 1043 MUX2_X1
* cell instance $25956 r0 *1 110.96,21
X$25956 1043 1088 1119 109 77 1124 MUX2_X2
* cell instance $25957 m0 *1 111.91,21
X$25957 167 958 77 109 1089 NAND2_X1
* cell instance $25960 r0 *1 112.67,21
X$25960 1126 1089 1044 77 1125 109 AOI21_X1
* cell instance $25962 m0 *1 112.86,21
X$25962 493 959 77 109 1044 NAND2_X1
* cell instance $25963 r0 *1 113.43,21
X$25963 77 442 109 1122 BUF_X8
* cell instance $25964 m0 *1 114,21
X$25964 887 77 109 805 CLKBUF_X3
* cell instance $25966 m0 *1 114.95,21
X$25966 805 109 881 77 BUF_X4
* cell instance $25967 m0 *1 116.28,21
X$25967 406 959 77 109 1046 NAND2_X1
* cell instance $25968 m0 *1 116.85,21
X$25968 961 1046 1003 77 109 1045 NAND3_X1
* cell instance $25975 r0 *1 117.04,21
X$25975 1045 1003 1092 109 77 1476 OAI21_X2
* cell instance $25976 m0 *1 118.18,21
X$25976 861 77 109 19126 INV_X1
* cell instance $25978 m0 *1 118.56,21
X$25978 409 77 109 861 CLKBUF_X3
* cell instance $25979 m0 *1 120.84,21
X$25979 930 1093 879 109 77 1094 MUX2_X2
* cell instance $25982 m0 *1 124.83,21
X$25982 77 18298 886 1008 447 109 DFF_X1
* cell instance $25984 r0 *1 118.37,21
X$25984 1162 442 1092 77 109 1161 MUX2_X1
* cell instance $25985 r0 *1 119.7,21
X$25985 1047 77 109 803 CLKBUF_X3
* cell instance $25989 r0 *1 122.74,21
X$25989 90 960 864 77 109 1097 MUX2_X1
* cell instance $25990 r0 *1 124.07,21
X$25990 359 805 90 77 109 1127 MUX2_X1
* cell instance $25991 r0 *1 125.4,21
X$25991 359 1174 649 77 109 1171 MUX2_X1
* cell instance $25993 r0 *1 127.49,21
X$25993 96 645 808 77 109 1048 MUX2_X1
* cell instance $25994 m0 *1 128.63,21
X$25994 95 959 284 77 109 1050 MUX2_X1
* cell instance $25998 r0 *1 128.82,21
X$25998 888 1003 1050 77 109 1312 MUX2_X1
* cell instance $26001 m0 *1 131.1,21
X$26001 962 77 109 1400 CLKBUF_X3
* cell instance $26002 m0 *1 132.81,21
X$26002 1011 960 1012 77 109 1163 MUX2_X1
* cell instance $26003 m0 *1 134.14,21
X$26003 1051 887 417 77 109 1012 MUX2_X1
* cell instance $26004 m0 *1 135.47,21
X$26004 146 878 137 77 109 1052 MUX2_X1
* cell instance $26006 m0 *1 136.99,21
X$26006 137 959 866 77 109 1053 MUX2_X1
* cell instance $26007 m0 *1 138.32,21
X$26007 77 18359 1054 1055 653 109 DFF_X1
* cell instance $26012 r0 *1 131.86,21
X$26012 1051 1122 963 77 109 1226 MUX2_X1
* cell instance $26013 r0 *1 133.19,21
X$26013 963 964 1003 109 77 1098 MUX2_X2
* cell instance $26015 r0 *1 136.42,21
X$26015 1054 878 866 77 109 1177 MUX2_X1
* cell instance $26018 r0 *1 138.7,21
X$26018 1054 1122 1056 77 109 1055 MUX2_X1
* cell instance $26020 r0 *1 143.07,21
X$26020 77 653 18700 1103 1104 102 109 DFFR_X1
* cell instance $26021 m0 *1 146.68,21
X$26021 77 653 18601 1057 1013 102 109 DFFR_X1
* cell instance $26023 m0 *1 150.48,21
X$26023 1016 965 77 109 1013 NOR2_X1
* cell instance $26024 m0 *1 151.05,21
X$26024 813 501 77 109 1105 NAND2_X1
* cell instance $26025 m0 *1 151.62,21
X$26025 453 1166 1105 77 1016 109 AOI21_X1
* cell instance $26026 m0 *1 152.38,21
X$26026 968 967 77 109 813 NOR2_X2
* cell instance $26028 r0 *1 146.87,21
X$26028 1103 77 109 1129 BUF_X2
* cell instance $26030 r0 *1 150.67,21
X$26030 1057 77 109 966 CLKBUF_X3
* cell instance $26033 m0 *1 153.71,21
X$26033 968 602 77 109 890 NAND2_X1
* cell instance $26034 m0 *1 155.8,21
X$26034 1058 726 77 109 893 OR2_X1
* cell instance $26035 m0 *1 156.56,21
X$26035 1059 973 77 109 1021 NAND2_X1
* cell instance $26036 m0 *1 157.13,21
X$26036 722 1108 1021 109 970 77 OAI21_X1
* cell instance $26037 m0 *1 157.89,21
X$26037 971 1023 892 77 109 968 NAND3_X1
* cell instance $26038 m0 *1 158.65,21
X$26038 971 894 77 109 947 NAND2_X1
* cell instance $26039 m0 *1 159.22,21
X$26039 1060 966 892 971 77 822 109 NAND4_X2
* cell instance $26040 m0 *1 160.93,21
X$26040 971 1023 501 77 109 1024 NAND3_X1
* cell instance $26041 m0 *1 161.69,21
X$26041 453 1024 1113 77 823 109 AOI21_X1
* cell instance $26045 r0 *1 156.18,21
X$26045 1058 77 109 973 CLKBUF_X3
* cell instance $26047 r0 *1 157.32,21
X$26047 461 1084 77 109 787 OR2_X1
* cell instance $26048 r0 *1 158.08,21
X$26048 1111 966 892 971 77 819 109 NAND4_X2
* cell instance $26049 r0 *1 159.79,21
X$26049 971 1060 892 77 109 1108 NAND3_X1
* cell instance $26051 r0 *1 160.74,21
X$26051 1132 602 77 109 972 NAND2_X1
* cell instance $26052 r0 *1 161.31,21
X$26052 1023 1112 77 109 1132 NAND2_X1
* cell instance $26053 r0 *1 161.88,21
X$26053 973 1156 77 109 1113 NAND2_X1
* cell instance $26054 r0 *1 162.45,21
X$26054 1025 1112 109 77 971 AND2_X2
* cell instance $26057 m0 *1 163.59,21
X$26057 484 973 77 109 507 NAND2_X1
* cell instance $26059 r0 *1 163.59,21
X$26059 77 977 18839 1116 1061 102 109 DFFR_X1
* cell instance $26060 m0 *1 166.63,21
X$26060 1029 288 975 77 1115 109 AOI21_X1
* cell instance $26061 m0 *1 166.06,21
X$26061 1030 974 77 109 975 NAND2_X1
* cell instance $26063 m0 *1 167.58,21
X$26063 77 977 1115 102 18958 897 109 DFFR_X2
* cell instance $26065 m0 *1 171.95,21
X$26065 77 981 605 1114 606 897 109 AOI22_X4
* cell instance $26066 m0 *1 175.18,21
X$26066 839 973 77 109 1036 NAND2_X1
* cell instance $26067 m0 *1 175.75,21
X$26067 978 973 77 109 790 NAND2_X1
* cell instance $26069 m0 *1 176.51,21
X$26069 735 873 77 109 940 NAND2_X1
* cell instance $26070 m0 *1 177.08,21
X$26070 237 1110 980 181 77 109 1109 AOI22_X2
* cell instance $26071 m0 *1 178.79,21
X$26071 983 611 695 966 77 109 1107 AOI22_X2
* cell instance $26072 m0 *1 180.5,21
X$26072 909 733 737 594 77 109 1106 AOI22_X2
* cell instance $26074 r0 *1 167.39,21
X$26074 1116 77 109 1112 BUF_X2
* cell instance $26076 r0 *1 168.34,21
X$26076 77 977 18793 1245 1062 102 109 DFFR_X1
* cell instance $26081 r0 *1 172.52,21
X$26081 996 973 77 109 976 NAND2_X1
* cell instance $26083 r0 *1 173.28,21
X$26083 621 973 77 109 604 NAND2_X1
* cell instance $26084 r0 *1 173.85,21
X$26084 904 375 377 892 77 109 1323 AOI22_X2
* cell instance $26085 r0 *1 175.56,21
X$26085 461 1063 77 109 979 OR2_X1
* cell instance $26089 r0 *1 178.41,21
X$26089 615 1110 980 873 77 109 1160 AOI22_X2
* cell instance $26092 m0 *1 182.59,21
X$26092 1035 109 978 77 BUF_X4
* cell instance $26093 m0 *1 188.1,21
X$26093 1028 77 109 898 BUF_X2
* cell instance $26095 m0 *1 189.05,21
X$26095 899 303 77 109 1064 NAND2_X1
* cell instance $26098 m0 *1 191.33,21
X$26098 831 77 109 305 CLKBUF_X3
* cell instance $26101 m0 *1 193.99,21
X$26101 1059 329 1101 77 109 1018 MUX2_X1
* cell instance $26102 m0 *1 195.32,21
X$26102 1102 741 1018 77 1020 109 AOI21_X1
* cell instance $26104 m0 *1 196.27,21
X$26104 983 982 385 77 1068 109 AOI21_X1
* cell instance $26107 m0 *1 199.31,21
X$26107 908 1095 1402 472 109 77 835 OAI22_X1
* cell instance $26110 m0 *1 201.97,21
X$26110 985 1095 1084 472 109 77 860 OAI22_X1
* cell instance $26111 m0 *1 202.92,21
X$26111 984 909 77 109 986 NAND2_X1
* cell instance $26113 m0 *1 203.68,21
X$26113 905 1009 969 472 109 77 1069 OAI22_X1
* cell instance $26116 r0 *1 184.87,21
X$26116 1136 77 109 329 CLKBUF_X3
* cell instance $26118 r0 *1 186.2,21
X$26118 77 1139 1026 102 19004 981 109 DFFR_X2
* cell instance $26119 r0 *1 190.38,21
X$26119 831 77 109 303 CLKBUF_X3
* cell instance $26124 r0 *1 194.18,21
X$26124 1066 77 109 1067 INV_X1
* cell instance $26125 r0 *1 194.56,21
X$26125 1067 1099 303 109 1100 77 OAI21_X1
* cell instance $26127 r0 *1 195.51,21
X$26127 904 1100 385 77 1102 109 AOI21_X1
* cell instance $26128 r0 *1 196.27,21
X$26128 1068 741 1138 77 1096 109 AOI21_X1
* cell instance $26129 r0 *1 197.03,21
X$26129 77 1139 18740 983 1096 102 109 DFFR_X1
* cell instance $26134 r0 *1 203.68,21
X$26134 467 910 77 109 1009 OR2_X1
* cell instance $26136 m0 *1 205.2,21
X$26136 986 1009 1087 472 109 77 1005 OAI22_X1
* cell instance $26138 m0 *1 206.15,21
X$26138 910 985 77 109 395 OR2_X2
* cell instance $26141 r0 *1 205.2,21
X$26141 1091 741 1069 77 1090 109 AOI21_X1
* cell instance $26142 r0 *1 205.96,21
X$26142 77 1083 1090 102 19014 1137 109 DFFR_X2
* cell instance $26144 m0 *1 210.9,21
X$26144 77 1083 18665 1070 1085 102 109 DFFR_X1
* cell instance $26145 m0 *1 210.52,21
X$26145 1001 77 109 1086 INV_X1
* cell instance $26147 m0 *1 214.89,21
X$26147 788 912 1080 77 109 1002 MUX2_X1
* cell instance $26148 m0 *1 216.22,21
X$26148 77 750 18647 1080 1002 102 109 DFFR_X1
* cell instance $26152 r0 *1 212.23,21
X$26152 1059 747 1150 109 1085 77 OAI21_X1
* cell instance $26154 r0 *1 213.37,21
X$26154 748 1070 77 109 1150 NAND2_X1
* cell instance $26157 r0 *1 215.08,21
X$26157 77 1083 18883 1222 1081 1146 109 DFFR_X1
* cell instance $26160 m0 *1 220.4,21
X$26160 77 750 18632 913 997 102 109 DFFR_X1
* cell instance $26162 r0 *1 222.3,21
X$26162 750 77 109 19277 CLKBUF_X1
* cell instance $26166 r0 *1 224.2,21
X$26166 77 1072 18768 987 1071 1146 109 DFFR_X1
* cell instance $26167 m0 *1 224.77,21
X$26167 996 843 995 109 1071 77 OAI21_X1
* cell instance $26171 m0 *1 227.24,21
X$26171 77 1072 18673 988 915 102 109 DFFR_X1
* cell instance $26172 m0 *1 226.67,21
X$26172 844 987 77 109 995 NAND2_X1
* cell instance $26174 m0 *1 231.23,21
X$26174 844 988 77 109 994 NAND2_X1
* cell instance $26179 r0 *1 228,21
X$26179 77 1072 18721 1214 1079 102 109 DFFR_X1
* cell instance $26181 m0 *1 235.98,21
X$26181 748 989 77 109 1074 NAND2_X1
* cell instance $26182 m0 *1 232.18,21
X$26182 77 753 18683 1073 1078 992 109 DFFR_X1
* cell instance $26183 m0 *1 236.55,21
X$26183 753 77 109 19133 INV_X1
* cell instance $26187 r0 *1 232.56,21
X$26187 978 747 1077 109 1078 77 OAI21_X1
* cell instance $26189 r0 *1 233.51,21
X$26189 748 1073 77 109 1077 NAND2_X1
* cell instance $26190 r0 *1 234.08,21
X$26190 839 747 1074 109 1075 77 OAI21_X1
* cell instance $26191 r0 *1 234.84,21
X$26191 999 77 109 753 CLKBUF_X3
* cell instance $26192 r0 *1 235.79,21
X$26192 77 753 18859 989 1075 992 109 DFFR_X1
* cell instance $26212 m0 *1 88.73,18.2
X$26212 797 394 86 77 109 918 MUX2_X1
* cell instance $26237 r0 *1 86.64,18.2
X$26237 77 18420 797 918 877 109 DFF_X1
* cell instance $26239 r0 *1 90.25,18.2
X$26239 77 18407 953 990 877 109 DFF_X1
* cell instance $26240 m0 *1 91.39,18.2
X$26240 77 18319 799 798 877 109 DFF_X1
* cell instance $26246 r0 *1 95.19,18.2
X$26246 1039 394 119 77 109 993 MUX2_X1
* cell instance $26247 m0 *1 95.95,18.2
X$26247 640 486 800 77 109 641 MUX2_X1
* cell instance $26253 r0 *1 97.09,18.2
X$26253 77 18479 956 954 955 109 DFF_X1
* cell instance $26255 m0 *1 99.18,18.2
X$26255 82 281 799 77 109 957 MUX2_X1
* cell instance $26256 m0 *1 101.27,18.2
X$26256 77 18313 802 854 644 109 DFF_X1
* cell instance $26257 m0 *1 104.5,18.2
X$26257 802 878 441 77 109 1000 MUX2_X1
* cell instance $26258 m0 *1 105.83,18.2
X$26258 409 77 109 644 CLKBUF_X3
* cell instance $26259 m0 *1 106.78,18.2
X$26259 643 879 921 77 109 880 MUX2_X1
* cell instance $26263 m0 *1 111.34,18.2
X$26263 525 803 77 109 883 NAND2_X1
* cell instance $26267 m0 *1 114.38,18.2
X$26267 926 960 924 77 109 1342 MUX2_X1
* cell instance $26271 r0 *1 102.03,18.2
X$26271 645 109 885 77 BUF_X4
* cell instance $26272 r0 *1 103.36,18.2
X$26272 640 878 215 77 109 998 MUX2_X1
* cell instance $26274 r0 *1 105.07,18.2
X$26274 998 1000 1119 109 77 927 MUX2_X2
* cell instance $26276 r0 *1 107.16,18.2
X$26276 881 77 109 879 INV_X2
* cell instance $26279 r0 *1 110.01,18.2
X$26279 138 958 77 109 882 NAND2_X1
* cell instance $26280 r0 *1 110.58,18.2
X$26280 881 882 883 77 925 109 AOI21_X2
* cell instance $26281 r0 *1 111.91,18.2
X$26281 77 1154 925 881 646 109 AOI21_X4
* cell instance $26290 m0 *1 117.99,18.2
X$26290 142 885 770 77 109 1092 MUX2_X1
* cell instance $26293 r0 *1 117.8,18.2
X$26293 77 18439 806 929 861 109 DFF_X1
* cell instance $26294 m0 *1 119.89,18.2
X$26294 806 442 930 77 109 929 MUX2_X1
* cell instance $26299 r0 *1 121.41,18.2
X$26299 806 805 408 77 109 1007 MUX2_X1
* cell instance $26301 m0 *1 123.12,18.2
X$26301 77 18345 864 807 861 109 DFF_X1
* cell instance $26305 r0 *1 122.74,18.2
X$26305 1006 960 1007 77 109 1049 MUX2_X1
* cell instance $26308 r0 *1 125.21,18.2
X$26308 886 442 888 77 109 1008 MUX2_X1
* cell instance $26311 r0 *1 128.82,18.2
X$26311 886 887 284 77 109 1010 MUX2_X1
* cell instance $26312 m0 *1 130.34,18.2
X$26312 143 887 95 77 109 889 MUX2_X1
* cell instance $26313 m0 *1 129.01,18.2
X$26313 143 885 809 77 109 888 MUX2_X1
* cell instance $26315 m0 *1 132.43,18.2
X$26315 212 645 715 77 109 963 MUX2_X1
* cell instance $26318 m0 *1 136.99,18.2
X$26318 77 18347 866 936 653 109 DFF_X1
* cell instance $26322 m0 *1 145.54,18.2
X$26322 77 653 811 102 18954 815 109 DFFR_X2
* cell instance $26323 m0 *1 149.72,18.2
X$26323 722 869 1015 109 812 77 OAI21_X1
* cell instance $26324 m0 *1 150.48,18.2
X$26324 813 720 814 77 109 869 NAND3_X1
* cell instance $26327 r0 *1 130.15,18.2
X$26327 889 960 1010 77 109 962 MUX2_X1
* cell instance $26329 r0 *1 131.86,18.2
X$26329 212 887 175 77 109 1011 MUX2_X1
* cell instance $26330 r0 *1 133.19,18.2
X$26330 175 959 417 77 109 964 MUX2_X1
* cell instance $26333 r0 *1 139.08,18.2
X$26333 146 885 810 77 109 1056 MUX2_X1
* cell instance $26337 r0 *1 142.5,18.2
X$26337 345 77 109 653 CLKBUF_X3
* cell instance $26338 r0 *1 143.45,18.2
X$26338 653 77 109 19268 CLKBUF_X1
* cell instance $26340 r0 *1 145.54,18.2
X$26340 77 653 18741 1014 948 102 109 DFFR_X1
* cell instance $26341 r0 *1 149.34,18.2
X$26341 1014 77 109 892 CLKBUF_X3
* cell instance $26344 r0 *1 150.86,18.2
X$26344 966 890 288 77 965 109 AOI21_X1
* cell instance $26345 r0 *1 151.62,18.2
X$26345 943 178 945 77 939 109 AOI21_X1
* cell instance $26347 m0 *1 152.38,18.2
X$26347 814 720 815 109 77 816 AND3_X1
* cell instance $26349 r0 *1 152.38,18.2
X$26349 966 77 109 967 INV_X1
* cell instance $26351 r0 *1 152.95,18.2
X$26351 814 1017 592 77 943 109 AOI21_X1
* cell instance $26352 r0 *1 153.71,18.2
X$26352 726 348 77 109 1017 NAND2_X1
* cell instance $26354 r0 *1 154.47,18.2
X$26354 891 893 1235 109 945 77 OAI21_X1
* cell instance $26356 m0 *1 154.47,18.2
X$26356 814 77 109 891 INV_X1
* cell instance $26357 m0 *1 155.42,18.2
X$26357 874 178 946 77 811 109 AOI21_X1
* cell instance $26360 m0 *1 156.37,18.2
X$26360 815 951 592 77 874 109 AOI21_X1
* cell instance $26362 m0 *1 157.32,18.2
X$26362 947 348 77 109 1019 NAND2_X1
* cell instance $26363 m0 *1 157.89,18.2
X$26363 815 720 814 77 109 728 NAND3_X2
* cell instance $26365 m0 *1 159.41,18.2
X$26365 821 822 227 109 951 77 OAI21_X1
* cell instance $26368 r0 *1 155.42,18.2
X$26368 893 728 602 969 109 77 946 OAI22_X1
* cell instance $26370 r0 *1 156.56,18.2
X$26370 949 178 970 77 948 109 AOI21_X1
* cell instance $26372 r0 *1 157.51,18.2
X$26372 892 1019 592 77 949 109 AOI21_X1
* cell instance $26373 r0 *1 158.27,18.2
X$26373 894 966 892 971 77 726 109 NAND4_X2
* cell instance $26374 r0 *1 159.98,18.2
X$26374 820 77 109 530 CLKBUF_X3
* cell instance $26376 m0 *1 160.55,18.2
X$26376 820 77 109 722 CLKBUF_X3
* cell instance $26378 r0 *1 161.12,18.2
X$26378 1025 972 288 77 952 109 AOI21_X1
* cell instance $26379 m0 *1 162.07,18.2
X$26379 823 952 77 109 824 NOR2_X1
* cell instance $26383 m0 *1 163.02,18.2
X$26383 464 77 109 178 CLKBUF_X3
* cell instance $26385 m0 *1 166.25,18.2
X$26385 464 77 109 288 CLKBUF_X3
* cell instance $26386 m0 *1 167.2,18.2
X$26386 605 109 733 77 BUF_X4
* cell instance $26388 m0 *1 168.72,18.2
X$26388 825 182 77 109 950 NOR2_X1
* cell instance $26389 m0 *1 169.29,18.2
X$26389 825 182 458 109 896 77 OAI21_X1
* cell instance $26391 m0 *1 170.81,18.2
X$26391 826 827 77 109 665 NAND2_X1
* cell instance $26392 m0 *1 171.38,18.2
X$26392 826 732 827 77 109 825 NAND3_X1
* cell instance $26393 m0 *1 172.14,18.2
X$26393 825 338 976 109 876 77 OAI21_X1
* cell instance $26395 r0 *1 165.68,18.2
X$26395 461 554 77 109 638 OR2_X1
* cell instance $26397 r0 *1 166.82,18.2
X$26397 950 501 897 77 109 1030 NAND3_X1
* cell instance $26398 r0 *1 167.58,18.2
X$26398 895 77 109 453 INV_X2
* cell instance $26399 r0 *1 168.15,18.2
X$26399 895 77 109 464 BUF_X2
* cell instance $26401 r0 *1 169.1,18.2
X$26401 897 896 464 77 1029 109 AOI21_X1
* cell instance $26407 r0 *1 172.14,18.2
X$26407 77 898 733 1037 737 732 109 AOI22_X4
* cell instance $26409 m0 *1 173.28,18.2
X$26409 665 298 1036 109 944 77 OAI21_X1
* cell instance $26410 m0 *1 174.23,18.2
X$26410 829 296 944 77 941 109 AOI21_X1
* cell instance $26411 m0 *1 174.99,18.2
X$26411 827 942 464 77 829 109 AOI21_X1
* cell instance $26412 m0 *1 175.75,18.2
X$26412 940 182 458 109 942 77 OAI21_X1
* cell instance $26413 m0 *1 176.51,18.2
X$26413 940 338 979 109 830 77 OAI21_X1
* cell instance $26414 m0 *1 177.27,18.2
X$26414 736 296 830 77 938 109 AOI21_X1
* cell instance $26416 m0 *1 178.22,18.2
X$26416 832 608 609 827 77 109 937 AOI22_X2
* cell instance $26419 r0 *1 175.37,18.2
X$26419 77 977 18838 827 941 102 109 DFFR_X1
* cell instance $26420 r0 *1 179.17,18.2
X$26420 77 152 18783 873 938 102 109 DFFR_X1
* cell instance $26422 m0 *1 181.07,18.2
X$26422 77 377 109 737 BUF_X8
* cell instance $26423 m0 *1 183.73,18.2
X$26423 1035 831 935 77 109 505 MUX2_X1
* cell instance $26425 m0 *1 185.25,18.2
X$26425 833 380 329 109 1033 77 OAI21_X1
* cell instance $26426 m0 *1 186.01,18.2
X$26426 833 380 934 77 109 933 NOR3_X1
* cell instance $26429 r0 *1 183.35,18.2
X$26429 1034 831 933 77 109 1032 MUX2_X1
* cell instance $26430 r0 *1 184.68,18.2
X$26430 932 184 1032 77 1031 109 AOI21_X1
* cell instance $26431 r0 *1 186.2,18.2
X$26431 898 77 109 934 INV_X1
* cell instance $26434 m0 *1 187.15,18.2
X$26434 1063 305 931 109 690 77 OAI21_X1
* cell instance $26437 r0 *1 187.91,18.2
X$26437 900 898 77 109 899 NAND2_X1
* cell instance $26438 m0 *1 188.48,18.2
X$26438 839 831 900 77 109 865 MUX2_X1
* cell instance $26441 m0 *1 190.76,18.2
X$26441 831 77 109 472 CLKBUF_X3
* cell instance $26442 m0 *1 191.71,18.2
X$26442 831 77 109 314 CLKBUF_X3
* cell instance $26445 m0 *1 199.5,18.2
X$26445 836 741 835 77 862 109 AOI21_X1
* cell instance $26446 m0 *1 200.26,18.2
X$26446 795 928 385 77 836 109 AOI21_X1
* cell instance $26447 m0 *1 201.02,18.2
X$26447 795 77 109 907 INV_X1
* cell instance $26448 m0 *1 201.4,18.2
X$26448 77 149 837 102 18920 744 109 DFFR_X2
* cell instance $26449 m0 *1 205.58,18.2
X$26449 77 149 838 102 18942 909 109 DFFR_X2
* cell instance $26454 r0 *1 188.67,18.2
X$26454 900 303 981 898 77 109 1022 NAND4_X1
* cell instance $26456 r0 *1 189.81,18.2
X$26456 1065 184 901 77 1026 109 AOI21_X1
* cell instance $26457 r0 *1 190.57,18.2
X$26457 903 305 1022 109 901 77 OAI21_X1
* cell instance $26459 r0 *1 192.09,18.2
X$26459 77 1139 1020 102 19005 904 109 DFFR_X2
* cell instance $26462 r0 *1 200.07,18.2
X$26462 905 906 314 109 928 77 OAI21_X1
* cell instance $26463 r0 *1 200.83,18.2
X$26463 905 907 77 109 984 NOR2_X1
* cell instance $26464 r0 *1 201.4,18.2
X$26464 907 905 77 109 908 OR2_X1
* cell instance $26465 r0 *1 202.16,18.2
X$26465 984 744 909 77 109 985 NAND3_X1
* cell instance $26467 r0 *1 203.11,18.2
X$26467 986 906 314 109 743 77 OAI21_X1
* cell instance $26469 r0 *1 204.06,18.2
X$26469 906 985 77 109 315 OR2_X2
* cell instance $26471 r0 *1 205.2,18.2
X$26471 908 910 314 109 1004 77 OAI21_X1
* cell instance $26472 r0 *1 205.96,18.2
X$26472 923 741 1005 77 838 109 AOI21_X1
* cell instance $26473 r0 *1 206.72,18.2
X$26473 909 1004 240 77 923 109 AOI21_X1
* cell instance $26477 r0 *1 211.66,18.2
X$26477 77 317 18819 1001 911 102 109 DFFR_X1
* cell instance $26478 m0 *1 212.61,18.2
X$26478 625 747 922 109 911 77 OAI21_X1
* cell instance $26480 m0 *1 213.37,18.2
X$26480 748 1001 77 109 922 NAND2_X1
* cell instance $26481 m0 *1 213.94,18.2
X$26481 77 317 18635 841 855 102 109 DFFR_X1
* cell instance $26482 m0 *1 217.74,18.2
X$26482 759 843 840 109 855 77 OAI21_X1
* cell instance $26483 m0 *1 218.5,18.2
X$26483 844 841 77 109 840 NAND2_X1
* cell instance $26486 m0 *1 220.78,18.2
X$26486 77 750 18633 853 842 102 109 DFFR_X1
* cell instance $26487 m0 *1 224.58,18.2
X$26487 621 843 852 109 919 77 OAI21_X1
* cell instance $26488 m0 *1 225.34,18.2
X$26488 844 914 77 109 852 NAND2_X1
* cell instance $26494 r0 *1 218.12,18.2
X$26494 912 77 109 748 CLKBUF_X3
* cell instance $26495 r0 *1 219.07,18.2
X$26495 912 77 109 747 CLKBUF_X3
* cell instance $26497 r0 *1 220.21,18.2
X$26497 748 913 77 109 920 NAND2_X1
* cell instance $26498 r0 *1 220.78,18.2
X$26498 996 747 920 109 997 77 OAI21_X1
* cell instance $26499 r0 *1 221.54,18.2
X$26499 999 77 109 750 CLKBUF_X3
* cell instance $26500 r0 *1 222.49,18.2
X$26500 77 750 18767 914 919 102 109 DFFR_X1
* cell instance $26502 r0 *1 226.48,18.2
X$26502 77 102 1146 109 BUF_X32
* cell instance $26506 m0 *1 228.57,18.2
X$26506 578 843 846 109 845 77 OAI21_X1
* cell instance $26507 m0 *1 227.81,18.2
X$26507 839 843 994 109 915 77 OAI21_X1
* cell instance $26508 m0 *1 229.33,18.2
X$26508 844 850 77 109 846 NAND2_X1
* cell instance $26509 m0 *1 229.9,18.2
X$26509 77 102 992 109 BUF_X32
* cell instance $26511 r0 *1 235.79,18.2
X$26511 503 747 916 109 917 77 OAI21_X1
* cell instance $26513 r0 *1 236.74,18.2
X$26513 748 847 77 109 916 NAND2_X1
* cell instance $26560 r0 *1 89.3,29.4
X$26560 77 18397 1427 1636 1487 109 DFF_X1
* cell instance $26561 r0 *1 92.53,29.4
X$26561 1427 332 324 77 109 1636 MUX2_X1
* cell instance $26562 m0 *1 94.24,29.4
X$26562 1488 418 1547 77 109 1549 MUX2_X1
* cell instance $26563 m0 *1 92.91,29.4
X$26563 324 216 1427 77 109 1547 MUX2_X1
* cell instance $26568 r0 *1 93.86,29.4
X$26568 77 18400 1488 1549 1487 109 DFF_X1
* cell instance $26570 r0 *1 97.47,29.4
X$26570 1489 442 1574 77 109 1575 MUX2_X1
* cell instance $26573 r0 *1 100.7,29.4
X$26573 77 18402 1491 1490 955 109 DFF_X1
* cell instance $26574 m0 *1 101.46,29.4
X$26574 1491 642 1492 77 109 1490 MUX2_X1
* cell instance $26578 m0 *1 104.69,29.4
X$26578 1428 1429 1119 109 77 1432 MUX2_X2
* cell instance $26579 m0 *1 103.93,29.4
X$26579 1119 1428 77 109 1551 OR2_X1
* cell instance $26580 m0 *1 106.4,29.4
X$26580 1551 1336 1429 109 77 1495 OAI21_X4
* cell instance $26581 m0 *1 108.87,29.4
X$26581 1493 1495 77 109 1496 NAND2_X2
* cell instance $26582 m0 *1 109.82,29.4
X$26582 1430 109 1339 77 BUF_X4
* cell instance $26583 m0 *1 111.15,29.4
X$26583 1495 109 1436 77 BUF_X4
* cell instance $26584 m0 *1 112.48,29.4
X$26584 1432 1338 1554 77 109 NOR2_X4
* cell instance $26585 m0 *1 114.19,29.4
X$26585 1500 1338 1499 77 109 NOR2_X4
* cell instance $26587 m0 *1 116.09,29.4
X$26587 1578 1434 1341 1501 77 109 1557 AOI22_X1
* cell instance $26588 m0 *1 117.04,29.4
X$26588 1435 1432 77 109 1501 NOR2_X1
* cell instance $26591 r0 *1 103.93,29.4
X$26591 1491 878 1489 77 109 1429 MUX2_X1
* cell instance $26592 r0 *1 105.26,29.4
X$26592 1489 959 77 109 1576 NAND2_X1
* cell instance $26593 r0 *1 105.83,29.4
X$26593 1334 1119 1335 77 109 1493 MUX2_X1
* cell instance $26594 r0 *1 107.16,29.4
X$26594 1493 109 1481 77 BUF_X4
* cell instance $26595 r0 *1 108.49,29.4
X$26595 1496 1430 1497 77 109 NOR2_X4
* cell instance $26596 r0 *1 110.2,29.4
X$26596 1498 1431 1499 1396 1481 1641 109 77 AOI221_X2
* cell instance $26597 r0 *1 112.29,29.4
X$26597 77 1340 1579 1433 2058 1436 109 OAI22_X4
* cell instance $26601 r0 *1 115.52,29.4
X$26601 1481 1495 77 109 1578 NOR2_X1
* cell instance $26602 r0 *1 116.09,29.4
X$26602 1433 1432 77 109 1500 NAND2_X2
* cell instance $26604 r0 *1 117.42,29.4
X$26604 858 1494 77 109 1647 NOR2_X1
* cell instance $26606 r0 *1 118.18,29.4
X$26606 927 1499 109 77 1584 AND2_X1
* cell instance $26607 m0 *1 119.7,29.4
X$26607 1431 1478 1502 77 1650 109 AOI21_X1
* cell instance $26608 m0 *1 118.75,29.4
X$26608 927 77 109 1503 CLKBUF_X3
* cell instance $26609 m0 *1 120.46,29.4
X$26609 1175 1435 1436 109 1502 77 OAI21_X1
* cell instance $26610 m0 *1 121.22,29.4
X$26610 1437 1175 1435 77 109 1478 NAND3_X1
* cell instance $26611 m0 *1 121.98,29.4
X$26611 1437 1175 1400 77 1504 109 AOI21_X1
* cell instance $26613 m0 *1 122.93,29.4
X$26613 1495 1172 1340 77 1480 109 AOI21_X1
* cell instance $26615 m0 *1 123.88,29.4
X$26615 1049 77 109 1440 CLKBUF_X3
* cell instance $26617 m0 *1 125.02,29.4
X$26617 1438 1436 1440 77 1558 109 AOI21_X1
* cell instance $26618 m0 *1 125.78,29.4
X$26618 1439 1440 1435 77 109 1505 NAND3_X1
* cell instance $26621 m0 *1 127.49,29.4
X$26621 1047 1441 77 109 1506 OR2_X1
* cell instance $26623 m0 *1 128.44,29.4
X$26623 1441 1442 1047 109 77 1814 MUX2_X2
* cell instance $26625 m0 *1 130.34,29.4
X$26625 77 1654 1443 1119 1444 109 AOI21_X4
* cell instance $26627 m0 *1 133,29.4
X$26627 1347 1346 1128 77 1561 109 AOI21_X1
* cell instance $26629 m0 *1 133.95,29.4
X$26629 1347 642 1562 77 109 1657 MUX2_X1
* cell instance $26631 m0 *1 135.47,29.4
X$26631 209 281 654 77 109 1562 MUX2_X1
* cell instance $26633 m0 *1 136.99,29.4
X$26633 77 717 18669 1563 1484 102 109 DFFR_X1
* cell instance $26635 r0 *1 118.94,29.4
X$26635 1583 1497 1650 1392 1503 1649 109 77 AOI221_X2
* cell instance $26637 r0 *1 121.22,29.4
X$26637 1392 1585 77 109 1690 NOR2_X1
* cell instance $26638 r0 *1 121.79,29.4
X$26638 1495 1431 77 109 1587 NOR2_X2
* cell instance $26639 r0 *1 122.74,29.4
X$26639 1504 77 109 1588 INV_X1
* cell instance $26642 r0 *1 123.69,29.4
X$26642 1495 1339 77 1589 109 NAND2_X4
* cell instance $26644 r0 *1 125.59,29.4
X$26644 1431 1558 1505 109 1590 77 OAI21_X1
* cell instance $26647 r0 *1 128.25,29.4
X$26647 1506 958 1442 109 77 1651 OAI21_X4
* cell instance $26649 r0 *1 130.91,29.4
X$26649 1047 1345 77 109 1592 OR2_X1
* cell instance $26650 r0 *1 131.67,29.4
X$26650 1655 1561 1047 109 77 1656 MUX2_X2
* cell instance $26653 r0 *1 134.33,29.4
X$26653 77 18411 1659 1657 1819 109 DFF_X1
* cell instance $26654 r0 *1 137.56,29.4
X$26654 1659 77 109 1347 BUF_X2
* cell instance $26657 m0 *1 141.17,29.4
X$26657 1563 77 109 1450 BUF_X2
* cell instance $26658 m0 *1 142.69,29.4
X$26658 77 1507 18640 1566 1446 102 109 DFFR_X1
* cell instance $26660 m0 *1 147.25,29.4
X$26660 1566 77 109 1449 BUF_X2
* cell instance $26662 m0 *1 148.2,29.4
X$26662 1485 1259 1567 77 1484 109 AOI21_X1
* cell instance $26664 m0 *1 149.15,29.4
X$26664 1450 1486 1263 77 1485 109 AOI21_X1
* cell instance $26666 m0 *1 150.1,29.4
X$26666 1448 77 109 1509 INV_X1
* cell instance $26668 m0 *1 150.67,29.4
X$26668 1509 1452 724 109 1486 77 OAI21_X1
* cell instance $26669 m0 *1 151.43,29.4
X$26669 1449 1448 1450 1511 109 77 1321 AND4_X1
* cell instance $26670 m0 *1 152.57,29.4
X$26670 1275 1451 1513 1512 77 109 1446 AOI22_X1
* cell instance $26671 m0 *1 153.52,29.4
X$26671 530 1511 1185 109 1512 77 OAI21_X1
* cell instance $26672 m0 *1 154.28,29.4
X$26672 1449 77 109 1513 INV_X1
* cell instance $26673 m0 *1 154.66,29.4
X$26673 1321 1453 631 77 109 1567 MUX2_X1
* cell instance $26675 m0 *1 156.18,29.4
X$26675 1449 1448 1450 1514 109 77 1257 AND4_X2
* cell instance $26676 m0 *1 157.51,29.4
X$26676 345 77 109 1130 CLKBUF_X3
* cell instance $26677 m0 *1 158.46,29.4
X$26677 1573 1572 77 109 1419 NAND2_X1
* cell instance $26678 m0 *1 159.03,29.4
X$26678 1130 77 109 19154 INV_X1
* cell instance $26679 m0 *1 159.41,29.4
X$26679 1450 1448 1449 1268 77 1516 109 NAND4_X2
* cell instance $26680 m0 *1 161.12,29.4
X$26680 1573 1454 77 109 1482 NAND2_X1
* cell instance $26681 m0 *1 161.69,29.4
X$26681 1517 1515 77 109 1455 NOR2_X1
* cell instance $26682 m0 *1 162.26,29.4
X$26682 722 1455 1185 109 1272 77 OAI21_X1
* cell instance $26683 m0 *1 163.02,29.4
X$26683 1455 724 1422 77 109 1571 NAND3_X1
* cell instance $26684 m0 *1 163.78,29.4
X$26684 1186 1571 1164 77 1423 109 AOI21_X1
* cell instance $26686 m0 *1 166.06,29.4
X$26686 1273 77 109 461 CLKBUF_X3
* cell instance $26687 m0 *1 167.01,29.4
X$26687 1519 1456 77 109 1351 NAND2_X2
* cell instance $26689 m0 *1 168.15,29.4
X$26689 1023 1453 1034 77 109 1521 MUX2_X1
* cell instance $26691 m0 *1 169.67,29.4
X$26691 1457 1453 978 77 109 1520 MUX2_X1
* cell instance $26692 m0 *1 171,29.4
X$26692 1355 1458 1263 77 1522 109 AOI21_X1
* cell instance $26694 m0 *1 171.95,29.4
X$26694 77 1523 1568 1146 18923 1355 109 DFFR_X2
* cell instance $26699 r0 *1 141.93,29.4
X$26699 1595 77 109 1699 BUF_X2
* cell instance $26700 r0 *1 142.69,29.4
X$26700 77 1507 18861 1667 1662 102 109 DFFR_X1
* cell instance $26704 r0 *1 149.15,29.4
X$26704 1667 77 109 1448 BUF_X2
* cell instance $26705 r0 *1 149.91,29.4
X$26705 1569 1509 1508 77 1662 109 AOI21_X1
* cell instance $26706 r0 *1 150.67,29.4
X$26706 722 1510 1185 109 1508 77 OAI21_X1
* cell instance $26707 r0 *1 151.43,29.4
X$26707 1510 724 1448 77 109 1669 NAND3_X1
* cell instance $26708 r0 *1 152.19,29.4
X$26708 1331 1669 580 77 1569 109 AOI21_X1
* cell instance $26709 r0 *1 152.95,29.4
X$26709 1511 1449 77 109 1452 NAND2_X1
* cell instance $26712 r0 *1 154.09,29.4
X$26712 1599 1515 1513 77 109 1510 NOR3_X1
* cell instance $26713 r0 *1 154.85,29.4
X$26713 1599 1602 77 109 1511 NOR2_X1
* cell instance $26716 r0 *1 156.37,29.4
X$26716 1599 1515 77 109 1514 NOR2_X1
* cell instance $26718 r0 *1 157.13,29.4
X$26718 1265 1599 1600 1516 109 1573 77 NOR4_X2
* cell instance $26719 r0 *1 158.84,29.4
X$26719 1600 1599 1265 1516 109 1601 77 OR4_X2
* cell instance $26721 r0 *1 160.36,29.4
X$26721 820 1602 77 109 1673 OR2_X1
* cell instance $26722 r0 *1 161.12,29.4
X$26722 1673 1608 507 109 1827 77 OAI21_X1
* cell instance $26723 r0 *1 161.88,29.4
X$26723 1673 1517 707 109 1605 77 OAI21_X1
* cell instance $26725 r0 *1 163.02,29.4
X$26725 1609 1422 1518 77 109 1599 NAND3_X2
* cell instance $26726 r0 *1 164.35,29.4
X$26726 1608 1607 77 109 1609 NOR2_X1
* cell instance $26728 r0 *1 165.11,29.4
X$26728 1609 1518 77 109 1517 NAND2_X1
* cell instance $26731 r0 *1 166.63,29.4
X$26731 1658 820 77 109 1164 NAND2_X1
* cell instance $26732 r0 *1 167.2,29.4
X$26732 1606 1519 1456 77 109 1274 NAND3_X2
* cell instance $26733 r0 *1 168.53,29.4
X$26733 1606 724 1456 77 109 1611 NAND3_X1
* cell instance $26735 r0 *1 169.67,29.4
X$26735 1519 1604 1263 77 1570 109 AOI21_X1
* cell instance $26736 r0 *1 170.43,29.4
X$26736 1570 1275 1520 77 1676 109 AOI21_X1
* cell instance $26740 r0 *1 171.19,29.4
X$26740 1522 1275 1521 77 1568 109 AOI21_X1
* cell instance $26742 r0 *1 172.14,29.4
X$26742 77 1523 1676 1146 19002 1519 109 DFFR_X2
* cell instance $26744 r0 *1 176.7,29.4
X$26744 1459 1110 980 1268 77 109 1680 AOI22_X2
* cell instance $26745 m0 *1 178.98,29.4
X$26745 1135 611 695 1519 77 109 1564 AOI22_X2
* cell instance $26746 m0 *1 177.27,29.4
X$26746 1360 1110 980 1450 77 109 1565 AOI22_X2
* cell instance $26747 m0 *1 180.69,29.4
X$26747 1525 611 695 1238 77 109 1524 AOI22_X2
* cell instance $26749 m0 *1 183.16,29.4
X$26749 1459 1279 1460 109 77 1560 AND3_X1
* cell instance $26750 m0 *1 184.11,29.4
X$26750 1530 1279 1460 77 1559 109 AOI21_X1
* cell instance $26751 m0 *1 184.87,29.4
X$26751 1560 1559 1532 77 109 1475 NOR3_X1
* cell instance $26752 m0 *1 185.63,29.4
X$26752 1158 471 77 109 1532 NOR2_X1
* cell instance $26755 m0 *1 188.48,29.4
X$26755 1534 413 414 77 1533 109 AOI21_X1
* cell instance $26756 m0 *1 189.24,29.4
X$26756 1158 1525 77 109 1535 NAND2_X1
* cell instance $26758 m0 *1 190,29.4
X$26758 1158 1360 77 109 1536 NAND2_X1
* cell instance $26759 m0 *1 190.57,29.4
X$26759 77 1364 18534 1664 1556 1146 109 DFFR_X1
* cell instance $26763 r0 *1 179.93,29.4
X$26763 1135 1612 1459 1525 77 109 1526 NAND4_X1
* cell instance $26764 r0 *1 180.88,29.4
X$26764 1526 1531 77 109 1677 NOR2_X1
* cell instance $26765 r0 *1 181.45,29.4
X$26765 1527 1616 1528 77 109 1358 NAND3_X1
* cell instance $26766 r0 *1 182.21,29.4
X$26766 1135 77 109 1528 INV_X1
* cell instance $26768 r0 *1 182.78,29.4
X$26768 1459 77 109 1615 INV_X1
* cell instance $26769 r0 *1 183.16,29.4
X$26769 1158 1615 77 109 1530 NAND2_X1
* cell instance $26771 r0 *1 184.11,29.4
X$26771 1613 1525 1529 109 77 1460 AND3_X1
* cell instance $26772 r0 *1 185.06,29.4
X$26772 1529 1613 77 109 1531 NAND2_X1
* cell instance $26775 r0 *1 186.58,29.4
X$26775 1531 1361 467 1525 77 109 1534 NOR4_X1
* cell instance $26776 r0 *1 187.53,29.4
X$26776 1613 1412 1529 109 77 1670 AND3_X1
* cell instance $26777 r0 *1 188.48,29.4
X$26777 1283 1533 1535 1670 109 77 1556 OAI22_X1
* cell instance $26778 r0 *1 189.43,29.4
X$26778 1618 1361 467 1357 77 109 1555 NOR4_X1
* cell instance $26780 r0 *1 190.57,29.4
X$26780 1555 1063 414 77 1619 109 AOI21_X1
* cell instance $26781 r0 *1 191.33,29.4
X$26781 1664 77 109 1525 BUF_X2
* cell instance $26784 r0 *1 195.89,29.4
X$26784 77 1364 18901 1537 1538 1146 109 DFFR_X1
* cell instance $26785 m0 *1 197.6,29.4
X$26785 1201 77 109 467 CLKBUF_X3
* cell instance $26786 m0 *1 196.27,29.4
X$26786 1402 1462 1537 77 109 1538 MUX2_X1
* cell instance $26791 r0 *1 200.07,29.4
X$26791 77 1713 18900 1623 1660 1146 109 DFFR_X1
* cell instance $26792 m0 *1 202.54,29.4
X$26792 969 1462 1465 77 109 1464 MUX2_X1
* cell instance $26793 m0 *1 201.21,29.4
X$26793 1463 1462 1623 77 109 1660 MUX2_X1
* cell instance $26796 m0 *1 205.58,29.4
X$26796 1087 1462 1552 77 109 1466 MUX2_X1
* cell instance $26797 m0 *1 206.91,29.4
X$26797 77 1553 18516 1552 1466 1146 109 DFFR_X1
* cell instance $26801 m0 *1 213.18,29.4
X$26801 77 1367 18676 1468 1467 1146 109 DFFR_X1
* cell instance $26802 m0 *1 216.98,29.4
X$26802 1084 912 1468 77 109 1467 MUX2_X1
* cell instance $26804 m0 *1 219.07,29.4
X$26804 912 109 1462 77 BUF_X4
* cell instance $26810 r0 *1 205.2,29.4
X$26810 1658 77 109 399 INV_X2
* cell instance $26811 r0 *1 205.77,29.4
X$26811 1087 1621 1624 77 109 1625 MUX2_X1
* cell instance $26816 r0 *1 209.95,29.4
X$26816 625 1540 1652 109 1653 77 OAI21_X1
* cell instance $26817 r0 *1 210.71,29.4
X$26817 1539 1626 77 109 1652 NAND2_X1
* cell instance $26820 r0 *1 211.85,29.4
X$26820 1539 1628 77 109 1541 NAND2_X1
* cell instance $26821 r0 *1 212.42,29.4
X$26821 405 1540 1541 109 1627 77 OAI21_X1
* cell instance $26822 r0 *1 213.18,29.4
X$26822 999 77 109 1367 CLKBUF_X3
* cell instance $26823 r0 *1 214.13,29.4
X$26823 1236 77 109 999 CLKBUF_X3
* cell instance $26824 r0 *1 215.08,29.4
X$26824 1305 109 1630 77 BUF_X4
* cell instance $26825 r0 *1 216.41,29.4
X$26825 1305 109 1621 77 BUF_X4
* cell instance $26827 r0 *1 218.12,29.4
X$26827 77 1468 1542 1646 1629 1469 109 AOI22_X4
* cell instance $26829 m0 *1 221.73,29.4
X$26829 1470 77 109 1207 CLKBUF_X3
* cell instance $26834 r0 *1 221.92,29.4
X$26834 685 1630 1644 77 109 1645 MUX2_X1
* cell instance $26836 m0 *1 224.01,29.4
X$26836 77 1072 1550 102 18963 1543 109 DFFR_X2
* cell instance $26840 m0 *1 229.14,29.4
X$26840 77 1546 1471 102 18940 1544 109 DFFR_X2
* cell instance $26841 m0 *1 233.32,29.4
X$26841 1470 77 109 1208 CLKBUF_X3
* cell instance $26844 r0 *1 225.53,29.4
X$26844 1629 914 77 109 1785 NAND2_X1
* cell instance $26845 r0 *1 226.1,29.4
X$26845 621 1540 1719 109 1631 77 OAI21_X1
* cell instance $26850 r0 *1 229.9,29.4
X$26850 839 1540 1548 109 1632 77 OAI21_X1
* cell instance $26852 r0 *1 230.85,29.4
X$26852 1539 1633 77 109 1548 NAND2_X1
* cell instance $26853 r0 *1 231.42,29.4
X$26853 999 77 109 1546 CLKBUF_X3
* cell instance $26854 r0 *1 232.37,29.4
X$26854 978 1540 1638 109 1639 77 OAI21_X1
* cell instance $26855 r0 *1 233.13,29.4
X$26855 1539 1634 77 109 1638 NAND2_X1
* cell instance $26857 r0 *1 234.46,29.4
X$26857 471 1462 1635 77 109 1545 MUX2_X1
* cell instance $26859 m0 *1 234.65,29.4
X$26859 77 1546 1472 992 18959 1372 109 DFFR_X2
* cell instance $26861 r0 *1 235.79,29.4
X$26861 77 1546 18800 1635 1545 992 109 DFFR_X1
* cell instance $26880 m0 *1 88.73,26.6
X$26880 77 18297 1248 1247 877 109 DFF_X1
* cell instance $26882 m0 *1 93.48,26.6
X$26882 1377 629 1376 77 109 1375 MUX2_X1
* cell instance $26885 m0 *1 97.09,26.6
X$26885 1379 629 1378 77 109 1333 MUX2_X1
* cell instance $26910 r0 *1 93.29,26.6
X$26910 77 18445 1377 1375 1487 109 DFF_X1
* cell instance $26912 r0 *1 96.9,26.6
X$26912 77 18438 1379 1333 955 109 DFF_X1
* cell instance $26913 m0 *1 99.75,26.6
X$26913 955 77 109 19128 INV_X1
* cell instance $26914 m0 *1 98.8,26.6
X$26914 409 77 109 955 CLKBUF_X3
* cell instance $26917 m0 *1 100.7,26.6
X$26917 83 645 1377 77 109 1380 MUX2_X1
* cell instance $26919 m0 *1 102.03,26.6
X$26919 320 645 1248 77 109 1303 MUX2_X1
* cell instance $26920 m0 *1 103.36,26.6
X$26920 320 878 117 77 109 1334 MUX2_X1
* cell instance $26921 m0 *1 104.69,26.6
X$26921 83 887 248 77 109 1249 MUX2_X1
* cell instance $26925 r0 *1 101.84,26.6
X$26925 139 885 1379 77 109 1492 MUX2_X1
* cell instance $26926 r0 *1 103.17,26.6
X$26926 139 878 324 77 109 1428 MUX2_X1
* cell instance $26928 r0 *1 104.69,26.6
X$26928 1119 1334 77 109 1383 OR2_X1
* cell instance $26930 r0 *1 105.64,26.6
X$26930 1383 1336 1335 109 77 1433 OAI21_X4
* cell instance $26931 m0 *1 108.68,26.6
X$26931 1249 1337 960 109 77 1338 MUX2_X2
* cell instance $26932 m0 *1 107.92,26.6
X$26932 1119 1249 77 109 1384 OR2_X1
* cell instance $26933 m0 *1 110.39,26.6
X$26933 960 1042 77 109 1387 OR2_X1
* cell instance $26934 m0 *1 111.15,26.6
X$26934 1387 1336 804 109 77 1396 OAI21_X4
* cell instance $26936 m0 *1 113.81,26.6
X$26936 196 1047 710 77 109 1391 MUX2_X1
* cell instance $26937 m0 *1 115.14,26.6
X$26937 1389 1391 879 109 77 1390 MUX2_X2
* cell instance $26938 m0 *1 116.85,26.6
X$26938 803 884 77 109 1394 OR2_X1
* cell instance $26939 m0 *1 117.61,26.6
X$26939 77 1124 1227 927 1250 1343 109 NOR4_X4
* cell instance $26940 m0 *1 121.03,26.6
X$26940 884 1395 960 109 77 1344 MUX2_X2
* cell instance $26943 r0 *1 108.49,26.6
X$26943 1384 1336 1337 109 77 1430 OAI21_X2
* cell instance $26945 r0 *1 110.01,26.6
X$26945 1338 109 1431 77 BUF_X4
* cell instance $26947 r0 *1 111.72,26.6
X$26947 1250 77 109 1388 CLKBUF_X3
* cell instance $26949 r0 *1 112.86,26.6
X$26949 1481 1339 1392 77 109 NOR2_X4
* cell instance $26951 r0 *1 114.95,26.6
X$26951 1341 1340 1094 77 109 1434 MUX2_X1
* cell instance $26955 r0 *1 116.28,26.6
X$26955 1433 109 1435 77 BUF_X4
* cell instance $26956 r0 *1 117.61,26.6
X$26956 1342 77 109 1341 CLKBUF_X3
* cell instance $26957 r0 *1 118.56,26.6
X$26957 1394 958 1395 109 77 1477 OAI21_X2
* cell instance $26958 r0 *1 119.89,26.6
X$26958 1250 927 77 109 1437 NAND2_X2
* cell instance $26961 r0 *1 121.22,26.6
X$26961 1437 1396 1340 77 109 NOR2_X4
* cell instance $26962 r0 *1 122.93,26.6
X$26962 1049 1344 1342 109 1692 77 NOR3_X2
* cell instance $26964 m0 *1 123.12,26.6
X$26964 803 1127 77 109 1397 OR2_X1
* cell instance $26965 m0 *1 124.07,26.6
X$26965 1397 958 1173 109 77 1310 OAI21_X4
* cell instance $26968 r0 *1 124.45,26.6
X$26968 1480 1481 77 109 1438 NOR2_X1
* cell instance $26969 r0 *1 125.02,26.6
X$26969 1340 1339 77 109 1439 NAND2_X1
* cell instance $26972 r0 *1 126.73,26.6
X$26972 1174 109 645 77 BUF_X4
* cell instance $26974 m0 *1 126.92,26.6
X$26974 96 881 82 77 109 1441 MUX2_X1
* cell instance $26975 m0 *1 129.01,26.6
X$26975 209 196 82 77 1399 109 AOI21_X1
* cell instance $26976 m0 *1 129.77,26.6
X$26976 145 881 196 77 109 1345 MUX2_X1
* cell instance $26978 m0 *1 131.29,26.6
X$26978 209 145 96 77 1655 109 AOI21_X1
* cell instance $26980 m0 *1 132.24,26.6
X$26980 1251 109 1119 77 BUF_X4
* cell instance $26981 m0 *1 133.57,26.6
X$26981 1346 642 1389 77 109 1401 MUX2_X1
* cell instance $26983 m0 *1 136.42,26.6
X$26983 345 77 109 717 CLKBUF_X3
* cell instance $26984 m0 *1 137.37,26.6
X$26984 717 77 109 19200 CLKBUF_X1
* cell instance $26990 r0 *1 128.25,26.6
X$26990 1128 881 1118 77 109 1442 MUX2_X1
* cell instance $26992 r0 *1 129.96,26.6
X$26992 1336 1399 109 77 1443 AND2_X1
* cell instance $26993 r0 *1 130.72,26.6
X$26993 1347 710 1118 77 1444 109 AOI21_X2
* cell instance $26994 r0 *1 132.05,26.6
X$26994 1346 881 710 77 109 1594 MUX2_X1
* cell instance $26995 r0 *1 133.38,26.6
X$26995 77 18478 1346 1401 717 109 DFF_X1
* cell instance $26997 r0 *1 138.13,26.6
X$26997 77 717 18868 1483 1405 102 109 DFFR_X1
* cell instance $26998 r0 *1 141.93,26.6
X$26998 77 717 18820 1252 1406 102 109 DFFR_X1
* cell instance $26999 m0 *1 143.83,26.6
X$26999 1483 77 109 1180 BUF_X2
* cell instance $27002 m0 *1 145.35,26.6
X$27002 1252 77 109 1258 BUF_X2
* cell instance $27003 m0 *1 146.11,26.6
X$27003 1255 1254 1263 77 1253 109 AOI21_X1
* cell instance $27004 m0 *1 146.87,26.6
X$27004 1256 1257 77 109 1409 NAND2_X1
* cell instance $27005 m0 *1 147.44,26.6
X$27005 1257 1129 1180 77 109 1319 NAND3_X1
* cell instance $27006 m0 *1 148.2,26.6
X$27006 1182 1349 1259 1350 77 109 1405 AOI22_X1
* cell instance $27007 m0 *1 149.15,26.6
X$27007 1182 1260 584 109 1350 77 OAI21_X1
* cell instance $27008 m0 *1 149.91,26.6
X$27008 1257 458 77 109 1260 NAND2_X1
* cell instance $27009 m0 *1 150.48,26.6
X$27009 1260 1261 431 109 1348 77 OAI21_X1
* cell instance $27010 m0 *1 151.24,26.6
X$27010 1256 1258 77 109 1261 NAND2_X1
* cell instance $27011 m0 *1 151.81,26.6
X$27011 1261 1262 724 109 1411 77 OAI21_X1
* cell instance $27012 m0 *1 152.57,26.6
X$27012 1331 77 109 1186 CLKBUF_X3
* cell instance $27014 m0 *1 153.71,26.6
X$27014 1238 1411 1263 77 1264 109 AOI21_X1
* cell instance $27016 m0 *1 154.66,26.6
X$27016 1256 1321 1238 1258 77 109 1413 NAND4_X1
* cell instance $27017 m0 *1 155.61,26.6
X$27017 1256 1238 1258 77 109 1265 NAND3_X2
* cell instance $27018 m0 *1 156.94,26.6
X$27018 1257 77 109 1417 INV_X1
* cell instance $27020 m0 *1 157.51,26.6
X$27020 1265 1417 227 109 1266 77 OAI21_X1
* cell instance $27021 m0 *1 158.27,26.6
X$27021 1268 1266 1263 77 1267 109 AOI21_X1
* cell instance $27022 m0 *1 159.03,26.6
X$27022 77 1269 1351 1270 894 109 NOR3_X4
* cell instance $27024 r0 *1 145.73,26.6
X$27024 1445 1259 1348 77 1406 109 AOI21_X1
* cell instance $27025 r0 *1 146.49,26.6
X$27025 1258 1408 1263 77 1445 109 AOI21_X1
* cell instance $27026 r0 *1 147.25,26.6
X$27026 1409 1179 77 109 1408 NAND2_X1
* cell instance $27028 r0 *1 148.58,26.6
X$27028 530 1257 1447 109 1349 77 OAI21_X1
* cell instance $27031 r0 *1 152.57,26.6
X$27031 530 1452 793 109 1451 77 OAI21_X1
* cell instance $27033 r0 *1 154.85,26.6
X$27033 722 1413 336 109 1187 77 OAI21_X1
* cell instance $27037 r0 *1 158.08,26.6
X$27037 1418 77 109 1416 CLKBUF_X3
* cell instance $27039 r0 *1 159.41,26.6
X$27039 1270 1351 1482 77 109 1111 NOR3_X1
* cell instance $27040 r0 *1 160.17,26.6
X$27040 1270 1351 1419 109 1060 77 NOR3_X2
* cell instance $27042 r0 *1 161.88,26.6
X$27042 77 1130 1352 102 18984 1422 109 DFFR_X2
* cell instance $27043 m0 *1 162.26,26.6
X$27043 1423 1271 1272 77 1352 109 AOI21_X1
* cell instance $27045 m0 *1 163.02,26.6
X$27045 1422 77 109 1271 INV_X1
* cell instance $27048 m0 *1 165.68,26.6
X$27048 1273 77 109 724 CLKBUF_X3
* cell instance $27049 m0 *1 166.63,26.6
X$27049 1273 77 109 1179 CLKBUF_X3
* cell instance $27051 m0 *1 167.77,26.6
X$27051 1274 77 109 1327 INV_X1
* cell instance $27052 m0 *1 168.15,26.6
X$27052 1274 602 77 109 1329 NAND2_X1
* cell instance $27053 m0 *1 168.72,26.6
X$27053 1457 1190 77 109 1353 NAND2_X1
* cell instance $27054 m0 *1 169.29,26.6
X$27054 1353 602 77 109 1426 NAND2_X1
* cell instance $27055 m0 *1 169.86,26.6
X$27055 1457 724 1354 1190 77 109 1326 NAND4_X1
* cell instance $27056 m0 *1 170.81,26.6
X$27056 1354 1426 1275 77 1325 109 AOI21_X1
* cell instance $27058 m0 *1 171.76,26.6
X$27058 77 977 18663 1356 1276 1146 109 DFFR_X1
* cell instance $27060 m0 *1 175.75,26.6
X$27060 1398 1322 77 109 431 NAND2_X1
* cell instance $27062 m0 *1 176.51,26.6
X$27062 1278 733 737 1180 77 109 1425 AOI22_X2
* cell instance $27065 r0 *1 166.44,26.6
X$27065 1351 1269 77 109 1457 NOR2_X1
* cell instance $27067 r0 *1 167.39,26.6
X$27067 1270 1274 77 109 1023 NOR2_X2
* cell instance $27069 r0 *1 169.1,26.6
X$27069 1327 1354 1190 77 109 1479 NAND3_X1
* cell instance $27071 r0 *1 170.05,26.6
X$27071 1479 348 77 109 1458 NAND2_X1
* cell instance $27073 r0 *1 171,26.6
X$27073 1354 1190 1355 77 1270 109 NAND3_X4
* cell instance $27079 r0 *1 175.18,26.6
X$27079 1356 77 109 1354 BUF_X2
* cell instance $27080 r0 *1 175.94,26.6
X$27080 1381 1322 77 109 336 NAND2_X1
* cell instance $27084 r0 *1 177.84,26.6
X$27084 1357 611 695 1190 77 109 1732 AOI22_X2
* cell instance $27086 m0 *1 178.6,26.6
X$27086 1196 608 609 1129 77 109 1424 AOI22_X2
* cell instance $27088 m0 *1 182.02,26.6
X$27088 1279 1527 109 77 1318 AND2_X1
* cell instance $27089 m0 *1 182.78,26.6
X$27089 405 1416 109 77 1359 AND2_X1
* cell instance $27091 m0 *1 184.3,26.6
X$27091 1421 1279 1280 77 1420 109 AOI21_X1
* cell instance $27092 m0 *1 185.06,26.6
X$27092 1415 1420 1359 77 109 1281 NOR3_X1
* cell instance $27093 m0 *1 185.82,26.6
X$27093 1278 1279 1280 109 77 1415 AND3_X1
* cell instance $27094 m0 *1 186.77,26.6
X$27094 1280 1278 77 109 1414 NAND2_X1
* cell instance $27095 m0 *1 187.34,26.6
X$27095 1278 1412 1280 109 77 1314 AND3_X1
* cell instance $27096 m0 *1 188.29,26.6
X$27096 1414 1361 1196 77 109 1282 NOR3_X1
* cell instance $27097 m0 *1 189.05,26.6
X$27097 1284 77 109 1362 INV_X1
* cell instance $27098 m0 *1 189.43,26.6
X$27098 1284 1412 109 77 1285 AND2_X1
* cell instance $27099 m0 *1 190.19,26.6
X$27099 1158 1196 77 109 1195 NAND2_X1
* cell instance $27101 r0 *1 179.55,26.6
X$27101 77 1139 18782 1459 1475 102 109 DFFR_X1
* cell instance $27103 r0 *1 183.54,26.6
X$27103 1278 1418 77 109 1421 OR2_X1
* cell instance $27104 r0 *1 184.3,26.6
X$27104 1284 1360 1278 1196 109 77 1461 AND4_X2
* cell instance $27105 r0 *1 185.63,26.6
X$27105 1284 1360 109 77 1280 AND2_X1
* cell instance $27108 r0 *1 188.1,26.6
X$27108 1361 1201 1360 1362 77 109 1474 NOR4_X1
* cell instance $27110 r0 *1 189.24,26.6
X$27110 1474 693 414 77 1363 109 AOI21_X1
* cell instance $27111 r0 *1 190,26.6
X$27111 1283 1363 1536 1285 109 77 1410 OAI22_X1
* cell instance $27114 m0 *1 191.14,26.6
X$27114 77 1139 18532 1407 1410 1146 109 DFFR_X1
* cell instance $27116 m0 *1 195.89,26.6
X$27116 1403 741 1286 77 1404 109 AOI21_X1
* cell instance $27119 m0 *1 197.6,26.6
X$27119 1201 77 109 414 CLKBUF_X3
* cell instance $27121 r0 *1 191.33,26.6
X$27121 1407 77 109 1360 CLKBUF_X2
* cell instance $27125 r0 *1 195.7,26.6
X$27125 77 1364 18785 1288 1404 1146 109 DFFR_X1
* cell instance $27126 m0 *1 199.12,26.6
X$27126 1288 77 109 1066 BUF_X2
* cell instance $27130 m0 *1 200.45,26.6
X$27130 77 1083 1289 1146 18965 1141 109 DFFR_X2
* cell instance $27135 r0 *1 202.92,26.6
X$27135 77 1553 18769 1465 1464 1146 109 DFFR_X1
* cell instance $27137 m0 *1 205.77,26.6
X$27137 77 1083 18497 1292 1205 102 109 DFFR_X1
* cell instance $27142 r0 *1 208.62,26.6
X$27142 1087 1207 1368 77 109 1473 MUX2_X1
* cell instance $27143 r0 *1 209.95,26.6
X$27143 77 1367 1473 1146 19018 1368 109 DFFR_X2
* cell instance $27144 m0 *1 212.99,26.6
X$27144 844 1366 77 109 1365 NAND2_X1
* cell instance $27145 m0 *1 212.23,26.6
X$27145 1059 843 1365 109 1293 77 OAI21_X1
* cell instance $27149 m0 *1 216.03,26.6
X$27149 1398 77 109 548 INV_X2
* cell instance $27152 m0 *1 220.4,26.6
X$27152 685 1207 1294 77 109 1393 MUX2_X1
* cell instance $27158 r0 *1 215.08,26.6
X$27158 1084 1305 1469 77 109 1369 MUX2_X1
* cell instance $27159 r0 *1 216.41,26.6
X$27159 77 1367 18858 1469 1369 1146 109 DFFR_X1
* cell instance $27161 r0 *1 220.4,26.6
X$27161 77 1721 1393 1146 18988 1294 109 DFFR_X2
* cell instance $27163 m0 *1 224.39,26.6
X$27163 625 1208 1296 109 1550 77 OAI21_X1
* cell instance $27165 r0 *1 224.96,26.6
X$27165 1207 1543 77 109 1296 NAND2_X1
* cell instance $27168 m0 *1 225.53,26.6
X$27168 1207 1297 77 109 1295 NAND2_X1
* cell instance $27169 m0 *1 226.29,26.6
X$27169 1072 77 109 19254 CLKBUF_X1
* cell instance $27170 m0 *1 226.86,26.6
X$27170 77 1072 1386 102 18947 1370 109 DFFR_X2
* cell instance $27172 m0 *1 231.8,26.6
X$27172 1330 77 109 772 INV_X2
* cell instance $27174 m0 *1 235.41,26.6
X$27174 77 753 1374 992 18952 1373 109 DFFR_X2
* cell instance $27180 r0 *1 227.24,26.6
X$27180 621 1208 1385 109 1386 77 OAI21_X1
* cell instance $27183 r0 *1 228.57,26.6
X$27183 1207 1370 77 109 1385 NAND2_X1
* cell instance $27186 r0 *1 230.09,26.6
X$27186 578 1208 1382 109 1471 77 OAI21_X1
* cell instance $27187 r0 *1 230.85,26.6
X$27187 1207 1544 77 109 1382 NAND2_X1
* cell instance $27189 r0 *1 231.8,26.6
X$27189 1381 77 109 413 INV_X4
* cell instance $27191 r0 *1 233.13,26.6
X$27191 1207 1372 77 109 1371 NAND2_X1
* cell instance $27192 r0 *1 233.7,26.6
X$27192 839 1208 1371 109 1472 77 OAI21_X1
* cell instance $27194 r0 *1 234.84,26.6
X$27194 1063 1207 1373 77 109 1374 MUX2_X1
* cell instance $27213 m0 *1 86.45,23.8
X$27213 77 18302 1038 1210 877 109 DFF_X1
* cell instance $27215 m0 *1 90.44,23.8
X$27215 77 18305 1167 1212 877 109 DFF_X1
* cell instance $27242 r0 *1 88.54,23.8
X$27242 320 486 1038 77 109 1300 MUX2_X1
* cell instance $27243 r0 *1 89.87,23.8
X$27243 1248 629 1300 77 109 1247 MUX2_X1
* cell instance $27246 r0 *1 93.1,23.8
X$27246 83 486 1167 77 109 1376 MUX2_X1
* cell instance $27248 m0 *1 95,23.8
X$27248 77 18308 1117 1213 955 109 DFF_X1
* cell instance $27251 m0 *1 98.99,23.8
X$27251 77 1152 955 18292 1118 109 DFF_X2
* cell instance $27252 m0 *1 102.6,23.8
X$27252 77 18323 1120 1153 644 109 DFF_X1
* cell instance $27253 m0 *1 105.83,23.8
X$27253 1120 878 355 77 109 1216 MUX2_X1
* cell instance $27255 m0 *1 107.92,23.8
X$27255 77 18329 1168 1155 861 109 DFF_X1
* cell instance $27256 m0 *1 111.15,23.8
X$27256 1168 1122 1123 77 109 1155 MUX2_X1
* cell instance $27259 r0 *1 96.71,23.8
X$27259 139 486 1117 77 109 1378 MUX2_X1
* cell instance $27263 r0 *1 104.69,23.8
X$27263 803 1041 77 109 1304 OR2_X1
* cell instance $27264 r0 *1 105.45,23.8
X$27264 1304 958 1216 109 77 1494 OAI21_X4
* cell instance $27265 r0 *1 107.92,23.8
X$27265 1041 1216 1119 109 77 1250 MUX2_X2
* cell instance $27266 r0 *1 109.63,23.8
X$27266 879 109 1003 77 BUF_X4
* cell instance $27267 r0 *1 110.96,23.8
X$27267 1042 1047 804 77 109 1169 MUX2_X1
* cell instance $27268 r0 *1 112.29,23.8
X$27268 82 1047 1118 77 109 1223 MUX2_X1
* cell instance $27270 m0 *1 112.86,23.8
X$27270 1125 1126 1123 77 1170 109 AOI21_X2
* cell instance $27272 r0 *1 113.62,23.8
X$27272 1048 1223 879 109 77 1307 MUX2_X2
* cell instance $27277 m0 *1 116.28,23.8
X$27277 77 18327 1162 1161 861 109 DFF_X1
* cell instance $27279 m0 *1 119.51,23.8
X$27279 1162 805 406 77 109 1395 MUX2_X1
* cell instance $27281 m0 *1 121.6,23.8
X$27281 1171 1097 879 109 77 1172 MUX2_X2
* cell instance $27283 m0 *1 124.07,23.8
X$27283 1308 805 864 77 109 1173 MUX2_X1
* cell instance $27288 r0 *1 116.47,23.8
X$27288 1236 77 109 409 CLKBUF_X3
* cell instance $27289 r0 *1 117.42,23.8
X$27289 409 77 109 19118 INV_X2
* cell instance $27292 r0 *1 119.7,23.8
X$27292 1308 442 1171 77 109 1224 MUX2_X1
* cell instance $27294 r0 *1 121.22,23.8
X$27294 77 18426 1308 1224 861 109 DFF_X1
* cell instance $27297 r0 *1 125.02,23.8
X$27297 1127 1173 960 109 77 1175 MUX2_X2
* cell instance $27298 r0 *1 126.73,23.8
X$27298 1119 77 109 960 CLKBUF_X3
* cell instance $27301 m0 *1 128.06,23.8
X$27301 1128 354 1048 77 109 1176 MUX2_X1
* cell instance $27304 r0 *1 128.63,23.8
X$27304 77 18458 1128 1176 717 109 DFF_X1
* cell instance $27306 m0 *1 131.29,23.8
X$27306 77 18303 1051 1226 717 109 DFF_X1
* cell instance $27307 r0 *1 131.86,23.8
X$27307 960 77 109 1047 CLKBUF_X3
* cell instance $27310 r0 *1 133.95,23.8
X$27310 145 1174 782 77 109 1389 MUX2_X1
* cell instance $27311 m0 *1 135.09,23.8
X$27311 77 354 109 1122 BUF_X8
* cell instance $27316 r0 *1 135.85,23.8
X$27316 345 77 109 19114 INV_X2
* cell instance $27317 r0 *1 136.42,23.8
X$27317 1052 1177 1251 109 77 1227 MUX2_X2
* cell instance $27318 m0 *1 138.13,23.8
X$27318 1056 1003 1053 77 109 1591 MUX2_X1
* cell instance $27323 r0 *1 138.13,23.8
X$27323 1236 77 109 345 CLKBUF_X3
* cell instance $27326 r0 *1 140.79,23.8
X$27326 77 717 1316 102 18978 1255 109 DFFR_X2
* cell instance $27328 m0 *1 143.64,23.8
X$27328 77 1130 1165 102 18946 1178 109 DFFR_X2
* cell instance $27329 r0 *1 144.97,23.8
X$27329 1253 1259 1315 77 1316 109 AOI21_X1
* cell instance $27330 r0 *1 145.73,23.8
X$27330 1319 1179 77 109 1254 NAND2_X1
* cell instance $27331 r0 *1 146.3,23.8
X$27331 1178 77 109 1228 INV_X1
* cell instance $27332 r0 *1 146.68,23.8
X$27332 1181 1228 77 109 1256 NOR2_X2
* cell instance $27333 r0 *1 147.63,23.8
X$27333 1180 77 109 1182 INV_X1
* cell instance $27334 r0 *1 148.01,23.8
X$27334 1255 1129 1180 77 109 1181 NAND3_X2
* cell instance $27336 m0 *1 148.2,23.8
X$27336 1229 1231 77 109 1165 NOR2_X1
* cell instance $27337 m0 *1 148.96,23.8
X$27337 1230 1183 77 109 1104 NOR2_X1
* cell instance $27338 m0 *1 149.53,23.8
X$27338 1129 1232 1185 77 1230 109 AOI21_X1
* cell instance $27339 m0 *1 150.29,23.8
X$27339 1178 1233 1185 77 1229 109 AOI21_X1
* cell instance $27341 r0 *1 149.34,23.8
X$27341 1182 1262 1179 109 1232 77 OAI21_X1
* cell instance $27342 r0 *1 150.1,23.8
X$27342 1181 1262 1179 109 1233 77 OAI21_X1
* cell instance $27343 r0 *1 150.86,23.8
X$27343 1260 1181 516 109 1315 77 OAI21_X1
* cell instance $27344 m0 *1 151.62,23.8
X$27344 1186 1184 730 77 1231 109 AOI21_X1
* cell instance $27347 r0 *1 151.62,23.8
X$27347 1256 1321 501 77 109 1184 NAND3_X1
* cell instance $27348 r0 *1 152.38,23.8
X$27348 1321 77 109 1262 INV_X1
* cell instance $27350 m0 *1 152.95,23.8
X$27350 1186 1234 604 77 1183 109 AOI21_X1
* cell instance $27354 r0 *1 153.33,23.8
X$27354 1321 373 1129 1180 77 109 1234 NAND4_X1
* cell instance $27355 m0 *1 154.28,23.8
X$27355 77 1130 1131 102 18955 1238 109 DFFR_X2
* cell instance $27359 m0 *1 160.74,23.8
X$27359 1058 77 109 820 CLKBUF_X3
* cell instance $27360 m0 *1 161.69,23.8
X$27360 722 1269 300 109 1328 77 OAI21_X1
* cell instance $27361 m0 *1 162.45,23.8
X$27361 722 894 1185 109 1133 77 OAI21_X1
* cell instance $27362 m0 *1 163.21,23.8
X$27362 1188 1240 1133 77 1061 109 AOI21_X1
* cell instance $27363 m0 *1 163.97,23.8
X$27363 1112 77 109 1240 INV_X1
* cell instance $27366 m0 *1 166.06,23.8
X$27366 606 109 1134 77 BUF_X4
* cell instance $27367 m0 *1 167.39,23.8
X$27367 605 109 1189 77 BUF_X4
* cell instance $27369 m0 *1 168.91,23.8
X$27369 1242 1243 77 109 1062 NOR2_X1
* cell instance $27371 m0 *1 170.24,23.8
X$27371 1186 1244 979 77 1242 109 AOI21_X1
* cell instance $27374 m0 *1 171.95,23.8
X$27374 1245 77 109 1190 CLKBUF_X3
* cell instance $27376 r0 *1 154.28,23.8
X$27376 1264 1259 1187 77 1131 109 AOI21_X1
* cell instance $27380 r0 *1 157.51,23.8
X$27380 1267 1259 1328 77 1239 109 AOI21_X1
* cell instance $27381 r0 *1 158.27,23.8
X$27381 77 1130 1239 102 19000 1268 109 DFFR_X2
* cell instance $27383 r0 *1 162.83,23.8
X$27383 894 724 1112 77 109 1332 NAND3_X1
* cell instance $27384 r0 *1 163.59,23.8
X$27384 1331 1332 974 77 1188 109 AOI21_X1
* cell instance $27387 r0 *1 164.92,23.8
X$27387 1273 77 109 501 CLKBUF_X3
* cell instance $27388 r0 *1 165.87,23.8
X$27388 1273 77 109 227 CLKBUF_X3
* cell instance $27390 r0 *1 167.2,23.8
X$27390 1273 77 109 373 CLKBUF_X3
* cell instance $27391 r0 *1 168.15,23.8
X$27391 1330 820 77 109 516 NAND2_X1
* cell instance $27393 r0 *1 168.91,23.8
X$27393 1190 1329 1275 77 1243 109 AOI21_X1
* cell instance $27395 r0 *1 170.05,23.8
X$27395 977 77 109 19161 INV_X1
* cell instance $27396 r0 *1 170.43,23.8
X$27396 349 77 109 977 CLKBUF_X3
* cell instance $27400 r0 *1 171.38,23.8
X$27400 1327 1179 1190 77 109 1244 NAND3_X1
* cell instance $27401 r0 *1 172.14,23.8
X$27401 1186 1326 1036 77 1246 109 AOI21_X1
* cell instance $27402 r0 *1 172.9,23.8
X$27402 1246 1325 77 109 1276 NOR2_X1
* cell instance $27403 m0 *1 174.61,23.8
X$27403 1066 1189 1134 1025 77 109 1277 AOI22_X2
* cell instance $27404 m0 *1 173.28,23.8
X$27404 1134 109 980 77 BUF_X4
* cell instance $27405 m0 *1 176.32,23.8
X$27405 1189 109 611 77 BUF_X4
* cell instance $27406 m0 *1 177.65,23.8
X$27406 190 1189 1134 118 77 109 1157 AOI22_X2
* cell instance $27407 m0 *1 179.36,23.8
X$27407 1137 611 695 815 77 109 1320 AOI22_X2
* cell instance $27410 r0 *1 173.47,23.8
X$27410 405 1322 77 109 584 NAND2_X1
* cell instance $27411 r0 *1 174.04,23.8
X$27411 1142 1189 1134 814 77 109 1324 AOI22_X2
* cell instance $27413 r0 *1 176.13,23.8
X$27413 1189 109 1110 77 BUF_X4
* cell instance $27414 r0 *1 177.46,23.8
X$27414 1141 611 695 720 77 109 1241 AOI22_X2
* cell instance $27416 r0 *1 179.36,23.8
X$27416 1134 109 695 77 BUF_X4
* cell instance $27418 r0 *1 181.07,23.8
X$27418 1035 831 1358 77 109 1191 MUX2_X1
* cell instance $27419 m0 *1 183.16,23.8
X$27419 1158 1135 77 109 1192 NAND2_X1
* cell instance $27420 m0 *1 182.21,23.8
X$27420 1136 77 109 831 CLKBUF_X3
* cell instance $27422 m0 *1 184.49,23.8
X$27422 77 1139 18541 1193 1281 102 109 DFFR_X1
* cell instance $27423 m0 *1 188.29,23.8
X$27423 831 621 77 109 1194 NOR2_X1
* cell instance $27426 r0 *1 182.4,23.8
X$27426 1283 1191 1192 1318 109 77 1159 OAI22_X1
* cell instance $27430 r0 *1 186.01,23.8
X$27430 1206 77 109 4037 INV_X1
* cell instance $27432 r0 *1 187.15,23.8
X$27432 1193 77 109 1278 CLKBUF_X2
* cell instance $27433 r0 *1 187.91,23.8
X$27433 1156 77 109 1198 INV_X1
* cell instance $27434 r0 *1 188.29,23.8
X$27434 1194 311 1282 77 1237 109 AOI21_X1
* cell instance $27435 r0 *1 189.05,23.8
X$27435 1283 1237 1195 1314 109 77 1313 OAI22_X1
* cell instance $27436 r0 *1 190,23.8
X$27436 77 1139 1313 1146 19021 1196 109 DFFR_X2
* cell instance $27437 m0 *1 191.71,23.8
X$27437 1236 77 109 349 CLKBUF_X3
* cell instance $27438 m0 *1 190.76,23.8
X$27438 831 77 109 311 CLKBUF_X3
* cell instance $27439 m0 *1 192.66,23.8
X$27439 349 77 109 19189 CLKBUF_X3
* cell instance $27440 m0 *1 193.61,23.8
X$27440 1139 77 109 19234 CLKBUF_X1
* cell instance $27441 m0 *1 194.18,23.8
X$27441 904 1066 77 109 1197 NAND2_X1
* cell instance $27442 m0 *1 194.75,23.8
X$27442 1197 1099 77 109 1101 NOR2_X1
* cell instance $27443 m0 *1 195.32,23.8
X$27443 467 1199 77 109 1200 OR2_X1
* cell instance $27444 m0 *1 196.08,23.8
X$27444 1197 1199 303 109 982 77 OAI21_X1
* cell instance $27445 m0 *1 196.84,23.8
X$27445 983 904 1066 77 109 1140 NAND3_X1
* cell instance $27446 m0 *1 197.6,23.8
X$27446 1199 1140 77 109 906 OR2_X1
* cell instance $27447 m0 *1 198.36,23.8
X$27447 1099 1140 77 109 910 OR2_X1
* cell instance $27450 r0 *1 194.18,23.8
X$27450 349 77 109 1139 CLKBUF_X3
* cell instance $27451 r0 *1 195.13,23.8
X$27451 1067 1200 1198 305 109 77 1286 OAI22_X1
* cell instance $27452 r0 *1 196.08,23.8
X$27452 1140 1200 1311 305 109 77 1138 OAI22_X1
* cell instance $27453 r0 *1 197.79,23.8
X$27453 1199 311 77 109 1287 NAND2_X1
* cell instance $27456 r0 *1 198.93,23.8
X$27456 1201 906 77 109 1095 OR2_X1
* cell instance $27459 m0 *1 200.26,23.8
X$27459 1137 1141 1142 77 109 905 NAND3_X2
* cell instance $27460 m0 *1 201.78,23.8
X$27460 1141 1142 77 109 1202 NAND2_X1
* cell instance $27461 m0 *1 202.35,23.8
X$27461 1202 910 303 109 1225 77 OAI21_X1
* cell instance $27465 r0 *1 201.02,23.8
X$27465 1095 1202 1622 305 109 77 1309 OAI22_X1
* cell instance $27466 r0 *1 201.97,23.8
X$27466 1290 741 1309 77 1289 109 AOI21_X1
* cell instance $27468 r0 *1 202.92,23.8
X$27468 1141 1143 385 77 1290 109 AOI21_X1
* cell instance $27470 m0 *1 203.49,23.8
X$27470 1203 906 303 109 1143 77 OAI21_X1
* cell instance $27471 m0 *1 204.44,23.8
X$27471 1142 77 109 1203 INV_X1
* cell instance $27472 m0 *1 204.82,23.8
X$27472 1137 1225 385 77 1091 109 AOI21_X1
* cell instance $27475 r0 *1 204.44,23.8
X$27475 1203 1009 1463 305 109 77 1204 OAI22_X1
* cell instance $27477 r0 *1 205.58,23.8
X$27477 1291 741 1204 77 1205 109 AOI21_X1
* cell instance $27478 m0 *1 206.15,23.8
X$27478 910 311 77 109 1306 NAND2_X1
* cell instance $27483 m0 *1 209.19,23.8
X$27483 77 1083 18530 1206 1151 102 109 DFFR_X1
* cell instance $27484 m0 *1 212.99,23.8
X$27484 625 843 1144 109 1151 77 OAI21_X1
* cell instance $27485 m0 *1 213.75,23.8
X$27485 844 1206 77 109 1144 NAND2_X1
* cell instance $27488 m0 *1 215.27,23.8
X$27488 788 1305 1222 77 109 1081 MUX2_X1
* cell instance $27492 m0 *1 220.59,23.8
X$27492 552 1207 1220 77 109 1221 MUX2_X1
* cell instance $27493 m0 *1 221.92,23.8
X$27493 996 1208 1218 109 1219 77 OAI21_X1
* cell instance $27494 m0 *1 222.68,23.8
X$27494 1207 1145 77 109 1218 NAND2_X1
* cell instance $27495 m0 *1 223.25,23.8
X$27495 77 1072 1219 1146 18962 1145 109 DFFR_X2
* cell instance $27496 m0 *1 227.43,23.8
X$27496 999 77 109 1072 CLKBUF_X3
* cell instance $27498 r0 *1 206.34,23.8
X$27498 1142 1306 385 77 1291 109 AOI21_X1
* cell instance $27500 r0 *1 208.62,23.8
X$27500 1292 77 109 1142 BUF_X2
* cell instance $27502 r0 *1 210.14,23.8
X$27502 999 77 109 1083 CLKBUF_X3
* cell instance $27503 r0 *1 211.09,23.8
X$27503 1083 77 109 19159 INV_X1
* cell instance $27504 r0 *1 211.47,23.8
X$27504 77 1083 18878 1366 1293 1146 109 DFFR_X1
* cell instance $27505 r0 *1 215.27,23.8
X$27505 1305 77 109 843 CLKBUF_X3
* cell instance $27506 r0 *1 216.22,23.8
X$27506 1305 77 109 844 CLKBUF_X3
* cell instance $27508 r0 *1 220.21,23.8
X$27508 77 750 1221 1146 18986 1220 109 DFFR_X2
* cell instance $27509 r0 *1 224.39,23.8
X$27509 405 1208 1295 109 1302 77 OAI21_X1
* cell instance $27510 r0 *1 225.15,23.8
X$27510 77 1072 1302 1146 19012 1297 109 DFFR_X2
* cell instance $27514 m0 *1 228.95,23.8
X$27514 978 843 1217 109 1079 77 OAI21_X1
* cell instance $27516 m0 *1 229.71,23.8
X$27516 503 843 1215 109 1301 77 OAI21_X1
* cell instance $27517 m0 *1 230.47,23.8
X$27517 844 1214 77 109 1217 NAND2_X1
* cell instance $27518 m0 *1 231.04,23.8
X$27518 844 1298 77 109 1215 NAND2_X1
* cell instance $27520 m0 *1 233.13,23.8
X$27520 978 1208 1147 109 1149 77 OAI21_X1
* cell instance $27521 m0 *1 233.89,23.8
X$27521 503 1208 1211 109 1148 77 OAI21_X1
* cell instance $27522 m0 *1 234.65,23.8
X$27522 1208 1299 77 109 1147 NAND2_X1
* cell instance $27524 m0 *1 235.41,23.8
X$27524 77 753 1148 992 18949 1209 109 DFFR_X2
* cell instance $27526 r0 *1 229.33,23.8
X$27526 77 1072 18774 1298 1301 102 109 DFFR_X1
* cell instance $27528 r0 *1 233.32,23.8
X$27528 1208 1209 77 109 1211 NAND2_X1
* cell instance $27529 r0 *1 233.89,23.8
X$27529 77 753 1149 992 19003 1299 109 DFFR_X2
* cell instance $27575 r0 *1 93.1,7
X$27575 332 77 109 394 CLKBUF_X3
* cell instance $27578 r0 *1 95,7
X$27578 440 394 196 77 109 485 MUX2_X1
* cell instance $27579 m0 *1 95.38,7
X$27579 77 18315 396 318 172 109 DFF_X1
* cell instance $27584 r0 *1 96.33,7
X$27584 396 394 138 77 109 318 MUX2_X1
* cell instance $27588 r0 *1 98.99,7
X$27588 77 18437 353 401 172 109 DFF_X1
* cell instance $27589 m0 *1 101.84,7
X$27589 215 85 214 77 109 400 MUX2_X1
* cell instance $27591 m0 *1 103.36,7
X$27591 216 77 109 85 CLKBUF_X3
* cell instance $27595 m0 *1 106.02,7
X$27595 77 18304 278 251 140 109 DFF_X1
* cell instance $27597 r0 *1 102.22,7
X$27597 353 88 400 77 109 401 MUX2_X1
* cell instance $27599 r0 *1 103.93,7
X$27599 156 352 217 77 109 277 MUX2_X1
* cell instance $27600 r0 *1 105.26,7
X$27600 355 354 277 77 109 356 MUX2_X1
* cell instance $27602 m0 *1 112.86,7
X$27602 77 18332 280 330 140 109 DFF_X1
* cell instance $27603 m0 *1 109.63,7
X$27603 77 18328 279 326 140 109 DFF_X1
* cell instance $27604 m0 *1 116.09,7
X$27604 280 88 218 77 109 330 MUX2_X1
* cell instance $27609 r0 *1 110.58,7
X$27609 167 352 279 77 109 491 MUX2_X1
* cell instance $27610 r0 *1 111.91,7
X$27610 409 77 109 140 CLKBUF_X3
* cell instance $27616 r0 *1 115.14,7
X$27616 406 354 443 77 109 407 MUX2_X1
* cell instance $27617 r0 *1 116.47,7
X$27617 77 18456 406 407 89 109 DFF_X1
* cell instance $27618 m0 *1 119.51,7
X$27618 89 77 109 19248 CLKBUF_X1
* cell instance $27621 m0 *1 122.93,7
X$27621 90 281 219 77 109 863 MUX2_X1
* cell instance $27624 m0 *1 128.06,7
X$27624 95 281 220 77 109 283 MUX2_X1
* cell instance $27625 m0 *1 129.39,7
X$27625 77 18346 284 285 93 109 DFF_X1
* cell instance $27627 r0 *1 119.7,7
X$27627 408 354 282 77 109 357 MUX2_X1
* cell instance $27629 r0 *1 121.22,7
X$27629 409 77 109 89 CLKBUF_X3
* cell instance $27633 r0 *1 129.2,7
X$27633 284 354 283 77 109 285 MUX2_X1
* cell instance $27634 r0 *1 130.53,7
X$27634 345 77 109 93 CLKBUF_X3
* cell instance $27635 r0 *1 131.48,7
X$27635 93 77 109 19196 CLKBUF_X2
* cell instance $27637 m0 *1 133.19,7
X$27637 175 281 211 77 109 286 MUX2_X1
* cell instance $27644 r0 *1 133.19,7
X$27644 417 354 286 77 109 416 MUX2_X1
* cell instance $27645 r0 *1 134.52,7
X$27645 418 77 109 88 CLKBUF_X3
* cell instance $27647 r0 *1 136.23,7
X$27647 137 281 97 77 109 361 MUX2_X1
* cell instance $27649 r0 *1 139.08,7
X$27649 77 18421 362 287 176 109 DFF_X1
* cell instance $27653 m0 *1 146.49,7
X$27653 100 333 77 109 268 OR2_X1
* cell instance $27657 r0 *1 147.06,7
X$27657 77 334 18891 427 421 102 109 DFFR_X1
* cell instance $27658 r0 *1 150.86,7
X$27658 425 426 77 109 421 NOR2_X1
* cell instance $27659 m0 *1 155.23,7
X$27659 337 77 109 258 BUF_X2
* cell instance $27660 m0 *1 151.43,7
X$27660 77 334 18671 337 335 102 109 DFFR_X1
* cell instance $27662 r0 *1 151.43,7
X$27662 366 424 288 77 426 109 AOI21_X1
* cell instance $27663 r0 *1 152.19,7
X$27663 427 77 109 366 BUF_X2
* cell instance $27666 r0 *1 154.09,7
X$27666 429 368 77 109 335 NOR2_X1
* cell instance $27667 r0 *1 154.66,7
X$27667 258 428 288 77 368 109 AOI21_X1
* cell instance $27671 m0 *1 156.37,7
X$27671 339 178 289 77 221 109 AOI21_X1
* cell instance $27672 m0 *1 157.32,7
X$27672 177 222 223 77 339 109 AOI21_X1
* cell instance $27675 r0 *1 156.75,7
X$27675 430 348 77 109 222 NAND2_X1
* cell instance $27676 r0 *1 157.32,7
X$27676 290 340 366 77 109 430 NAND3_X1
* cell instance $27677 r0 *1 158.08,7
X$27677 369 290 258 77 109 432 NAND3_X1
* cell instance $27679 r0 *1 158.84,7
X$27679 432 348 77 109 346 NAND2_X1
* cell instance $27685 r0 *1 160.74,7
X$27685 433 290 291 77 109 435 NAND3_X1
* cell instance $27686 r0 *1 161.5,7
X$27686 435 348 77 109 179 NAND2_X1
* cell instance $27689 r0 *1 165.49,7
X$27689 292 77 109 371 BUF_X2
* cell instance $27690 r0 *1 166.25,7
X$27690 372 293 438 77 294 109 AOI21_X1
* cell instance $27691 r0 *1 167.01,7
X$27691 437 288 77 109 438 NAND2_X1
* cell instance $27692 r0 *1 167.58,7
X$27692 295 77 109 293 INV_X1
* cell instance $27693 m0 *1 168.53,7
X$27693 349 77 109 157 CLKBUF_X3
* cell instance $27694 m0 *1 167.77,7
X$27694 350 77 109 295 BUF_X2
* cell instance $27695 m0 *1 169.48,7
X$27695 77 157 225 102 18929 226 109 DFFR_X2
* cell instance $27696 m0 *1 173.66,7
X$27696 118 270 223 77 344 109 AOI21_X1
* cell instance $27697 m0 *1 174.42,7
X$27697 344 296 343 77 269 109 AOI21_X1
* cell instance $27698 m0 *1 175.18,7
X$27698 297 299 227 109 267 77 OAI21_X1
* cell instance $27699 m0 *1 175.94,7
X$27699 228 338 336 109 229 77 OAI21_X1
* cell instance $27700 m0 *1 176.7,7
X$27700 264 296 229 77 116 109 AOI21_X1
* cell instance $27701 m0 *1 177.46,7
X$27701 230 118 77 109 228 NAND2_X1
* cell instance $27702 m0 *1 178.03,7
X$27702 261 296 231 77 183 109 AOI21_X1
* cell instance $27703 m0 *1 178.79,7
X$27703 232 230 118 77 109 259 NAND3_X1
* cell instance $27705 m0 *1 182.59,7
X$27705 77 152 18684 419 331 102 109 DFFR_X1
* cell instance $27711 r0 *1 169.29,7
X$27711 157 77 109 19305 CLKBUF_X1
* cell instance $27713 r0 *1 170.05,7
X$27713 226 374 223 77 347 109 AOI21_X1
* cell instance $27714 r0 *1 170.81,7
X$27714 347 296 434 77 225 109 AOI21_X1
* cell instance $27721 r0 *1 174.04,7
X$27721 297 298 431 109 343 77 OAI21_X1
* cell instance $27722 r0 *1 174.8,7
X$27722 118 77 109 297 INV_X1
* cell instance $27724 r0 *1 175.37,7
X$27724 259 299 227 109 423 77 OAI21_X1
* cell instance $27726 r0 *1 176.32,7
X$27726 259 298 300 109 231 77 OAI21_X1
* cell instance $27728 r0 *1 177.27,7
X$27728 376 423 223 77 301 109 AOI21_X1
* cell instance $27731 r0 *1 182.59,7
X$27731 312 375 377 258 77 109 420 AOI22_X2
* cell instance $27735 r0 *1 185.63,7
X$27735 380 303 77 109 233 NAND2_X1
* cell instance $27736 r0 *1 186.2,7
X$27736 419 77 109 379 BUF_X2
* cell instance $27740 m0 *1 187.53,7
X$27740 302 190 77 109 304 NAND2_X1
* cell instance $27741 m0 *1 188.29,7
X$27741 304 303 77 109 255 NAND2_X1
* cell instance $27743 m0 *1 189.05,7
X$27743 306 311 77 109 253 NAND2_X1
* cell instance $27746 m0 *1 194.75,7
X$27746 237 77 109 328 INV_X1
* cell instance $27747 m0 *1 195.13,7
X$27747 328 238 314 109 191 77 OAI21_X1
* cell instance $27750 m0 *1 199.12,7
X$27750 308 77 109 193 INV_X1
* cell instance $27752 r0 *1 187.53,7
X$27752 302 303 105 190 77 109 415 NAND4_X1
* cell instance $27753 r0 *1 188.48,7
X$27753 413 305 415 109 234 77 OAI21_X1
* cell instance $27756 r0 *1 189.81,7
X$27756 105 190 77 109 412 NAND2_X1
* cell instance $27758 r0 *1 190.57,7
X$27758 410 184 411 77 235 109 AOI21_X1
* cell instance $27759 r0 *1 191.33,7
X$27759 412 306 314 109 382 77 OAI21_X1
* cell instance $27760 r0 *1 192.09,7
X$27760 236 382 186 77 410 109 AOI21_X1
* cell instance $27763 r0 *1 193.42,7
X$27763 192 237 77 109 307 NAND2_X1
* cell instance $27764 r0 *1 193.99,7
X$27764 307 238 77 109 327 NOR2_X1
* cell instance $27766 r0 *1 194.75,7
X$27766 405 329 327 77 109 249 MUX2_X1
* cell instance $27769 m0 *1 200.07,7
X$27769 383 311 77 109 239 NAND2_X1
* cell instance $27773 m0 *1 204.44,7
X$27773 321 310 77 109 242 NAND2_X1
* cell instance $27774 m0 *1 205.01,7
X$27774 242 311 77 109 194 NAND2_X1
* cell instance $27775 m0 *1 205.58,7
X$27775 243 77 109 310 CLKBUF_X3
* cell instance $27778 m0 *1 207.48,7
X$27778 244 147 387 77 316 109 AOI21_X1
* cell instance $27779 m0 *1 208.24,7
X$27779 312 319 240 77 244 109 AOI21_X1
* cell instance $27780 m0 *1 209,7
X$27780 77 317 316 102 18921 312 109 DFFR_X2
* cell instance $27787 r0 *1 202.54,7
X$27787 385 403 322 402 77 109 309 AOI22_X1
* cell instance $27788 r0 *1 203.49,7
X$27788 310 77 109 322 INV_X1
* cell instance $27789 r0 *1 203.87,7
X$27789 321 303 245 310 77 109 398 NAND4_X1
* cell instance $27790 r0 *1 204.82,7
X$27790 399 305 398 109 241 77 OAI21_X1
* cell instance $27792 r0 *1 205.96,7
X$27792 386 395 77 109 321 NOR2_X1
* cell instance $27794 r0 *1 206.72,7
X$27794 312 77 109 397 INV_X1
* cell instance $27795 r0 *1 207.1,7
X$27795 397 313 77 109 386 OR2_X1
* cell instance $27797 r0 *1 208.05,7
X$27797 313 395 314 109 319 77 OAI21_X1
* cell instance $27799 r0 *1 209,7
X$27799 390 315 314 109 391 77 OAI21_X1
* cell instance $27800 r0 *1 209.76,7
X$27800 388 391 240 77 393 109 AOI21_X1
* cell instance $27832 m0 *1 88.92,15.4
X$27832 708 394 82 77 109 754 MUX2_X1
* cell instance $27835 m0 *1 91.96,15.4
X$27835 77 18333 756 678 520 109 DFF_X1
* cell instance $27836 m0 *1 95.19,15.4
X$27836 800 394 640 77 109 760 MUX2_X1
* cell instance $27838 m0 *1 96.71,15.4
X$27838 709 629 641 77 109 851 MUX2_X1
* cell instance $27840 m0 *1 99.56,15.4
X$27840 710 642 762 77 109 681 MUX2_X1
* cell instance $27841 m0 *1 100.89,15.4
X$27841 77 681 644 18288 710 109 DFF_X2
* cell instance $27865 r0 *1 86.64,15.4
X$27865 77 18422 708 754 877 109 DFF_X1
* cell instance $27866 r0 *1 89.87,15.4
X$27866 82 486 708 77 109 849 MUX2_X1
* cell instance $27867 r0 *1 91.2,15.4
X$27867 799 629 849 77 109 798 MUX2_X1
* cell instance $27870 r0 *1 93.1,15.4
X$27870 77 18443 800 760 520 109 DFF_X1
* cell instance $27872 r0 *1 96.71,15.4
X$27872 77 18446 709 851 644 109 DFF_X1
* cell instance $27875 r0 *1 100.51,15.4
X$27875 640 645 709 77 109 801 MUX2_X1
* cell instance $27876 r0 *1 101.84,15.4
X$27876 802 642 801 77 109 854 MUX2_X1
* cell instance $27877 r0 *1 103.17,15.4
X$27877 351 645 756 77 109 643 MUX2_X1
* cell instance $27879 m0 *1 105.07,15.4
X$27879 711 642 643 77 109 686 MUX2_X1
* cell instance $27881 m0 *1 106.4,15.4
X$27881 77 18321 711 686 644 109 DFF_X1
* cell instance $27882 m0 *1 109.63,15.4
X$27882 77 18320 712 687 644 109 DFF_X1
* cell instance $27883 m0 *1 112.86,15.4
X$27883 712 442 646 77 109 687 MUX2_X1
* cell instance $27887 r0 *1 105.45,15.4
X$27887 215 803 441 77 109 856 MUX2_X1
* cell instance $27888 r0 *1 106.78,15.4
X$27888 644 77 109 19185 INV_X1
* cell instance $27889 r0 *1 107.16,15.4
X$27889 801 856 879 109 77 858 MUX2_X2
* cell instance $27892 r0 *1 110.58,15.4
X$27892 711 805 526 77 109 804 MUX2_X1
* cell instance $27893 r0 *1 111.91,15.4
X$27893 712 805 525 77 109 924 MUX2_X1
* cell instance $27895 r0 *1 113.43,15.4
X$27895 444 805 138 77 109 926 MUX2_X1
* cell instance $27902 r0 *1 116.09,15.4
X$27902 77 18472 770 859 861 109 DFF_X1
* cell instance $27904 m0 *1 117.61,15.4
X$27904 770 647 648 77 109 859 MUX2_X1
* cell instance $27905 m0 *1 119.7,15.4
X$27905 77 18339 713 773 861 109 DFF_X1
* cell instance $27908 m0 *1 127.49,15.4
X$27908 808 647 650 77 109 774 MUX2_X1
* cell instance $27909 m0 *1 128.82,15.4
X$27909 345 77 109 447 CLKBUF_X3
* cell instance $27910 m0 *1 129.77,15.4
X$27910 809 647 776 77 109 714 MUX2_X1
* cell instance $27911 m0 *1 131.1,15.4
X$27911 447 77 109 19193 CLKBUF_X2
* cell instance $27913 m0 *1 133.38,15.4
X$27913 715 647 651 77 109 716 MUX2_X1
* cell instance $27920 r0 *1 123.31,15.4
X$27920 864 354 863 77 109 807 MUX2_X1
* cell instance $27922 r0 *1 125.4,15.4
X$27922 77 18463 808 774 447 109 DFF_X1
* cell instance $27924 r0 *1 129.39,15.4
X$27924 77 18447 809 714 447 109 DFF_X1
* cell instance $27926 r0 *1 133.38,15.4
X$27926 77 18453 715 716 717 109 DFF_X1
* cell instance $27927 m0 *1 135.28,15.4
X$27927 782 647 652 77 109 780 MUX2_X1
* cell instance $27929 m0 *1 136.61,15.4
X$27929 77 18364 782 780 653 109 DFF_X1
* cell instance $27931 m0 *1 140.03,15.4
X$27931 810 647 655 77 109 718 MUX2_X1
* cell instance $27935 r0 *1 136.61,15.4
X$27935 866 354 361 77 109 936 MUX2_X1
* cell instance $27938 r0 *1 139.84,15.4
X$27938 77 18448 810 718 653 109 DFF_X1
* cell instance $27942 r0 *1 144.4,15.4
X$27942 77 334 18742 867 939 102 109 DFFR_X1
* cell instance $27943 m0 *1 146.49,15.4
X$27943 77 334 18611 785 784 102 109 DFFR_X1
* cell instance $27945 m0 *1 150.29,15.4
X$27945 785 77 109 720 BUF_X2
* cell instance $27946 m0 *1 151.05,15.4
X$27946 722 723 288 109 656 77 OAI21_X1
* cell instance $27947 m0 *1 151.81,15.4
X$27947 723 724 594 77 109 657 NAND3_X1
* cell instance $27948 m0 *1 152.57,15.4
X$27948 723 724 77 109 786 NAND2_X1
* cell instance $27950 m0 *1 153.33,15.4
X$27950 725 726 77 109 723 NOR2_X1
* cell instance $27951 m0 *1 153.9,15.4
X$27951 786 597 602 788 109 77 658 OAI22_X1
* cell instance $27952 m0 *1 154.85,15.4
X$27952 789 659 787 109 570 77 OAI21_X1
* cell instance $27953 m0 *1 155.61,15.4
X$27953 726 725 77 109 576 OR2_X1
* cell instance $27955 r0 *1 148.2,15.4
X$27955 867 77 109 814 CLKBUF_X3
* cell instance $27956 r0 *1 149.15,15.4
X$27956 870 178 812 77 784 109 AOI21_X1
* cell instance $27957 r0 *1 149.91,15.4
X$27957 813 814 77 109 719 NAND2_X1
* cell instance $27958 r0 *1 150.48,15.4
X$27958 719 348 77 109 721 NAND2_X1
* cell instance $27959 r0 *1 151.05,15.4
X$27959 720 721 592 77 870 109 AOI21_X1
* cell instance $27960 r0 *1 151.81,15.4
X$27960 816 813 727 77 109 660 NAND3_X2
* cell instance $27961 r0 *1 153.14,15.4
X$27961 816 727 77 109 725 NAND2_X1
* cell instance $27963 r0 *1 154.09,15.4
X$27963 817 791 77 109 783 NOR2_X1
* cell instance $27964 r0 *1 154.66,15.4
X$27964 453 789 872 77 817 109 AOI21_X1
* cell instance $27965 r0 *1 155.42,15.4
X$27965 820 660 77 109 789 OR2_X1
* cell instance $27967 r0 *1 156.37,15.4
X$27967 727 818 288 77 791 109 AOI21_X1
* cell instance $27968 m0 *1 156.94,15.4
X$27968 727 77 109 792 INV_X1
* cell instance $27970 m0 *1 157.32,15.4
X$27970 77 792 819 728 597 290 109 NOR4_X4
* cell instance $27973 m0 *1 161.69,15.4
X$27973 461 685 77 109 793 OR2_X1
* cell instance $27974 m0 *1 162.45,15.4
X$27974 461 494 77 109 707 OR2_X1
* cell instance $27975 m0 *1 163.21,15.4
X$27975 453 1164 661 77 729 109 AOI21_X1
* cell instance $27978 r0 *1 157.32,15.4
X$27978 728 819 501 109 818 77 OAI21_X1
* cell instance $27981 r0 *1 158.65,15.4
X$27981 720 814 77 109 821 NAND2_X1
* cell instance $27982 r0 *1 159.22,15.4
X$27982 597 725 822 457 109 599 77 NOR4_X2
* cell instance $27985 r0 *1 161.5,15.4
X$27985 77 795 608 1027 609 727 109 AOI22_X4
* cell instance $27986 m0 *1 164.54,15.4
X$27986 464 77 109 592 CLKBUF_X3
* cell instance $27989 m0 *1 165.68,15.4
X$27989 673 605 606 340 77 109 796 AOI22_X2
* cell instance $27994 r0 *1 166.82,15.4
X$27994 453 730 338 77 663 109 AOI21_X1
* cell instance $27996 m0 *1 167.96,15.4
X$27996 77 157 794 102 18951 732 109 DFFR_X2
* cell instance $27999 m0 *1 172.33,15.4
X$27999 665 299 458 109 731 77 OAI21_X1
* cell instance $28002 m0 *1 174.8,15.4
X$28002 734 299 458 109 875 77 OAI21_X1
* cell instance $28003 m0 *1 175.56,15.4
X$28003 734 298 790 109 607 77 OAI21_X1
* cell instance $28004 m0 *1 176.32,15.4
X$28004 542 610 109 77 735 AND2_X1
* cell instance $28005 m0 *1 177.08,15.4
X$28005 610 542 77 109 734 NAND2_X1
* cell instance $28006 m0 *1 177.65,15.4
X$28006 77 616 611 696 695 295 109 AOI22_X4
* cell instance $28007 m0 *1 180.88,15.4
X$28007 77 105 733 692 737 230 109 AOI22_X4
* cell instance $28008 m0 *1 184.11,15.4
X$28008 379 187 77 109 738 NAND2_X1
* cell instance $28012 r0 *1 168.91,15.4
X$28012 578 820 77 109 730 NAND2_X1
* cell instance $28013 r0 *1 169.48,15.4
X$28013 77 737 109 606 BUF_X8
* cell instance $28017 r0 *1 171.95,15.4
X$28017 828 296 876 77 794 109 AOI21_X1
* cell instance $28018 r0 *1 172.71,15.4
X$28018 732 731 464 77 828 109 AOI21_X1
* cell instance $28020 r0 *1 174.23,15.4
X$28020 733 109 608 77 BUF_X4
* cell instance $28021 r0 *1 175.56,15.4
X$28021 873 875 464 77 736 109 AOI21_X1
* cell instance $28022 r0 *1 176.32,15.4
X$28022 873 735 109 77 826 AND2_X1
* cell instance $28024 r0 *1 177.27,15.4
X$28024 737 109 609 77 BUF_X4
* cell instance $28026 r0 *1 178.79,15.4
X$28026 744 611 695 529 77 109 871 AOI22_X2
* cell instance $28027 r0 *1 180.5,15.4
X$28027 77 379 733 868 737 542 109 AOI22_X4
* cell instance $28029 r0 *1 183.92,15.4
X$28029 738 466 77 109 935 NOR2_X1
* cell instance $28030 r0 *1 184.49,15.4
X$28030 615 379 187 832 77 833 109 NAND4_X2
* cell instance $28032 m0 *1 185.06,15.4
X$28032 738 380 329 109 614 77 OAI21_X1
* cell instance $28033 m0 *1 186.58,15.4
X$28033 781 543 383 778 777 779 77 109 667 OAI33_X1
* cell instance $28034 m0 *1 187.91,15.4
X$28034 586 667 186 77 666 109 AOI21_X1
* cell instance $28035 m0 *1 192.85,15.4
X$28035 772 305 668 109 670 77 OAI21_X1
* cell instance $28036 m0 *1 193.61,15.4
X$28036 616 669 186 77 740 109 AOI21_X1
* cell instance $28037 m0 *1 194.37,15.4
X$28037 740 147 670 77 771 109 AOI21_X1
* cell instance $28039 m0 *1 199.12,15.4
X$28039 769 77 109 616 BUF_X2
* cell instance $28044 r0 *1 186.2,15.4
X$28044 615 379 187 77 109 739 NAND3_X1
* cell instance $28045 r0 *1 186.96,15.4
X$28045 467 380 739 77 109 931 OR3_X1
* cell instance $28046 r0 *1 187.91,15.4
X$28046 833 466 77 109 900 NOR2_X1
* cell instance $28048 r0 *1 188.67,15.4
X$28048 739 466 329 109 834 77 OAI21_X1
* cell instance $28051 r0 *1 190,15.4
X$28051 902 184 865 77 775 109 AOI21_X1
* cell instance $28056 r0 *1 197.79,15.4
X$28056 77 149 862 102 19019 795 109 DFFR_X2
* cell instance $28057 r0 *1 201.97,15.4
X$28057 742 741 860 77 837 109 AOI21_X1
* cell instance $28059 r0 *1 203.11,15.4
X$28059 744 743 240 77 742 109 AOI21_X1
* cell instance $28062 m0 *1 205.77,15.4
X$28062 395 311 77 109 745 NAND2_X1
* cell instance $28064 m0 *1 206.34,15.4
X$28064 628 745 240 77 746 109 AOI21_X1
* cell instance $28065 m0 *1 207.1,15.4
X$28065 671 546 788 472 109 77 680 OAI22_X1
* cell instance $28066 m0 *1 208.05,15.4
X$28066 628 77 109 671 INV_X1
* cell instance $28067 m0 *1 208.43,15.4
X$28067 671 315 314 109 672 77 OAI21_X1
* cell instance $28068 m0 *1 209.19,15.4
X$28068 673 672 240 77 765 109 AOI21_X1
* cell instance $28069 m0 *1 209.95,15.4
X$28069 759 329 767 77 109 766 MUX2_X1
* cell instance $28070 m0 *1 211.28,15.4
X$28070 765 147 766 77 764 109 AOI21_X1
* cell instance $28072 m0 *1 213.56,15.4
X$28072 405 747 763 109 677 77 OAI21_X1
* cell instance $28073 m0 *1 214.32,15.4
X$28073 748 749 77 109 763 NAND2_X1
* cell instance $28075 m0 *1 215.08,15.4
X$28075 748 674 77 109 761 NAND2_X1
* cell instance $28076 m0 *1 215.65,15.4
X$28076 999 77 109 317 CLKBUF_X3
* cell instance $28077 m0 *1 216.6,15.4
X$28077 759 747 761 109 675 77 OAI21_X1
* cell instance $28078 m0 *1 217.36,15.4
X$28078 77 750 18675 674 675 102 109 DFFR_X1
* cell instance $28083 r0 *1 206.53,15.4
X$28083 746 741 680 77 768 109 AOI21_X1
* cell instance $28084 r0 *1 207.29,15.4
X$28084 77 149 18825 857 768 102 109 DFFR_X1
* cell instance $28085 r0 *1 211.09,15.4
X$28085 857 77 109 628 BUF_X2
* cell instance $28088 r0 *1 213.75,15.4
X$28088 77 317 677 102 18975 749 109 DFFR_X2
* cell instance $28091 r0 *1 221.73,15.4
X$28091 405 843 758 109 842 77 OAI21_X1
* cell instance $28093 r0 *1 222.68,15.4
X$28093 844 853 77 109 758 NAND2_X1
* cell instance $28095 m0 *1 224.01,15.4
X$28095 621 747 755 109 757 77 OAI21_X1
* cell instance $28097 m0 *1 224.77,15.4
X$28097 77 750 18680 751 757 102 109 DFFR_X1
* cell instance $28105 r0 *1 227.05,15.4
X$28105 748 751 77 109 755 NAND2_X1
* cell instance $28106 r0 *1 227.62,15.4
X$28106 77 750 18899 850 845 102 109 DFFR_X1
* cell instance $28107 m0 *1 231.42,15.4
X$28107 77 753 18631 752 676 102 109 DFFR_X1
* cell instance $28114 r0 *1 232.37,15.4
X$28114 578 747 848 109 676 77 OAI21_X1
* cell instance $28116 r0 *1 233.32,15.4
X$28116 748 752 77 109 848 NAND2_X1
* cell instance $28118 r0 *1 234.27,15.4
X$28118 77 753 18862 847 917 102 109 DFFR_X1
* cell instance $28162 m0 *1 91.58,12.6
X$28162 351 486 519 77 109 627 MUX2_X1
* cell instance $28163 m0 *1 88.35,12.6
X$28163 77 18296 519 549 520 109 DFF_X1
* cell instance $28168 r0 *1 91.2,12.6
X$28168 756 629 627 77 109 678 MUX2_X1
* cell instance $28171 r0 *1 93.1,12.6
X$28171 409 77 109 520 CLKBUF_X3
* cell instance $28172 r0 *1 94.05,12.6
X$28172 520 77 109 19122 INV_X2
* cell instance $28174 r0 *1 94.81,12.6
X$28174 418 77 109 629 CLKBUF_X3
* cell instance $28177 m0 *1 96.33,12.6
X$28177 523 629 551 77 109 679 MUX2_X1
* cell instance $28178 m0 *1 97.85,12.6
X$28178 524 629 521 77 109 522 MUX2_X1
* cell instance $28179 m0 *1 99.18,12.6
X$28179 196 281 523 77 109 762 MUX2_X1
* cell instance $28184 r0 *1 96.71,12.6
X$28184 77 18436 523 679 172 109 DFF_X1
* cell instance $28187 m0 *1 103.36,12.6
X$28187 138 281 524 77 109 555 MUX2_X1
* cell instance $28189 m0 *1 104.69,12.6
X$28189 525 354 555 77 109 684 MUX2_X1
* cell instance $28191 m0 *1 107.54,12.6
X$28191 77 18324 526 556 140 109 DFF_X1
* cell instance $28195 m0 *1 114.76,12.6
X$28195 444 450 527 77 109 589 MUX2_X1
* cell instance $28197 m0 *1 116.85,12.6
X$28197 77 18311 558 559 89 109 DFF_X1
* cell instance $28201 r0 *1 104.5,12.6
X$28201 77 18405 525 684 172 109 DFF_X1
* cell instance $28203 r0 *1 110.77,12.6
X$28203 77 18461 588 633 644 109 DFF_X1
* cell instance $28204 r0 *1 114,12.6
X$28204 444 645 588 77 109 646 MUX2_X1
* cell instance $28208 r0 *1 115.33,12.6
X$28208 588 647 589 77 109 633 MUX2_X1
* cell instance $28211 r0 *1 117.8,12.6
X$28211 142 450 558 77 109 648 MUX2_X1
* cell instance $28218 r0 *1 122.55,12.6
X$28218 713 647 688 77 109 773 MUX2_X1
* cell instance $28220 r0 *1 123.88,12.6
X$28220 77 18401 649 689 447 109 DFF_X1
* cell instance $28222 m0 *1 124.45,12.6
X$28222 359 450 445 77 109 561 MUX2_X1
* cell instance $28223 m0 *1 125.97,12.6
X$28223 649 647 561 77 109 689 MUX2_X1
* cell instance $28226 r0 *1 127.3,12.6
X$28226 96 450 360 77 109 650 MUX2_X1
* cell instance $28228 m0 *1 127.68,12.6
X$28228 77 18335 563 562 447 109 DFF_X1
* cell instance $28230 r0 *1 129.39,12.6
X$28230 143 450 563 77 109 776 MUX2_X1
* cell instance $28233 m0 *1 131.29,12.6
X$28233 77 18367 564 565 447 109 DFF_X1
* cell instance $28235 m0 *1 136.8,12.6
X$28235 418 77 109 647 CLKBUF_X3
* cell instance $28238 m0 *1 138.7,12.6
X$28238 209 450 362 77 109 590 MUX2_X1
* cell instance $28243 r0 *1 133.19,12.6
X$28243 212 450 564 77 109 651 MUX2_X1
* cell instance $28245 r0 *1 135.28,12.6
X$28245 145 450 448 77 109 652 MUX2_X1
* cell instance $28248 r0 *1 138.89,12.6
X$28248 654 647 590 77 109 698 MUX2_X1
* cell instance $28249 r0 *1 140.22,12.6
X$28249 77 18389 654 698 176 109 DFF_X1
* cell instance $28251 m0 *1 143.64,12.6
X$28251 77 176 18572 591 635 102 109 DFFR_X1
* cell instance $28254 m0 *1 147.63,12.6
X$28254 345 77 109 334 CLKBUF_X3
* cell instance $28258 r0 *1 144.4,12.6
X$28258 77 334 18765 700 783 102 109 DFFR_X1
* cell instance $28259 r0 *1 148.2,12.6
X$28259 591 77 109 594 BUF_X2
* cell instance $28261 r0 *1 149.34,12.6
X$28261 700 77 109 727 BUF_X2
* cell instance $28262 m0 *1 149.91,12.6
X$28262 528 178 570 77 568 109 AOI21_X1
* cell instance $28264 m0 *1 150.67,12.6
X$28264 529 593 592 77 528 109 AOI21_X1
* cell instance $28266 m0 *1 151.62,12.6
X$28266 77 334 637 102 18932 596 109 DFFR_X2
* cell instance $28267 m0 *1 155.8,12.6
X$28267 597 576 77 109 365 NOR2_X2
* cell instance $28269 m0 *1 156.94,12.6
X$28269 530 290 592 109 573 77 OAI21_X1
* cell instance $28271 m0 *1 157.89,12.6
X$28271 461 77 109 602 CLKBUF_X3
* cell instance $28273 m0 *1 159.6,12.6
X$28273 457 597 576 109 533 77 NOR3_X2
* cell instance $28274 m0 *1 160.93,12.6
X$28274 530 531 793 109 275 77 OAI21_X1
* cell instance $28275 m0 *1 161.69,12.6
X$28275 291 180 109 77 532 AND2_X2
* cell instance $28276 m0 *1 162.64,12.6
X$28276 532 371 77 109 639 NAND2_X1
* cell instance $28278 m0 *1 163.4,12.6
X$28278 291 77 109 598 INV_X1
* cell instance $28280 m0 *1 164.54,12.6
X$28280 530 534 592 109 600 77 OAI21_X1
* cell instance $28281 m0 *1 165.3,12.6
X$28281 532 599 371 77 109 535 NAND3_X1
* cell instance $28282 m0 *1 166.06,12.6
X$28282 537 532 599 371 77 109 536 NAND4_X1
* cell instance $28283 m0 *1 167.01,12.6
X$28283 293 601 536 77 109 182 OR3_X2
* cell instance $28284 m0 *1 168.15,12.6
X$28284 103 77 109 601 INV_X1
* cell instance $28287 r0 *1 150.48,12.6
X$28287 636 595 656 77 635 109 AOI21_X1
* cell instance $28289 r0 *1 151.43,12.6
X$28289 594 77 109 595 INV_X1
* cell instance $28290 r0 *1 151.81,12.6
X$28290 453 657 703 77 636 109 AOI21_X1
* cell instance $28292 r0 *1 152.76,12.6
X$28292 595 660 227 109 593 77 OAI21_X1
* cell instance $28294 r0 *1 153.71,12.6
X$28294 704 178 658 77 637 109 AOI21_X1
* cell instance $28295 r0 *1 154.47,12.6
X$28295 529 594 77 109 659 NAND2_X1
* cell instance $28296 r0 *1 155.04,12.6
X$28296 596 705 592 77 704 109 AOI21_X1
* cell instance $28297 r0 *1 155.8,12.6
X$28297 659 576 227 109 705 77 OAI21_X1
* cell instance $28298 r0 *1 156.56,12.6
X$28298 529 594 596 77 597 109 NAND3_X4
* cell instance $28299 r0 *1 159.03,12.6
X$28299 77 660 597 457 639 538 109 NOR4_X4
* cell instance $28301 r0 *1 162.64,12.6
X$28301 533 373 291 77 109 661 NAND3_X1
* cell instance $28302 r0 *1 163.4,12.6
X$28302 729 598 662 77 202 109 AOI21_X1
* cell instance $28303 r0 *1 164.16,12.6
X$28303 530 599 592 109 662 77 OAI21_X1
* cell instance $28304 r0 *1 164.92,12.6
X$28304 530 538 592 109 706 77 OAI21_X1
* cell instance $28306 r0 *1 166.06,12.6
X$28306 663 601 600 77 160 109 AOI21_X1
* cell instance $28307 r0 *1 166.82,12.6
X$28307 536 602 77 109 437 NAND2_X1
* cell instance $28309 r0 *1 168.15,12.6
X$28309 288 664 583 706 77 109 104 AOI22_X1
* cell instance $28311 m0 *1 168.91,12.6
X$28311 583 535 227 109 462 77 OAI21_X1
* cell instance $28312 m0 *1 169.86,12.6
X$28312 181 77 109 583 INV_X1
* cell instance $28313 m0 *1 170.24,12.6
X$28313 181 266 226 109 77 537 AND3_X1
* cell instance $28314 m0 *1 171.19,12.6
X$28314 538 103 295 537 77 299 109 NAND4_X2
* cell instance $28317 r0 *1 169.1,12.6
X$28317 583 603 602 693 109 77 664 OAI22_X1
* cell instance $28318 r0 *1 170.05,12.6
X$28318 538 458 77 109 603 NAND2_X1
* cell instance $28320 r0 *1 170.81,12.6
X$28320 460 603 604 109 434 77 OAI21_X1
* cell instance $28325 r0 *1 171.76,12.6
X$28325 612 605 606 366 77 109 702 AOI22_X2
* cell instance $28326 r0 *1 173.47,12.6
X$28326 323 605 606 371 77 109 701 AOI22_X2
* cell instance $28328 m0 *1 174.04,12.6
X$28328 539 296 607 77 585 109 AOI21_X1
* cell instance $28329 m0 *1 174.99,12.6
X$28329 542 540 464 77 539 109 AOI21_X1
* cell instance $28330 m0 *1 175.75,12.6
X$28330 586 608 609 103 77 109 634 AOI22_X2
* cell instance $28331 m0 *1 177.46,12.6
X$28331 259 541 77 109 610 NOR2_X1
* cell instance $28332 m0 *1 182.21,12.6
X$28332 376 77 109 541 INV_X1
* cell instance $28333 m0 *1 182.59,12.6
X$28333 77 152 581 102 18960 615 109 DFFR_X2
* cell instance $28334 m0 *1 186.77,12.6
X$28334 578 329 302 77 109 617 MUX2_X1
* cell instance $28337 m0 *1 191.33,12.6
X$28337 619 586 616 77 109 469 NAND3_X1
* cell instance $28340 m0 *1 193.04,12.6
X$28340 543 238 77 109 620 NOR2_X1
* cell instance $28343 m0 *1 195.32,12.6
X$28343 632 77 109 475 INV_X1
* cell instance $28348 r0 *1 175.37,12.6
X$28348 478 608 609 180 77 109 699 AOI22_X2
* cell instance $28350 r0 *1 177.27,12.6
X$28350 77 245 611 697 695 291 109 AOI22_X4
* cell instance $28352 r0 *1 180.69,12.6
X$28352 192 611 695 266 77 109 694 AOI22_X2
* cell instance $28354 r0 *1 182.59,12.6
X$28354 628 375 377 596 77 109 691 AOI22_X2
* cell instance $28355 r0 *1 184.3,12.6
X$28355 613 184 690 77 581 109 AOI21_X1
* cell instance $28356 r0 *1 185.06,12.6
X$28356 615 614 186 77 613 109 AOI21_X1
* cell instance $28359 r0 *1 186.39,12.6
X$28359 616 77 109 781 INV_X1
* cell instance $28361 r0 *1 187.15,12.6
X$28361 666 184 617 77 618 109 AOI21_X1
* cell instance $28362 r0 *1 187.91,12.6
X$28362 77 152 18805 586 618 102 109 DFFR_X1
* cell instance $28364 r0 *1 192.09,12.6
X$28364 543 77 109 619 INV_X1
* cell instance $28365 r0 *1 192.47,12.6
X$28365 620 311 616 77 109 668 NAND3_X1
* cell instance $28366 r0 *1 193.23,12.6
X$28366 467 620 77 109 669 OR2_X1
* cell instance $28369 r0 *1 194.94,12.6
X$28369 619 622 621 414 77 109 632 AOI22_X1
* cell instance $28370 r0 *1 195.89,12.6
X$28370 383 467 77 109 622 NOR2_X1
* cell instance $28372 r0 *1 196.84,12.6
X$28372 237 622 631 414 77 109 308 AOI22_X1
* cell instance $28375 m0 *1 198.36,12.6
X$28375 414 238 567 109 566 77 OAI21_X1
* cell instance $28377 m0 *1 200.07,12.6
X$28377 414 625 77 109 567 NAND2_X1
* cell instance $28378 m0 *1 200.64,12.6
X$28378 545 323 77 109 383 NAND2_X2
* cell instance $28380 m0 *1 201.78,12.6
X$28380 480 544 77 109 545 NOR2_X1
* cell instance $28381 m0 *1 202.35,12.6
X$28381 545 311 77 109 623 NAND2_X1
* cell instance $28383 m0 *1 203.11,12.6
X$28383 77 149 630 102 18927 478 109 DFFR_X2
* cell instance $28385 m0 *1 208.05,12.6
X$28385 390 546 552 472 109 77 553 OAI22_X1
* cell instance $28387 m0 *1 209.19,12.6
X$28387 547 147 553 77 550 109 AOI21_X1
* cell instance $28388 m0 *1 209.95,12.6
X$28388 612 626 240 77 547 109 AOI21_X1
* cell instance $28393 r0 *1 202.54,12.6
X$28393 685 305 623 109 683 77 OAI21_X1
* cell instance $28394 r0 *1 203.3,12.6
X$28394 682 147 683 77 630 109 AOI21_X1
* cell instance $28395 r0 *1 204.06,12.6
X$28395 349 77 109 149 CLKBUF_X3
* cell instance $28396 r0 *1 205.01,12.6
X$28396 478 489 240 77 682 109 AOI21_X1
* cell instance $28397 r0 *1 205.77,12.6
X$28397 149 77 109 19274 CLKBUF_X1
* cell instance $28400 r0 *1 208.05,12.6
X$28400 673 628 612 77 109 390 NAND3_X1
* cell instance $28402 r0 *1 209,12.6
X$28402 624 395 314 109 626 77 OAI21_X1
* cell instance $28403 r0 *1 209.76,12.6
X$28403 673 628 77 109 624 NAND2_X1
* cell instance $28404 r0 *1 210.33,12.6
X$28404 624 315 77 109 767 NOR2_X1
* cell instance $28407 r0 *1 211.85,12.6
X$28407 77 317 764 102 19011 673 109 DFFR_X2
* cell instance $28409 m0 *1 211.85,12.6
X$28409 77 317 550 102 18915 612 109 DFFR_X2
* cell instance $28416 r0 *1 216.03,12.6
X$28416 317 77 109 19160 INV_X1
* cell instance $28419 r0 *1 218.12,12.6
X$28419 631 77 109 693 INV_X2
* cell instance $28447 m0 *1 92.72,9.8
X$28447 77 18314 440 485 520 109 DFF_X1
* cell instance $28448 m0 *1 95.95,9.8
X$28448 216 77 109 486 CLKBUF_X3
* cell instance $28449 m0 *1 96.9,9.8
X$28449 138 486 396 77 109 521 MUX2_X1
* cell instance $28452 m0 *1 99.94,9.8
X$28452 409 77 109 172 CLKBUF_X3
* cell instance $28453 m0 *1 100.89,9.8
X$28453 215 352 353 77 109 487 MUX2_X1
* cell instance $28454 m0 *1 102.22,9.8
X$28454 441 442 487 77 109 488 MUX2_X1
* cell instance $28481 r0 *1 90.63,9.8
X$28481 519 394 351 77 109 549 MUX2_X1
* cell instance $28484 r0 *1 95.19,9.8
X$28484 196 486 440 77 109 551 MUX2_X1
* cell instance $28488 r0 *1 97.85,9.8
X$28488 77 18433 524 522 172 109 DFF_X1
* cell instance $28490 r0 *1 101.84,9.8
X$28490 77 18432 441 488 172 109 DFF_X1
* cell instance $28492 m0 *1 104.69,9.8
X$28492 77 18325 355 356 140 109 DFF_X1
* cell instance $28494 m0 *1 110.96,9.8
X$28494 493 354 491 77 109 492 MUX2_X1
* cell instance $28501 r0 *1 108.11,9.8
X$28501 526 442 490 77 109 556 MUX2_X1
* cell instance $28503 r0 *1 109.63,9.8
X$28503 77 18459 493 492 140 109 DFF_X1
* cell instance $28504 r0 *1 112.86,9.8
X$28504 77 18460 527 557 89 109 DFF_X1
* cell instance $28508 r0 *1 116.09,9.8
X$28508 527 358 444 77 109 557 MUX2_X1
* cell instance $28510 r0 *1 117.61,9.8
X$28510 558 358 142 77 109 559 MUX2_X1
* cell instance $28512 m0 *1 119.51,9.8
X$28512 77 18338 408 357 89 109 DFF_X1
* cell instance $28517 r0 *1 121.22,9.8
X$28517 77 18388 496 560 89 109 DFF_X1
* cell instance $28518 r0 *1 124.45,9.8
X$28518 77 18412 445 446 93 109 DFF_X1
* cell instance $28520 m0 *1 124.45,9.8
X$28520 445 358 359 77 109 446 MUX2_X1
* cell instance $28521 m0 *1 127.3,9.8
X$28521 360 358 96 77 109 498 MUX2_X1
* cell instance $28522 m0 *1 128.63,9.8
X$28522 77 18369 360 498 447 109 DFF_X1
* cell instance $28526 r0 *1 128.82,9.8
X$28526 563 358 143 77 109 562 MUX2_X1
* cell instance $28527 r0 *1 130.15,9.8
X$28527 352 109 281 77 BUF_X4
* cell instance $28530 m0 *1 132.24,9.8
X$28530 77 18380 417 416 93 109 DFF_X1
* cell instance $28531 r0 *1 132.24,9.8
X$28531 564 358 212 77 109 565 MUX2_X1
* cell instance $28535 r0 *1 134.9,9.8
X$28535 216 77 109 450 CLKBUF_X3
* cell instance $28536 m0 *1 137.18,9.8
X$28536 332 77 109 358 CLKBUF_X3
* cell instance $28537 m0 *1 135.85,9.8
X$28537 448 358 145 77 109 449 MUX2_X1
* cell instance $28539 m0 *1 138.32,9.8
X$28539 176 77 109 19237 CLKBUF_X1
* cell instance $28540 m0 *1 138.89,9.8
X$28540 362 358 209 77 109 287 MUX2_X1
* cell instance $28541 m0 *1 140.22,9.8
X$28541 499 358 146 77 109 363 MUX2_X1
* cell instance $28542 m0 *1 141.55,9.8
X$28542 345 77 109 176 CLKBUF_X3
* cell instance $28546 m0 *1 146.49,9.8
X$28546 77 334 18563 451 500 102 109 DFFR_X1
* cell instance $28547 m0 *1 150.29,9.8
X$28547 502 501 77 109 424 NAND2_X1
* cell instance $28548 m0 *1 150.86,9.8
X$28548 365 340 77 109 502 NAND2_X1
* cell instance $28551 m0 *1 152.38,9.8
X$28551 365 373 340 366 77 109 364 NAND4_X1
* cell instance $28553 r0 *1 135.85,9.8
X$28553 77 18409 448 449 176 109 DFF_X1
* cell instance $28555 r0 *1 139.27,9.8
X$28555 146 450 499 77 109 655 MUX2_X1
* cell instance $28557 r0 *1 140.98,9.8
X$28557 77 18419 499 363 176 109 DFF_X1
* cell instance $28561 r0 *1 146.68,9.8
X$28561 77 334 568 102 18983 529 109 DFFR_X2
* cell instance $28562 r0 *1 150.86,9.8
X$28562 451 77 109 340 BUF_X2
* cell instance $28564 r0 *1 152,9.8
X$28564 453 572 364 77 425 109 AOI21_X1
* cell instance $28566 m0 *1 154.28,9.8
X$28566 369 365 77 109 367 NAND2_X1
* cell instance $28567 m0 *1 153.71,9.8
X$28567 367 501 77 109 428 NAND2_X1
* cell instance $28568 m0 *1 154.85,9.8
X$28568 369 365 373 258 77 109 452 NAND4_X1
* cell instance $28571 m0 *1 157.51,9.8
X$28571 369 77 109 454 INV_X1
* cell instance $28572 m0 *1 157.89,9.8
X$28572 177 366 340 109 77 369 AND3_X2
* cell instance $28576 r0 *1 155.23,9.8
X$28576 453 638 452 77 429 109 AOI21_X1
* cell instance $28579 r0 *1 156.56,9.8
X$28579 288 574 455 573 77 109 500 AOI22_X1
* cell instance $28580 r0 *1 157.51,9.8
X$28580 340 77 109 455 INV_X1
* cell instance $28581 r0 *1 157.89,9.8
X$28581 454 456 507 109 289 77 OAI21_X1
* cell instance $28582 r0 *1 158.65,9.8
X$28582 455 456 575 109 574 77 OAI21_X1
* cell instance $28583 r0 *1 159.41,9.8
X$28583 290 458 77 109 456 NAND2_X1
* cell instance $28584 r0 *1 159.98,9.8
X$28584 457 456 707 109 342 77 OAI21_X1
* cell instance $28586 r0 *1 160.93,9.8
X$28586 433 290 180 291 77 109 531 NAND4_X1
* cell instance $28587 r0 *1 161.88,9.8
X$28587 433 290 371 532 77 579 109 NAND4_X2
* cell instance $28588 m0 *1 162.07,9.8
X$28588 370 178 508 77 224 109 AOI21_X1
* cell instance $28591 m0 *1 163.02,9.8
X$28591 371 510 223 77 370 109 AOI21_X1
* cell instance $28592 m0 *1 163.78,9.8
X$28592 511 348 77 109 510 NAND2_X1
* cell instance $28595 m0 *1 165.3,9.8
X$28595 371 77 109 514 INV_X1
* cell instance $28596 m0 *1 165.68,9.8
X$28596 460 511 514 109 517 77 NOR3_X2
* cell instance $28597 m0 *1 167.01,9.8
X$28597 453 516 439 77 372 109 AOI21_X1
* cell instance $28598 m0 *1 167.77,9.8
X$28598 517 373 295 77 109 439 NAND3_X1
* cell instance $28600 m0 *1 169.29,9.8
X$28600 266 462 223 77 518 109 AOI21_X1
* cell instance $28601 m0 *1 170.05,9.8
X$28601 266 181 77 109 436 NAND2_X1
* cell instance $28603 r0 *1 163.59,9.8
X$28603 532 533 77 109 511 NAND2_X1
* cell instance $28604 r0 *1 164.16,9.8
X$28604 532 533 458 371 77 109 459 NAND4_X1
* cell instance $28605 r0 *1 165.11,9.8
X$28605 459 580 77 109 508 NAND2_X1
* cell instance $28607 r0 *1 165.87,9.8
X$28607 460 579 293 109 534 77 NOR3_X2
* cell instance $28609 r0 *1 167.39,9.8
X$28609 534 461 103 77 109 338 NAND3_X2
* cell instance $28611 r0 *1 168.91,9.8
X$28611 436 579 227 109 374 77 OAI21_X1
* cell instance $28613 r0 *1 169.86,9.8
X$28613 436 459 584 109 463 77 OAI21_X1
* cell instance $28614 r0 *1 170.62,9.8
X$28614 226 266 181 77 109 460 NAND3_X2
* cell instance $28622 r0 *1 172.52,9.8
X$28622 461 103 295 517 77 298 109 NAND4_X2
* cell instance $28623 m0 *1 172.9,9.8
X$28623 464 77 109 223 CLKBUF_X3
* cell instance $28625 m0 *1 177.27,9.8
X$28625 301 296 512 77 422 109 AOI21_X1
* cell instance $28627 m0 *1 178.22,9.8
X$28627 77 388 375 509 377 177 109 AOI22_X4
* cell instance $28628 m0 *1 181.45,9.8
X$28628 77 236 375 506 377 232 109 AOI22_X4
* cell instance $28629 m0 *1 184.68,9.8
X$28629 378 184 505 77 331 109 AOI21_X1
* cell instance $28630 m0 *1 185.44,9.8
X$28630 379 504 186 77 378 109 AOI21_X1
* cell instance $28631 m0 *1 186.2,9.8
X$28631 187 77 109 381 INV_X1
* cell instance $28632 m0 *1 186.58,9.8
X$28632 380 467 381 77 109 468 NOR3_X1
* cell instance $28633 m0 *1 187.34,9.8
X$28633 468 503 414 77 256 109 AOI21_X1
* cell instance $28634 m0 *1 188.1,9.8
X$28634 469 383 77 109 302 NOR2_X1
* cell instance $28636 m0 *1 188.86,9.8
X$28636 306 470 77 109 466 OR2_X1
* cell instance $28637 m0 *1 189.62,9.8
X$28637 236 105 190 77 109 470 NAND3_X1
* cell instance $28639 r0 *1 174.23,9.8
X$28639 464 77 109 296 CLKBUF_X3
* cell instance $28640 r0 *1 175.18,9.8
X$28640 465 182 227 109 540 77 OAI21_X1
* cell instance $28641 r0 *1 175.94,9.8
X$28641 461 471 77 109 300 OR2_X1
* cell instance $28642 r0 *1 176.7,9.8
X$28642 465 338 513 109 512 77 OAI21_X1
* cell instance $28643 r0 *1 177.46,9.8
X$28643 541 259 77 109 465 OR2_X1
* cell instance $28645 r0 *1 178.98,9.8
X$28645 474 375 377 226 77 109 587 AOI22_X2
* cell instance $28646 r0 *1 180.69,9.8
X$28646 77 187 375 582 377 376 109 AOI22_X4
* cell instance $28648 r0 *1 185.25,9.8
X$28648 381 466 329 109 504 77 OAI21_X1
* cell instance $28650 r0 *1 186.2,9.8
X$28650 349 77 109 152 CLKBUF_X3
* cell instance $28651 r0 *1 187.15,9.8
X$28651 152 77 109 19164 INV_X1
* cell instance $28653 r0 *1 187.72,9.8
X$28653 383 469 470 77 109 380 OR3_X2
* cell instance $28656 r0 *1 190,9.8
X$28656 470 473 471 472 109 77 411 OAI22_X1
* cell instance $28658 m0 *1 190.76,9.8
X$28658 467 306 77 109 473 OR2_X1
* cell instance $28659 r0 *1 190.95,9.8
X$28659 190 77 109 577 INV_X1
* cell instance $28660 r0 *1 191.33,9.8
X$28660 577 473 548 472 109 77 106 OAI22_X1
* cell instance $28661 m0 *1 192.09,9.8
X$28661 238 469 77 109 306 OR2_X1
* cell instance $28664 r0 *1 192.28,9.8
X$28664 474 192 237 77 109 543 NAND3_X1
* cell instance $28666 m0 *1 193.42,9.8
X$28666 307 383 314 109 569 77 OAI21_X1
* cell instance $28670 r0 *1 193.61,9.8
X$28670 474 569 186 77 497 109 AOI21_X1
* cell instance $28672 m0 *1 194.56,9.8
X$28672 497 147 475 77 571 109 AOI21_X1
* cell instance $28673 m0 *1 198.93,9.8
X$28673 323 77 109 476 INV_X1
* cell instance $28677 m0 *1 201.78,9.8
X$28677 414 479 385 109 402 77 OAI21_X1
* cell instance $28678 m0 *1 202.54,9.8
X$28678 479 329 310 77 109 404 NAND3_X1
* cell instance $28679 m0 *1 203.3,9.8
X$28679 479 245 310 77 109 480 NAND3_X1
* cell instance $28682 m0 *1 205.01,9.8
X$28682 386 315 77 109 479 NOR2_X1
* cell instance $28683 m0 *1 205.58,9.8
X$28683 478 245 310 77 109 481 NAND3_X1
* cell instance $28685 m0 *1 207.86,9.8
X$28685 388 77 109 389 INV_X1
* cell instance $28686 m0 *1 208.24,9.8
X$28686 389 390 77 109 313 OR2_X1
* cell instance $28687 m0 *1 209,9.8
X$28687 390 315 389 77 109 483 NOR3_X1
* cell instance $28688 m0 *1 209.76,9.8
X$28688 484 329 483 77 109 392 MUX2_X1
* cell instance $28689 m0 *1 211.09,9.8
X$28689 393 147 392 77 482 109 AOI21_X1
* cell instance $28697 r0 *1 198.36,9.8
X$28697 385 566 476 495 77 109 384 AOI22_X1
* cell instance $28699 r0 *1 200.07,9.8
X$28699 414 477 385 109 495 77 OAI21_X1
* cell instance $28700 r0 *1 200.83,9.8
X$28700 477 323 77 109 238 NAND2_X2
* cell instance $28702 r0 *1 201.97,9.8
X$28702 478 77 109 544 INV_X1
* cell instance $28704 r0 *1 202.54,9.8
X$28704 494 472 404 109 403 77 OAI21_X1
* cell instance $28705 r0 *1 203.3,9.8
X$28705 480 311 77 109 489 NAND2_X1
* cell instance $28707 r0 *1 205.39,9.8
X$28707 481 386 395 109 477 77 NOR3_X2
* cell instance $28708 r0 *1 206.72,9.8
X$28708 467 395 77 109 546 OR2_X1
* cell instance $28709 r0 *1 207.48,9.8
X$28709 386 546 554 472 109 77 387 OAI22_X1
* cell instance $28712 r0 *1 210.71,9.8
X$28712 77 317 482 102 19022 388 109 DFFR_X2
* cell instance $28770 r0 *1 98.04,4.2
X$28770 77 18462 214 246 172 109 DFF_X1
* cell instance $28773 m0 *1 102.98,4.2
X$28773 156 85 154 77 109 159 MUX2_X1
* cell instance $28774 m0 *1 104.31,4.2
X$28774 217 88 159 77 109 247 MUX2_X1
* cell instance $28775 m0 *1 108.87,4.2
X$28775 77 18322 87 124 140 109 DFF_X1
* cell instance $28777 m0 *1 112.29,4.2
X$28777 167 85 87 77 109 201 MUX2_X1
* cell instance $28779 m0 *1 113.81,4.2
X$28779 77 18300 80 127 140 109 DFF_X1
* cell instance $28781 m0 *1 118.37,4.2
X$28781 141 88 170 77 109 204 MUX2_X1
* cell instance $28783 m0 *1 122.36,4.2
X$28783 90 85 91 77 109 207 MUX2_X1
* cell instance $28785 m0 *1 124.45,4.2
X$28785 77 18384 91 92 93 109 DFF_X1
* cell instance $28790 r0 *1 103.36,4.2
X$28790 77 18404 217 247 172 109 DFF_X1
* cell instance $28794 r0 *1 108.87,4.2
X$28794 278 88 173 77 109 251 MUX2_X1
* cell instance $28798 r0 *1 112.1,4.2
X$28798 279 88 201 77 109 326 MUX2_X1
* cell instance $28807 r0 *1 117.8,4.2
X$28807 77 18440 141 204 89 109 DFF_X1
* cell instance $28809 r0 *1 121.22,4.2
X$28809 77 18408 219 260 89 109 DFF_X1
* cell instance $28810 r0 *1 124.45,4.2
X$28810 219 88 207 77 109 260 MUX2_X1
* cell instance $28813 r0 *1 127.49,4.2
X$28813 220 88 174 77 109 262 MUX2_X1
* cell instance $28815 m0 *1 128.06,4.2
X$28815 95 85 94 77 109 174 MUX2_X1
* cell instance $28817 r0 *1 128.82,4.2
X$28817 77 18429 220 262 93 109 DFF_X1
* cell instance $28819 m0 *1 133.19,4.2
X$28819 175 85 134 77 109 144 MUX2_X1
* cell instance $28822 m0 *1 136.04,4.2
X$28822 137 85 135 77 109 168 MUX2_X1
* cell instance $28823 m0 *1 137.37,4.2
X$28823 97 88 168 77 109 210 MUX2_X1
* cell instance $28832 r0 *1 133.38,4.2
X$28832 211 88 144 77 109 265 MUX2_X1
* cell instance $28834 r0 *1 134.9,4.2
X$28834 77 18454 211 265 176 109 DFF_X1
* cell instance $28836 r0 *1 138.32,4.2
X$28836 77 18434 97 210 176 109 DFF_X1
* cell instance $28838 m0 *1 146.49,4.2
X$28838 77 98 18528 164 268 102 109 DFFR_X1
* cell instance $28839 m0 *1 150.29,4.2
X$28839 166 77 109 98 CLKBUF_X3
* cell instance $28844 r0 *1 149.91,4.2
X$28844 273 205 109 77 274 AND2_X1
* cell instance $28845 r0 *1 150.67,4.2
X$28845 208 77 109 273 CLKBUF_X3
* cell instance $28846 r0 *1 151.62,4.2
X$28846 272 77 109 208 CLKBUF_X3
* cell instance $28848 m0 *1 152.57,4.2
X$28848 130 206 77 109 205 DLL_X1
* cell instance $28849 m0 *1 154.47,4.2
X$28849 99 164 77 109 165 OR2_X1
* cell instance $28854 m0 *1 157.13,4.2
X$28854 162 77 109 101 INV_X1
* cell instance $28861 r0 *1 160.93,4.2
X$28861 203 178 275 77 161 109 AOI21_X1
* cell instance $28862 r0 *1 161.69,4.2
X$28862 180 179 223 77 203 109 AOI21_X1
* cell instance $28866 r0 *1 164.92,4.2
X$28866 123 77 109 291 BUF_X2
* cell instance $28867 m0 *1 169.29,4.2
X$28867 77 157 18637 158 104 102 109 DFFR_X1
* cell instance $28868 m0 *1 165.49,4.2
X$28868 77 157 18509 121 160 102 109 DFFR_X1
* cell instance $28869 m0 *1 173.09,4.2
X$28869 158 77 109 181 BUF_X2
* cell instance $28871 m0 *1 174.04,4.2
X$28871 77 157 18508 155 269 102 109 DFFR_X1
* cell instance $28872 m0 *1 177.84,4.2
X$28872 155 77 109 118 CLKBUF_X2
* cell instance $28874 m0 *1 185.44,4.2
X$28874 153 77 109 187 BUF_X2
* cell instance $28877 m0 *1 189.43,4.2
X$28877 189 184 106 77 151 109 AOI21_X1
* cell instance $28879 m0 *1 190.38,4.2
X$28879 77 152 18698 107 151 102 109 DFFR_X1
* cell instance $28882 m0 *1 203.11,4.2
X$28882 111 77 109 237 BUF_X2
* cell instance $28884 m0 *1 204.63,4.2
X$28884 195 147 241 77 150 109 AOI21_X1
* cell instance $28885 m0 *1 205.39,4.2
X$28885 77 149 18638 148 150 102 109 DFFR_X1
* cell instance $28886 m0 *1 209.19,4.2
X$28886 148 77 109 245 BUF_X2
* cell instance $28892 r0 *1 165.68,4.2
X$28892 77 157 18845 350 294 102 109 DFFR_X1
* cell instance $28895 r0 *1 170.43,4.2
X$28895 182 348 77 109 270 NAND2_X1
* cell instance $28901 r0 *1 174.42,4.2
X$28901 271 77 109 266 BUF_X2
* cell instance $28903 r0 *1 175.94,4.2
X$28903 228 182 227 109 263 77 OAI21_X1
* cell instance $28904 r0 *1 176.7,4.2
X$28904 230 267 223 77 264 109 AOI21_X1
* cell instance $28905 r0 *1 177.46,4.2
X$28905 232 263 223 77 261 109 AOI21_X1
* cell instance $28909 r0 *1 184.49,4.2
X$28909 185 184 257 77 200 109 AOI21_X1
* cell instance $28910 r0 *1 185.25,4.2
X$28910 187 233 186 77 185 109 AOI21_X1
* cell instance $28911 r0 *1 186.01,4.2
X$28911 256 77 109 257 INV_X1
* cell instance $28915 r0 *1 188.48,4.2
X$28915 105 255 186 77 188 109 AOI21_X1
* cell instance $28916 r0 *1 189.24,4.2
X$28916 190 253 186 77 189 109 AOI21_X1
* cell instance $28922 r0 *1 194.37,4.2
X$28922 198 147 249 77 199 109 AOI21_X1
* cell instance $28923 r0 *1 195.13,4.2
X$28923 192 191 186 77 198 109 AOI21_X1
* cell instance $28928 r0 *1 200.45,4.2
X$28928 237 239 240 77 197 109 AOI21_X1
* cell instance $28931 r0 *1 202.16,4.2
X$28931 77 149 18790 243 309 102 109 DFFR_X1
* cell instance $28932 r0 *1 205.96,4.2
X$28932 245 194 240 77 195 109 AOI21_X1
* cell instance $28941 m0 *1 230.28,4.2
X$28941 77 110 102 109 BUF_X32
* cell instance $29012 m0 *1 140.03,225.4
X$29012 77 17928 17866 17846 17765 17766 109 FA_X1
* cell instance $29014 m0 *1 144.02,225.4
X$29014 17281 17897 77 109 17699 NAND2_X1
* cell instance $29015 m0 *1 144.59,225.4
X$29015 16823 17630 77 109 17952 NAND2_X1
* cell instance $29019 r0 *1 141.93,225.4
X$29019 77 17952 17928 17954 17699 17985 109 FA_X1
* cell instance $29020 r0 *1 144.97,225.4
X$29020 77 17954 17951 17893 17929 17877 109 FA_X1
* cell instance $29021 m0 *1 145.73,225.4
X$29021 77 17893 17847 17592 18026 17986 109 FA_X1
* cell instance $29027 m0 *1 149.91,225.4
X$29027 17875 77 109 17765 INV_X2
* cell instance $29029 m0 *1 150.86,225.4
X$29029 17930 77 109 17874 INV_X1
* cell instance $29030 m0 *1 151.43,225.4
X$29030 17281 16854 77 109 17930 NAND2_X1
* cell instance $29034 r0 *1 151.24,225.4
X$29034 77 17960 17967 17932 17848 17930 109 FA_X1
* cell instance $29035 m0 *1 153.33,225.4
X$29035 77 17925 17703 17895 17932 17894 109 FA_X1
* cell instance $29037 m0 *1 156.37,225.4
X$29037 77 17896 17925 18102 17926 17934 109 FA_X1
* cell instance $29040 r0 *1 155.04,225.4
X$29040 15541 77 109 17897 INV_X2
* cell instance $29041 r0 *1 155.61,225.4
X$29041 16781 17933 77 109 17960 NAND2_X1
* cell instance $29042 r0 *1 156.18,225.4
X$29042 16823 17933 77 109 18030 NAND2_X1
* cell instance $29045 r0 *1 157.89,225.4
X$29045 17118 17897 77 109 17934 NAND2_X1
* cell instance $29048 r0 *1 159.03,225.4
X$29048 77 17963 18032 18103 17965 17935 109 FA_X1
* cell instance $29049 m0 *1 159.98,225.4
X$29049 17630 16891 77 109 17935 NAND2_X1
* cell instance $29051 m0 *1 160.55,225.4
X$29051 15385 17897 77 109 17963 NAND2_X1
* cell instance $29054 m0 *1 162.07,225.4
X$29054 15444 77 109 17118 CLKBUF_X3
* cell instance $29057 m0 *1 163.97,225.4
X$29057 77 18006 17836 17640 18105 17885 109 FA_X1
* cell instance $29059 m0 *1 168.53,225.4
X$29059 77 17899 17639 17641 18007 17900 109 FA_X1
* cell instance $29062 m0 *1 172.52,225.4
X$29062 15813 77 109 17603 INV_X2
* cell instance $29063 m0 *1 173.09,225.4
X$29063 77 17902 17741 17644 17927 17901 109 FA_X1
* cell instance $29065 m0 *1 177.65,225.4
X$29065 77 18053 17643 17598 17938 17904 109 FA_X1
* cell instance $29066 m0 *1 180.69,225.4
X$29066 15812 77 109 17604 INV_X2
* cell instance $29073 r0 *1 162.64,225.4
X$29073 16781 17969 77 109 17968 NAND2_X1
* cell instance $29076 r0 *1 166.63,225.4
X$29076 15541 77 109 17971 CLKBUF_X3
* cell instance $29077 r0 *1 167.58,225.4
X$29077 15541 15836 77 109 17999 NOR2_X1
* cell instance $29081 r0 *1 170.81,225.4
X$29081 15813 17787 77 109 17965 NAND2_X1
* cell instance $29086 r0 *1 171.57,225.4
X$29086 77 18212 17900 17901 18108 17964 109 FA_X1
* cell instance $29088 r0 *1 174.99,225.4
X$29088 15813 77 109 16983 CLKBUF_X3
* cell instance $29091 r0 *1 176.51,225.4
X$29091 15813 17969 77 109 18050 NAND2_X1
* cell instance $29092 r0 *1 177.08,225.4
X$29092 16891 17970 77 109 17998 NAND2_X1
* cell instance $29096 r0 *1 179.74,225.4
X$29096 15812 77 109 16891 CLKBUF_X3
* cell instance $29098 r0 *1 182.21,225.4
X$29098 15812 18035 77 109 17974 NAND2_X1
* cell instance $29100 r0 *1 183.16,225.4
X$29100 17702 16051 77 109 18056 NAND2_X1
* cell instance $29102 r0 *1 184.11,225.4
X$29102 77 18064 17962 17961 18133 17939 109 FA_X1
* cell instance $29103 r0 *1 187.15,225.4
X$29103 17787 16287 77 109 17992 NAND2_X1
* cell instance $29105 r0 *1 187.91,225.4
X$29105 17630 16225 77 109 17975 NAND2_X1
* cell instance $29108 r0 *1 189.43,225.4
X$29108 15239 77 109 16479 INV_X1
* cell instance $29109 r0 *1 189.81,225.4
X$29109 77 18052 17409 17536 17854 17940 109 FA_X1
* cell instance $29110 m0 *1 191.71,225.4
X$29110 77 17922 17575 17920 17717 17921 109 FA_X1
* cell instance $29113 r0 *1 192.85,225.4
X$29113 15239 109 15690 77 BUF_X4
* cell instance $29115 m0 *1 195.32,225.4
X$29115 77 17959 17573 17801 18048 17920 109 FA_X1
* cell instance $29120 m0 *1 200.83,225.4
X$29120 17905 77 109 17957 INV_X1
* cell instance $29124 r0 *1 197.41,225.4
X$29124 17941 77 109 17959 INV_X1
* cell instance $29127 r0 *1 198.93,225.4
X$29127 17958 77 109 17803 INV_X1
* cell instance $29128 r0 *1 199.31,225.4
X$29128 17976 77 109 17942 INV_X1
* cell instance $29130 r0 *1 199.88,225.4
X$29130 77 17987 17958 17906 17957 17956 109 FA_X1
* cell instance $29133 m0 *1 203.11,225.4
X$29133 17906 77 109 17918 INV_X1
* cell instance $29134 m0 *1 205.01,225.4
X$29134 77 17917 17855 17864 17918 17945 109 FA_X1
* cell instance $29135 m0 *1 208.05,225.4
X$29135 17868 77 109 17946 INV_X2
* cell instance $29137 m0 *1 210.14,225.4
X$29137 17916 77 109 17857 INV_X1
* cell instance $29138 m0 *1 210.52,225.4
X$29138 77 17915 17916 17858 17865 17914 109 FA_X1
* cell instance $29139 m0 *1 213.56,225.4
X$29139 17907 77 109 17810 INV_X1
* cell instance $29140 m0 *1 213.94,225.4
X$29140 17913 77 109 17859 INV_X2
* cell instance $29147 m0 *1 236.74,225.4
X$29147 17908 77 109 17860 BUF_X1
* cell instance $29149 m0 *1 237.5,225.4
X$29149 17909 77 109 17910 BUF_X1
* cell instance $29151 r0 *1 203.11,225.4
X$29151 17944 17943 17953 109 77 17956 HA_X1
* cell instance $29153 r0 *1 206.53,225.4
X$29153 17955 77 109 17945 INV_X1
* cell instance $29154 r0 *1 206.91,225.4
X$29154 77 17947 17955 17913 17953 17946 109 FA_X1
* cell instance $29157 r0 *1 211.66,225.4
X$29157 18018 77 109 17552 INV_X1
* cell instance $29160 r0 *1 213.75,225.4
X$29160 17978 77 109 17756 INV_X1
* cell instance $29161 r0 *1 214.13,225.4
X$29161 17858 77 109 18017 INV_X1
* cell instance $29164 r0 *1 215.46,225.4
X$29164 17983 17982 17367 109 77 17950 HA_X1
* cell instance $29174 r0 *1 236.93,225.4
X$29174 17908 77 109 LOGIC0_X1
* cell instance $29175 r0 *1 237.31,225.4
X$29175 17909 77 109 LOGIC0_X1
* cell instance $29178 r0 *1 238.26,225.4
X$29178 17979 77 109 17949 BUF_X1
* cell instance $29179 m0 *1 238.83,225.4
X$29179 17911 77 109 17912 BUF_X1
* cell instance $29180 m0 *1 238.45,225.4
X$29180 17911 77 109 LOGIC0_X1
* cell instance $29183 r0 *1 238.83,225.4
X$29183 17948 77 109 17981 BUF_X1
* cell instance $29213 m0 *1 145.92,231
X$29213 77 18125 17929 18076 18124 18077 109 FA_X1
* cell instance $29214 m0 *1 148.96,231
X$29214 17280 17117 77 109 18077 NAND2_X1
* cell instance $29255 r0 *1 147.82,231
X$29255 17348 17604 77 109 18124 NAND2_X1
* cell instance $29258 r0 *1 149.53,231
X$29258 18066 16983 77 109 18125 NAND2_X1
* cell instance $29260 m0 *1 149.91,231
X$29260 77 18079 17631 17705 18078 18099 109 FA_X1
* cell instance $29261 r0 *1 150.1,231
X$29261 16312 15836 77 109 18150 NAND2_X1
* cell instance $29265 r0 *1 152,231
X$29265 77 18100 18099 18080 18153 18155 109 FA_X1
* cell instance $29266 m0 *1 153.52,231
X$29266 77 18101 17931 17746 17895 18080 109 FA_X1
* cell instance $29270 m0 *1 157.51,231
X$29270 77 18127 17881 17936 18083 17994 109 FA_X1
* cell instance $29273 m0 *1 161.5,231
X$29273 77 18004 17996 18129 18088 18194 109 FA_X1
* cell instance $29276 r0 *1 156.56,231
X$29276 77 18224 18101 18127 18102 18157 109 FA_X1
* cell instance $29278 r0 *1 159.98,231
X$29278 77 18104 18083 18128 18156 18103 109 FA_X1
* cell instance $29279 r0 *1 163.02,231
X$29279 77 18129 17849 18006 18128 18209 109 FA_X1
* cell instance $29280 m0 *1 165.11,231
X$29280 77 18130 17898 18164 18089 18090 109 FA_X1
* cell instance $29282 m0 *1 168.15,231
X$29282 18106 77 109 18089 INV_X1
* cell instance $29287 r0 *1 166.44,231
X$29287 17879 17604 77 109 18161 NOR2_X1
* cell instance $29289 r0 *1 167.39,231
X$29289 17633 15836 77 109 18134 NOR2_X1
* cell instance $29293 r0 *1 169.29,231
X$29293 17633 15010 77 109 18136 NOR2_X1
* cell instance $29294 r0 *1 169.86,231
X$29294 17604 17971 77 109 18166 NOR2_X1
* cell instance $29295 r0 *1 170.43,231
X$29295 77 17999 18107 18138 18165 18137 109 FA_X1
* cell instance $29299 m0 *1 171.38,231
X$29299 17879 15010 77 109 18165 NOR2_X1
* cell instance $29304 m0 *1 173.09,231
X$29304 17117 17969 77 109 18044 NAND2_X1
* cell instance $29307 m0 *1 174.04,231
X$29307 77 18060 17937 18062 18093 18061 109 FA_X1
* cell instance $29309 m0 *1 178.03,231
X$29309 16854 109 17970 77 BUF_X4
* cell instance $29311 m0 *1 180.12,231
X$29311 77 18110 17938 18096 18097 18063 109 FA_X1
* cell instance $29312 m0 *1 183.16,231
X$29312 77 18112 18097 18064 18175 18095 109 FA_X1
* cell instance $29313 m0 *1 186.2,231
X$29313 77 18091 18095 18065 18094 18092 109 FA_X1
* cell instance $29314 m0 *1 189.24,231
X$29314 16312 16124 77 109 18091 NAND2_X1
* cell instance $29315 m0 *1 189.81,231
X$29315 18066 16225 77 109 18131 NAND2_X1
* cell instance $29316 m0 *1 190.38,231
X$29316 77 18114 18113 18115 18131 18067 109 FA_X1
* cell instance $29318 m0 *1 193.61,231
X$29318 18086 18087 18084 109 77 18116 HA_X1
* cell instance $29323 r0 *1 175.56,231
X$29323 18170 77 109 18061 INV_X1
* cell instance $29326 r0 *1 177.84,231
X$29326 17971 15010 77 109 18169 NOR2_X1
* cell instance $29327 r0 *1 178.41,231
X$29327 17633 15823 77 109 18198 NOR2_X1
* cell instance $29329 r0 *1 179.17,231
X$29329 77 18174 18132 18110 18214 18140 109 FA_X1
* cell instance $29332 r0 *1 183.16,231
X$29332 15839 16126 77 109 18111 NAND2_X1
* cell instance $29333 r0 *1 183.73,231
X$29333 17412 16228 77 109 18201 NAND2_X1
* cell instance $29338 r0 *1 187.15,231
X$29338 17412 16260 77 109 18092 NAND2_X1
* cell instance $29340 r0 *1 187.91,231
X$29340 77 18065 18133 18202 18113 18167 109 FA_X1
* cell instance $29343 r0 *1 191.9,231
X$29343 15839 16287 77 109 18114 NAND2_X1
* cell instance $29346 r0 *1 193.04,231
X$29346 18115 77 109 18160 INV_X1
* cell instance $29347 r0 *1 193.42,231
X$29347 77 18116 18141 18159 18179 18160 109 FA_X1
* cell instance $29348 r0 *1 196.46,231
X$29348 77 18117 18010 18085 18126 18159 109 FA_X1
* cell instance $29349 m0 *1 197.6,231
X$29349 18085 77 109 18048 INV_X1
* cell instance $29352 m0 *1 198.74,231
X$29352 18084 18068 18082 109 77 18126 HA_X1
* cell instance $29353 m0 *1 200.64,231
X$29353 77 18118 17919 18069 18081 18152 109 FA_X1
* cell instance $29356 r0 *1 200.26,231
X$29356 15346 15931 77 109 18192 NAND2_X1
* cell instance $29357 r0 *1 200.83,231
X$29357 17970 16119 77 109 18154 NAND2_X1
* cell instance $29358 r0 *1 201.4,231
X$29358 17702 16126 77 109 18189 NAND2_X1
* cell instance $29362 m0 *1 204.06,231
X$29362 17879 15690 77 109 18149 NOR2_X1
* cell instance $29365 r0 *1 204.82,231
X$29365 18148 18149 18121 109 77 18142 HA_X1
* cell instance $29367 m0 *1 205.01,231
X$29367 17971 16124 77 109 18148 NOR2_X1
* cell instance $29369 m0 *1 205.96,231
X$29369 15346 16228 77 109 18123 NAND2_X1
* cell instance $29370 m0 *1 206.72,231
X$29370 17933 16225 77 109 18075 NAND2_X1
* cell instance $29371 m0 *1 207.29,231
X$29371 16854 16260 77 109 18074 NAND2_X1
* cell instance $29372 m0 *1 207.86,231
X$29372 17933 16287 77 109 18185 NAND2_X1
* cell instance $29373 m0 *1 208.43,231
X$29373 77 18123 18119 18073 18074 18075 109 FA_X1
* cell instance $29375 m0 *1 211.66,231
X$29375 18073 77 109 18072 INV_X1
* cell instance $29377 m0 *1 212.8,231
X$29377 18121 18122 17861 109 77 18071 HA_X1
* cell instance $29385 r0 *1 207.29,231
X$29385 15346 16126 77 109 18143 NAND2_X1
* cell instance $29388 r0 *1 209,231
X$29388 18119 77 109 18146 INV_X1
* cell instance $29390 r0 *1 210.9,231
X$29390 18144 18146 18122 109 77 18120 HA_X1
* cell instance $29416 m0 *1 13.3,65.8
X$29416 77 4389 4195 4392 4391 2157 109 DFFR_X1
* cell instance $29420 r0 *1 15.01,65.8
X$29420 77 4389 4626 4699 4493 2157 109 DFFR_X1
* cell instance $29421 m0 *1 17.67,65.8
X$29421 4195 4309 4308 77 109 4569 MUX2_X1
* cell instance $29423 m0 *1 19,65.8
X$29423 4196 4309 4197 77 109 4494 MUX2_X1
* cell instance $29424 m0 *1 20.33,65.8
X$29424 4125 4309 4199 77 109 4629 MUX2_X1
* cell instance $29425 m0 *1 21.66,65.8
X$29425 4125 3607 4199 77 109 4395 MUX2_X1
* cell instance $29426 m0 *1 22.99,65.8
X$29426 4310 4284 4311 77 109 4396 MUX2_X1
* cell instance $29430 r0 *1 19.19,65.8
X$29430 4494 4627 4569 77 109 4628 MUX2_X1
* cell instance $29433 r0 *1 22.8,65.8
X$29433 4495 3600 4395 77 109 4311 MUX2_X1
* cell instance $29435 m0 *1 25.65,65.8
X$29435 3968 77 109 19205 CLKBUF_X1
* cell instance $29437 m0 *1 26.22,65.8
X$29437 4396 3483 4210 109 77 4572 MUX2_X2
* cell instance $29438 m0 *1 27.93,65.8
X$29438 77 3968 4312 4399 4397 2157 109 DFFR_X1
* cell instance $29440 m0 *1 31.92,65.8
X$29440 4312 3042 4313 77 109 4401 MUX2_X1
* cell instance $29441 m0 *1 33.25,65.8
X$29441 4314 3600 4401 77 109 4315 MUX2_X1
* cell instance $29442 m0 *1 34.58,65.8
X$29442 4312 4205 4313 77 109 4402 MUX2_X1
* cell instance $29443 m0 *1 35.91,65.8
X$29443 3887 77 109 2539 BUF_X2
* cell instance $29445 m0 *1 36.86,65.8
X$29445 3445 77 109 2541 CLKBUF_X3
* cell instance $29446 m0 *1 37.81,65.8
X$29446 77 3894 4203 4135 4405 2157 109 DFFR_X1
* cell instance $29447 m0 *1 41.61,65.8
X$29447 77 4287 109 4497 BUF_X8
* cell instance $29452 r0 *1 29.26,65.8
X$29452 4399 4126 2539 77 109 4397 MUX2_X1
* cell instance $29455 r0 *1 32.49,65.8
X$29455 4856 3479 4712 77 109 4314 MUX2_X1
* cell instance $29456 r0 *1 33.82,65.8
X$29456 4713 4496 4402 77 109 4574 MUX2_X1
* cell instance $29457 r0 *1 35.15,65.8
X$29457 4201 4632 4574 77 109 4633 MUX2_X1
* cell instance $29458 r0 *1 36.48,65.8
X$29458 77 4497 2938 109 BUF_X16
* cell instance $29460 r0 *1 41.42,65.8
X$29460 77 4497 3042 109 BUF_X16
* cell instance $29461 m0 *1 45.79,65.8
X$29461 4411 4318 4319 109 77 4578 OAI21_X4
* cell instance $29462 m0 *1 44.46,65.8
X$29462 4316 3600 4862 77 109 4408 MUX2_X1
* cell instance $29463 m0 *1 48.26,65.8
X$29463 4719 3607 4634 77 109 4580 MUX2_X1
* cell instance $29464 m0 *1 49.59,65.8
X$29464 4582 3042 4069 77 109 4584 MUX2_X1
* cell instance $29465 m0 *1 50.92,65.8
X$29465 2543 77 109 3698 CLKBUF_X3
* cell instance $29466 m0 *1 51.87,65.8
X$29466 3698 77 109 19215 CLKBUF_X1
* cell instance $29469 r0 *1 46.17,65.8
X$29469 77 3894 4634 4579 4578 2157 109 DFFR_X1
* cell instance $29470 r0 *1 49.97,65.8
X$29470 4580 3541 4584 77 109 4206 MUX2_X1
* cell instance $29473 r0 *1 52.44,65.8
X$29473 4775 4205 4866 77 109 4585 MUX2_X1
* cell instance $29475 m0 *1 53.58,65.8
X$29475 4418 4496 4417 77 109 4499 MUX2_X1
* cell instance $29476 m0 *1 57.95,65.8
X$29476 77 4504 4071 4503 4501 2157 109 DFFR_X1
* cell instance $29480 r0 *1 53.77,65.8
X$29480 4777 4322 4498 77 109 4586 MUX2_X1
* cell instance $29481 r0 *1 55.1,65.8
X$29481 4585 4496 4500 77 109 4636 MUX2_X1
* cell instance $29482 r0 *1 56.43,65.8
X$29482 4321 4284 4586 77 109 4587 MUX2_X1
* cell instance $29483 r0 *1 57.76,65.8
X$29483 4587 4420 4210 109 77 4588 MUX2_X2
* cell instance $29487 r0 *1 59.47,65.8
X$29487 3799 4502 77 109 4637 NAND2_X1
* cell instance $29490 r0 *1 60.99,65.8
X$29490 4505 4503 77 109 4638 NAND2_X1
* cell instance $29492 r0 *1 61.75,65.8
X$29492 77 4504 3986 4592 4725 1663 109 DFFR_X1
* cell instance $29494 m0 *1 64.41,65.8
X$29494 4505 4592 77 109 4727 NAND2_X1
* cell instance $29496 m0 *1 67.26,65.8
X$29496 4423 4284 4323 77 109 4507 MUX2_X1
* cell instance $29497 m0 *1 68.59,65.8
X$29497 4595 4322 4594 77 109 4423 MUX2_X1
* cell instance $29501 r0 *1 65.93,65.8
X$29501 77 4504 4508 4728 4506 1663 109 DFFR_X1
* cell instance $29503 r0 *1 70.11,65.8
X$29503 4508 4287 4325 77 109 4595 MUX2_X1
* cell instance $29505 m0 *1 71.06,65.8
X$29505 4211 4287 4510 77 109 4594 MUX2_X1
* cell instance $29506 m0 *1 75.43,65.8
X$29506 3906 109 4496 77 BUF_X4
* cell instance $29507 m0 *1 76.76,65.8
X$29507 77 4324 4434 4427 4326 1663 109 DFFR_X1
* cell instance $29509 m0 *1 80.75,65.8
X$29509 2543 77 109 3908 CLKBUF_X3
* cell instance $29510 m0 *1 81.7,65.8
X$29510 3908 77 109 19145 INV_X1
* cell instance $29512 r0 *1 71.44,65.8
X$29512 3799 4732 77 109 4730 NAND2_X1
* cell instance $29513 r0 *1 72.01,65.8
X$29513 4508 4509 4211 77 109 4733 MUX2_X1
* cell instance $29514 r0 *1 73.34,65.8
X$29514 4325 4509 4510 77 109 4644 MUX2_X1
* cell instance $29518 r0 *1 76,65.8
X$29518 77 3906 109 4509 BUF_X8
* cell instance $29519 r0 *1 78.47,65.8
X$29519 3903 4327 4647 109 4645 77 OAI21_X1
* cell instance $29520 r0 *1 79.23,65.8
X$29520 4072 4646 77 109 4647 NAND2_X1
* cell instance $29522 m0 *1 82.65,65.8
X$29522 4650 77 109 2417 CLKBUF_X3
* cell instance $29552 m0 *1 136.04,219.8
X$29552 17743 77 109 17695 INV_X1
* cell instance $29592 r0 *1 132.81,219.8
X$29592 17763 77 109 17742 INV_X1
* cell instance $29594 r0 *1 133.38,219.8
X$29594 77 17764 17763 17516 17765 17766 109 FA_X1
* cell instance $29595 r0 *1 136.42,219.8
X$29595 77 17767 17743 17697 17765 17766 109 FA_X1
* cell instance $29596 m0 *1 136.99,219.8
X$29596 17670 77 109 17764 INV_X1
* cell instance $29600 m0 *1 138.32,219.8
X$29600 77 17698 17696 17671 17697 17565 109 FA_X1
* cell instance $29605 r0 *1 141.74,219.8
X$29605 17768 77 109 17061 INV_X1
* cell instance $29608 m0 *1 142.5,219.8
X$29608 77 17745 17767 17700 17699 17731 109 FA_X1
* cell instance $29609 m0 *1 145.73,219.8
X$29609 16781 17630 77 109 17731 NAND2_X1
* cell instance $29613 r0 *1 144.21,219.8
X$29613 16211 17787 77 109 17745 NAND2_X1
* cell instance $29614 r0 *1 144.78,219.8
X$29614 77 17700 17698 17821 17770 17591 109 FA_X1
* cell instance $29615 m0 *1 149.72,219.8
X$29615 17736 77 109 17418 INV_X1
* cell instance $29616 m0 *1 146.68,219.8
X$29616 77 17701 17734 17632 17966 17704 109 FA_X1
* cell instance $29617 m0 *1 150.1,219.8
X$29617 16212 109 17702 77 BUF_X4
* cell instance $29619 m0 *1 151.62,219.8
X$29619 77 17703 17736 17738 17701 17704 109 FA_X1
* cell instance $29621 m0 *1 154.85,219.8
X$29621 17635 77 109 17704 INV_X4
* cell instance $29627 r0 *1 149.53,219.8
X$29627 11838 15484 9805 77 109 17280 MUX2_X1
* cell instance $29628 r0 *1 150.86,219.8
X$29628 17412 17117 77 109 17827 NAND2_X1
* cell instance $29630 r0 *1 152.95,219.8
X$29630 15543 77 109 17787 INV_X2
* cell instance $29634 r0 *1 155.99,219.8
X$29634 77 17832 17773 17747 17746 17881 109 FA_X1
* cell instance $29635 m0 *1 159.41,219.8
X$29635 17281 15445 77 109 17707 NAND2_X2
* cell instance $29636 m0 *1 158.46,219.8
X$29636 15385 77 109 17117 CLKBUF_X3
* cell instance $29637 m0 *1 160.36,219.8
X$29637 17707 77 109 17708 INV_X1
* cell instance $29638 m0 *1 160.74,219.8
X$29638 17281 16592 77 109 17774 NAND2_X1
* cell instance $29640 r0 *1 159.03,219.8
X$29640 17789 77 109 17449 INV_X1
* cell instance $29644 r0 *1 161.5,219.8
X$29644 77 17776 17833 17850 17775 17777 109 FA_X1
* cell instance $29645 m0 *1 161.88,219.8
X$29645 17637 77 109 17776 INV_X1
* cell instance $29648 m0 *1 163.02,219.8
X$29648 77 17774 17775 17710 17739 17707 109 FA_X1
* cell instance $29651 m0 *1 167.01,219.8
X$29651 16781 17711 77 109 17739 NAND2_X1
* cell instance $29653 m0 *1 169.1,219.8
X$29653 16781 16592 77 109 17780 NAND2_X1
* cell instance $29655 r0 *1 164.54,219.8
X$29655 17454 77 109 17777 INV_X1
* cell instance $29659 r0 *1 166.25,219.8
X$29659 17710 77 109 17791 INV_X1
* cell instance $29662 r0 *1 167.2,219.8
X$29662 17778 77 109 17838 INV_X1
* cell instance $29664 r0 *1 167.96,219.8
X$29664 77 17707 17778 17844 17780 17779 109 FA_X1
* cell instance $29666 m0 *1 170.05,219.8
X$29666 16823 17711 77 109 17779 NAND2_X1
* cell instance $29668 m0 *1 173.85,219.8
X$29668 16781 15445 77 109 17781 NAND2_X1
* cell instance $29669 m0 *1 174.42,219.8
X$29669 17118 17711 77 109 17748 NAND2_X1
* cell instance $29672 m0 *1 177.27,219.8
X$29672 16889 109 17711 77 BUF_X4
* cell instance $29673 m0 *1 178.6,219.8
X$29673 17117 17711 77 109 17783 NAND2_X1
* cell instance $29676 m0 *1 181.45,219.8
X$29676 16983 17711 77 109 17740 NAND2_X1
* cell instance $29684 r0 *1 172.71,219.8
X$29684 77 17748 17842 17793 17781 17749 109 FA_X1
* cell instance $29686 r0 *1 175.94,219.8
X$29686 16823 17714 77 109 17749 NAND2_X1
* cell instance $29689 r0 *1 177.08,219.8
X$29689 77 17785 17845 17794 17783 17784 109 FA_X1
* cell instance $29690 r0 *1 180.12,219.8
X$29690 17118 17714 77 109 17785 NAND2_X1
* cell instance $29691 r0 *1 180.69,219.8
X$29691 16823 17599 77 109 17784 NAND2_X1
* cell instance $29693 m0 *1 183.35,219.8
X$29693 77 17694 17786 17715 17648 17627 109 FA_X1
* cell instance $29696 m0 *1 187.15,219.8
X$29696 17016 109 17714 77 BUF_X4
* cell instance $29701 r0 *1 185.63,219.8
X$29701 77 17650 17840 17750 17782 17600 109 FA_X1
* cell instance $29702 r0 *1 188.67,219.8
X$29702 77 17751 17782 17753 17797 17835 109 FA_X1
* cell instance $29704 m0 *1 188.86,219.8
X$29704 16891 17714 77 109 17751 NAND2_X1
* cell instance $29705 m0 *1 189.62,219.8
X$29705 77 17716 17752 17717 17737 17753 109 FA_X1
* cell instance $29710 r0 *1 191.9,219.8
X$29710 15445 109 17599 77 BUF_X4
* cell instance $29711 r0 *1 193.23,219.8
X$29711 16891 17599 77 109 17834 NAND2_X2
* cell instance $29712 r0 *1 194.18,219.8
X$29712 16549 17719 77 109 17798 NAND2_X1
* cell instance $29713 r0 *1 194.75,219.8
X$29713 16051 17689 77 109 17799 NAND2_X1
* cell instance $29715 r0 *1 196.08,219.8
X$29715 16549 17557 77 17829 109 NAND2_X4
* cell instance $29716 m0 *1 197.03,219.8
X$29716 17676 77 109 17772 INV_X1
* cell instance $29719 m0 *1 197.98,219.8
X$29719 16051 17599 77 109 17771 NAND2_X1
* cell instance $29722 r0 *1 197.79,219.8
X$29722 16051 17719 77 109 17830 NAND2_X2
* cell instance $29723 r0 *1 198.74,219.8
X$29723 16543 17689 77 109 17802 NAND2_X1
* cell instance $29724 m0 *1 199.12,219.8
X$29724 15931 17689 77 109 17735 NAND2_X1
* cell instance $29729 r0 *1 199.69,219.8
X$29729 77 17735 17826 17815 17771 17769 109 FA_X1
* cell instance $29730 m0 *1 201.78,219.8
X$29730 16543 17719 77 109 17769 NAND2_X1
* cell instance $29733 m0 *1 202.54,219.8
X$29733 77 17855 17222 17730 17733 17732 109 FA_X1
* cell instance $29734 m0 *1 205.58,219.8
X$29734 15931 17719 77 109 17760 NAND2_X1
* cell instance $29736 m0 *1 206.34,219.8
X$29736 17365 16119 77 109 17761 NAND2_X1
* cell instance $29737 m0 *1 206.91,219.8
X$29737 16119 17719 77 109 17729 NAND2_X2
* cell instance $29739 r0 *1 202.73,219.8
X$29739 17820 77 109 17732 INV_X1
* cell instance $29740 r0 *1 203.11,219.8
X$29740 17675 77 109 17813 INV_X1
* cell instance $29743 r0 *1 204.06,219.8
X$29743 16543 17557 77 109 17762 NAND2_X1
* cell instance $29746 r0 *1 205.58,219.8
X$29746 77 17760 17814 17759 17762 17761 109 FA_X1
* cell instance $29747 m0 *1 208.81,219.8
X$29747 77 17666 17915 17757 17759 17728 109 FA_X1
* cell instance $29748 m0 *1 208.24,219.8
X$29748 17730 77 109 17665 INV_X2
* cell instance $29751 m0 *1 212.8,219.8
X$29751 17758 77 109 17720 INV_X1
* cell instance $29757 r0 *1 212.8,219.8
X$29757 77 17727 17758 17809 17757 17756 109 FA_X1
* cell instance $29758 m0 *1 215.27,219.8
X$29758 77 17754 17725 17722 17726 17723 109 FA_X1
* cell instance $29766 r0 *1 216.22,219.8
X$29766 17755 77 109 17721 INV_X2
* cell instance $29769 r0 *1 217.36,219.8
X$29769 17807 77 109 17658 INV_X1
* cell instance $29770 r0 *1 217.74,219.8
X$29770 17809 77 109 17808 INV_X1
* cell instance $29843 m0 *1 140.22,228.2
X$29843 77 17766 17867 17986 17765 18024 109 FA_X1
* cell instance $29847 r0 *1 142.69,228.2
X$29847 77 18000 18024 18027 18025 18001 109 FA_X1
* cell instance $29848 m0 *1 143.83,228.2
X$29848 15844 109 18066 77 BUF_X4
* cell instance $29850 m0 *1 145.16,228.2
X$29850 15715 17787 77 109 18000 NAND2_X1
* cell instance $29851 m0 *1 145.73,228.2
X$29851 16781 17787 77 109 17985 NAND2_X1
* cell instance $29852 m0 *1 146.3,228.2
X$29852 17118 17630 77 109 18025 NAND2_X1
* cell instance $29854 r0 *1 145.73,228.2
X$29854 16781 17897 77 109 18001 NAND2_X1
* cell instance $29856 r0 *1 147.06,228.2
X$29856 77 18059 18026 18079 18076 18027 109 FA_X1
* cell instance $29857 m0 *1 147.44,228.2
X$29857 15715 77 109 16823 CLKBUF_X3
* cell instance $29859 m0 *1 148.39,228.2
X$29859 77 18002 17966 18078 17765 17967 109 FA_X1
* cell instance $29860 m0 *1 151.43,228.2
X$29860 15444 17787 77 109 18028 NAND2_X1
* cell instance $29864 r0 *1 151.05,228.2
X$29864 77 18029 18002 18100 18028 18003 109 FA_X1
* cell instance $29865 m0 *1 152.95,228.2
X$29865 16823 17897 77 109 18029 NAND2_X1
* cell instance $29866 m0 *1 152.38,228.2
X$29866 17117 17630 77 109 18003 NAND2_X1
* cell instance $29870 m0 *1 157.7,228.2
X$29870 77 18033 17788 17994 18032 17995 109 FA_X1
* cell instance $29871 m0 *1 154.66,228.2
X$29871 77 18030 17894 17995 17848 18031 109 FA_X1
* cell instance $29872 m0 *1 160.74,228.2
X$29872 77 18036 18033 18004 18034 17968 109 FA_X1
* cell instance $29873 m0 *1 163.78,228.2
X$29873 15715 17969 77 109 18037 NAND2_X1
* cell instance $29874 m0 *1 164.35,228.2
X$29874 17118 17970 77 109 18005 NAND2_X1
* cell instance $29878 r0 *1 158.65,228.2
X$29878 17702 77 109 17933 CLKBUF_X3
* cell instance $29880 r0 *1 160.36,228.2
X$29880 16781 17970 77 109 18031 NAND2_X1
* cell instance $29881 r0 *1 160.93,228.2
X$29881 17118 17933 77 109 18034 NAND2_X1
* cell instance $29884 r0 *1 162.07,228.2
X$29884 16823 17970 77 109 18036 NAND2_X1
* cell instance $29886 r0 *1 162.83,228.2
X$29886 77 18038 18088 18090 18037 18005 109 FA_X1
* cell instance $29887 r0 *1 165.87,228.2
X$29887 17117 17933 77 109 18038 NAND2_X1
* cell instance $29889 m0 *1 166.06,228.2
X$29889 15444 17969 77 109 18039 NAND2_X1
* cell instance $29890 m0 *1 166.82,228.2
X$29890 17603 17971 77 109 18162 NOR2_X1
* cell instance $29892 m0 *1 167.58,228.2
X$29892 17117 17970 77 109 18040 NAND2_X1
* cell instance $29895 r0 *1 166.82,228.2
X$29895 77 18041 18130 17972 18039 18040 109 FA_X1
* cell instance $29897 m0 *1 168.53,228.2
X$29897 16983 17933 77 109 18041 NAND2_X1
* cell instance $29898 m0 *1 169.29,228.2
X$29898 77 18008 17851 17964 18042 17972 109 FA_X1
* cell instance $29901 r0 *1 170.05,228.2
X$29901 18107 77 109 18042 INV_X1
* cell instance $29902 r0 *1 170.43,228.2
X$29902 15346 109 17969 77 BUF_X4
* cell instance $29906 r0 *1 171.76,228.2
X$29906 77 18047 18008 18060 18043 18044 109 FA_X1
* cell instance $29907 m0 *1 173.28,228.2
X$29907 16983 17970 77 109 18047 NAND2_X1
* cell instance $29908 m0 *1 172.71,228.2
X$29908 16891 17933 77 109 18043 NAND2_X1
* cell instance $29912 m0 *1 175.56,228.2
X$29912 77 18051 18093 17997 18050 17998 109 FA_X1
* cell instance $29913 m0 *1 174.99,228.2
X$29913 16549 17933 77 109 18051 NAND2_X1
* cell instance $29914 m0 *1 178.6,228.2
X$29914 77 17973 17903 18063 18173 17997 109 FA_X1
* cell instance $29915 m0 *1 181.64,228.2
X$29915 77 18056 17973 18057 17974 17993 109 FA_X1
* cell instance $29916 m0 *1 184.68,228.2
X$29916 16549 17970 77 109 17993 NAND2_X1
* cell instance $29918 m0 *1 186.01,228.2
X$29918 17897 16228 77 109 17991 NAND2_X1
* cell instance $29921 r0 *1 174.99,228.2
X$29921 77 18062 17902 18053 18109 18132 109 FA_X1
* cell instance $29923 r0 *1 184.11,228.2
X$29923 77 18177 17924 17939 18009 18057 109 FA_X1
* cell instance $29924 r0 *1 187.15,228.2
X$29924 15839 16228 77 109 18094 NAND2_X1
* cell instance $29926 m0 *1 187.72,228.2
X$29926 77 17992 18049 18058 17975 17991 109 FA_X1
* cell instance $29928 m0 *1 191.71,228.2
X$29928 18058 77 109 17989 INV_X1
* cell instance $29934 r0 *1 190.19,228.2
X$29934 16479 18066 109 77 18087 AND2_X1
* cell instance $29937 r0 *1 191.9,228.2
X$29937 16312 15690 77 109 18067 NAND2_X1
* cell instance $29940 m0 *1 193.23,228.2
X$29940 15839 77 109 18055 INV_X1
* cell instance $29941 m0 *1 194.18,228.2
X$29941 18055 15239 77 109 18054 NOR2_X1
* cell instance $29944 m0 *1 195.51,228.2
X$29944 17633 15239 77 109 18045 NOR2_X1
* cell instance $29945 m0 *1 196.08,228.2
X$29945 18054 17989 17943 109 77 17988 HA_X1
* cell instance $29946 m0 *1 197.98,228.2
X$29946 77 18082 17941 17987 17942 17988 109 FA_X1
* cell instance $29949 r0 *1 194.18,228.2
X$29949 18055 16124 77 109 18086 NOR2_X1
* cell instance $29953 r0 *1 196.08,228.2
X$29953 18010 77 109 18052 INV_X1
* cell instance $29954 r0 *1 196.46,228.2
X$29954 77 18011 17921 17976 18046 18049 109 FA_X1
* cell instance $29957 m0 *1 201.59,228.2
X$29957 77 18013 18012 18023 18045 17977 109 FA_X1
* cell instance $29960 m0 *1 206.15,228.2
X$29960 16225 77 109 16124 INV_X2
* cell instance $29961 m0 *1 206.72,228.2
X$29961 17971 15690 77 109 17982 NOR2_X1
* cell instance $29962 m0 *1 207.29,228.2
X$29962 18023 18070 18016 109 77 17947 HA_X1
* cell instance $29965 m0 *1 210.9,228.2
X$29965 18020 77 109 17984 INV_X1
* cell instance $29967 m0 *1 211.47,228.2
X$29967 18072 17984 17983 109 77 17978 HA_X1
* cell instance $29968 m0 *1 213.37,228.2
X$29968 77 18016 17907 18015 18017 18071 109 FA_X1
* cell instance $29970 m0 *1 217.17,228.2
X$29970 18015 77 109 17724 INV_X1
* cell instance $29976 r0 *1 201.78,228.2
X$29976 18012 77 109 18081 INV_X1
* cell instance $29978 r0 *1 202.54,228.2
X$29978 17971 16224 77 109 17977 NOR2_X1
* cell instance $29979 r0 *1 203.11,228.2
X$29979 17879 16124 77 109 18013 NOR2_X1
* cell instance $29980 r0 *1 203.68,228.2
X$29980 18069 77 109 17944 INV_X1
* cell instance $29981 r0 *1 204.06,228.2
X$29981 18035 16260 77 109 18022 NAND2_X1
* cell instance $29984 r0 *1 206.34,228.2
X$29984 17933 16479 77 109 18019 NAND2_X1
* cell instance $29986 r0 *1 207.29,228.2
X$29986 16854 16225 77 109 18021 NAND2_X1
* cell instance $29989 r0 *1 208.81,228.2
X$29989 77 18022 18020 18018 18021 18019 109 FA_X1
* cell instance $29991 r0 *1 212.04,228.2
X$29991 18120 77 109 17914 INV_X1
* cell instance $30000 m0 *1 237.88,228.2
X$30000 17979 77 109 LOGIC0_X1
* cell instance $30002 m0 *1 238.26,228.2
X$30002 18014 77 109 LOGIC0_X1
* cell instance $30003 m0 *1 238.64,228.2
X$30003 17948 77 109 LOGIC0_X1
* cell instance $30004 m0 *1 239.02,228.2
X$30004 18014 77 109 17980 BUF_X1
* cell instance $30027 r0 *1 10.07,63
X$30027 4390 4065 4193 77 109 4194 MUX2_X1
* cell instance $30028 r0 *1 11.4,63
X$30028 77 3596 4308 4390 4194 2157 109 DFFR_X1
* cell instance $30030 m0 *1 13.11,63
X$30030 77 3596 4197 3966 3885 2157 109 DFFR_X1
* cell instance $30031 r0 *1 15.2,63
X$30031 4392 3786 2779 77 109 4391 MUX2_X1
* cell instance $30033 m0 *1 21.09,63
X$30033 4061 4128 2779 77 109 4062 MUX2_X1
* cell instance $30034 m0 *1 17.29,63
X$30034 77 3596 4199 4061 4062 2157 109 DFFR_X1
* cell instance $30036 m0 *1 22.61,63
X$30036 4063 4126 2779 77 109 4124 MUX2_X1
* cell instance $30041 r0 *1 17.48,63
X$30041 4195 3479 4308 77 109 4276 MUX2_X1
* cell instance $30042 r0 *1 18.81,63
X$30042 4196 3970 4197 77 109 4198 MUX2_X1
* cell instance $30044 r0 *1 20.52,63
X$30044 4198 4393 4276 77 109 4310 MUX2_X1
* cell instance $30049 m0 *1 26.6,63
X$30049 4277 4065 3484 77 109 4129 MUX2_X1
* cell instance $30050 m0 *1 28.12,63
X$30050 77 3968 3889 4277 4129 2157 109 DFFR_X1
* cell instance $30051 m0 *1 31.92,63
X$30051 4130 3600 4132 77 109 4280 MUX2_X1
* cell instance $30052 m0 *1 33.25,63
X$30052 4131 3370 4064 77 109 4201 MUX2_X1
* cell instance $30055 r0 *1 26.79,63
X$30055 2541 77 109 3968 CLKBUF_X3
* cell instance $30057 r0 *1 28.12,63
X$30057 4279 4128 2539 77 109 4398 MUX2_X1
* cell instance $30058 r0 *1 29.45,63
X$30058 77 3968 4313 4279 4398 2157 109 DFFR_X1
* cell instance $30060 r0 *1 34.01,63
X$30060 4280 4284 4315 77 109 4400 MUX2_X1
* cell instance $30061 r0 *1 35.34,63
X$30061 4400 3606 4210 109 77 4404 MUX2_X2
* cell instance $30062 m0 *1 35.91,63
X$30062 4282 3786 2787 77 109 4133 MUX2_X1
* cell instance $30064 m0 *1 37.24,63
X$30064 77 3894 4202 4282 4133 2157 109 DFFR_X1
* cell instance $30067 m0 *1 41.99,63
X$30067 4202 3896 4203 77 109 4407 MUX2_X1
* cell instance $30071 r0 *1 37.62,63
X$30071 4202 3607 4203 77 109 3895 MUX2_X1
* cell instance $30072 r0 *1 38.95,63
X$30072 77 3607 109 4497 BUF_X8
* cell instance $30074 r0 *1 41.61,63
X$30074 4066 4284 4408 77 109 4575 MUX2_X1
* cell instance $30076 r0 *1 43.32,63
X$30076 4406 4320 4407 77 109 4412 MUX2_X1
* cell instance $30078 m0 *1 43.7,63
X$30078 3106 109 4138 77 BUF_X4
* cell instance $30080 m0 *1 45.6,63
X$30080 77 3698 4069 4140 4067 2157 109 DFFR_X1
* cell instance $30082 m0 *1 49.4,63
X$30082 4142 3799 2700 109 77 4067 OAI21_X4
* cell instance $30083 m0 *1 51.87,63
X$30083 3799 4140 77 109 4142 NAND2_X1
* cell instance $30087 r0 *1 47.12,63
X$30087 4204 4414 77 109 4317 NAND2_X1
* cell instance $30088 r0 *1 47.69,63
X$30088 4318 4579 77 109 4411 NAND2_X1
* cell instance $30089 r0 *1 48.26,63
X$30089 4205 109 3896 77 BUF_X4
* cell instance $30091 r0 *1 49.97,63
X$30091 4416 4284 4206 77 109 4286 MUX2_X1
* cell instance $30095 r0 *1 52.63,63
X$30095 3612 4205 2602 77 109 4418 MUX2_X1
* cell instance $30096 m0 *1 54.15,63
X$30096 3049 3970 2601 77 109 4208 MUX2_X1
* cell instance $30097 m0 *1 52.82,63
X$30097 3612 3970 2602 77 109 4207 MUX2_X1
* cell instance $30099 r0 *1 53.96,63
X$30099 3049 4205 2601 77 109 4417 MUX2_X1
* cell instance $30100 r0 *1 55.29,63
X$30100 4207 4393 4208 77 109 4321 MUX2_X1
* cell instance $30101 m0 *1 56.05,63
X$30101 4145 3600 4070 77 109 4209 MUX2_X1
* cell instance $30103 m0 *1 57.38,63
X$30103 4071 3970 4144 77 109 4145 MUX2_X1
* cell instance $30107 r0 *1 57.76,63
X$30107 4209 4284 3493 77 109 4420 MUX2_X1
* cell instance $30115 m0 *1 62.89,63
X$30115 4072 4150 77 109 4148 NAND2_X1
* cell instance $30116 m0 *1 59.09,63
X$30116 77 3618 4144 4150 4146 2157 109 DFFR_X1
* cell instance $30118 m0 *1 63.65,63
X$30118 3793 3903 4153 109 3984 77 OAI21_X1
* cell instance $30121 r0 *1 60.8,63
X$30121 4286 3616 4210 109 77 4421 MUX2_X2
* cell instance $30124 m0 *1 64.79,63
X$30124 4072 4151 77 109 4153 NAND2_X1
* cell instance $30127 m0 *1 65.74,63
X$30127 3987 4632 4073 77 109 4593 MUX2_X1
* cell instance $30208 m0 *1 137.94,222.6
X$30208 17817 77 109 16764 INV_X1
* cell instance $30211 m0 *1 138.51,222.6
X$30211 77 17866 17817 17818 17701 17704 109 FA_X1
* cell instance $30213 m0 *1 141.74,222.6
X$30213 77 17951 17744 17823 17846 17821 109 FA_X1
* cell instance $30214 m0 *1 144.78,222.6
X$30214 77 17823 17347 17570 17847 17824 109 FA_X1
* cell instance $30216 m0 *1 148.01,222.6
X$30216 77 17828 17770 17877 17825 17827 109 FA_X1
* cell instance $30218 m0 *1 151.24,222.6
X$30218 15444 17280 77 109 17825 NAND2_X1
* cell instance $30219 m0 *1 151.81,222.6
X$30219 17348 17603 77 109 17828 NAND2_X1
* cell instance $30222 m0 *1 153.33,222.6
X$30222 15543 109 17879 77 BUF_X4
* cell instance $30223 m0 *1 154.66,222.6
X$30223 17831 77 109 17706 INV_X1
* cell instance $30224 m0 *1 155.04,222.6
X$30224 77 17788 17831 17832 17701 17704 109 FA_X1
* cell instance $30229 r0 *1 140.6,222.6
X$30229 77 17701 17768 17824 17867 17704 109 FA_X1
* cell instance $30232 r0 *1 144.59,222.6
X$30232 17871 77 109 17766 INV_X2
* cell instance $30236 r0 *1 147.63,222.6
X$30236 77 17876 17871 17875 17873 17874 109 FA_X1
* cell instance $30237 r0 *1 150.67,222.6
X$30237 17702 17281 109 77 17876 AND2_X1
* cell instance $30238 r0 *1 151.43,222.6
X$30238 17848 77 109 17873 INV_X1
* cell instance $30241 r0 *1 155.61,222.6
X$30241 17281 15346 77 109 17848 NAND2_X1
* cell instance $30245 r0 *1 157.51,222.6
X$30245 17630 16983 77 109 17926 NAND2_X1
* cell instance $30246 r0 *1 158.08,222.6
X$30246 15385 17787 77 109 17896 NAND2_X1
* cell instance $30249 m0 *1 159.22,222.6
X$30249 77 17833 17789 17790 17996 17704 109 FA_X1
* cell instance $30253 r0 *1 159.6,222.6
X$30253 77 17849 17678 17709 17790 17936 109 FA_X1
* cell instance $30254 r0 *1 162.64,222.6
X$30254 17883 77 109 17451 INV_X1
* cell instance $30255 r0 *1 163.02,222.6
X$30255 77 17884 17883 17885 17898 17850 109 FA_X1
* cell instance $30256 m0 *1 165.11,222.6
X$30256 17837 77 109 17884 INV_X1
* cell instance $30258 m0 *1 165.49,222.6
X$30258 77 17454 17837 17841 17791 17838 109 FA_X1
* cell instance $30262 r0 *1 167.2,222.6
X$30262 17888 77 109 17525 INV_X1
* cell instance $30263 r0 *1 167.58,222.6
X$30263 77 17887 17888 17899 17839 17851 109 FA_X1
* cell instance $30264 m0 *1 169.1,222.6
X$30264 17841 77 109 17887 INV_X1
* cell instance $30268 m0 *1 170.43,222.6
X$30268 77 17842 17839 17892 17777 17844 109 FA_X1
* cell instance $30271 r0 *1 171,222.6
X$30271 17891 77 109 17852 INV_X1
* cell instance $30276 r0 *1 171.57,222.6
X$30276 77 17892 17891 17927 17792 17937 109 FA_X1
* cell instance $30278 m0 *1 173.85,222.6
X$30278 77 17845 17792 17889 17777 17793 109 FA_X1
* cell instance $30280 m0 *1 177.84,222.6
X$30280 77 17794 17886 17843 17642 17645 109 FA_X1
* cell instance $30281 m0 *1 180.88,222.6
X$30281 77 17843 17531 17795 17786 17924 109 FA_X1
* cell instance $30282 m0 *1 183.92,222.6
X$30282 77 17715 17459 17882 17840 17923 109 FA_X1
* cell instance $30283 m0 *1 186.96,222.6
X$30283 17796 77 109 17120 INV_X1
* cell instance $30289 r0 *1 175.94,222.6
X$30289 17890 77 109 17712 INV_X1
* cell instance $30290 r0 *1 176.32,222.6
X$30290 77 17886 17890 17904 17903 17889 109 FA_X1
* cell instance $30293 r0 *1 181.64,222.6
X$30293 77 17795 17713 17296 18096 17962 109 FA_X1
* cell instance $30295 r0 *1 185.06,222.6
X$30295 77 17882 17601 17361 17961 17853 109 FA_X1
* cell instance $30296 r0 *1 188.1,222.6
X$30296 77 17750 17796 17854 17752 17990 109 FA_X1
* cell instance $30297 m0 *1 189.43,222.6
X$30297 16983 17599 77 109 17797 NAND2_X1
* cell instance $30301 m0 *1 191.71,222.6
X$30301 16549 17689 77 109 17835 NAND2_X1
* cell instance $30302 m0 *1 192.28,222.6
X$30302 77 17834 17716 17880 17799 17798 109 FA_X1
* cell instance $30303 m0 *1 195.32,222.6
X$30303 77 17802 17800 17822 17830 17829 109 FA_X1
* cell instance $30304 m0 *1 198.36,222.6
X$30304 77 17822 17804 17816 17826 17772 109 FA_X1
* cell instance $30305 m0 *1 201.4,222.6
X$30305 77 17819 17820 17869 17654 17395 109 FA_X1
* cell instance $30307 m0 *1 205.2,222.6
X$30307 77 17814 17870 17865 17815 17813 109 FA_X1
* cell instance $30309 m0 *1 209.76,222.6
X$30309 17805 77 109 17812 INV_X1
* cell instance $30310 m0 *1 210.14,222.6
X$30310 77 17811 17806 17755 17864 17812 109 FA_X1
* cell instance $30311 m0 *1 213.18,222.6
X$30311 77 17859 17811 17754 17862 17810 109 FA_X1
* cell instance $30316 r0 *1 193.23,222.6
X$30316 77 17800 17922 17878 17880 17652 109 FA_X1
* cell instance $30319 r0 *1 197.22,222.6
X$30319 77 17804 17572 17905 17878 17919 109 FA_X1
* cell instance $30323 r0 *1 202.92,222.6
X$30323 17872 77 109 17819 INV_X1
* cell instance $30324 r0 *1 203.3,222.6
X$30324 77 17816 17872 17868 17870 17856 109 FA_X1
* cell instance $30325 r0 *1 206.34,222.6
X$30325 17869 77 109 17917 INV_X1
* cell instance $30330 r0 *1 209.57,222.6
X$30330 77 17857 17805 17863 17657 17718 109 FA_X1
* cell instance $30332 r0 *1 212.99,222.6
X$30332 17863 77 109 17862 INV_X1
* cell instance $30335 m0 *1 216.6,222.6
X$30335 77 17861 17807 17475 17950 17808 109 FA_X1
* cell instance $30379 m0 *1 158.08,236.6
X$30379 77 18207 18224 18104 18223 18206 109 FA_X1
* cell instance $30382 m0 *1 162.07,236.6
X$30382 77 18208 18156 18226 18250 18225 109 FA_X1
* cell instance $30383 m0 *1 165.11,236.6
X$30383 77 18228 18209 18227 18226 18230 109 FA_X1
* cell instance $30384 m0 *1 168.15,236.6
X$30384 18135 77 109 18228 INV_X1
* cell instance $30409 r0 *1 113.43,236.6
X$30409 16003 77 109 18261 BUF_X1
* cell instance $30413 r0 *1 118.18,236.6
X$30413 18098 77 109 18263 BUF_X1
* cell instance $30415 r0 *1 118.94,236.6
X$30415 15556 77 109 18265 BUF_X1
* cell instance $30417 r0 *1 119.89,236.6
X$30417 16652 77 109 18264 BUF_X1
* cell instance $30431 r0 *1 163.4,236.6
X$30431 16312 15823 77 109 18250 NAND2_X1
* cell instance $30435 r0 *1 169.29,236.6
X$30435 77 18210 18230 18211 18251 18252 109 FA_X1
* cell instance $30436 m0 *1 169.86,236.6
X$30436 18066 15931 77 109 18251 NAND2_X1
* cell instance $30438 m0 *1 170.43,236.6
X$30438 77 18242 18229 18212 18231 18211 109 FA_X1
* cell instance $30443 r0 *1 172.9,236.6
X$30443 16312 16482 77 109 18252 NAND2_X1
* cell instance $30444 r0 *1 173.47,236.6
X$30444 77 18254 18242 18139 18253 18255 109 FA_X1
* cell instance $30446 m0 *1 174.61,236.6
X$30446 15839 15931 77 109 18253 NAND2_X1
* cell instance $30447 m0 *1 175.75,236.6
X$30447 17412 16119 77 109 18255 NAND2_X1
* cell instance $30451 r0 *1 176.51,236.6
X$30451 16312 16353 77 109 18254 NAND2_X1
* cell instance $30453 m0 *1 177.65,236.6
X$30453 77 18235 18232 18214 18234 18213 109 FA_X1
* cell instance $30455 m0 *1 180.69,236.6
X$30455 17412 16126 77 109 18235 NAND2_X1
* cell instance $30457 m0 *1 181.45,236.6
X$30457 77 18237 18172 18236 18238 18243 109 FA_X1
* cell instance $30458 m0 *1 184.49,236.6
X$30458 18236 77 109 18112 INV_X1
* cell instance $30460 m0 *1 185.63,236.6
X$30460 18066 109 17412 77 BUF_X4
* cell instance $30461 m0 *1 186.96,236.6
X$30461 17702 16543 77 109 18239 NAND2_X1
* cell instance $30467 r0 *1 182.97,236.6
X$30467 17879 15823 77 109 18243 NOR2_X1
* cell instance $30471 r0 *1 186.2,236.6
X$30471 18257 77 109 18009 INV_X1
* cell instance $30474 r0 *1 187.72,236.6
X$30474 17633 16353 77 109 18259 NOR2_X1
* cell instance $30476 m0 *1 187.91,236.6
X$30476 16312 16123 77 109 18234 NAND2_X1
* cell instance $30477 m0 *1 189.24,236.6
X$30477 17879 16482 77 109 18256 NOR2_X1
* cell instance $30479 m0 *1 190,236.6
X$30479 17971 15823 77 109 18244 NOR2_X1
* cell instance $30481 m0 *1 191.33,236.6
X$30481 18245 77 109 18215 INV_X1
* cell instance $30484 r0 *1 188.29,236.6
X$30484 77 18244 18257 18258 18256 18259 109 FA_X1
* cell instance $30485 r0 *1 191.33,236.6
X$30485 18258 77 109 18167 INV_X1
* cell instance $30487 r0 *1 192.47,236.6
X$30487 77 18216 18245 18179 18262 18249 109 FA_X1
* cell instance $30488 m0 *1 193.8,236.6
X$30488 77 18180 18241 18181 18240 18233 109 FA_X1
* cell instance $30489 m0 *1 192.85,236.6
X$30489 17633 16123 77 109 18216 NOR2_X2
* cell instance $30490 m0 *1 196.84,236.6
X$30490 17633 16224 77 109 18248 NOR2_X1
* cell instance $30494 r0 *1 195.51,236.6
X$30494 17879 16353 77 109 18249 NOR2_X2
* cell instance $30498 r0 *1 197.79,236.6
X$30498 18247 77 109 18182 INV_X1
* cell instance $30499 r0 *1 198.17,236.6
X$30499 77 18246 18247 18068 18248 18260 109 FA_X1
* cell instance $30500 m0 *1 200.64,236.6
X$30500 16543 18035 77 109 18217 NAND2_X1
* cell instance $30501 m0 *1 200.07,236.6
X$30501 16854 15931 77 109 18222 NAND2_X1
* cell instance $30503 m0 *1 201.4,236.6
X$30503 17702 16228 77 109 18220 NAND2_X1
* cell instance $30506 r0 *1 201.21,236.6
X$30506 17879 16123 77 109 18246 NOR2_X1
* cell instance $30508 m0 *1 203.3,236.6
X$30508 16854 16126 77 109 18221 NAND2_X1
* cell instance $30510 m0 *1 203.87,236.6
X$30510 15346 16119 77 109 18218 NAND2_X1
* cell instance $30552 m0 *1 39.33,211.4
X$30552 77 17134 16800 17133 17272 8687 109 DFFR_X1
* cell instance $30565 m0 *1 45.98,211.4
X$30565 17134 77 109 19198 CLKBUF_X1
* cell instance $30567 m0 *1 46.55,211.4
X$30567 77 17134 16858 17185 17273 8687 109 DFFR_X1
* cell instance $30571 m0 *1 58.71,211.4
X$30571 17312 12312 15626 77 109 17310 MUX2_X1
* cell instance $30577 m0 *1 61.94,211.4
X$30577 17369 13682 15626 77 109 17337 MUX2_X1
* cell instance $30580 m0 *1 63.65,211.4
X$30580 77 17074 15662 17369 17337 8687 109 DFFR_X1
* cell instance $30581 m0 *1 70.49,211.4
X$30581 17373 10508 15566 77 109 17314 MUX2_X1
* cell instance $30586 r0 *1 70.11,211.4
X$30586 17374 13682 15566 77 109 17370 MUX2_X1
* cell instance $30587 r0 *1 71.44,211.4
X$30587 77 16752 17274 17374 17370 8687 109 DFFR_X1
* cell instance $30588 m0 *1 73.15,211.4
X$30588 16752 77 109 19229 CLKBUF_X1
* cell instance $30590 m0 *1 73.72,211.4
X$30590 14049 77 109 16752 CLKBUF_X3
* cell instance $30593 m0 *1 75.05,211.4
X$30593 17274 7153 17076 77 109 17318 MUX2_X1
* cell instance $30596 r0 *1 75.81,211.4
X$30596 17338 13146 15566 77 109 17474 MUX2_X1
* cell instance $30597 m0 *1 76.95,211.4
X$30597 77 16752 17077 17320 17319 8687 109 DFFR_X1
* cell instance $30599 m0 *1 80.75,211.4
X$30599 77 16958 17200 17379 17275 8687 109 DFFR_X1
* cell instance $30602 m0 *1 88.35,211.4
X$30602 17276 3183 17277 77 109 17323 MUX2_X1
* cell instance $30603 m0 *1 89.68,211.4
X$30603 14049 77 109 16958 CLKBUF_X3
* cell instance $30606 m0 *1 91.58,211.4
X$30606 17389 10508 15339 77 109 17278 MUX2_X1
* cell instance $30607 m0 *1 92.91,211.4
X$30607 77 16203 17147 17389 17278 8201 109 DFFR_X1
* cell instance $30610 r0 *1 77.52,211.4
X$30610 17478 10198 15434 77 109 17477 MUX2_X1
* cell instance $30613 r0 *1 79.99,211.4
X$30613 17379 13145 15434 77 109 17275 MUX2_X1
* cell instance $30617 r0 *1 84.93,211.4
X$30617 17383 10198 15737 77 109 17480 MUX2_X1
* cell instance $30620 r0 *1 87.4,211.4
X$30620 17386 13145 15737 77 109 17339 MUX2_X1
* cell instance $30621 r0 *1 88.73,211.4
X$30621 77 16958 17206 17386 17339 8687 109 DFFR_X1
* cell instance $30623 r0 *1 92.72,211.4
X$30623 77 16203 17146 17482 17436 12731 109 DFFR_X1
* cell instance $30624 r0 *1 96.52,211.4
X$30624 77 16203 17151 17390 17388 12731 109 DFFR_X1
* cell instance $30625 m0 *1 97.28,211.4
X$30625 17390 13146 15339 77 109 17388 MUX2_X1
* cell instance $30627 m0 *1 98.61,211.4
X$30627 14026 77 109 16203 CLKBUF_X3
* cell instance $30642 m0 *1 128.44,211.4
X$30642 16760 17341 109 77 17329 XNOR2_X1
* cell instance $30643 m0 *1 127.3,211.4
X$30643 17340 17329 109 77 17327 XNOR2_X1
* cell instance $30644 m0 *1 129.58,211.4
X$30644 17399 17327 109 77 17328 XNOR2_X1
* cell instance $30649 r0 *1 128.63,211.4
X$30649 77 17342 17341 17490 17394 17343 109 FA_X1
* cell instance $30650 m0 *1 131.48,211.4
X$30650 17279 17343 77 109 17400 XOR2_X1
* cell instance $30651 m0 *1 131.1,211.4
X$30651 17279 77 109 17342 INV_X1
* cell instance $30652 m0 *1 132.62,211.4
X$30652 17400 17334 109 77 17399 XNOR2_X1
* cell instance $30654 m0 *1 133.95,211.4
X$30654 17403 17229 109 77 17334 XNOR2_X1
* cell instance $30656 m0 *1 135.28,211.4
X$30656 77 17413 17403 17279 17344 17345 109 FA_X1
* cell instance $30660 m0 *1 143.07,211.4
X$30660 17281 17280 77 109 17345 NAND2_X2
* cell instance $30661 m0 *1 144.02,211.4
X$30661 17281 17412 77 109 17344 NAND2_X1
* cell instance $30664 r0 *1 131.86,211.4
X$30664 17406 77 109 17394 INV_X1
* cell instance $30665 r0 *1 132.24,211.4
X$30665 77 17398 17489 17438 17343 17405 109 FA_X1
* cell instance $30666 r0 *1 135.28,211.4
X$30666 17493 77 109 17405 INV_X1
* cell instance $30667 r0 *1 135.66,211.4
X$30667 77 17407 17406 17493 17344 17345 109 FA_X1
* cell instance $30668 r0 *1 138.7,211.4
X$30668 17346 77 109 17398 INV_X1
* cell instance $30670 r0 *1 139.27,211.4
X$30670 17496 77 109 17439 INV_X1
* cell instance $30672 r0 *1 139.84,211.4
X$30672 77 17345 17346 17496 17408 17415 109 FA_X1
* cell instance $30674 r0 *1 143.07,211.4
X$30674 15163 17280 77 109 17441 NAND2_X1
* cell instance $30676 r0 *1 143.83,211.4
X$30676 15163 17412 77 109 17408 NAND2_X1
* cell instance $30678 m0 *1 145.16,211.4
X$30678 16667 17348 77 109 17413 NAND2_X1
* cell instance $30682 m0 *1 148.01,211.4
X$30682 17282 77 109 17351 INV_X1
* cell instance $30683 m0 *1 148.39,211.4
X$30683 77 17500 16852 17283 17352 17353 109 FA_X1
* cell instance $30686 r0 *1 145.54,211.4
X$30686 17349 17348 77 109 17407 NAND2_X1
* cell instance $30687 r0 *1 146.11,211.4
X$30687 77 17351 17350 17352 17442 17570 109 FA_X1
* cell instance $30689 r0 *1 149.34,211.4
X$30689 77 17417 17444 17445 17240 17418 109 FA_X1
* cell instance $30691 m0 *1 151.81,211.4
X$30691 15163 77 109 17349 INV_X1
* cell instance $30692 m0 *1 152.95,211.4
X$30692 17336 17335 17419 109 77 17417 HA_X1
* cell instance $30694 m0 *1 156.37,211.4
X$30694 17285 17284 17424 109 77 17420 HA_X1
* cell instance $30698 r0 *1 152.57,211.4
X$30698 77 17706 17446 17423 17419 17420 109 FA_X1
* cell instance $30700 r0 *1 155.8,211.4
X$30700 17423 77 109 17503 INV_X1
* cell instance $30702 r0 *1 156.37,211.4
X$30702 17421 77 109 17506 INV_X1
* cell instance $30703 r0 *1 156.75,211.4
X$30703 77 17449 17421 17426 17424 17507 109 FA_X1
* cell instance $30704 m0 *1 159.6,211.4
X$30704 17354 77 109 17333 INV_X1
* cell instance $30706 m0 *1 159.98,211.4
X$30706 17355 77 109 17331 INV_X1
* cell instance $30708 r0 *1 159.79,211.4
X$30708 17426 77 109 17574 INV_X1
* cell instance $30710 r0 *1 160.55,211.4
X$30710 17429 77 109 17510 INV_X1
* cell instance $30711 m0 *1 160.93,211.4
X$30711 17427 17330 17428 109 77 17507 HA_X1
* cell instance $30714 r0 *1 160.93,211.4
X$30714 77 17432 17429 17511 17451 17428 109 FA_X1
* cell instance $30715 m0 *1 163.4,211.4
X$30715 17286 17163 17435 109 77 17432 HA_X1
* cell instance $30720 r0 *1 164.92,211.4
X$30720 16667 15260 77 109 17434 NOR2_X1
* cell instance $30721 r0 *1 165.49,211.4
X$30721 77 17433 16656 17454 17357 17434 109 FA_X1
* cell instance $30722 m0 *1 167.58,211.4
X$30722 17288 77 109 17433 INV_X1
* cell instance $30723 m0 *1 165.68,211.4
X$30723 17287 17453 16680 109 77 16450 HA_X1
* cell instance $30724 m0 *1 167.96,211.4
X$30724 15639 16667 77 109 17288 OR2_X1
* cell instance $30730 r0 *1 169.67,211.4
X$30730 17290 17289 17425 109 77 17455 HA_X1
* cell instance $30731 m0 *1 174.42,211.4
X$30731 15260 17349 77 109 17430 OR2_X1
* cell instance $30732 m0 *1 171.38,211.4
X$30732 77 17430 17264 17642 17263 17288 109 FA_X1
* cell instance $30734 m0 *1 176.7,211.4
X$30734 17349 15639 77 109 17292 NOR2_X1
* cell instance $30737 m0 *1 179.55,211.4
X$30737 77 17422 16977 16888 17359 17325 109 FA_X1
* cell instance $30740 r0 *1 171.95,211.4
X$30740 17356 77 109 17431 INV_X1
* cell instance $30741 r0 *1 172.33,211.4
X$30741 17431 17528 16552 109 77 16391 HA_X1
* cell instance $30744 r0 *1 175.37,211.4
X$30744 77 17502 17326 17457 17357 17292 109 FA_X1
* cell instance $30745 r0 *1 178.41,211.4
X$30745 77 17294 17504 17458 17291 17358 109 FA_X1
* cell instance $30747 r0 *1 181.64,211.4
X$30747 17349 15578 77 109 17587 NOR2_X1
* cell instance $30749 r0 *1 182.59,211.4
X$30749 17360 15260 77 109 17499 NOR2_X1
* cell instance $30751 m0 *1 182.97,211.4
X$30751 77 17601 17325 17324 17416 17296 109 FA_X1
* cell instance $30753 m0 *1 186.96,211.4
X$30753 77 17576 17092 16687 17460 17297 109 FA_X1
* cell instance $30756 m0 *1 190.95,211.4
X$30756 17411 77 109 17363 INV_X1
* cell instance $30760 r0 *1 183.35,211.4
X$30760 17459 77 109 17295 INV_X1
* cell instance $30764 r0 *1 185.82,211.4
X$30764 77 17361 16780 17297 17414 17409 109 FA_X1
* cell instance $30766 r0 *1 189.62,211.4
X$30766 16979 77 109 17362 INV_X1
* cell instance $30767 r0 *1 190,211.4
X$30767 17410 77 109 17461 INV_X1
* cell instance $30768 r0 *1 190.38,211.4
X$30768 77 17363 17410 17492 17115 17448 109 FA_X1
* cell instance $30770 m0 *1 195.13,211.4
X$30770 17404 77 109 17401 INV_X1
* cell instance $30771 m0 *1 194.75,211.4
X$30771 17321 77 109 17397 INV_X1
* cell instance $30774 m0 *1 196.46,211.4
X$30774 17299 77 109 17171 INV_X1
* cell instance $30776 m0 *1 197.03,211.4
X$30776 77 17172 17385 17380 17110 17364 109 FA_X1
* cell instance $30779 r0 *1 194.94,211.4
X$30779 17402 77 109 17462 INV_X1
* cell instance $30780 r0 *1 195.32,211.4
X$30780 17397 17401 17395 109 77 17463 HA_X1
* cell instance $30783 r0 *1 198.17,211.4
X$30783 17300 77 109 17464 INV_X1
* cell instance $30786 r0 *1 199.12,211.4
X$30786 17393 77 109 17364 INV_X1
* cell instance $30790 r0 *1 200.83,211.4
X$30790 15528 16561 77 109 17392 NOR2_X1
* cell instance $30791 r0 *1 201.4,211.4
X$30791 77 17487 17393 17485 17392 17391 109 FA_X1
* cell instance $30792 m0 *1 202.16,211.4
X$30792 15010 16125 77 109 17174 NOR2_X1
* cell instance $30794 m0 *1 202.73,211.4
X$30794 15836 16125 77 109 17391 NOR2_X1
* cell instance $30798 m0 *1 204.63,211.4
X$30798 17016 16228 77 109 17204 NAND2_X1
* cell instance $30801 m0 *1 205.39,211.4
X$30801 77 17301 17378 17387 17486 17317 109 FA_X1
* cell instance $30803 m0 *1 208.62,211.4
X$30803 17387 77 109 17381 INV_X2
* cell instance $30804 m0 *1 209.19,211.4
X$30804 17381 17303 17377 109 77 17382 HA_X1
* cell instance $30805 m0 *1 211.09,211.4
X$30805 17382 77 109 17315 INV_X1
* cell instance $30806 m0 *1 211.47,211.4
X$30806 17552 17316 17313 109 77 17366 HA_X1
* cell instance $30807 m0 *1 213.37,211.4
X$30807 17377 17313 17004 109 77 17311 HA_X1
* cell instance $30808 m0 *1 215.27,211.4
X$30808 17304 77 109 17309 INV_X1
* cell instance $30812 r0 *1 205.58,211.4
X$30812 17016 16126 77 109 17466 NAND2_X1
* cell instance $30816 r0 *1 208.62,211.4
X$30816 17385 77 109 17468 INV_X1
* cell instance $30819 r0 *1 209.57,211.4
X$30819 17380 77 109 17483 INV_X1
* cell instance $30822 r0 *1 213.75,211.4
X$30822 17366 77 109 17469 INV_X1
* cell instance $30825 r0 *1 215.84,211.4
X$30825 17376 17367 17177 109 77 17472 HA_X1
* cell instance $30826 m0 *1 217.74,211.4
X$30826 17190 77 109 17178 BUF_X2
* cell instance $30829 m0 *1 218.69,211.4
X$30829 17375 77 109 17305 INV_X1
* cell instance $30832 r0 *1 217.74,211.4
X$30832 77 17470 17375 17371 17547 17607 109 FA_X1
* cell instance $30833 r0 *1 220.78,211.4
X$30833 17371 77 109 17307 INV_X1
* cell instance $30835 m0 *1 220.97,211.4
X$30835 77 17309 17306 17308 17368 17182 109 FA_X1
* cell instance $30840 r0 *1 221.54,211.4
X$30840 17471 77 109 17368 INV_X1
* cell instance $30902 r0 *1 7.98,191.8
X$30902 77 15461 15850 15897 15849 9814 109 DFFR_X1
* cell instance $30903 m0 *1 8.74,191.8
X$30903 15558 6280 15897 77 109 15849 MUX2_X1
* cell instance $30907 m0 *1 11.78,191.8
X$30907 15558 6214 15899 77 109 15898 MUX2_X1
* cell instance $30908 m0 *1 13.11,191.8
X$30908 14461 77 109 15461 CLKBUF_X3
* cell instance $30909 m0 *1 14.06,191.8
X$30909 15461 77 109 19153 INV_X1
* cell instance $30911 r0 *1 11.78,191.8
X$30911 77 15461 15991 15899 15898 9814 109 DFFR_X1
* cell instance $30912 m0 *1 15.01,191.8
X$30912 15601 8535 15725 77 109 15900 MUX2_X1
* cell instance $30916 m0 *1 18.62,191.8
X$30916 77 15851 15651 15852 15904 9814 109 DFFR_X1
* cell instance $30917 m0 *1 22.42,191.8
X$30917 15852 12312 15368 77 109 15904 MUX2_X1
* cell instance $30920 m0 *1 24.7,191.8
X$30920 77 15727 15908 15786 15726 9814 109 DFFR_X1
* cell instance $30922 m0 *1 31.54,191.8
X$30922 14461 77 109 15727 CLKBUF_X3
* cell instance $30923 m0 *1 32.49,191.8
X$30923 15727 77 109 19232 CLKBUF_X1
* cell instance $30925 m0 *1 33.82,191.8
X$30925 77 15727 15919 15799 15916 4086 109 DFFR_X1
* cell instance $30930 r0 *1 15.58,191.8
X$30930 15850 8535 15991 77 109 15901 MUX2_X1
* cell instance $30932 r0 *1 17.67,191.8
X$30932 15900 3364 15901 77 109 15903 MUX2_X1
* cell instance $30936 r0 *1 22.99,191.8
X$30936 3364 109 4627 77 BUF_X4
* cell instance $30939 r0 *1 25.27,191.8
X$30939 15853 12153 15992 77 109 15854 MUX2_X1
* cell instance $30940 r0 *1 26.6,191.8
X$30940 15854 12240 15909 77 109 16034 MUX2_X1
* cell instance $30941 r0 *1 27.93,191.8
X$30941 15728 15375 15908 77 109 15909 MUX2_X1
* cell instance $30942 r0 *1 29.26,191.8
X$30942 15728 10138 15908 77 109 15993 MUX2_X1
* cell instance $30943 r0 *1 30.59,191.8
X$30943 16034 7063 16035 77 109 15918 MUX2_X1
* cell instance $30944 r0 *1 31.92,191.8
X$30944 7598 109 15167 77 BUF_X4
* cell instance $30948 r0 *1 35.34,191.8
X$30948 15918 6296 16039 77 109 15172 MUX2_X1
* cell instance $30950 r0 *1 36.86,191.8
X$30950 15855 8535 15919 77 109 15924 MUX2_X1
* cell instance $30951 r0 *1 38.19,191.8
X$30951 15855 10957 15919 77 109 16041 MUX2_X1
* cell instance $30952 r0 *1 39.52,191.8
X$30952 16040 3364 15924 77 109 15856 MUX2_X1
* cell instance $30953 r0 *1 40.85,191.8
X$30953 15856 9652 15903 77 109 15930 MUX2_X1
* cell instance $30956 r0 *1 43.13,191.8
X$30956 77 15369 15855 15933 16043 4086 109 DFFR_X1
* cell instance $30958 m0 *1 43.32,191.8
X$30958 15930 10065 15729 77 109 15468 MUX2_X1
* cell instance $30961 m0 *1 47.12,191.8
X$30961 9938 77 109 15858 BUF_X2
* cell instance $30963 m0 *1 48.07,191.8
X$30963 77 15369 14839 15807 15857 8687 109 DFFR_X1
* cell instance $30966 r0 *1 46.93,191.8
X$30966 9938 12709 15933 77 109 16043 MUX2_X1
* cell instance $30967 r0 *1 48.26,191.8
X$30967 15807 4631 15858 77 109 15857 MUX2_X1
* cell instance $30970 r0 *1 50.54,191.8
X$30970 9938 77 109 15467 BUF_X2
* cell instance $30971 r0 *1 51.3,191.8
X$30971 14135 77 109 15369 CLKBUF_X3
* cell instance $30972 r0 *1 52.25,191.8
X$30972 77 15369 15372 15859 16045 8687 109 DFFR_X1
* cell instance $30973 m0 *1 53.2,191.8
X$30973 3445 77 109 14135 CLKBUF_X3
* cell instance $30975 m0 *1 54.15,191.8
X$30975 77 15369 15424 15860 15939 8687 109 DFFR_X1
* cell instance $30976 m0 *1 57.95,191.8
X$30976 77 15861 15656 15809 15808 8687 109 DFFR_X1
* cell instance $30977 m0 *1 61.75,191.8
X$30977 15941 9652 15731 77 109 15658 MUX2_X1
* cell instance $30978 m0 *1 63.08,191.8
X$30978 15732 3694 15940 77 109 15941 MUX2_X1
* cell instance $30979 m0 *1 64.41,191.8
X$30979 15659 11563 15660 77 109 15862 MUX2_X1
* cell instance $30980 m0 *1 65.74,191.8
X$30980 15862 9429 15943 77 109 15940 MUX2_X1
* cell instance $30982 r0 *1 56.05,191.8
X$30982 15859 14047 15626 77 109 16045 MUX2_X1
* cell instance $30983 r0 *1 57.38,191.8
X$30983 15860 13767 15626 77 109 15939 MUX2_X1
* cell instance $30985 r0 *1 58.9,191.8
X$30985 77 15861 15657 16048 16046 8687 109 DFFR_X1
* cell instance $30993 m0 *1 67.45,191.8
X$30993 15662 11563 15942 77 109 15943 MUX2_X1
* cell instance $30996 m0 *1 74.1,191.8
X$30996 77 15630 15734 15817 15663 8687 109 DFFR_X1
* cell instance $30998 m0 *1 78.09,191.8
X$30998 15945 5169 15734 77 109 15818 MUX2_X1
* cell instance $30999 m0 *1 79.42,191.8
X$30999 15947 5169 16082 77 109 15946 MUX2_X1
* cell instance $31003 r0 *1 68.59,191.8
X$31003 16049 4708 15566 77 109 16163 MUX2_X1
* cell instance $31006 r0 *1 70.87,191.8
X$31006 16193 10065 15863 77 109 15819 MUX2_X1
* cell instance $31009 r0 *1 74.1,191.8
X$31009 77 15630 15945 15997 15864 8687 109 DFFR_X1
* cell instance $31011 r0 *1 78.66,191.8
X$31011 15945 7877 16509 77 109 15735 MUX2_X1
* cell instance $31013 m0 *1 81.32,191.8
X$31013 15946 9895 15818 77 109 15475 MUX2_X1
* cell instance $31017 m0 *1 83.03,191.8
X$31017 15947 10299 15736 77 109 15665 MUX2_X1
* cell instance $31020 r0 *1 84.17,191.8
X$31020 15950 4631 15737 77 109 15948 MUX2_X1
* cell instance $31021 m0 *1 88.54,191.8
X$31021 14049 77 109 15865 CLKBUF_X3
* cell instance $31022 m0 *1 84.74,191.8
X$31022 77 15865 15136 15950 15948 8687 109 DFFR_X1
* cell instance $31023 m0 *1 89.49,191.8
X$31023 3599 109 10065 77 BUF_X4
* cell instance $31026 m0 *1 94.62,191.8
X$31026 15869 6296 77 109 15825 NOR2_X1
* cell instance $31028 r0 *1 85.5,191.8
X$31028 15949 8363 16398 8031 15998 15286 109 77 AOI221_X2
* cell instance $31030 r0 *1 87.97,191.8
X$31030 77 15865 15952 16053 15866 8687 109 DFFR_X1
* cell instance $31031 r0 *1 91.77,191.8
X$31031 15867 9829 15671 77 109 16054 MUX2_X1
* cell instance $31034 r0 *1 93.67,191.8
X$31034 15953 4632 15956 77 109 15869 MUX2_X1
* cell instance $31037 r0 *1 95.57,191.8
X$31037 12413 16056 15954 8499 15958 16057 77 109 15724 OAI33_X1
* cell instance $31038 m0 *1 98.8,191.8
X$31038 15959 13767 15671 77 109 15738 MUX2_X1
* cell instance $31039 m0 *1 95.57,191.8
X$31039 77 12413 15955 16093 15358 8499 109 OAI22_X4
* cell instance $31040 m0 *1 100.13,191.8
X$31040 77 15149 15477 15959 15738 8201 109 DFFR_X1
* cell instance $31041 m0 *1 103.93,191.8
X$31041 8870 77 109 15671 BUF_X2
* cell instance $31042 m0 *1 104.69,191.8
X$31042 15870 8864 15739 77 109 15960 MUX2_X1
* cell instance $31043 m0 *1 106.02,191.8
X$31043 15478 8864 15830 77 109 15961 MUX2_X1
* cell instance $31045 m0 *1 107.54,191.8
X$31045 77 15672 15739 15964 15962 8201 109 DFFR_X1
* cell instance $31047 m0 *1 111.53,191.8
X$31047 14026 77 109 15672 CLKBUF_X3
* cell instance $31048 m0 *1 112.48,191.8
X$31048 15833 10787 15968 77 15965 109 AOI21_X2
* cell instance $31050 m0 *1 114,191.8
X$31050 15191 15185 77 109 15835 NOR2_X1
* cell instance $31052 m0 *1 114.76,191.8
X$31052 15967 13141 15570 77 15966 109 AOI21_X2
* cell instance $31054 m0 *1 116.28,191.8
X$31054 15481 10787 15571 77 15874 109 AOI21_X2
* cell instance $31056 m0 *1 117.8,191.8
X$31056 16065 13141 15572 77 18098 109 AOI21_X2
* cell instance $31058 m0 *1 119.32,191.8
X$31058 15741 13141 15970 77 15875 109 AOI21_X2
* cell instance $31060 m0 *1 120.84,191.8
X$31060 11685 15185 77 109 15971 NOR2_X1
* cell instance $31062 m0 *1 121.6,191.8
X$31062 15971 10787 15742 77 16652 109 AOI21_X2
* cell instance $31064 m0 *1 123.12,191.8
X$31064 77 12828 15876 15877 15843 12731 109 DFFR_X1
* cell instance $31065 m0 *1 126.92,191.8
X$31065 15877 15193 15975 77 109 15843 MUX2_X1
* cell instance $31069 r0 *1 97.28,191.8
X$31069 16175 5415 77 109 15958 NOR2_X1
* cell instance $31071 r0 *1 103.93,191.8
X$31071 15952 7877 15870 77 109 15479 MUX2_X1
* cell instance $31073 r0 *1 105.64,191.8
X$31073 15960 3791 15961 77 109 15953 MUX2_X1
* cell instance $31075 r0 *1 107.16,191.8
X$31075 8870 77 109 14717 BUF_X2
* cell instance $31077 r0 *1 108.3,191.8
X$31077 14717 8008 15964 77 109 15962 MUX2_X1
* cell instance $31079 r0 *1 110.01,191.8
X$31079 77 15672 15478 16004 16001 8201 109 DFFR_X1
* cell instance $31082 r0 *1 114.38,191.8
X$31082 15872 8232 15873 77 109 16002 MUX2_X1
* cell instance $31086 r0 *1 115.71,191.8
X$31086 15872 7279 15969 77 109 16066 MUX2_X1
* cell instance $31090 r0 *1 119.51,191.8
X$31090 12844 12421 77 109 15741 NOR2_X1
* cell instance $31091 r0 *1 120.08,191.8
X$31091 15383 12421 77 109 16065 NOR2_X1
* cell instance $31095 r0 *1 121.41,191.8
X$31095 77 12828 16063 16005 16064 12731 109 DFFR_X1
* cell instance $31097 r0 *1 125.4,191.8
X$31097 16063 14949 15876 77 109 15878 MUX2_X1
* cell instance $31100 r0 *1 127.3,191.8
X$31100 15878 14485 16173 77 109 15980 MUX2_X1
* cell instance $31103 r0 *1 129.77,191.8
X$31103 77 14580 15977 15880 15979 12731 109 DFFR_X1
* cell instance $31105 m0 *1 131.67,191.8
X$31105 15977 14200 15743 77 109 15846 MUX2_X1
* cell instance $31106 m0 *1 133.19,191.8
X$31106 15879 14485 15846 77 109 15845 MUX2_X1
* cell instance $31108 m0 *1 135.28,191.8
X$31108 16059 14608 15980 77 109 15674 MUX2_X1
* cell instance $31110 m0 *1 137.37,191.8
X$31110 15983 15193 15483 77 109 15982 MUX2_X1
* cell instance $31111 m0 *1 138.7,191.8
X$31111 15455 77 109 19239 CLKBUF_X1
* cell instance $31113 m0 *1 140.03,191.8
X$31113 15745 9585 6397 109 15986 77 NOR3_X2
* cell instance $31117 r0 *1 133.95,191.8
X$31117 15880 15193 15848 77 109 15979 MUX2_X1
* cell instance $31120 r0 *1 135.85,191.8
X$31120 77 15455 15984 15983 15982 12731 109 DFFR_X1
* cell instance $31122 r0 *1 139.84,191.8
X$31122 15984 14949 15453 77 109 16006 MUX2_X1
* cell instance $31125 r0 *1 142.31,191.8
X$31125 77 15455 15985 12731 18985 15676 109 DFFR_X2
* cell instance $31126 m0 *1 142.69,191.8
X$31126 11685 15484 12550 77 109 15844 MUX2_X1
* cell instance $31129 m0 *1 144.78,191.8
X$31129 15448 12734 16312 77 109 NOR2_X4
* cell instance $31130 m0 *1 146.49,191.8
X$31130 15676 15195 15448 77 109 NOR2_X4
* cell instance $31131 m0 *1 148.2,191.8
X$31131 77 15836 15986 13183 15745 109 AOI21_X4
* cell instance $31133 r0 *1 146.49,191.8
X$31133 15676 14734 15748 77 109 15985 MUX2_X1
* cell instance $31136 r0 *1 149.53,191.8
X$31136 15195 14734 16107 77 109 16169 MUX2_X1
* cell instance $31137 r0 *1 150.86,191.8
X$31137 15748 14734 15747 77 109 15988 MUX2_X1
* cell instance $31138 m0 *1 152.38,191.8
X$31138 15072 109 15348 77 BUF_X4
* cell instance $31139 m0 *1 151.05,191.8
X$31139 15484 109 15072 77 BUF_X4
* cell instance $31140 m0 *1 153.71,191.8
X$31140 12546 15881 77 109 15074 NAND2_X1
* cell instance $31141 m0 *1 154.28,191.8
X$31141 12541 77 109 15832 BUF_X1
* cell instance $31143 r0 *1 152.19,191.8
X$31143 77 15988 12731 15748 15749 109 DFFS_X2
* cell instance $31144 m0 *1 155.42,191.8
X$31144 15748 15195 15071 77 109 15990 OR3_X1
* cell instance $31146 m0 *1 156.37,191.8
X$31146 15990 77 109 15488 CLKBUF_X3
* cell instance $31147 m0 *1 157.32,191.8
X$31147 15881 15195 77 109 15677 OR2_X2
* cell instance $31150 r0 *1 156.18,191.8
X$31150 15749 77 109 19289 CLKBUF_X1
* cell instance $31152 r0 *1 157.51,191.8
X$31152 16008 15750 14686 15989 109 77 16167 OAI22_X1
* cell instance $31154 r0 *1 158.84,191.8
X$31154 13951 16166 77 109 15989 NOR2_X1
* cell instance $31155 m0 *1 160.74,191.8
X$31155 15987 109 16051 77 BUF_X4
* cell instance $31156 m0 *1 159.41,191.8
X$31156 15677 109 15082 77 BUF_X4
* cell instance $31158 m0 *1 162.26,191.8
X$31158 16113 14852 15751 109 77 14738 OAI21_X4
* cell instance $31159 m0 *1 164.73,191.8
X$31159 77 15823 15752 9122 15745 109 AOI21_X4
* cell instance $31160 m0 *1 167.2,191.8
X$31160 15299 15978 15976 109 15388 77 OAI21_X1
* cell instance $31161 m0 *1 167.96,191.8
X$31161 15753 15390 77 109 15822 NOR2_X1
* cell instance $31162 m0 *1 168.53,191.8
X$31162 15300 12994 77 109 15976 NAND2_X1
* cell instance $31164 r0 *1 159.41,191.8
X$31164 16052 14852 14550 77 109 15882 NAND3_X1
* cell instance $31166 r0 *1 160.36,191.8
X$31166 14550 14908 15882 109 16009 77 OAI21_X1
* cell instance $31170 r0 *1 163.59,191.8
X$31170 15165 13951 14810 77 109 16010 MUX2_X1
* cell instance $31171 r0 *1 164.92,191.8
X$31171 15827 109 15931 77 BUF_X4
* cell instance $31172 r0 *1 166.25,191.8
X$31172 77 15302 15243 12731 15972 15075 109 DFFR_X2
* cell instance $31173 m0 *1 170.81,191.8
X$31173 15300 15884 77 109 15635 NOR2_X1
* cell instance $31174 m0 *1 169.48,191.8
X$31174 15973 15974 8264 77 109 13363 NAND3_X2
* cell instance $31176 m0 *1 171.57,191.8
X$31176 16220 16013 15884 109 77 15706 HA_X1
* cell instance $31177 m0 *1 173.47,191.8
X$31177 14560 77 109 15302 CLKBUF_X3
* cell instance $31178 m0 *1 174.42,191.8
X$31178 13067 15758 15815 109 15816 77 OAI21_X1
* cell instance $31179 m0 *1 175.18,191.8
X$31179 12546 77 109 15524 CLKBUF_X2
* cell instance $31180 m0 *1 175.94,191.8
X$31180 12993 15524 77 109 15755 OR2_X1
* cell instance $31181 m0 *1 176.7,191.8
X$31181 13352 15758 15756 109 15957 77 OAI21_X1
* cell instance $31182 m0 *1 177.46,191.8
X$31182 13236 15524 77 109 15944 OR2_X1
* cell instance $31184 m0 *1 178.41,191.8
X$31184 12994 15524 77 109 15951 OR2_X1
* cell instance $31185 m0 *1 179.17,191.8
X$31185 12985 15581 15951 109 15757 77 OAI21_X1
* cell instance $31186 m0 *1 179.93,191.8
X$31186 15760 15757 15686 15197 77 109 15810 AOI22_X2
* cell instance $31187 m0 *1 181.64,191.8
X$31187 15760 15811 15686 15014 77 109 15934 AOI22_X2
* cell instance $31188 m0 *1 183.35,191.8
X$31188 15760 15759 15686 14677 77 109 15928 AOI22_X2
* cell instance $31189 m0 *1 185.06,191.8
X$31189 15758 12896 77 109 15761 NOR2_X1
* cell instance $31190 m0 *1 185.63,191.8
X$31190 15761 13071 15581 77 15886 109 AOI21_X1
* cell instance $31191 m0 *1 186.39,191.8
X$31191 77 15938 15802 15688 15936 15937 109 FA_X1
* cell instance $31192 m0 *1 189.43,191.8
X$31192 77 15888 15804 15689 15763 15935 109 FA_X1
* cell instance $31193 m0 *1 192.47,191.8
X$31193 15804 77 109 15929 INV_X1
* cell instance $31194 m0 *1 192.85,191.8
X$31194 15802 77 109 15801 INV_X1
* cell instance $31200 r0 *1 170.81,191.8
X$31200 15972 77 109 13352 BUF_X2
* cell instance $31204 r0 *1 171.57,191.8
X$31204 15488 12753 77 109 15680 NOR2_X1
* cell instance $31205 r0 *1 172.14,191.8
X$31205 15302 77 109 19279 CLKBUF_X1
* cell instance $31207 r0 *1 172.9,191.8
X$31207 15885 15816 13832 15348 77 109 15963 AOI22_X1
* cell instance $31208 r0 *1 173.85,191.8
X$31208 15963 77 109 16013 INV_X1
* cell instance $31209 r0 *1 174.23,191.8
X$31209 15071 77 109 15758 CLKBUF_X3
* cell instance $31213 r0 *1 176.51,191.8
X$31213 15885 15957 15348 15075 77 109 16015 AOI22_X2
* cell instance $31216 r0 *1 178.79,191.8
X$31216 16116 12755 15581 77 16044 109 AOI21_X1
* cell instance $31217 r0 *1 179.55,191.8
X$31217 15758 14617 77 109 16296 NOR2_X1
* cell instance $31219 r0 *1 180.5,191.8
X$31219 15885 109 15760 77 BUF_X4
* cell instance $31221 r0 *1 182.02,191.8
X$31221 13115 15524 77 109 16042 OR2_X1
* cell instance $31223 r0 *1 183.16,191.8
X$31223 12897 15758 15944 109 16016 77 OAI21_X1
* cell instance $31225 r0 *1 184.11,191.8
X$31225 15760 16016 13840 15686 77 109 16038 AOI22_X1
* cell instance $31228 r0 *1 185.63,191.8
X$31228 15760 15886 15686 14348 77 109 15935 AOI22_X2
* cell instance $31230 r0 *1 187.72,191.8
X$31230 15707 15887 77 109 15937 NAND2_X1
* cell instance $31233 r0 *1 194.56,191.8
X$31233 77 15928 16018 15932 15889 16020 109 FA_X1
* cell instance $31234 r0 *1 197.6,191.8
X$31234 15932 77 109 15691 INV_X1
* cell instance $31236 r0 *1 199.5,191.8
X$31236 15927 77 109 15764 INV_X1
* cell instance $31238 m0 *1 202.16,191.8
X$31238 15926 77 109 15921 INV_X1
* cell instance $31242 m0 *1 203.11,191.8
X$31242 15925 77 109 15923 INV_X1
* cell instance $31244 m0 *1 203.49,191.8
X$31244 15923 15921 15792 109 77 15920 HA_X1
* cell instance $31246 m0 *1 206.91,191.8
X$31246 15920 77 109 15915 INV_X1
* cell instance $31248 r0 *1 203.68,191.8
X$31248 16145 16032 15922 109 77 15917 HA_X1
* cell instance $31251 r0 *1 206.15,191.8
X$31251 15917 16131 15891 109 77 15892 HA_X1
* cell instance $31252 m0 *1 207.86,191.8
X$31252 77 15914 15913 15911 15915 15766 109 FA_X1
* cell instance $31255 r0 *1 208.05,191.8
X$31255 16030 77 109 15766 INV_X1
* cell instance $31256 r0 *1 208.43,191.8
X$31256 15892 77 109 15914 INV_X1
* cell instance $31258 m0 *1 211.66,191.8
X$31258 15913 77 109 15912 INV_X1
* cell instance $31259 m0 *1 211.28,191.8
X$31259 15911 77 109 15767 INV_X1
* cell instance $31261 m0 *1 212.61,191.8
X$31261 77 15910 15785 15787 15912 15893 109 FA_X1
* cell instance $31265 m0 *1 217.36,191.8
X$31265 15768 77 109 15590 INV_X1
* cell instance $31266 m0 *1 217.74,191.8
X$31266 15905 15768 15594 77 15906 109 AOI21_X1
* cell instance $31267 m0 *1 218.5,191.8
X$31267 15894 15769 15768 15589 77 109 16027 NAND4_X1
* cell instance $31268 m0 *1 219.45,191.8
X$31268 15906 15770 77 109 15902 NOR2_X1
* cell instance $31269 m0 *1 220.02,191.8
X$31269 15905 77 109 15593 INV_X1
* cell instance $31270 m0 *1 220.4,191.8
X$31270 15772 15771 77 109 15751 XNOR2_X2
* cell instance $31278 r0 *1 216.22,191.8
X$31278 16134 15785 15768 109 77 15905 HA_X1
* cell instance $31279 r0 *1 218.12,191.8
X$31279 15907 16027 15508 109 77 16029 OAI21_X2
* cell instance $31280 r0 *1 219.45,191.8
X$31280 15894 15895 15902 109 77 15907 OAI21_X2
* cell instance $31281 r0 *1 220.78,191.8
X$31281 15693 15902 15895 109 15771 77 NOR3_X2
* cell instance $31282 r0 *1 222.11,191.8
X$31282 15894 77 109 15772 INV_X1
* cell instance $31283 r0 *1 222.49,191.8
X$31283 15895 77 109 16025 INV_X1
* cell instance $31291 m0 *1 236.36,191.8
X$31291 15896 77 109 15774 BUF_X1
* cell instance $31302 m0 *1 15.2,194.6
X$31302 15850 11276 15991 77 109 15780 MUX2_X1
* cell instance $31305 m0 *1 19.76,194.6
X$31305 15167 3594 16028 77 109 16137 MUX2_X1
* cell instance $31306 m0 *1 21.09,194.6
X$31306 77 15851 15992 16028 16137 9814 109 DFFR_X1
* cell instance $31316 r0 *1 14.63,194.6
X$31316 15167 3784 16238 77 109 16067 MUX2_X1
* cell instance $31317 r0 *1 15.96,194.6
X$31317 77 15851 15853 16238 16067 9814 109 DFFR_X1
* cell instance $31320 r0 *1 20.71,194.6
X$31320 14461 77 109 15851 CLKBUF_X3
* cell instance $31324 r0 *1 24.32,194.6
X$31324 77 15851 16182 16068 16144 9814 109 DFFR_X1
* cell instance $31325 m0 *1 25.46,194.6
X$31325 15853 10138 15992 77 109 16147 MUX2_X1
* cell instance $31330 r0 *1 28.12,194.6
X$31330 16068 4708 16069 77 109 16144 MUX2_X1
* cell instance $31332 m0 *1 29.45,194.6
X$31332 16147 10283 15993 77 109 16247 MUX2_X1
* cell instance $31336 r0 *1 30.4,194.6
X$31336 16247 10368 16185 77 109 16256 MUX2_X1
* cell instance $31337 r0 *1 31.73,194.6
X$31337 7598 109 16069 77 BUF_X4
* cell instance $31338 m0 *1 32.11,194.6
X$31338 16070 7063 15994 77 109 16039 MUX2_X1
* cell instance $31340 m0 *1 33.44,194.6
X$31340 15558 3594 16153 77 109 16071 MUX2_X1
* cell instance $31341 m0 *1 34.77,194.6
X$31341 77 15727 15995 16153 16071 4086 109 DFFR_X1
* cell instance $31342 m0 *1 38.57,194.6
X$31342 16072 8535 15995 77 109 16040 MUX2_X1
* cell instance $31348 r0 *1 34.2,194.6
X$31348 16376 7197 16256 77 109 15464 MUX2_X1
* cell instance $31350 r0 *1 35.91,194.6
X$31350 15558 3784 16255 77 109 16186 MUX2_X1
* cell instance $31353 r0 *1 38.19,194.6
X$31353 16072 10440 15995 77 109 16073 MUX2_X1
* cell instance $31354 r0 *1 39.52,194.6
X$31354 16073 11125 16041 77 109 16074 MUX2_X1
* cell instance $31355 r0 *1 40.85,194.6
X$31355 16074 10368 16155 77 109 16078 MUX2_X1
* cell instance $31356 r0 *1 42.18,194.6
X$31356 16262 4708 15858 77 109 16261 MUX2_X1
* cell instance $31357 r0 *1 43.51,194.6
X$31357 77 15620 16156 16262 16261 4086 109 DFFR_X1
* cell instance $31359 m0 *1 44.08,194.6
X$31359 14135 77 109 15620 CLKBUF_X3
* cell instance $31361 m0 *1 47.12,194.6
X$31361 16188 10129 16156 77 109 16076 MUX2_X1
* cell instance $31364 m0 *1 48.64,194.6
X$31364 16076 9895 16077 77 109 15175 MUX2_X1
* cell instance $31369 r0 *1 47.69,194.6
X$31369 16075 10129 16425 77 109 16077 MUX2_X1
* cell instance $31373 r0 *1 50.35,194.6
X$31373 16329 7197 16078 77 109 15730 MUX2_X1
* cell instance $31376 r0 *1 53.96,194.6
X$31376 14712 8232 16159 77 109 16268 MUX2_X1
* cell instance $31377 r0 *1 55.29,194.6
X$31377 77 16330 16191 16159 16268 8687 109 DFFR_X1
* cell instance $31382 m0 *1 59.66,194.6
X$31382 14712 7279 16048 77 109 16046 MUX2_X1
* cell instance $31386 m0 *1 61.94,194.6
X$31386 16161 12481 14712 77 109 15996 MUX2_X1
* cell instance $31387 m0 *1 63.27,194.6
X$31387 77 15126 15660 16161 15996 8687 109 DFFR_X1
* cell instance $31391 r0 *1 61.37,194.6
X$31391 16271 3694 16079 77 109 15731 MUX2_X1
* cell instance $31392 r0 *1 62.7,194.6
X$31392 77 15861 15942 16274 16273 8687 109 DFFR_X1
* cell instance $31395 m0 *1 68.4,194.6
X$31395 77 15630 16081 16049 16163 8687 109 DFFR_X1
* cell instance $31397 m0 *1 72.2,194.6
X$31397 77 6231 109 3791 BUF_X8
* cell instance $31398 m0 *1 74.67,194.6
X$31398 14049 77 109 15630 CLKBUF_X3
* cell instance $31401 m0 *1 76.57,194.6
X$31401 15997 14047 15434 77 109 15864 MUX2_X1
* cell instance $31404 m0 *1 78.85,194.6
X$31404 16050 13926 15434 77 109 16165 MUX2_X1
* cell instance $31405 m0 *1 80.18,194.6
X$31405 77 15865 15947 16050 16165 8687 109 DFFR_X1
* cell instance $31408 m0 *1 87.21,194.6
X$31408 15999 9429 16086 77 109 15476 MUX2_X1
* cell instance $31409 m0 *1 88.54,194.6
X$31409 15865 77 109 19204 CLKBUF_X1
* cell instance $31410 m0 *1 89.11,194.6
X$31410 16053 13926 15671 77 109 15866 MUX2_X1
* cell instance $31414 r0 *1 69.35,194.6
X$31414 16276 10435 16081 77 109 16080 MUX2_X1
* cell instance $31415 r0 *1 70.68,194.6
X$31415 16080 5536 16195 77 109 15863 MUX2_X1
* cell instance $31416 r0 *1 72.01,194.6
X$31416 16276 7936 16081 77 109 16279 MUX2_X1
* cell instance $31418 r0 *1 74.1,194.6
X$31418 16279 8375 16280 77 109 15441 MUX2_X1
* cell instance $31421 r0 *1 76.38,194.6
X$31421 77 15630 16082 16197 16281 8687 109 DFFR_X1
* cell instance $31422 r0 *1 80.18,194.6
X$31422 16082 7447 16397 77 109 16083 MUX2_X1
* cell instance $31426 r0 *1 83.98,194.6
X$31426 16285 6459 16084 77 109 15998 MUX2_X1
* cell instance $31429 r0 *1 86.45,194.6
X$31429 16198 11128 16085 77 109 15999 MUX2_X1
* cell instance $31430 r0 *1 87.78,194.6
X$31430 16198 10149 16085 77 109 16087 MUX2_X1
* cell instance $31431 r0 *1 89.11,194.6
X$31431 16087 8689 77 109 16290 NOR2_X1
* cell instance $31433 m0 *1 91.01,194.6
X$31433 77 15865 16089 15867 16054 8687 109 DFFR_X1
* cell instance $31437 m0 *1 95.76,194.6
X$31437 16091 6459 77 109 16057 NOR2_X1
* cell instance $31438 m0 *1 96.33,194.6
X$31438 16176 4632 16000 77 109 16055 MUX2_X1
* cell instance $31439 m0 *1 97.66,194.6
X$31439 16060 6459 77 109 16058 NOR2_X1
* cell instance $31440 m0 *1 98.23,194.6
X$31440 16095 11128 16178 77 109 16177 MUX2_X1
* cell instance $31442 m0 *1 99.75,194.6
X$31442 16095 7936 16178 77 109 16060 MUX2_X1
* cell instance $31443 m0 *1 101.08,194.6
X$31443 77 15672 16096 16061 16062 8201 109 DFFR_X1
* cell instance $31444 m0 *1 104.88,194.6
X$31444 8870 12709 16061 77 109 16062 MUX2_X1
* cell instance $31445 m0 *1 106.21,194.6
X$31445 8870 77 109 15872 BUF_X2
* cell instance $31447 m0 *1 108.49,194.6
X$31447 14717 7636 16100 77 109 16179 MUX2_X1
* cell instance $31448 m0 *1 109.82,194.6
X$31448 15872 8166 16004 77 109 16001 MUX2_X1
* cell instance $31450 m0 *1 111.34,194.6
X$31450 77 15672 15870 15873 16002 12731 109 DFFR_X1
* cell instance $31451 m0 *1 115.14,194.6
X$31451 77 16101 16097 15969 16066 12731 109 DFFR_X1
* cell instance $31453 m0 *1 119.13,194.6
X$31453 77 7197 109 6742 BUF_X8
* cell instance $31458 r0 *1 91.96,194.6
X$31458 14019 16200 16290 13929 16058 16088 77 109 15568 OAI33_X1
* cell instance $31461 r0 *1 94.24,194.6
X$31461 16407 8689 77 109 16056 NOR2_X1
* cell instance $31462 r0 *1 94.81,194.6
X$31462 16089 9831 16090 77 109 16091 MUX2_X1
* cell instance $31465 r0 *1 97.09,194.6
X$31465 16092 9831 16094 77 109 16175 MUX2_X1
* cell instance $31466 r0 *1 98.42,194.6
X$31466 16177 9429 16295 77 109 16176 MUX2_X1
* cell instance $31467 r0 *1 99.75,194.6
X$31467 16096 11128 16097 77 109 16295 MUX2_X1
* cell instance $31468 r0 *1 101.08,194.6
X$31468 16096 7936 16097 77 109 16098 MUX2_X1
* cell instance $31469 r0 *1 102.41,194.6
X$31469 16098 9030 77 109 16088 NOR2_X1
* cell instance $31472 r0 *1 106.78,194.6
X$31472 77 16343 16095 16100 16179 8201 109 DFFR_X1
* cell instance $31473 r0 *1 110.58,194.6
X$31473 77 15672 16178 16206 16302 8201 109 DFFR_X1
* cell instance $31483 r0 *1 123.12,194.6
X$31483 77 12828 16305 16102 16174 12731 109 DFFR_X1
* cell instance $31484 m0 *1 124.45,194.6
X$31484 16005 13822 15842 77 109 16064 MUX2_X1
* cell instance $31488 m0 *1 126.73,194.6
X$31488 16102 13822 15981 77 109 16174 MUX2_X1
* cell instance $31491 m0 *1 129.77,194.6
X$31491 77 14580 16306 16103 16172 12731 109 DFFR_X1
* cell instance $31492 m0 *1 133.57,194.6
X$31492 16103 15193 15289 77 109 16172 MUX2_X1
* cell instance $31494 m0 *1 136.42,194.6
X$31494 16308 15193 15290 77 109 16171 MUX2_X1
* cell instance $31495 m0 *1 137.75,194.6
X$31495 13437 77 109 15455 CLKBUF_X3
* cell instance $31497 m0 *1 138.89,194.6
X$31497 16170 15193 15675 77 109 16104 MUX2_X1
* cell instance $31499 m0 *1 140.98,194.6
X$31499 16311 14485 16006 77 109 16059 MUX2_X1
* cell instance $31503 r0 *1 126.92,194.6
X$31503 16305 14949 16207 77 109 16173 MUX2_X1
* cell instance $31505 r0 *1 128.63,194.6
X$31505 16208 15193 15650 77 109 16304 MUX2_X1
* cell instance $31506 r0 *1 129.96,194.6
X$31506 77 15455 16209 16210 16307 12731 109 DFFR_X1
* cell instance $31508 r0 *1 133.95,194.6
X$31508 16210 15193 15744 77 109 16307 MUX2_X1
* cell instance $31509 r0 *1 135.28,194.6
X$31509 77 15455 16310 16308 16171 12731 109 DFFR_X1
* cell instance $31511 r0 *1 139.27,194.6
X$31511 77 15455 16309 16170 16104 12731 109 DFFR_X1
* cell instance $31513 r0 *1 143.83,194.6
X$31513 8830 16105 15265 109 16211 77 NOR3_X2
* cell instance $31514 r0 *1 145.16,194.6
X$31514 16105 109 15745 77 BUF_X4
* cell instance $31515 r0 *1 146.49,194.6
X$31515 15195 15885 77 109 16105 NOR2_X2
* cell instance $31517 m0 *1 146.49,194.6
X$31517 15885 14734 15676 77 109 16106 MUX2_X1
* cell instance $31519 m0 *1 148.39,194.6
X$31519 77 15749 16007 16168 16169 12731 109 DFFR_X1
* cell instance $31521 m0 *1 152.19,194.6
X$31521 16168 109 15195 77 BUF_X4
* cell instance $31523 m0 *1 153.71,194.6
X$31523 15881 109 15885 77 BUF_X4
* cell instance $31527 r0 *1 150.1,194.6
X$31527 15885 15071 109 77 16107 AND2_X2
* cell instance $31530 r0 *1 152,194.6
X$31530 16007 16108 8830 77 109 16109 OR3_X1
* cell instance $31532 r0 *1 153.14,194.6
X$31532 16109 77 109 16110 BUF_X2
* cell instance $31533 r0 *1 153.9,194.6
X$31533 15071 15881 77 109 16213 NAND2_X1
* cell instance $31534 r0 *1 154.47,194.6
X$31534 14560 77 109 15749 CLKBUF_X3
* cell instance $31536 m0 *1 155.42,194.6
X$31536 77 15749 16108 16166 16167 12731 109 DFFR_X1
* cell instance $31537 r0 *1 155.42,194.6
X$31537 13234 16214 16110 109 16408 77 OAI21_X1
* cell instance $31538 r0 *1 156.18,194.6
X$31538 15082 77 109 16111 BUF_X2
* cell instance $31539 r0 *1 156.94,194.6
X$31539 12985 16214 16110 109 16313 77 OAI21_X1
* cell instance $31540 r0 *1 157.7,194.6
X$31540 16111 16112 109 77 16350 AND2_X1
* cell instance $31541 r0 *1 158.46,194.6
X$31541 12983 16214 16110 109 16112 77 OAI21_X1
* cell instance $31543 r0 *1 159.41,194.6
X$31543 16107 15078 77 109 16318 NAND2_X1
* cell instance $31545 m0 *1 159.6,194.6
X$31545 16114 13951 16009 77 109 16321 MUX2_X1
* cell instance $31546 m0 *1 161.69,194.6
X$31546 16166 15195 77 109 16162 NAND2_X1
* cell instance $31548 m0 *1 163.78,194.6
X$31548 77 15302 16010 12731 16164 15165 109 DFFR_X2
* cell instance $31549 m0 *1 167.96,194.6
X$31549 16164 77 109 13234 BUF_X2
* cell instance $31551 m0 *1 168.91,194.6
X$31551 15386 15884 77 109 15974 NAND2_X1
* cell instance $31553 m0 *1 170.24,194.6
X$31553 16107 15143 77 109 16219 NAND2_X1
* cell instance $31554 m0 *1 170.81,194.6
X$31554 16107 12896 77 109 16115 NAND2_X1
* cell instance $31558 r0 *1 160.17,194.6
X$31558 77 15749 18706 16114 16321 12731 109 DFFR_X1
* cell instance $31559 r0 *1 163.97,194.6
X$31559 16114 15195 77 109 16322 NAND2_X1
* cell instance $31564 r0 *1 167.39,194.6
X$31564 16107 14617 77 109 16324 NAND2_X1
* cell instance $31566 r0 *1 168.15,194.6
X$31566 13067 16214 16322 109 16216 77 OAI21_X1
* cell instance $31567 r0 *1 168.91,194.6
X$31567 16107 15422 77 109 16217 NAND2_X1
* cell instance $31569 r0 *1 169.67,194.6
X$31569 77 15302 15240 12731 16303 14699 109 DFFR_X2
* cell instance $31574 m0 *1 173.28,194.6
X$31574 15071 15143 77 109 16047 NOR2_X1
* cell instance $31576 r0 *1 173.85,194.6
X$31576 16303 77 109 12811 BUF_X2
* cell instance $31577 r0 *1 174.61,194.6
X$31577 12897 16214 16162 109 16451 77 OAI21_X1
* cell instance $31578 m0 *1 175.75,194.6
X$31578 15071 77 109 15581 CLKBUF_X3
* cell instance $31579 m0 *1 174.99,194.6
X$31579 13234 15758 15755 109 16160 77 OAI21_X1
* cell instance $31580 m0 *1 176.7,194.6
X$31580 16047 12819 15581 77 16158 109 AOI21_X1
* cell instance $31581 m0 *1 177.46,194.6
X$31581 15885 16158 15348 13908 77 109 16157 AOI22_X2
* cell instance $31582 m0 *1 179.17,194.6
X$31582 15885 16044 15348 14959 77 109 16117 AOI22_X2
* cell instance $31585 r0 *1 176.13,194.6
X$31585 15885 16160 15348 15165 77 109 16301 AOI22_X2
* cell instance $31588 r0 *1 178.79,194.6
X$31588 15758 15078 77 109 16116 NOR2_X1
* cell instance $31589 r0 *1 179.36,194.6
X$31589 16296 12823 15581 77 16118 109 AOI21_X1
* cell instance $31591 r0 *1 180.31,194.6
X$31591 15885 16118 15348 14739 77 109 16611 AOI22_X2
* cell instance $31592 m0 *1 182.59,194.6
X$31592 15760 16120 15686 14699 77 109 16033 AOI22_X2
* cell instance $31593 m0 *1 181.26,194.6
X$31593 15348 109 15686 77 BUF_X4
* cell instance $31595 m0 *1 184.49,194.6
X$31595 16121 13112 15581 77 16154 109 AOI21_X1
* cell instance $31597 m0 *1 185.44,194.6
X$31597 15760 16154 15686 14791 77 109 16037 AOI22_X2
* cell instance $31598 m0 *1 187.15,194.6
X$31598 15714 109 16225 77 BUF_X4
* cell instance $31599 m0 *1 188.48,194.6
X$31599 16017 77 109 15523 INV_X1
* cell instance $31600 m0 *1 188.86,194.6
X$31600 77 16151 16019 16036 16152 16037 109 FA_X1
* cell instance $31602 m0 *1 192.66,194.6
X$31602 77 16275 15926 15927 16036 16018 109 FA_X1
* cell instance $31604 m0 *1 195.89,194.6
X$31604 16126 15887 77 109 16020 NAND2_X1
* cell instance $31608 r0 *1 182.21,194.6
X$31608 16286 16223 77 109 16222 NAND2_X2
* cell instance $31610 r0 *1 183.35,194.6
X$31610 77 16228 109 15526 BUF_X8
* cell instance $31611 r0 *1 185.82,194.6
X$31611 77 16226 16282 16017 16038 16227 109 FA_X1
* cell instance $31612 r0 *1 188.86,194.6
X$31612 16282 77 109 15687 INV_X1
* cell instance $31613 r0 *1 189.24,194.6
X$31613 15526 77 109 16123 INV_X2
* cell instance $31614 r0 *1 189.81,194.6
X$31614 16119 15762 77 109 16152 NAND2_X1
* cell instance $31615 r0 *1 190.38,194.6
X$31615 16225 16122 77 109 15936 NAND2_X1
* cell instance $31616 r0 *1 190.95,194.6
X$31616 16126 16122 77 109 16151 NAND2_X1
* cell instance $31617 r0 *1 191.52,194.6
X$31617 15639 16124 77 109 16277 NOR2_X1
* cell instance $31620 r0 *1 192.66,194.6
X$31620 16278 77 109 16275 INV_X1
* cell instance $31621 r0 *1 193.04,194.6
X$31621 15837 109 16122 77 BUF_X4
* cell instance $31622 r0 *1 194.37,194.6
X$31622 15260 15690 77 109 16270 NOR2_X1
* cell instance $31623 r0 *1 194.94,194.6
X$31623 16228 16122 77 109 15889 NAND2_X1
* cell instance $31624 r0 *1 195.51,194.6
X$31624 16124 16125 77 109 15890 NOR2_X1
* cell instance $31625 r0 *1 196.08,194.6
X$31625 15931 16380 77 109 16269 NAND2_X1
* cell instance $31626 r0 *1 196.65,194.6
X$31626 16119 16122 77 109 16263 NAND2_X1
* cell instance $31627 r0 *1 197.22,194.6
X$31627 77 16149 16264 16150 16033 16263 109 FA_X1
* cell instance $31628 m0 *1 198.17,194.6
X$31628 77 16127 16146 15925 16150 16019 109 FA_X1
* cell instance $31629 m0 *1 197.6,194.6
X$31629 15931 15887 77 109 16149 NAND2_X1
* cell instance $31630 m0 *1 201.21,194.6
X$31630 16148 77 109 16127 INV_X1
* cell instance $31631 m0 *1 201.59,194.6
X$31631 77 16230 16148 16032 16130 16021 109 FA_X1
* cell instance $31633 m0 *1 204.82,194.6
X$31633 15445 77 109 16254 INV_X1
* cell instance $31634 m0 *1 205.2,194.6
X$31634 16146 77 109 16031 INV_X1
* cell instance $31637 r0 *1 200.64,194.6
X$31637 16128 77 109 16129 INV_X1
* cell instance $31640 r0 *1 201.59,194.6
X$31640 16123 16125 77 109 16130 NOR2_X1
* cell instance $31643 r0 *1 203.11,194.6
X$31643 15260 16124 77 109 16230 NOR2_X1
* cell instance $31645 r0 *1 204.44,194.6
X$31645 16254 15690 77 109 16145 NOR2_X1
* cell instance $31646 r0 *1 205.01,194.6
X$31646 16254 16124 77 109 16253 NOR2_X1
* cell instance $31648 r0 *1 205.77,194.6
X$31648 16251 16371 16131 109 77 16249 HA_X1
* cell instance $31650 m0 *1 205.96,194.6
X$31650 16022 77 109 16143 INV_X1
* cell instance $31653 m0 *1 207.48,194.6
X$31653 16143 16031 16030 109 77 16142 HA_X1
* cell instance $31654 m0 *1 209.57,194.6
X$31654 16142 77 109 16141 INV_X1
* cell instance $31656 m0 *1 210.14,194.6
X$31656 77 16244 16132 16140 16141 16023 109 FA_X1
* cell instance $31657 m0 *1 213.18,194.6
X$31657 16140 77 109 16138 INV_X1
* cell instance $31660 r0 *1 209.19,194.6
X$31660 16249 16231 15788 109 77 16245 HA_X1
* cell instance $31661 r0 *1 211.09,194.6
X$31661 16245 77 109 16244 INV_X1
* cell instance $31662 r0 *1 211.47,194.6
X$31662 16132 77 109 16139 INV_X1
* cell instance $31666 m0 *1 213.94,194.6
X$31666 16138 16243 15893 109 77 16133 HA_X1
* cell instance $31669 r0 *1 214.13,194.6
X$31669 77 16139 16242 16134 16471 16133 109 FA_X1
* cell instance $31671 r0 *1 217.55,194.6
X$31671 16135 77 109 16240 INV_X1
* cell instance $31672 r0 *1 217.93,194.6
X$31672 16242 16240 16136 109 77 15895 HA_X1
* cell instance $31673 m0 *1 219.26,194.6
X$31673 15768 15905 15769 109 16026 77 OAI21_X1
* cell instance $31674 m0 *1 218.5,194.6
X$31674 16136 77 109 15769 BUF_X2
* cell instance $31675 m0 *1 220.02,194.6
X$31675 16236 15895 15905 77 109 16024 OR3_X4
* cell instance $31676 m0 *1 222.11,194.6
X$31676 15772 16026 16025 77 16363 109 AOI21_X2
* cell instance $31685 r0 *1 220.4,194.6
X$31685 16024 15594 15589 15588 16237 109 77 AOI211_X2
* cell instance $31718 m0 *1 25.08,205.8
X$31718 77 16942 16638 16994 16943 8687 109 DFFR_X1
* cell instance $31730 r0 *1 21.85,205.8
X$31730 77 16942 16734 16944 16995 9814 109 DFFR_X1
* cell instance $31731 r0 *1 25.65,205.8
X$31731 16944 13682 16069 77 109 16995 MUX2_X1
* cell instance $31732 r0 *1 26.98,205.8
X$31732 77 16942 16499 16945 16996 8687 109 DFFR_X1
* cell instance $31733 m0 *1 30.21,205.8
X$31733 77 16942 16735 16946 16998 8687 109 DFFR_X1
* cell instance $31735 m0 *1 34.01,205.8
X$31735 16946 10198 15467 77 109 16998 MUX2_X1
* cell instance $31736 m0 *1 35.34,205.8
X$31736 16735 11276 16855 77 109 16856 MUX2_X1
* cell instance $31737 m0 *1 36.67,205.8
X$31737 16573 77 109 19233 CLKBUF_X1
* cell instance $31739 m0 *1 37.43,205.8
X$31739 77 16573 16639 16947 17001 8687 109 DFFR_X1
* cell instance $31740 m0 *1 41.23,205.8
X$31740 16947 12481 15858 77 109 17001 MUX2_X1
* cell instance $31742 r0 *1 30.78,205.8
X$31742 16945 13149 16069 77 109 16996 MUX2_X1
* cell instance $31746 r0 *1 34.58,205.8
X$31746 77 16573 16736 17073 17000 8687 109 DFFR_X1
* cell instance $31747 r0 *1 38.38,205.8
X$31747 17073 13145 15467 77 109 17000 MUX2_X1
* cell instance $31750 m0 *1 43.13,205.8
X$31750 77 15620 16741 17002 17003 8687 109 DFFR_X1
* cell instance $31752 m0 *1 46.93,205.8
X$31752 16948 10440 16741 77 109 16742 MUX2_X1
* cell instance $31754 m0 *1 49.02,205.8
X$31754 16858 10440 17006 77 109 16910 MUX2_X1
* cell instance $31757 m0 *1 51.3,205.8
X$31757 17010 13926 15467 77 109 17011 MUX2_X1
* cell instance $31759 m0 *1 55.67,205.8
X$31759 77 16330 16747 16950 17013 8687 109 DFFR_X1
* cell instance $31760 m0 *1 59.47,205.8
X$31760 16950 14187 15626 77 109 17013 MUX2_X1
* cell instance $31761 m0 *1 60.8,205.8
X$31761 16860 11563 16749 77 109 16643 MUX2_X1
* cell instance $31765 r0 *1 43.32,205.8
X$31765 17002 13548 15558 77 109 17003 MUX2_X1
* cell instance $31768 r0 *1 45.79,205.8
X$31768 17009 13408 15558 77 109 16949 MUX2_X1
* cell instance $31769 r0 *1 47.12,205.8
X$31769 77 17134 17006 17009 16949 8687 109 DFFR_X1
* cell instance $31770 r0 *1 50.92,205.8
X$31770 77 17134 16859 17010 17011 8687 109 DFFR_X1
* cell instance $31774 r0 *1 58.33,205.8
X$31774 77 17074 15659 16951 17014 8687 109 DFFR_X1
* cell instance $31778 r0 *1 62.13,205.8
X$31778 16951 10508 15626 77 109 17014 MUX2_X1
* cell instance $31781 m0 *1 65.74,205.8
X$31781 16917 13548 16431 77 109 16916 MUX2_X1
* cell instance $31786 r0 *1 66.12,205.8
X$31786 77 17074 16508 16952 17015 8687 109 DFFR_X1
* cell instance $31787 m0 *1 72.77,205.8
X$31787 16954 7153 16861 77 109 17020 MUX2_X1
* cell instance $31788 m0 *1 68.97,205.8
X$31788 77 17074 16954 16953 17018 8687 109 DFFR_X1
* cell instance $31789 m0 *1 74.1,205.8
X$31789 16954 10149 16861 77 109 17025 MUX2_X1
* cell instance $31790 m0 *1 75.43,205.8
X$31790 17020 3978 16921 77 109 16955 MUX2_X1
* cell instance $31791 m0 *1 76.76,205.8
X$31791 16955 3599 17142 77 109 16821 MUX2_X1
* cell instance $31793 m0 *1 78.85,205.8
X$31793 16431 7279 17023 77 109 17022 MUX2_X1
* cell instance $31796 m0 *1 81.13,205.8
X$31796 16862 7153 16956 77 109 16921 MUX2_X1
* cell instance $31797 m0 *1 82.46,205.8
X$31797 16862 8993 16956 77 109 16863 MUX2_X1
* cell instance $31799 m0 *1 84.55,205.8
X$31799 17025 8375 77 109 16753 NOR2_X1
* cell instance $31801 m0 *1 86.64,205.8
X$31801 17029 13408 15872 77 109 16827 MUX2_X1
* cell instance $31803 m0 *1 88.16,205.8
X$31803 17032 13145 15671 77 109 16864 MUX2_X1
* cell instance $31804 m0 *1 89.49,205.8
X$31804 77 16958 16865 17032 16864 8687 109 DFFR_X1
* cell instance $31806 m0 *1 93.48,205.8
X$31806 17038 13682 15671 77 109 16866 MUX2_X1
* cell instance $31807 m0 *1 94.81,205.8
X$31807 77 16958 16092 17038 16866 8201 109 DFFR_X1
* cell instance $31812 r0 *1 69.92,205.8
X$31812 16952 13408 16431 77 109 17015 MUX2_X1
* cell instance $31813 r0 *1 71.25,205.8
X$31813 16431 7636 16953 77 109 17018 MUX2_X1
* cell instance $31816 r0 *1 74.86,205.8
X$31816 17075 8375 17021 77 109 15949 MUX2_X1
* cell instance $31820 r0 *1 78.85,205.8
X$31820 77 16336 16956 17023 17022 8687 109 DFFR_X1
* cell instance $31821 r0 *1 82.65,205.8
X$31821 14049 77 109 16336 CLKBUF_X3
* cell instance $31823 r0 *1 83.98,205.8
X$31823 77 16958 16512 16957 17031 8687 109 DFFR_X1
* cell instance $31824 r0 *1 87.78,205.8
X$31824 16957 13098 15872 77 109 17031 MUX2_X1
* cell instance $31827 r0 *1 91.39,205.8
X$31827 17035 12481 15872 77 109 16959 MUX2_X1
* cell instance $31828 r0 *1 92.72,205.8
X$31828 77 16958 16090 17035 16959 8201 109 DFFR_X1
* cell instance $31829 r0 *1 96.52,205.8
X$31829 17037 14046 15737 77 109 16960 MUX2_X1
* cell instance $31830 r0 *1 97.85,205.8
X$31830 77 16203 16515 17037 16960 8201 109 DFFR_X1
* cell instance $31831 r0 *1 101.65,205.8
X$31831 77 16203 16517 16961 17039 12731 109 DFFR_X1
* cell instance $31832 m0 *1 104.5,205.8
X$31832 77 16343 16868 16926 16867 12731 109 DFFR_X1
* cell instance $31834 m0 *1 108.3,205.8
X$31834 77 16343 16759 16962 17047 12731 109 DFFR_X1
* cell instance $31835 m0 *1 112.1,205.8
X$31835 16435 7279 16962 77 109 17047 MUX2_X1
* cell instance $31840 r0 *1 105.45,205.8
X$31840 16961 13548 16435 77 109 17039 MUX2_X1
* cell instance $31841 r0 *1 106.78,205.8
X$31841 77 16343 16726 17045 17040 12731 109 DFFR_X1
* cell instance $31842 r0 *1 110.58,205.8
X$31842 16435 7636 17045 77 109 17040 MUX2_X1
* cell instance $31850 m0 *1 127.87,205.8
X$31850 16346 16345 16940 109 77 19030 HA_X1
* cell instance $31851 m0 *1 126.73,205.8
X$31851 16941 16940 77 109 16655 XOR2_X1
* cell instance $31853 m0 *1 131.29,205.8
X$31853 16869 77 109 17080 INV_X1
* cell instance $31856 m0 *1 132.62,205.8
X$31856 77 16848 17052 17054 16963 16938 109 FA_X1
* cell instance $31858 m0 *1 135.85,205.8
X$31858 16935 77 109 16936 INV_X1
* cell instance $31859 m0 *1 136.23,205.8
X$31859 77 17056 16871 16872 17231 16936 109 FA_X1
* cell instance $31864 r0 *1 128.44,205.8
X$31864 17079 17051 109 77 17129 XNOR2_X1
* cell instance $31866 r0 *1 132.62,205.8
X$31866 17052 77 109 17128 INV_X1
* cell instance $31868 r0 *1 133.76,205.8
X$31868 17054 77 109 17053 INV_X1
* cell instance $31869 r0 *1 134.14,205.8
X$31869 77 16964 17157 17056 17053 17055 109 FA_X1
* cell instance $31873 r0 *1 139.65,205.8
X$31873 16873 77 109 17232 INV_X1
* cell instance $31875 m0 *1 140.79,205.8
X$31875 77 17061 16965 16966 17059 16931 109 FA_X1
* cell instance $31876 m0 *1 140.41,205.8
X$31876 17081 77 109 16934 INV_X1
* cell instance $31877 m0 *1 143.83,205.8
X$31877 16875 77 109 16850 INV_X1
* cell instance $31878 m0 *1 144.21,205.8
X$31878 16849 16928 17063 109 77 17059 HA_X1
* cell instance $31879 m0 *1 146.11,205.8
X$31879 17064 77 109 16928 INV_X1
* cell instance $31880 m0 *1 146.49,205.8
X$31880 77 16876 17064 16967 16524 16668 109 FA_X1
* cell instance $31881 m0 *1 149.53,205.8
X$31881 15163 109 16781 77 BUF_X4
* cell instance $31884 m0 *1 151.81,205.8
X$31884 16878 77 109 17084 INV_X1
* cell instance $31887 m0 *1 153.14,205.8
X$31887 77 16775 16968 16969 16441 16346 109 FA_X1
* cell instance $31888 m0 *1 156.18,205.8
X$31888 77 16346 17071 16971 16345 16350 109 FA_X1
* cell instance $31890 m0 *1 159.41,205.8
X$31890 77 16346 17072 16882 16775 16540 109 FA_X1
* cell instance $31891 m0 *1 162.45,205.8
X$31891 16881 77 109 16845 INV_X1
* cell instance $31894 r0 *1 140.98,205.8
X$31894 16965 77 109 17158 INV_X1
* cell instance $31898 r0 *1 144.02,205.8
X$31898 16966 77 109 17237 INV_X1
* cell instance $31899 r0 *1 144.4,205.8
X$31899 77 17350 16929 17067 17127 17065 109 FA_X1
* cell instance $31902 r0 *1 148.58,205.8
X$31902 17067 77 109 16877 INV_X1
* cell instance $31903 r0 *1 148.96,205.8
X$31903 16967 77 109 17083 INV_X1
* cell instance $31905 r0 *1 149.53,205.8
X$31905 17281 16359 109 16346 77 AND2_X4
* cell instance $31908 r0 *1 152.95,205.8
X$31908 16968 77 109 17085 INV_X1
* cell instance $31909 r0 *1 153.33,205.8
X$31909 17160 77 109 17070 INV_X1
* cell instance $31911 r0 *1 155.23,205.8
X$31911 17071 77 109 16970 INV_X1
* cell instance $31912 r0 *1 155.61,205.8
X$31912 16969 77 109 17086 INV_X1
* cell instance $31917 r0 *1 158.84,205.8
X$31917 16971 77 109 17247 INV_X1
* cell instance $31919 r0 *1 159.41,205.8
X$31919 17072 77 109 17124 INV_X1
* cell instance $31923 r0 *1 162.45,205.8
X$31923 16882 77 109 17252 INV_X1
* cell instance $31925 r0 *1 163.02,205.8
X$31925 16972 77 109 17123 INV_X1
* cell instance $31926 m0 *1 163.4,205.8
X$31926 77 16447 16972 16973 16775 16346 109 FA_X1
* cell instance $31928 m0 *1 166.44,205.8
X$31928 16883 77 109 17257 INV_X1
* cell instance $31931 m0 *1 169.1,205.8
X$31931 16885 77 109 16974 INV_X1
* cell instance $31932 m0 *1 169.48,205.8
X$31932 16884 77 109 17068 INV_X1
* cell instance $31935 m0 *1 170.81,205.8
X$31935 77 16837 16975 17066 16393 16346 109 FA_X1
* cell instance $31936 m0 *1 173.85,205.8
X$31936 77 16484 17062 16976 16837 16346 109 FA_X1
* cell instance $31937 m0 *1 176.89,205.8
X$31937 77 16837 17060 17048 16451 16346 109 FA_X1
* cell instance $31938 m0 *1 179.93,205.8
X$31938 6564 15484 15832 77 109 16592 MUX2_X1
* cell instance $31939 m0 *1 181.26,205.8
X$31939 7053 15484 8462 77 109 16889 MUX2_X1
* cell instance $31941 m0 *1 182.78,205.8
X$31941 17048 77 109 17049 INV_X1
* cell instance $31947 r0 *1 166.06,205.8
X$31947 16973 77 109 17122 INV_X1
* cell instance $31950 r0 *1 167.58,205.8
X$31950 77 16524 17087 17166 17068 16974 109 FA_X1
* cell instance $31955 r0 *1 171.38,205.8
X$31955 16975 77 109 17261 INV_X1
* cell instance $31959 r0 *1 174.23,205.8
X$31959 17062 77 109 17270 INV_X1
* cell instance $31961 r0 *1 174.8,205.8
X$31961 17066 77 109 17121 INV_X1
* cell instance $31965 r0 *1 176.51,205.8
X$31965 16976 77 109 17058 INV_X1
* cell instance $31966 r0 *1 176.89,205.8
X$31966 17060 77 109 17057 INV_X1
* cell instance $31967 r0 *1 177.27,205.8
X$31967 77 17057 17271 17260 17262 17058 109 FA_X1
* cell instance $31969 r0 *1 180.69,205.8
X$31969 17050 77 109 17089 INV_X1
* cell instance $31971 r0 *1 181.26,205.8
X$31971 77 17049 17050 17046 16887 17090 109 FA_X1
* cell instance $31972 r0 *1 184.3,205.8
X$31972 17046 77 109 17044 INV_X1
* cell instance $31973 r0 *1 184.68,205.8
X$31973 17044 17042 16979 109 77 17091 HA_X1
* cell instance $31974 m0 *1 185.25,205.8
X$31974 17041 77 109 17042 INV_X1
* cell instance $31978 m0 *1 186.01,205.8
X$31978 77 16981 17041 17036 17043 16982 109 FA_X1
* cell instance $31980 m0 *1 190,205.8
X$31980 16983 16359 77 109 17033 NAND2_X1
* cell instance $31981 m0 *1 190.57,205.8
X$31981 77 15810 17034 17172 17033 16890 109 FA_X1
* cell instance $31982 m0 *1 193.61,205.8
X$31982 16891 16380 77 109 17030 NAND2_X1
* cell instance $31983 m0 *1 194.18,205.8
X$31983 16891 16360 77 109 16915 NAND2_X2
* cell instance $31984 m0 *1 195.13,205.8
X$31984 77 17027 17109 17026 16611 16915 109 FA_X1
* cell instance $31986 m0 *1 198.36,205.8
X$31986 77 16816 17214 16913 17026 17024 109 FA_X1
* cell instance $31987 m0 *1 201.4,205.8
X$31987 77 17019 16984 17008 16985 16892 109 FA_X1
* cell instance $31989 m0 *1 204.63,205.8
X$31989 15445 16228 77 109 17017 NAND2_X1
* cell instance $31990 m0 *1 205.2,205.8
X$31990 17016 16287 77 109 17012 NAND2_X1
* cell instance $31995 r0 *1 187.91,205.8
X$31995 16980 77 109 16982 INV_X1
* cell instance $31996 r0 *1 188.29,205.8
X$31996 16823 15762 77 109 17119 NAND2_X1
* cell instance $31997 r0 *1 188.86,205.8
X$31997 17036 77 109 17115 INV_X2
* cell instance $31998 r0 *1 189.43,205.8
X$31998 17118 15762 77 109 17112 NAND2_X1
* cell instance $31999 r0 *1 190,205.8
X$31999 16983 15762 77 109 17028 NAND2_X1
* cell instance $32003 r0 *1 191.9,205.8
X$32003 17117 15887 77 109 16890 NAND2_X1
* cell instance $32004 r0 *1 192.47,205.8
X$32004 77 17030 17110 17108 16301 17028 109 FA_X1
* cell instance $32007 r0 *1 196.08,205.8
X$32007 17234 109 16457 77 BUF_X4
* cell instance $32010 r0 *1 200.64,205.8
X$32010 16984 77 109 17024 INV_X1
* cell instance $32013 r0 *1 202.16,205.8
X$32013 16482 16561 77 109 16985 NOR2_X1
* cell instance $32014 r0 *1 202.73,205.8
X$32014 15823 16229 77 109 17019 NOR2_X2
* cell instance $32016 r0 *1 203.87,205.8
X$32016 77 16986 17094 16912 17017 17012 109 FA_X1
* cell instance $32017 m0 *1 206.72,205.8
X$32017 16913 77 109 16911 INV_X2
* cell instance $32018 m0 *1 206.15,205.8
X$32018 16889 16225 77 109 16986 NAND2_X1
* cell instance $32019 m0 *1 207.29,205.8
X$32019 16854 77 109 17007 INV_X1
* cell instance $32020 m0 *1 207.67,205.8
X$32020 17007 15690 77 109 16894 NOR2_X1
* cell instance $32022 m0 *1 209,205.8
X$32022 16911 16906 16784 109 77 17096 HA_X1
* cell instance $32024 m0 *1 211.09,205.8
X$32024 16987 16907 16905 109 77 17005 HA_X1
* cell instance $32026 m0 *1 213.18,205.8
X$32026 17005 77 109 16895 INV_X1
* cell instance $32029 m0 *1 216.79,205.8
X$32029 17101 16899 77 109 14737 XNOR2_X2
* cell instance $32030 m0 *1 218.69,205.8
X$32030 16902 77 109 16991 INV_X1
* cell instance $32031 m0 *1 219.07,205.8
X$32031 16794 16999 16997 77 16900 109 AOI21_X1
* cell instance $32032 m0 *1 219.83,205.8
X$32032 16999 17097 17099 109 77 16899 OAI21_X2
* cell instance $32033 m0 *1 221.16,205.8
X$32033 16788 16992 109 15296 77 XOR2_X2
* cell instance $32035 m0 *1 223.06,205.8
X$32035 16991 17098 16466 109 77 16789 HA_X1
* cell instance $32036 m0 *1 224.96,205.8
X$32036 16997 77 109 16791 INV_X2
* cell instance $32043 r0 *1 207.48,205.8
X$32043 17008 77 109 17095 INV_X1
* cell instance $32046 r0 *1 214.32,205.8
X$32046 17102 17193 77 109 16548 XNOR2_X2
* cell instance $32047 r0 *1 216.22,205.8
X$32047 16457 17178 17102 77 109 16896 AND3_X4
* cell instance $32048 r0 *1 218.31,205.8
X$32048 77 16568 16988 16999 16997 109 AOI21_X4
* cell instance $32049 r0 *1 220.78,205.8
X$32049 16989 16993 77 109 15295 XNOR2_X2
* cell instance $32050 r0 *1 222.68,205.8
X$32050 16990 16992 16897 77 16993 109 AOI21_X2
* cell instance $32123 m0 *1 152.19,233.8
X$32123 17280 16983 77 109 18151 NAND2_X1
* cell instance $32124 m0 *1 149.15,233.8
X$32124 77 18190 18059 18155 18150 18151 109 FA_X1
* cell instance $32125 m0 *1 152.76,233.8
X$32125 18066 16891 77 109 18190 NAND2_X1
* cell instance $32127 m0 *1 156.37,233.8
X$32127 17280 16891 77 109 18191 NAND2_X1
* cell instance $32128 m0 *1 156.94,233.8
X$32128 77 18191 18153 18157 18193 18158 109 FA_X1
* cell instance $32131 m0 *1 162.26,233.8
X$32131 17348 15010 77 109 18158 NAND2_X1
* cell instance $32133 m0 *1 164.35,233.8
X$32133 18195 77 109 18194 INV_X1
* cell instance $32136 m0 *1 165.68,233.8
X$32136 77 18134 18195 18135 18162 18161 109 FA_X1
* cell instance $32137 m0 *1 168.72,233.8
X$32137 77 18196 18106 18176 18136 18166 109 FA_X1
* cell instance $32138 m0 *1 171.76,233.8
X$32138 17633 15528 77 109 18137 NOR2_X1
* cell instance $32140 m0 *1 173.09,233.8
X$32140 18138 77 109 18168 INV_X1
* cell instance $32141 m0 *1 173.47,233.8
X$32141 77 18139 18108 18109 18232 18168 109 FA_X1
* cell instance $32142 m0 *1 176.51,233.8
X$32142 77 18198 18170 18200 18169 18171 109 FA_X1
* cell instance $32143 m0 *1 179.55,233.8
X$32143 17879 15528 77 109 18171 NOR2_X1
* cell instance $32144 m0 *1 180.12,233.8
X$32144 18172 77 109 18173 INV_X1
* cell instance $32145 m0 *1 180.5,233.8
X$32145 18200 77 109 18174 INV_X1
* cell instance $32152 r0 *1 157.32,233.8
X$32152 18066 16549 77 109 18193 NAND2_X1
* cell instance $32156 r0 *1 159.22,233.8
X$32156 17280 16549 77 109 18223 NAND2_X1
* cell instance $32157 r0 *1 159.79,233.8
X$32157 17412 16051 77 109 18206 NAND2_X1
* cell instance $32159 r0 *1 160.74,233.8
X$32159 16312 15528 77 109 18207 NAND2_X1
* cell instance $32162 r0 *1 163.21,233.8
X$32162 15839 16051 77 109 18225 NAND2_X1
* cell instance $32164 r0 *1 163.97,233.8
X$32164 18066 16543 77 109 18208 NAND2_X1
* cell instance $32167 r0 *1 166.25,233.8
X$32167 77 18227 18105 18007 18229 18164 109 FA_X1
* cell instance $32170 r0 *1 170.24,233.8
X$32170 17879 15836 77 109 18196 NOR2_X1
* cell instance $32171 r0 *1 170.81,233.8
X$32171 15839 16543 77 109 18210 NAND2_X1
* cell instance $32176 r0 *1 171.76,233.8
X$32176 18176 77 109 18231 INV_X1
* cell instance $32179 r0 *1 178.98,233.8
X$32179 15839 16119 77 109 18213 NAND2_X1
* cell instance $32183 m0 *1 182.21,233.8
X$32183 77 18201 18140 18175 18204 18111 109 FA_X1
* cell instance $32185 m0 *1 185.25,233.8
X$32185 16312 16224 77 109 18204 NAND2_X1
* cell instance $32188 r0 *1 182.02,233.8
X$32188 17633 16482 77 109 18237 NOR2_X1
* cell instance $32189 r0 *1 182.59,233.8
X$32189 17971 15528 77 109 18238 NOR2_X1
* cell instance $32190 r0 *1 183.16,233.8
X$32190 77 18035 109 15346 BUF_X8
* cell instance $32191 r0 *1 185.63,233.8
X$32191 77 18205 18177 18203 18239 18178 109 FA_X1
* cell instance $32192 m0 *1 187.53,233.8
X$32192 16051 17970 77 109 18205 NAND2_X1
* cell instance $32193 m0 *1 186.96,233.8
X$32193 16549 18035 77 109 18178 NAND2_X1
* cell instance $32198 r0 *1 189.62,233.8
X$32198 77 18203 17923 18199 18241 18215 109 FA_X1
* cell instance $32199 m0 *1 190.19,233.8
X$32199 77 18199 17853 17940 18202 18163 109 FA_X1
* cell instance $32201 m0 *1 193.23,233.8
X$32201 18141 77 109 18163 INV_X1
* cell instance $32204 m0 *1 195.32,233.8
X$32204 17702 15931 77 109 18180 NAND2_X1
* cell instance $32207 m0 *1 198.17,233.8
X$32207 18183 77 109 18117 INV_X1
* cell instance $32209 m0 *1 199.31,233.8
X$32209 17702 16119 77 109 18197 NAND2_X1
* cell instance $32210 m0 *1 199.88,233.8
X$32210 77 18189 18046 18152 18192 18154 109 FA_X1
* cell instance $32215 r0 *1 194.18,233.8
X$32215 16854 16543 77 109 18240 NAND2_X1
* cell instance $32216 r0 *1 194.75,233.8
X$32216 16051 18035 77 109 18233 NAND2_X2
* cell instance $32217 r0 *1 195.7,233.8
X$32217 77 18184 17990 18183 18181 18182 109 FA_X1
* cell instance $32218 r0 *1 198.74,233.8
X$32218 77 18222 18184 18011 18197 18217 109 FA_X1
* cell instance $32220 r0 *1 202.16,233.8
X$32220 77 18218 18118 18219 18221 18220 109 FA_X1
* cell instance $32221 r0 *1 205.2,233.8
X$32221 77 18188 17856 18186 18187 18219 109 FA_X1
* cell instance $32222 m0 *1 205.77,233.8
X$32222 17970 16228 77 109 18147 NAND2_X1
* cell instance $32224 m0 *1 206.34,233.8
X$32224 18142 77 109 18187 INV_X1
* cell instance $32225 m0 *1 206.72,233.8
X$32225 77 18185 18188 18145 18143 18147 109 FA_X1
* cell instance $32227 r0 *1 208.24,233.8
X$32227 18186 77 109 18070 INV_X1
* cell instance $32230 m0 *1 210.14,233.8
X$32230 18145 77 109 18144 INV_X1
* cell instance $32254 m0 *1 18.81,197.4
X$32254 77 15851 16181 16180 16239 9814 109 DFFR_X1
* cell instance $32255 m0 *1 22.61,197.4
X$32255 16180 4768 16069 77 109 16239 MUX2_X1
* cell instance $32258 m0 *1 27.17,197.4
X$32258 16181 15375 16182 77 109 16183 MUX2_X1
* cell instance $32270 r0 *1 22.04,197.4
X$32270 16366 4128 16069 77 109 16367 MUX2_X1
* cell instance $32271 r0 *1 23.37,197.4
X$32271 77 15851 16422 16366 16367 9814 109 DFFR_X1
* cell instance $32272 r0 *1 27.17,197.4
X$32272 16181 10966 16182 77 109 16325 MUX2_X1
* cell instance $32273 r0 *1 28.5,197.4
X$32273 16325 10283 16373 77 109 16377 MUX2_X1
* cell instance $32275 m0 *1 28.88,197.4
X$32275 16183 6231 16184 77 109 15994 MUX2_X1
* cell instance $32276 m0 *1 30.97,197.4
X$32276 16326 8407 16327 77 109 16375 MUX2_X1
* cell instance $32280 r0 *1 29.83,197.4
X$32280 16499 10966 16423 77 109 16326 MUX2_X1
* cell instance $32281 r0 *1 31.16,197.4
X$32281 16424 10966 16478 77 109 16327 MUX2_X1
* cell instance $32282 r0 *1 32.49,197.4
X$32282 16375 10368 16377 77 109 16376 MUX2_X1
* cell instance $32285 r0 *1 34.39,197.4
X$32285 16378 13408 15167 77 109 16480 MUX2_X1
* cell instance $32286 m0 *1 35.15,197.4
X$32286 77 16573 16072 16255 16186 4086 109 DFFR_X1
* cell instance $32291 m0 *1 41.42,197.4
X$32291 77 15620 16188 16187 16259 4086 109 DFFR_X1
* cell instance $32292 m0 *1 45.22,197.4
X$32292 16187 4768 15467 77 109 16259 MUX2_X1
* cell instance $32293 m0 *1 46.55,197.4
X$32293 15620 77 109 19235 CLKBUF_X1
* cell instance $32294 m0 *1 47.12,197.4
X$32294 16188 10440 16156 77 109 16189 MUX2_X1
* cell instance $32301 r0 *1 42.75,197.4
X$32301 16379 4126 15858 77 109 16382 MUX2_X1
* cell instance $32302 r0 *1 44.08,197.4
X$32302 77 15620 16075 16379 16382 4086 109 DFFR_X1
* cell instance $32303 r0 *1 47.88,197.4
X$32303 16189 10283 16426 77 109 16328 MUX2_X1
* cell instance $32304 r0 *1 49.21,197.4
X$32304 16641 10368 16328 77 109 16329 MUX2_X1
* cell instance $32306 r0 *1 50.92,197.4
X$32306 77 15369 16428 16190 16383 8687 109 DFFR_X1
* cell instance $32307 m0 *1 51.3,197.4
X$32307 16190 14047 15467 77 109 16383 MUX2_X1
* cell instance $32313 r0 *1 55.86,197.4
X$32313 77 16330 16429 16488 16385 8687 109 DFFR_X1
* cell instance $32317 m0 *1 60.42,197.4
X$32317 16192 9429 16332 77 109 16271 MUX2_X1
* cell instance $32318 m0 *1 59.09,197.4
X$32318 16191 11563 16429 77 109 16192 MUX2_X1
* cell instance $32321 m0 *1 63.46,197.4
X$32321 16274 13146 14712 77 109 16273 MUX2_X1
* cell instance $32325 m0 *1 67.26,197.4
X$32325 77 15126 16276 16389 16334 8687 109 DFFR_X1
* cell instance $32326 m0 *1 71.06,197.4
X$32326 16194 10435 16196 77 109 16195 MUX2_X1
* cell instance $32328 m0 *1 72.58,197.4
X$32328 16194 7936 16196 77 109 16280 MUX2_X1
* cell instance $32333 r0 *1 60.04,197.4
X$32333 16489 10283 16331 77 109 16333 MUX2_X1
* cell instance $32334 r0 *1 61.37,197.4
X$32334 16333 10368 16430 77 109 15124 MUX2_X1
* cell instance $32336 r0 *1 63.08,197.4
X$32336 14135 77 109 15861 CLKBUF_X3
* cell instance $32337 r0 *1 64.03,197.4
X$32337 15861 77 109 19315 CLKBUF_X1
* cell instance $32341 r0 *1 67.26,197.4
X$32341 16389 4768 15566 77 109 16334 MUX2_X1
* cell instance $32343 r0 *1 69.35,197.4
X$32343 77 15126 16196 16496 16495 8687 109 DFFR_X1
* cell instance $32346 r0 *1 75.05,197.4
X$32346 16431 8008 16395 77 109 16335 MUX2_X1
* cell instance $32347 r0 *1 76.38,197.4
X$32347 77 15630 16397 16395 16335 8687 109 DFFR_X1
* cell instance $32348 m0 *1 76.76,197.4
X$32348 16197 14046 15434 77 109 16281 MUX2_X1
* cell instance $32350 m0 *1 78.09,197.4
X$32350 16431 8232 16283 77 109 16284 MUX2_X1
* cell instance $32351 m0 *1 79.42,197.4
X$32351 77 16336 15736 16283 16284 8687 109 DFFR_X1
* cell instance $32353 r0 *1 80.18,197.4
X$32353 15736 7153 16397 77 109 16432 MUX2_X1
* cell instance $32356 r0 *1 83.22,197.4
X$32356 77 16336 16085 16337 16401 8687 109 DFFR_X1
* cell instance $32357 m0 *1 87.4,197.4
X$32357 16199 13149 15872 77 109 16289 MUX2_X1
* cell instance $32358 m0 *1 83.6,197.4
X$32358 77 15865 16198 16199 16289 8687 109 DFFR_X1
* cell instance $32361 m0 *1 91.01,197.4
X$32361 16291 9631 15671 77 109 16404 MUX2_X1
* cell instance $32362 m0 *1 92.34,197.4
X$32362 16201 5536 16292 77 109 15344 MUX2_X1
* cell instance $32365 m0 *1 94.62,197.4
X$32365 16089 11128 16090 77 109 16202 MUX2_X1
* cell instance $32366 m0 *1 95.95,197.4
X$32366 16202 9429 16294 77 109 16000 MUX2_X1
* cell instance $32367 m0 *1 97.28,197.4
X$32367 16092 11128 16094 77 109 16294 MUX2_X1
* cell instance $32370 m0 *1 100.32,197.4
X$32370 16297 14047 15737 77 109 16204 MUX2_X1
* cell instance $32371 m0 *1 101.65,197.4
X$32371 77 16203 16298 16297 16204 8201 109 DFFR_X1
* cell instance $32374 r0 *1 87.02,197.4
X$32374 16337 13548 15872 77 109 16401 MUX2_X1
* cell instance $32377 r0 *1 89.3,197.4
X$32377 77 16338 16339 16291 16404 8687 109 DFFR_X1
* cell instance $32378 r0 *1 93.1,197.4
X$32378 16339 10149 16340 77 109 16407 MUX2_X1
* cell instance $32380 r0 *1 94.62,197.4
X$32380 77 16338 16094 16610 16409 8201 109 DFFR_X1
* cell instance $32383 r0 *1 99.56,197.4
X$32383 16411 13767 15737 77 109 16413 MUX2_X1
* cell instance $32384 r0 *1 100.89,197.4
X$32384 77 16338 16341 16411 16413 8201 109 DFFR_X1
* cell instance $32385 r0 *1 104.69,197.4
X$32385 16298 10435 16341 77 109 16292 MUX2_X1
* cell instance $32387 r0 *1 106.21,197.4
X$32387 16341 7447 16342 77 109 16414 MUX2_X1
* cell instance $32389 m0 *1 106.59,197.4
X$32389 16298 7335 16205 77 109 16415 MUX2_X1
* cell instance $32391 r0 *1 107.54,197.4
X$32391 16415 8993 16414 77 109 15740 MUX2_X1
* cell instance $32393 r0 *1 109.06,197.4
X$32393 16205 3183 16342 77 109 16433 MUX2_X1
* cell instance $32394 r0 *1 110.39,197.4
X$32394 77 16343 16205 16344 16420 8201 109 DFFR_X1
* cell instance $32395 m0 *1 111.53,197.4
X$32395 15672 77 109 19104 INV_X2
* cell instance $32398 m0 *1 112.86,197.4
X$32398 15872 6993 16206 77 109 16302 MUX2_X1
* cell instance $32408 r0 *1 115.14,197.4
X$32408 77 16101 16342 16418 16419 12731 109 DFFR_X1
* cell instance $32409 r0 *1 118.94,197.4
X$32409 16435 8235 16418 77 109 16419 MUX2_X1
* cell instance $32413 m0 *1 124.64,197.4
X$32413 77 12828 16207 16208 16304 12731 109 DFFR_X1
* cell instance $32417 m0 *1 132.24,197.4
X$32417 16209 14949 16306 77 109 15879 MUX2_X1
* cell instance $32422 r0 *1 134.14,197.4
X$32422 77 16319 16436 16416 16345 16346 109 FA_X1
* cell instance $32423 r0 *1 137.18,197.4
X$32423 16416 77 109 16492 INV_X1
* cell instance $32424 r0 *1 137.56,197.4
X$32424 16417 77 109 16437 INV_X1
* cell instance $32426 r0 *1 138.32,197.4
X$32426 77 16345 16417 16621 16402 16346 109 FA_X1
* cell instance $32428 m0 *1 140.03,197.4
X$32428 16310 14949 16309 77 109 16311 MUX2_X1
* cell instance $32431 m0 *1 146.11,197.4
X$32431 16111 16313 109 77 16412 AND2_X1
* cell instance $32434 r0 *1 142.12,197.4
X$32434 77 16346 16438 16625 16345 16412 109 FA_X1
* cell instance $32435 r0 *1 145.16,197.4
X$32435 14338 16111 77 16667 109 NAND2_X4
* cell instance $32452 m0 *1 24.7,208.6
X$32452 16942 77 109 19207 CLKBUF_X1
* cell instance $32454 m0 *1 25.27,208.6
X$32454 16994 13146 16069 77 109 16943 MUX2_X1
* cell instance $32456 m0 *1 26.79,208.6
X$32456 77 16942 16424 17130 17100 8687 109 DFFR_X1
* cell instance $32457 m0 *1 30.59,208.6
X$32457 17130 13098 16069 77 109 17100 MUX2_X1
* cell instance $32460 m0 *1 35.72,208.6
X$32460 77 16573 16737 17132 17181 8687 109 DFFR_X1
* cell instance $32461 m0 *1 39.52,208.6
X$32461 77 17134 16739 17135 17106 8687 109 DFFR_X1
* cell instance $32462 m0 *1 43.32,208.6
X$32462 17135 13146 15858 77 109 17106 MUX2_X1
* cell instance $32467 r0 *1 26.6,208.6
X$32467 14461 77 109 16942 CLKBUF_X3
* cell instance $32472 r0 *1 30.4,208.6
X$32472 77 16942 16855 17131 17179 8687 109 DFFR_X1
* cell instance $32473 r0 *1 34.2,208.6
X$32473 17131 14187 15467 77 109 17179 MUX2_X1
* cell instance $32476 r0 *1 39.33,208.6
X$32476 17132 12312 15467 77 109 17181 MUX2_X1
* cell instance $32479 r0 *1 41.8,208.6
X$32479 17133 13682 15858 77 109 17272 MUX2_X1
* cell instance $32480 r0 *1 43.13,208.6
X$32480 77 17134 16948 17136 17183 8687 109 DFFR_X1
* cell instance $32481 m0 *1 45.98,208.6
X$32481 14135 77 109 17134 CLKBUF_X3
* cell instance $32486 m0 *1 49.4,208.6
X$32486 17186 14046 15467 77 109 17137 MUX2_X1
* cell instance $32487 m0 *1 50.73,208.6
X$32487 77 17134 16746 17186 17137 8687 109 DFFR_X1
* cell instance $32488 m0 *1 54.53,208.6
X$32488 77 16330 16809 17114 17187 8687 109 DFFR_X1
* cell instance $32489 m0 *1 58.33,208.6
X$32489 77 17074 16749 17138 17188 8687 109 DFFR_X1
* cell instance $32491 m0 *1 62.32,208.6
X$32491 17138 13145 15626 77 109 17188 MUX2_X1
* cell instance $32493 m0 *1 64.41,208.6
X$32493 14135 77 109 17074 CLKBUF_X3
* cell instance $32494 m0 *1 65.36,208.6
X$32494 17074 77 109 19242 CLKBUF_X1
* cell instance $32497 m0 *1 73.53,208.6
X$32497 17191 10149 17140 77 109 17075 MUX2_X1
* cell instance $32498 m0 *1 74.86,208.6
X$32498 17274 10149 17076 77 109 17021 MUX2_X1
* cell instance $32501 r0 *1 46.93,208.6
X$32501 17136 13149 15858 77 109 17183 MUX2_X1
* cell instance $32502 r0 *1 48.26,208.6
X$32502 17185 13098 15858 77 109 17273 MUX2_X1
* cell instance $32507 r0 *1 55.29,208.6
X$32507 17114 10198 15626 77 109 17187 MUX2_X1
* cell instance $32509 r0 *1 56.81,208.6
X$32509 77 16330 16860 17312 17310 8687 109 DFFR_X1
* cell instance $32515 r0 *1 63.84,208.6
X$32515 77 17074 16750 17139 17189 8687 109 DFFR_X1
* cell instance $32516 r0 *1 67.64,208.6
X$32516 17139 13149 15566 77 109 17189 MUX2_X1
* cell instance $32518 r0 *1 69.73,208.6
X$32518 77 17074 17191 17373 17314 8687 109 DFFR_X1
* cell instance $32521 r0 *1 74.1,208.6
X$32521 17191 7153 17140 77 109 17141 MUX2_X1
* cell instance $32522 r0 *1 75.43,208.6
X$32522 17141 3978 17318 77 109 17142 MUX2_X1
* cell instance $32524 r0 *1 77.52,208.6
X$32524 17320 14187 15434 77 109 17319 MUX2_X1
* cell instance $32526 r0 *1 79.23,208.6
X$32526 17143 7153 17077 77 109 17144 MUX2_X1
* cell instance $32528 m0 *1 79.61,208.6
X$32528 17143 4914 17077 77 109 16285 MUX2_X1
* cell instance $32529 r0 *1 80.56,208.6
X$32529 17144 3978 17198 77 109 16646 MUX2_X1
* cell instance $32530 m0 *1 81.51,208.6
X$32530 16336 77 109 19236 CLKBUF_X1
* cell instance $32534 m0 *1 85.31,208.6
X$32534 17202 14187 15737 77 109 17126 MUX2_X1
* cell instance $32537 m0 *1 88.35,208.6
X$32537 17276 11240 17277 77 109 17145 MUX2_X1
* cell instance $32538 m0 *1 89.68,208.6
X$32538 17145 3622 17078 77 109 15955 MUX2_X1
* cell instance $32542 r0 *1 81.89,208.6
X$32542 17196 7153 17200 77 109 17198 MUX2_X1
* cell instance $32543 r0 *1 83.22,208.6
X$32543 17196 4914 17200 77 109 16084 MUX2_X1
* cell instance $32545 r0 *1 84.93,208.6
X$32545 77 16958 17277 17202 17126 8687 109 DFFR_X1
* cell instance $32547 r0 *1 89.49,208.6
X$32547 17208 11240 17206 77 109 17078 MUX2_X1
* cell instance $32548 r0 *1 90.82,208.6
X$32548 17208 3183 17206 77 109 17210 MUX2_X1
* cell instance $32549 r0 *1 92.15,208.6
X$32549 17323 3791 17210 77 109 16722 MUX2_X1
* cell instance $32551 r0 *1 93.86,208.6
X$32551 17147 8993 17146 77 109 17148 MUX2_X1
* cell instance $32552 r0 *1 95.19,208.6
X$32552 17147 3183 17146 77 109 17149 MUX2_X1
* cell instance $32553 m0 *1 95.38,208.6
X$32553 17148 3622 17211 77 109 16093 MUX2_X1
* cell instance $32556 m0 *1 98.23,208.6
X$32556 17215 13149 15339 77 109 17216 MUX2_X1
* cell instance $32557 m0 *1 99.56,208.6
X$32557 77 16203 16516 17215 17216 12731 109 DFFR_X1
* cell instance $32560 m0 *1 104.31,208.6
X$32560 17219 13408 16435 77 109 17153 MUX2_X1
* cell instance $32561 m0 *1 105.64,208.6
X$32561 77 16343 16839 17219 17153 12731 109 DFFR_X1
* cell instance $32568 r0 *1 96.52,208.6
X$32568 17149 3791 17213 77 109 17150 MUX2_X1
* cell instance $32569 r0 *1 97.85,208.6
X$32569 17212 3183 17151 77 109 17213 MUX2_X1
* cell instance $32570 r0 *1 99.18,208.6
X$32570 17212 11240 17151 77 109 17211 MUX2_X1
* cell instance $32571 r0 *1 100.51,208.6
X$32571 77 16203 16757 17152 17220 12731 109 DFFR_X1
* cell instance $32572 r0 *1 104.31,208.6
X$32572 17152 13098 16435 77 109 17220 MUX2_X1
* cell instance $32585 r0 *1 126.35,208.6
X$32585 17437 17224 109 77 17340 XNOR2_X1
* cell instance $32586 m0 *1 128.44,208.6
X$32586 17225 17129 109 77 17154 XNOR2_X1
* cell instance $32587 m0 *1 127.3,208.6
X$32587 17228 16656 77 109 17225 XOR2_X1
* cell instance $32591 r0 *1 128.63,208.6
X$32591 17154 17155 109 77 17156 XNOR2_X1
* cell instance $32592 r0 *1 129.77,208.6
X$32592 17156 17328 109 77 17227 XNOR2_X1
* cell instance $32593 m0 *1 130.15,208.6
X$32593 77 17332 17228 17230 17396 17080 109 FA_X1
* cell instance $32595 m0 *1 133.19,208.6
X$32595 77 17230 17229 16870 17157 17128 109 FA_X1
* cell instance $32599 m0 *1 140.22,208.6
X$32599 77 17236 17081 16875 17158 17235 109 FA_X1
* cell instance $32600 m0 *1 143.26,208.6
X$32600 77 17237 17236 17065 17347 17082 109 FA_X1
* cell instance $32601 m0 *1 146.3,208.6
X$32601 17239 77 109 17127 INV_X1
* cell instance $32606 r0 *1 137.75,208.6
X$32606 77 17440 17231 17235 17232 17495 109 FA_X1
* cell instance $32610 r0 *1 145.54,208.6
X$32610 77 17241 17239 17282 17063 17159 109 FA_X1
* cell instance $32611 m0 *1 148.01,208.6
X$32611 17242 77 109 17125 INV_X1
* cell instance $32613 m0 *1 148.39,208.6
X$32613 17083 17125 17240 109 77 17241 HA_X1
* cell instance $32614 m0 *1 150.29,208.6
X$32614 77 17085 17242 17244 16524 17084 109 FA_X1
* cell instance $32617 r0 *1 151.62,208.6
X$32617 17283 77 109 17069 INV_X1
* cell instance $32620 r0 *1 153.14,208.6
X$32620 17244 77 109 17336 INV_X1
* cell instance $32621 r0 *1 153.52,208.6
X$32621 17161 77 109 17335 INV_X1
* cell instance $32623 m0 *1 153.71,208.6
X$32623 77 17086 17161 17245 16524 16970 109 FA_X1
* cell instance $32625 m0 *1 157.7,208.6
X$32625 77 16524 17162 17251 17247 17124 109 FA_X1
* cell instance $32630 r0 *1 156.56,208.6
X$32630 17245 77 109 17284 INV_X1
* cell instance $32633 r0 *1 157.51,208.6
X$32633 17162 77 109 17285 INV_X1
* cell instance $32635 r0 *1 159.41,208.6
X$32635 17333 17331 16537 109 77 16675 HA_X1
* cell instance $32636 m0 *1 161.31,208.6
X$32636 77 16524 17250 17164 17252 17123 109 FA_X1
* cell instance $32638 m0 *1 164.35,208.6
X$32638 77 17257 17254 17259 16524 17122 109 FA_X1
* cell instance $32639 m0 *1 167.39,208.6
X$32639 17259 77 109 17258 INV_X1
* cell instance $32640 m0 *1 167.77,208.6
X$32640 17087 77 109 17165 INV_X1
* cell instance $32643 r0 *1 161.31,208.6
X$32643 17250 77 109 17330 INV_X1
* cell instance $32644 r0 *1 161.69,208.6
X$32644 17251 77 109 17427 INV_X1
* cell instance $32647 r0 *1 163.97,208.6
X$32647 17164 77 109 17286 INV_X1
* cell instance $32648 r0 *1 164.35,208.6
X$32648 17254 77 109 17163 INV_X1
* cell instance $32651 r0 *1 167.01,208.6
X$32651 17258 17165 17508 109 77 17579 HA_X1
* cell instance $32654 r0 *1 169.86,208.6
X$32654 17088 77 109 17289 INV_X1
* cell instance $32655 m0 *1 170.24,208.6
X$32655 77 17264 17088 17265 17261 16886 109 FA_X1
* cell instance $32658 m0 *1 173.47,208.6
X$32658 77 17167 17266 17269 17270 17121 109 FA_X1
* cell instance $32660 m0 *1 177.27,208.6
X$32660 17271 77 109 17168 INV_X1
* cell instance $32664 m0 *1 180.12,208.6
X$32664 17260 77 109 17255 INV_X1
* cell instance $32665 m0 *1 180.5,208.6
X$32665 17255 17089 17249 109 77 17170 HA_X1
* cell instance $32667 m0 *1 183.16,208.6
X$32667 17584 77 109 17090 INV_X1
* cell instance $32669 m0 *1 184.3,208.6
X$32669 77 17091 16778 17246 17249 17120 109 FA_X1
* cell instance $32670 m0 *1 187.34,208.6
X$32670 77 17119 17116 17226 16157 17243 109 FA_X1
* cell instance $32671 m0 *1 190.38,208.6
X$32671 77 17112 17111 17093 16117 17238 109 FA_X1
* cell instance $32674 r0 *1 170.24,208.6
X$32674 17166 77 109 17290 INV_X1
* cell instance $32676 r0 *1 170.81,208.6
X$32676 15578 16667 77 109 17263 OR2_X1
* cell instance $32682 r0 *1 172.71,208.6
X$32682 17263 77 109 17357 INV_X1
* cell instance $32683 r0 *1 173.09,208.6
X$32683 17265 77 109 17267 INV_X1
* cell instance $32684 r0 *1 173.47,208.6
X$32684 17266 77 109 17268 INV_X1
* cell instance $32686 r0 *1 174.04,208.6
X$32686 17267 17268 17291 109 77 17583 HA_X1
* cell instance $32687 r0 *1 175.94,208.6
X$32687 17326 77 109 17167 INV_X1
* cell instance $32690 r0 *1 177.27,208.6
X$32690 17269 77 109 17293 INV_X1
* cell instance $32691 r0 *1 177.65,208.6
X$32691 17293 17168 17169 109 77 17294 HA_X1
* cell instance $32694 r0 *1 180.12,208.6
X$32694 17256 77 109 17262 INV_X1
* cell instance $32696 r0 *1 180.88,208.6
X$32696 17253 77 109 17422 INV_X1
* cell instance $32697 r0 *1 181.26,208.6
X$32697 77 17295 17253 17248 17170 17169 109 FA_X1
* cell instance $32698 r0 *1 184.3,208.6
X$32698 17248 77 109 17416 INV_X1
* cell instance $32702 r0 *1 187.15,208.6
X$32702 17246 77 109 17414 INV_X1
* cell instance $32704 r0 *1 188.29,208.6
X$32704 17118 15837 77 109 17243 NAND2_X1
* cell instance $32706 r0 *1 190.38,208.6
X$32706 17117 15837 77 109 17238 NAND2_X1
* cell instance $32707 r0 *1 190.95,208.6
X$32707 77 17113 17411 17321 17116 17322 109 FA_X1
* cell instance $32710 r0 *1 195.13,208.6
X$32710 77 17226 17404 17300 17111 17171 109 FA_X1
* cell instance $32712 m0 *1 195.32,208.6
X$32712 17298 77 109 17233 INV_X1
* cell instance $32713 m0 *1 195.89,208.6
X$32713 17233 17223 17234 109 77 16560 HA_X1
* cell instance $32715 m0 *1 198.55,208.6
X$32715 77 17109 17107 17105 17108 17173 109 FA_X1
* cell instance $32716 m0 *1 201.59,208.6
X$32716 15823 16561 77 109 17218 NOR2_X1
* cell instance $32718 m0 *1 202.35,208.6
X$32718 15528 16229 77 109 17217 NOR2_X1
* cell instance $32720 r0 *1 198.17,208.6
X$32720 17222 77 109 17223 INV_X1
* cell instance $32723 r0 *1 200.26,208.6
X$32723 17221 77 109 17173 INV_X1
* cell instance $32725 r0 *1 200.83,208.6
X$32725 77 17217 17221 17209 17218 17174 109 FA_X1
* cell instance $32726 m0 *1 203.49,208.6
X$32726 17214 77 109 17104 INV_X1
* cell instance $32729 m0 *1 204.06,208.6
X$32729 17107 77 109 17384 INV_X1
* cell instance $32730 m0 *1 204.44,208.6
X$32730 17207 17104 17201 109 77 17175 HA_X1
* cell instance $32733 m0 *1 207.29,208.6
X$32733 77 17094 17103 17203 17095 17176 109 FA_X1
* cell instance $32734 m0 *1 210.33,208.6
X$32734 17203 77 109 16987 INV_X2
* cell instance $32736 r0 *1 203.87,208.6
X$32736 17105 77 109 17207 INV_X2
* cell instance $32738 r0 *1 205.2,208.6
X$32738 17209 77 109 17317 INV_X1
* cell instance $32739 r0 *1 205.58,208.6
X$32739 17365 16287 77 109 17205 NAND2_X1
* cell instance $32740 r0 *1 206.15,208.6
X$32740 77 17204 17301 17176 17302 17205 109 FA_X1
* cell instance $32741 r0 *1 209.19,208.6
X$32741 17103 77 109 17303 INV_X1
* cell instance $32744 r0 *1 210.71,208.6
X$32744 17201 77 109 17199 INV_X1
* cell instance $32745 r0 *1 211.09,208.6
X$32745 77 17194 17182 17195 17199 17315 109 FA_X1
* cell instance $32747 m0 *1 211.28,208.6
X$32747 17096 77 109 17194 INV_X1
* cell instance $32750 m0 *1 216.98,208.6
X$32750 17545 17178 16900 77 17193 109 AOI21_X2
* cell instance $32751 m0 *1 218.31,208.6
X$32751 17178 77 109 17101 BUF_X1
* cell instance $32753 m0 *1 219.64,208.6
X$32753 16989 77 109 17097 INV_X1
* cell instance $32754 m0 *1 220.02,208.6
X$32754 16793 77 109 16999 INV_X1
* cell instance $32756 m0 *1 220.59,208.6
X$32756 16989 16992 16990 109 77 16997 OAI21_X4
* cell instance $32757 m0 *1 223.06,208.6
X$32757 16990 16992 16788 77 17099 109 AOI21_X2
* cell instance $32758 m0 *1 224.39,208.6
X$32758 17180 77 109 16992 BUF_X2
* cell instance $32764 r0 *1 214.13,208.6
X$32764 17195 77 109 17197 INV_X1
* cell instance $32765 r0 *1 214.51,208.6
X$32765 77 17311 17304 17192 17197 17177 109 FA_X1
* cell instance $32766 r0 *1 217.55,208.6
X$32766 17192 77 109 16786 INV_X1
* cell instance $32767 r0 *1 217.93,208.6
X$32767 17190 17102 77 109 16988 NAND2_X2
* cell instance $32768 r0 *1 218.88,208.6
X$32768 17372 17305 16989 109 77 16793 HA_X1
* cell instance $32769 r0 *1 220.78,208.6
X$32769 17306 77 109 17184 INV_X1
* cell instance $32770 r0 *1 221.16,208.6
X$32770 17307 17184 17180 109 77 16990 HA_X1
* cell instance $32772 r0 *1 223.44,208.6
X$32772 17308 77 109 17098 INV_X2
* cell instance $32815 m0 *1 70.3,214.2
X$32815 17476 12481 15566 77 109 17512 MUX2_X1
* cell instance $32820 r0 *1 70.68,214.2
X$32820 77 16752 17140 17476 17512 8687 109 DFFR_X1
* cell instance $32821 m0 *1 72.96,214.2
X$32821 77 16752 17076 17338 17474 8687 109 DFFR_X1
* cell instance $32824 m0 *1 76.95,214.2
X$32824 77 16752 17143 17478 17477 8687 109 DFFR_X1
* cell instance $32831 r0 *1 78.85,214.2
X$32831 17549 12312 15434 77 109 17513 MUX2_X1
* cell instance $32832 r0 *1 80.18,214.2
X$32832 77 16336 17196 17549 17513 8687 109 DFFR_X1
* cell instance $32834 m0 *1 84.36,214.2
X$32834 77 16336 17276 17383 17480 8687 109 DFFR_X1
* cell instance $32836 m0 *1 88.16,214.2
X$32836 17550 12312 15737 77 109 17514 MUX2_X1
* cell instance $32839 m0 *1 92.72,214.2
X$32839 17482 12481 15339 77 109 17436 MUX2_X1
* cell instance $32843 r0 *1 87.78,214.2
X$32843 77 16958 17208 17550 17514 8687 109 DFFR_X1
* cell instance $32847 m0 *1 95.19,214.2
X$32847 17484 13682 15339 77 109 17515 MUX2_X1
* cell instance $32853 m0 *1 127.11,214.2
X$32853 77 17489 17437 17488 17555 17490 109 FA_X1
* cell instance $32854 m0 *1 130.15,214.2
X$32854 17488 77 109 17556 INV_X1
* cell instance $32857 m0 *1 132.24,214.2
X$32857 77 17519 17396 17055 17517 17560 109 FA_X1
* cell instance $32858 m0 *1 135.28,214.2
X$32858 17438 77 109 17559 INV_X1
* cell instance $32859 m0 *1 135.66,214.2
X$32859 17494 77 109 17558 INV_X1
* cell instance $32861 m0 *1 137.56,214.2
X$32861 77 17439 17494 17563 17562 17343 109 FA_X1
* cell instance $32862 m0 *1 140.6,214.2
X$32862 17343 77 109 17566 INV_X1
* cell instance $32864 m0 *1 141.17,214.2
X$32864 17497 77 109 17562 INV_X1
* cell instance $32868 r0 *1 95.95,214.2
X$32868 77 16203 17212 17484 17515 12731 109 DFFR_X1
* cell instance $32880 r0 *1 128.44,214.2
X$32880 17516 77 109 17555 INV_X1
* cell instance $32881 r0 *1 128.82,214.2
X$32881 77 17518 17079 17332 17517 17556 109 FA_X1
* cell instance $32882 r0 *1 131.86,214.2
X$32882 77 17559 17518 17560 17558 17516 109 FA_X1
* cell instance $32884 r0 *1 135.09,214.2
X$32884 77 17561 17519 17589 17516 17520 109 FA_X1
* cell instance $32886 r0 *1 138.32,214.2
X$32886 17563 77 109 17520 INV_X1
* cell instance $32888 r0 *1 139.08,214.2
X$32888 77 17615 17561 17565 17566 17564 109 FA_X1
* cell instance $32889 m0 *1 144.97,214.2
X$32889 16823 17412 77 109 17498 NAND2_X1
* cell instance $32890 m0 *1 141.93,214.2
X$32890 77 17568 17497 17564 17441 17498 109 FA_X1
* cell instance $32893 m0 *1 147.25,214.2
X$32893 17348 17443 77 109 17415 NAND2_X1
* cell instance $32894 m0 *1 147.82,214.2
X$32894 15715 77 109 17443 INV_X1
* cell instance $32900 r0 *1 144.21,214.2
X$32900 16211 109 17281 77 BUF_X4
* cell instance $32901 r0 *1 145.54,214.2
X$32901 15715 17280 77 109 17617 NAND2_X1
* cell instance $32904 m0 *1 149.53,214.2
X$32904 17444 77 109 17500 INV_X1
* cell instance $32908 r0 *1 149.91,214.2
X$32908 77 17634 17353 17571 17619 17521 109 FA_X1
* cell instance $32909 m0 *1 152.38,214.2
X$32909 17445 77 109 17521 INV_X1
* cell instance $32910 m0 *1 151.81,214.2
X$32910 17348 77 109 17448 BUF_X1
* cell instance $32911 m0 *1 152.76,214.2
X$32911 17446 77 109 17522 INV_X1
* cell instance $32913 r0 *1 152.95,214.2
X$32913 77 17522 17160 16879 17571 17523 109 FA_X1
* cell instance $32914 m0 *1 156.56,214.2
X$32914 77 17506 16880 17354 17505 17524 109 FA_X1
* cell instance $32915 m0 *1 153.52,214.2
X$32915 77 17447 17523 17505 17503 17773 109 FA_X1
* cell instance $32916 m0 *1 159.6,214.2
X$32916 77 17509 17355 16881 17510 17450 109 FA_X1
* cell instance $32920 r0 *1 156.94,214.2
X$32920 15385 77 109 17534 INV_X1
* cell instance $32922 r0 *1 157.7,214.2
X$32922 77 17574 17524 17450 17678 17747 109 FA_X1
* cell instance $32924 m0 *1 163.4,214.2
X$32924 17448 17360 77 109 17568 NAND2_X1
* cell instance $32925 m0 *1 163.02,214.2
X$32925 17511 77 109 17593 INV_X1
* cell instance $32929 m0 *1 164.35,214.2
X$32929 15444 77 109 17360 INV_X1
* cell instance $32932 r0 *1 164.92,214.2
X$32932 77 17579 17577 17578 17435 17525 109 FA_X1
* cell instance $32934 m0 *1 165.87,214.2
X$32934 17452 77 109 17453 INV_X1
* cell instance $32936 m0 *1 166.63,214.2
X$32936 17624 77 109 17287 INV_X1
* cell instance $32938 m0 *1 169.29,214.2
X$32938 77 17455 17526 17456 17508 17852 109 FA_X1
* cell instance $32944 r0 *1 169.67,214.2
X$32944 17526 77 109 17625 INV_X1
* cell instance $32950 r0 *1 171.95,214.2
X$32950 17456 77 109 17527 INV_X1
* cell instance $32951 r0 *1 172.33,214.2
X$32951 17594 77 109 17528 INV_X1
* cell instance $32954 r0 *1 173.66,214.2
X$32954 17581 77 109 17690 INV_X1
* cell instance $32955 r0 *1 174.04,214.2
X$32955 77 17712 17581 17530 17583 17425 109 FA_X1
* cell instance $32956 m0 *1 176.89,214.2
X$32956 17443 15260 77 109 17502 NOR2_X1
* cell instance $32957 m0 *1 176.51,214.2
X$32957 17529 77 109 16832 INV_X1
* cell instance $32960 m0 *1 178.41,214.2
X$32960 17504 77 109 17586 INV_X1
* cell instance $32963 r0 *1 177.08,214.2
X$32963 77 17597 17529 16978 17586 17585 109 FA_X1
* cell instance $32965 r0 *1 180.5,214.2
X$32965 17531 77 109 17358 INV_X1
* cell instance $32966 m0 *1 181.26,214.2
X$32966 77 17587 17256 17588 17501 17499 109 FA_X1
* cell instance $32967 m0 *1 180.69,214.2
X$32967 17443 15639 77 109 17501 NOR2_X1
* cell instance $32968 m0 *1 184.3,214.2
X$32968 17443 15578 77 109 17533 NOR2_X1
* cell instance $32971 r0 *1 180.88,214.2
X$32971 17458 77 109 17532 INV_X1
* cell instance $32976 r0 *1 184.11,214.2
X$32976 17588 77 109 17600 INV_X1
* cell instance $32977 r0 *1 184.49,214.2
X$32977 77 17582 17584 17686 17580 17533 109 FA_X1
* cell instance $32979 m0 *1 186.01,214.2
X$32979 17360 15639 77 109 17582 NOR2_X1
* cell instance $32981 m0 *1 188.29,214.2
X$32981 77 17461 17460 17535 17575 17362 109 FA_X1
* cell instance $32983 m0 *1 192.85,214.2
X$32983 77 17677 16688 17298 17462 17491 109 FA_X1
* cell instance $32984 m0 *1 195.89,214.2
X$32984 77 17463 17402 17465 17492 17538 109 FA_X1
* cell instance $32989 r0 *1 188.1,214.2
X$32989 17534 16561 77 109 17580 NOR2_X1
* cell instance $32990 r0 *1 188.67,214.2
X$32990 17360 15578 77 109 17623 NOR2_X1
* cell instance $32991 r0 *1 189.24,214.2
X$32991 17534 15639 77 109 17602 NOR2_X1
* cell instance $32994 r0 *1 190.95,214.2
X$32994 77 17573 17576 17491 17535 17536 109 FA_X1
* cell instance $32997 r0 *1 197.22,214.2
X$32997 15707 77 109 16260 BUF_X2
* cell instance $32998 r0 *1 197.98,214.2
X$32998 17572 77 109 17538 INV_X1
* cell instance $32999 r0 *1 198.36,214.2
X$32999 17465 77 109 17539 INV_X1
* cell instance $33000 r0 *1 198.74,214.2
X$33000 77 17093 17540 17611 17034 17569 109 FA_X1
* cell instance $33001 r0 *1 201.78,214.2
X$33001 17541 77 109 17569 INV_X1
* cell instance $33002 r0 *1 202.16,214.2
X$33002 15010 16561 77 109 17613 NOR2_X1
* cell instance $33003 m0 *1 202.54,214.2
X$33003 15010 16229 77 109 17487 NOR2_X2
* cell instance $33007 r0 *1 202.73,214.2
X$33007 15836 16229 77 109 17567 NOR2_X1
* cell instance $33009 m0 *1 207.67,214.2
X$33009 16126 17557 77 109 17302 NAND2_X2
* cell instance $33010 m0 *1 204.63,214.2
X$33010 77 17466 17554 17486 17542 17467 109 FA_X1
* cell instance $33012 m0 *1 208.81,214.2
X$33012 17485 77 109 17543 INV_X1
* cell instance $33014 m0 *1 209.95,214.2
X$33014 17483 17384 17479 109 77 17662 HA_X1
* cell instance $33016 m0 *1 212.04,214.2
X$33016 77 17378 17551 17544 17553 17469 109 FA_X1
* cell instance $33017 m0 *1 215.08,214.2
X$33017 77 17481 17548 17473 17175 17479 109 FA_X1
* cell instance $33019 m0 *1 218.31,214.2
X$33019 77 17473 17546 17471 17475 17472 109 FA_X1
* cell instance $33026 r0 *1 205.96,214.2
X$33026 17365 16228 77 109 17467 NAND2_X1
* cell instance $33027 r0 *1 206.53,214.2
X$33027 16119 17557 77 109 17542 NAND2_X1
* cell instance $33030 r0 *1 209,214.2
X$33030 77 17554 17727 17553 17656 17543 109 FA_X1
* cell instance $33031 r0 *1 212.04,214.2
X$33031 17551 77 109 17481 INV_X1
* cell instance $33036 r0 *1 215.27,214.2
X$33036 17544 77 109 17376 INV_X1
* cell instance $33038 r0 *1 216.41,214.2
X$33038 17609 17102 17545 77 16693 109 AOI21_X2
* cell instance $33040 r0 *1 218.5,214.2
X$33040 17546 77 109 17470 INV_X1
* cell instance $33041 r0 *1 218.88,214.2
X$33041 17548 77 109 17547 INV_X1
* cell instance $33074 m0 *1 129.01,217
X$33074 17516 17612 109 77 17155 XNOR2_X1
* cell instance $33075 m0 *1 130.15,217
X$33075 17612 77 109 17517 INV_X1
* cell instance $33115 r0 *1 130.34,217
X$33115 77 17742 16760 17612 17629 17635 109 FA_X1
* cell instance $33116 r0 *1 133.38,217
X$33116 77 17695 16963 17668 17629 17635 109 FA_X1
* cell instance $33118 m0 *1 136.23,217
X$33118 77 17696 16964 17495 17669 17589 109 FA_X1
* cell instance $33122 r0 *1 137.18,217
X$33122 17668 77 109 17669 INV_X1
* cell instance $33125 r0 *1 139.46,217
X$33125 77 17744 17440 17082 17818 17671 109 FA_X1
* cell instance $33126 r0 *1 142.5,217
X$33126 77 17672 17670 17343 17673 17674 109 FA_X1
* cell instance $33127 m0 *1 143.83,217
X$33127 17745 77 109 17672 INV_X1
* cell instance $33128 m0 *1 143.45,217
X$33128 17699 77 109 17673 INV_X1
* cell instance $33130 m0 *1 144.4,217
X$33130 77 17620 17615 17591 17617 17590 109 FA_X1
* cell instance $33132 m0 *1 147.63,217
X$33132 77 17631 17442 17619 17592 17632 109 FA_X1
* cell instance $33133 m0 *1 150.67,217
X$33133 15448 12734 77 109 17348 NOR2_X2
* cell instance $33134 m0 *1 151.62,217
X$33134 17348 17534 77 109 17620 NAND2_X1
* cell instance $33137 m0 *1 159.03,217
X$33137 16889 17281 109 77 17680 AND2_X1
* cell instance $33139 m0 *1 161.31,217
X$33139 77 17709 17509 17684 17836 17593 109 FA_X1
* cell instance $33140 m0 *1 164.35,217
X$33140 17577 77 109 17683 INV_X1
* cell instance $33142 m0 *1 164.92,217
X$33142 15385 15445 77 109 17638 NAND2_X1
* cell instance $33144 m0 *1 167.01,217
X$33144 17578 77 109 17687 INV_X1
* cell instance $33147 r0 *1 145.73,217
X$33147 17412 17118 77 109 17590 NAND2_X1
* cell instance $33149 r0 *1 146.68,217
X$33149 17734 77 109 17159 INV_X1
* cell instance $33152 r0 *1 147.63,217
X$33152 16667 17633 77 109 17674 NOR2_X1
* cell instance $33154 r0 *1 148.96,217
X$33154 17629 77 109 17701 INV_X2
* cell instance $33155 r0 *1 149.53,217
X$33155 15545 77 109 17630 INV_X2
* cell instance $33156 r0 *1 150.1,217
X$33156 15545 109 17633 77 BUF_X4
* cell instance $33158 r0 *1 151.81,217
X$33158 77 17705 17634 17447 17738 17931 109 FA_X1
* cell instance $33160 r0 *1 155.23,217
X$33160 77 17637 17629 17635 17679 17454 109 FA_X1
* cell instance $33161 r0 *1 158.27,217
X$33161 77 17636 17679 17637 17680 17708 109 FA_X1
* cell instance $33162 r0 *1 161.31,217
X$33162 17774 77 109 17636 INV_X1
* cell instance $33166 r0 *1 163.02,217
X$33166 77 17685 16923 17452 17683 17684 109 FA_X1
* cell instance $33167 r0 *1 166.06,217
X$33167 77 17640 17685 17626 17687 17639 109 FA_X1
* cell instance $33168 m0 *1 167.96,217
X$33168 77 17688 17624 17356 17625 17626 109 FA_X1
* cell instance $33174 r0 *1 170.24,217
X$33174 77 17527 17688 17595 17741 17641 109 FA_X1
* cell instance $33178 m0 *1 175.18,217
X$33178 17628 77 109 17596 INV_X1
* cell instance $33179 m0 *1 172.14,217
X$33179 77 17690 17594 17628 17595 17693 109 FA_X1
* cell instance $33185 r0 *1 175.37,217
X$33185 77 17643 17693 17585 17691 17644 109 FA_X1
* cell instance $33187 m0 *1 176.7,217
X$33187 17530 77 109 17691 INV_X1
* cell instance $33190 m0 *1 182.02,217
X$33190 17118 17599 77 109 17646 NAND2_X1
* cell instance $33191 m0 *1 178.98,217
X$33191 77 17532 17597 17359 17598 17713 109 FA_X1
* cell instance $33194 m0 *1 184.3,217
X$33194 17457 77 109 17694 INV_X1
* cell instance $33195 m0 *1 184.68,217
X$33195 77 17692 17627 17650 17638 17649 109 FA_X1
* cell instance $33199 r0 *1 180.5,217
X$33199 77 17647 17645 17648 17740 17646 109 FA_X1
* cell instance $33200 r0 *1 183.54,217
X$33200 17117 17714 77 109 17647 NAND2_X1
* cell instance $33203 r0 *1 186.01,217
X$33203 16891 17689 77 109 17692 NAND2_X1
* cell instance $33204 r0 *1 186.58,217
X$33204 16983 17714 77 109 17649 NAND2_X1
* cell instance $33206 r0 *1 187.91,217
X$33206 15829 77 109 17365 BUF_X2
* cell instance $33207 m0 *1 191.14,217
X$33207 17603 16561 77 109 17622 NOR2_X1
* cell instance $33208 m0 *1 188.1,217
X$33208 77 17622 16980 17682 17623 17602 109 FA_X1
* cell instance $33209 m0 *1 191.71,217
X$33209 17534 15578 77 109 17621 NOR2_X1
* cell instance $33211 m0 *1 193.8,217
X$33211 17603 16229 77 109 17651 NOR2_X1
* cell instance $33212 m0 *1 194.37,217
X$33212 17603 15578 77 109 17605 NOR2_X1
* cell instance $33213 m0 *1 194.94,217
X$33213 17604 16561 77 109 17537 NOR2_X1
* cell instance $33215 r0 *1 188.67,217
X$33215 77 17689 109 15829 BUF_X8
* cell instance $33216 r0 *1 191.14,217
X$33216 17686 77 109 17737 INV_X1
* cell instance $33220 r0 *1 192.85,217
X$33220 17682 77 109 17652 INV_X1
* cell instance $33221 r0 *1 193.23,217
X$33221 17681 77 109 17322 INV_X1
* cell instance $33222 r0 *1 193.61,217
X$33222 77 17621 17681 17676 17651 17537 109 FA_X1
* cell instance $33223 m0 *1 196.46,217
X$33223 77 17605 17299 17675 17618 17616 109 FA_X1
* cell instance $33224 m0 *1 195.89,217
X$33224 17604 16229 77 109 17618 NOR2_X1
* cell instance $33225 m0 *1 199.5,217
X$33225 15836 16561 77 109 17616 NOR2_X1
* cell instance $33226 m0 *1 200.07,217
X$33226 17540 77 109 17653 INV_X1
* cell instance $33227 m0 *1 200.45,217
X$33227 17604 16125 77 109 17614 NOR2_X2
* cell instance $33228 m0 *1 201.4,217
X$33228 77 17567 17541 17606 17613 17614 109 FA_X1
* cell instance $33229 m0 *1 204.44,217
X$33229 77 17557 109 15445 BUF_X8
* cell instance $33230 m0 *1 206.91,217
X$33230 15931 17557 77 109 17655 NAND2_X1
* cell instance $33231 m0 *1 207.48,217
X$33231 17365 16126 77 109 17667 NAND2_X1
* cell instance $33232 m0 *1 208.05,217
X$33232 17611 77 109 17610 INV_X1
* cell instance $33234 m0 *1 209.19,217
X$33234 17610 17468 17664 109 77 17657 HA_X1
* cell instance $33237 m0 *1 213.37,217
X$33237 17660 17665 17102 109 77 17609 HA_X1
* cell instance $33238 m0 *1 215.27,217
X$33238 17725 77 109 17608 INV_X1
* cell instance $33241 m0 *1 216.6,217
X$33241 17608 17721 17190 109 77 17545 HA_X1
* cell instance $33249 r0 *1 197.03,217
X$33249 77 17803 17677 17733 17801 17539 109 FA_X1
* cell instance $33251 r0 *1 200.26,217
X$33251 17464 17653 17718 109 77 17654 HA_X1
* cell instance $33254 r0 *1 204.06,217
X$33254 17606 77 109 17728 INV_X1
* cell instance $33255 r0 *1 204.44,217
X$33255 77 17719 109 17016 BUF_X8
* cell instance $33257 r0 *1 207.1,217
X$33257 77 17729 17666 17656 17655 17667 109 FA_X1
* cell instance $33260 r0 *1 210.71,217
X$33260 17806 77 109 17660 INV_X1
* cell instance $33261 r0 *1 211.09,217
X$33261 77 17720 17663 17661 17662 17664 109 FA_X1
* cell instance $33262 r0 *1 214.13,217
X$33262 17663 77 109 17723 INV_X1
* cell instance $33263 r0 *1 214.51,217
X$33263 17661 77 109 17659 INV_X1
* cell instance $33267 r0 *1 216.22,217
X$33267 77 17659 17726 17607 17724 17658 109 FA_X1
* cell instance $33268 r0 *1 219.26,217
X$33268 17722 77 109 17372 INV_X2
* cell instance $33286 m0 *1 19,200.2
X$33286 77 15851 16421 16498 16469 9814 109 DFFR_X1
* cell instance $33287 m0 *1 22.8,200.2
X$33287 16498 4126 16069 77 109 16469 MUX2_X1
* cell instance $33289 m0 *1 27.17,200.2
X$33289 16421 10138 16422 77 109 16373 MUX2_X1
* cell instance $33290 m0 *1 28.5,200.2
X$33290 16421 15375 16422 77 109 16184 MUX2_X1
* cell instance $33292 m0 *1 30.59,200.2
X$33292 16424 15375 16478 77 109 16501 MUX2_X1
* cell instance $33305 r0 *1 22.04,200.2
X$33305 77 15851 16790 16700 16699 9814 109 DFFR_X1
* cell instance $33308 r0 *1 27.55,200.2
X$33308 16570 10283 16637 77 109 16185 MUX2_X1
* cell instance $33309 r0 *1 28.88,200.2
X$33309 9652 109 6299 77 BUF_X4
* cell instance $33310 r0 *1 30.21,200.2
X$33310 16499 15375 16423 77 109 16500 MUX2_X1
* cell instance $33311 r0 *1 31.54,200.2
X$33311 16500 12240 16501 77 109 16070 MUX2_X1
* cell instance $33313 m0 *1 34.01,200.2
X$33313 77 16573 16478 16378 16480 4086 109 DFFR_X1
* cell instance $33316 m0 *1 40.85,200.2
X$33316 16502 10440 16639 77 109 16581 MUX2_X1
* cell instance $33317 m0 *1 42.18,200.2
X$33317 16581 11125 16582 77 109 16155 MUX2_X1
* cell instance $33324 r0 *1 37.24,200.2
X$33324 77 16573 16502 16503 16580 4086 109 DFFR_X1
* cell instance $33325 r0 *1 41.04,200.2
X$33325 16503 10508 15858 77 109 16580 MUX2_X1
* cell instance $33329 r0 *1 45.03,200.2
X$33329 77 15620 16425 16588 16585 4086 109 DFFR_X1
* cell instance $33330 m0 *1 46.36,200.2
X$33330 16588 4128 15858 77 109 16585 MUX2_X1
* cell instance $33332 m0 *1 47.69,200.2
X$33332 16075 10440 16425 77 109 16426 MUX2_X1
* cell instance $33337 r0 *1 49.78,200.2
X$33337 77 16330 16427 16589 16587 8687 109 DFFR_X1
* cell instance $33338 m0 *1 51.11,200.2
X$33338 16589 13767 15467 77 109 16587 MUX2_X1
* cell instance $33340 m0 *1 52.44,200.2
X$33340 16428 9812 16427 77 109 16642 MUX2_X1
* cell instance $33341 m0 *1 53.77,200.2
X$33341 16428 10957 16427 77 109 16504 MUX2_X1
* cell instance $33345 r0 *1 53.96,200.2
X$33345 16808 11125 16504 77 109 15179 MUX2_X1
* cell instance $33348 r0 *1 55.86,200.2
X$33348 77 16330 16506 16591 16505 8687 109 DFFR_X1
* cell instance $33349 m0 *1 57.57,200.2
X$33349 14048 8166 16591 77 109 16505 MUX2_X1
* cell instance $33350 m0 *1 56.24,200.2
X$33350 14048 8008 16488 77 109 16385 MUX2_X1
* cell instance $33352 m0 *1 59.09,200.2
X$33352 16191 10138 16429 77 109 16489 MUX2_X1
* cell instance $33353 m0 *1 60.42,200.2
X$33353 16506 11563 16593 77 109 16332 MUX2_X1
* cell instance $33355 m0 *1 61.94,200.2
X$33355 14048 8235 16595 77 109 16594 MUX2_X1
* cell instance $33359 m0 *1 65.74,200.2
X$33359 77 15861 16194 16493 16596 8687 109 DFFR_X1
* cell instance $33360 m0 *1 69.54,200.2
X$33360 16496 4128 15566 77 109 16495 MUX2_X1
* cell instance $33367 r0 *1 59.85,200.2
X$33367 16506 10440 16593 77 109 16331 MUX2_X1
* cell instance $33369 r0 *1 61.37,200.2
X$33369 77 15861 16593 16595 16594 8687 109 DFFR_X1
* cell instance $33371 r0 *1 65.55,200.2
X$33371 16716 13098 16431 77 109 16644 MUX2_X1
* cell instance $33373 r0 *1 67.26,200.2
X$33373 16493 4126 15566 77 109 16596 MUX2_X1
* cell instance $33376 r0 *1 69.16,200.2
X$33376 16507 10435 16508 77 109 16645 MUX2_X1
* cell instance $33378 m0 *1 73.34,200.2
X$33378 77 15630 15664 16597 16598 8687 109 DFFR_X1
* cell instance $33379 m0 *1 72.01,200.2
X$33379 16431 8235 16597 77 109 16598 MUX2_X1
* cell instance $33383 r0 *1 72.96,200.2
X$33383 16507 5589 16508 77 109 16603 MUX2_X1
* cell instance $33385 r0 *1 74.67,200.2
X$33385 16431 8166 16718 77 109 16819 MUX2_X1
* cell instance $33389 r0 *1 77.33,200.2
X$33389 9666 77 109 15566 BUF_X2
* cell instance $33390 m0 *1 77.71,200.2
X$33390 9666 77 109 16431 BUF_X2
* cell instance $33392 m0 *1 78.47,200.2
X$33392 16509 7153 15664 77 109 16497 MUX2_X1
* cell instance $33393 m0 *1 79.8,200.2
X$33393 16432 3978 16497 77 109 16824 MUX2_X1
* cell instance $33397 m0 *1 88.16,200.2
X$33397 16605 14187 15671 77 109 16608 MUX2_X1
* cell instance $33398 m0 *1 89.49,200.2
X$33398 77 16338 16340 16605 16608 8687 109 DFFR_X1
* cell instance $33399 m0 *1 93.29,200.2
X$33399 16339 8864 16340 77 109 16609 MUX2_X1
* cell instance $33400 m0 *1 94.62,200.2
X$33400 14049 77 109 16338 CLKBUF_X3
* cell instance $33401 m0 *1 95.57,200.2
X$33401 16338 77 109 19212 CLKBUF_X1
* cell instance $33402 m0 *1 96.14,200.2
X$33402 16610 13146 15872 77 109 16409 MUX2_X1
* cell instance $33405 m0 *1 109.63,200.2
X$33405 16614 3791 16433 77 109 16434 MUX2_X1
* cell instance $33410 r0 *1 79.99,200.2
X$33410 16821 6299 16601 77 109 16511 MUX2_X1
* cell instance $33412 r0 *1 81.7,200.2
X$33412 16510 3622 77 109 16720 NOR2_X1
* cell instance $33415 r0 *1 83.41,200.2
X$33415 16603 9030 77 109 16647 NOR2_X1
* cell instance $33416 r0 *1 83.98,200.2
X$33416 14019 16647 16720 13929 16753 16825 77 109 16398 OAI33_X1
* cell instance $33418 r0 *1 86.83,200.2
X$33418 16512 11563 16648 77 109 16086 MUX2_X1
* cell instance $33421 r0 *1 89.87,200.2
X$33421 16606 9030 77 109 16200 NOR2_X1
* cell instance $33422 r0 *1 90.44,200.2
X$33422 77 15375 109 8864 BUF_X8
* cell instance $33424 r0 *1 93.67,200.2
X$33424 16609 3791 16513 77 109 15956 MUX2_X1
* cell instance $33425 r0 *1 95,200.2
X$33425 16434 4632 16722 77 109 16649 MUX2_X1
* cell instance $33428 r0 *1 97.28,200.2
X$33428 77 16338 16514 16723 16650 8201 109 DFFR_X1
* cell instance $33429 r0 *1 101.08,200.2
X$33429 16514 10435 16515 77 109 16201 MUX2_X1
* cell instance $33431 r0 *1 102.6,200.2
X$33431 16514 8209 16516 77 109 16613 MUX2_X1
* cell instance $33433 r0 *1 104.12,200.2
X$33433 16515 8209 16517 77 109 16518 MUX2_X1
* cell instance $33435 r0 *1 105.64,200.2
X$33435 16613 6742 16612 77 109 15548 MUX2_X1
* cell instance $33436 r0 *1 106.97,200.2
X$33436 16518 6742 16724 77 109 16099 MUX2_X1
* cell instance $33437 r0 *1 108.3,200.2
X$33437 16519 8209 16726 77 109 16612 MUX2_X1
* cell instance $33438 r0 *1 109.63,200.2
X$33438 16519 3183 16651 77 109 16614 MUX2_X1
* cell instance $33439 r0 *1 110.96,200.2
X$33439 16651 8209 16728 77 109 16724 MUX2_X1
* cell instance $33441 r0 *1 112.67,200.2
X$33441 77 16101 16519 16616 16494 12731 109 DFFR_X1
* cell instance $33442 m0 *1 114.19,200.2
X$33442 16435 8232 16616 77 109 16494 MUX2_X1
* cell instance $33443 m0 *1 112.86,200.2
X$33443 16435 8166 16344 77 109 16420 MUX2_X1
* cell instance $33445 m0 *1 117.04,200.2
X$33445 16101 77 109 19087 INV_X4
* cell instance $33446 m0 *1 117.99,200.2
X$33446 16435 8008 16617 77 109 16618 MUX2_X1
* cell instance $33447 m0 *1 119.32,200.2
X$33447 14026 77 109 16101 CLKBUF_X3
* cell instance $33453 r0 *1 116.47,200.2
X$33453 77 16101 16651 16617 16618 12731 109 DFFR_X1
* cell instance $33458 m0 *1 126.73,200.2
X$33458 77 16346 17224 16520 16345 16317 109 FA_X1
* cell instance $33460 r0 *1 127.68,200.2
X$33460 77 16521 16654 16657 16656 16520 109 FA_X1
* cell instance $33462 m0 *1 130.15,200.2
X$33462 77 16346 16521 16620 16345 16491 109 FA_X1
* cell instance $33463 m0 *1 133.38,200.2
X$33463 16436 77 109 16522 INV_X1
* cell instance $33465 m0 *1 135.28,200.2
X$33465 77 16437 16523 16525 16524 16492 109 FA_X1
* cell instance $33471 r0 *1 131.67,200.2
X$33471 77 16522 16658 16659 16524 16729 109 FA_X1
* cell instance $33472 r0 *1 134.71,200.2
X$33472 16620 77 109 16729 INV_X1
* cell instance $33473 r0 *1 135.09,200.2
X$33473 16523 77 109 16660 INV_X1
* cell instance $33475 r0 *1 138.51,200.2
X$33475 16525 77 109 16662 INV_X1
* cell instance $33478 r0 *1 139.46,200.2
X$33478 16622 77 109 16663 INV_X1
* cell instance $33479 r0 *1 139.84,200.2
X$33479 77 16527 16622 16665 16524 16526 109 FA_X1
* cell instance $33480 m0 *1 141.17,200.2
X$33480 16621 77 109 16526 INV_X1
* cell instance $33483 m0 *1 141.74,200.2
X$33483 16438 77 109 16527 INV_X1
* cell instance $33488 r0 *1 143.07,200.2
X$33488 16664 77 109 16531 INV_X1
* cell instance $33489 r0 *1 143.45,200.2
X$33489 77 16623 16666 16731 16524 16626 109 FA_X1
* cell instance $33490 m0 *1 144.97,200.2
X$33490 16625 77 109 16626 INV_X1
* cell instance $33493 m0 *1 145.54,200.2
X$33493 16624 77 109 16623 INV_X1
* cell instance $33494 m0 *1 145.92,200.2
X$33494 77 16346 16624 16528 16345 16439 109 FA_X1
* cell instance $33497 m0 *1 150.67,200.2
X$33497 16529 16533 109 77 16052 XNOR2_X1
* cell instance $33498 m0 *1 151.81,200.2
X$33498 16440 16670 77 109 14927 XNOR2_X2
* cell instance $33499 m0 *1 153.71,200.2
X$33499 16630 77 109 16348 INV_X1
* cell instance $33501 r0 *1 146.49,200.2
X$33501 16767 77 109 16351 CLKBUF_X2
* cell instance $33505 r0 *1 148.58,200.2
X$33505 16528 77 109 16668 INV_X1
* cell instance $33507 r0 *1 149.15,200.2
X$33507 16628 16529 16669 77 16490 109 AOI21_X1
* cell instance $33508 r0 *1 149.91,200.2
X$33508 16530 16440 16531 109 16669 77 OAI21_X1
* cell instance $33511 r0 *1 151.24,200.2
X$33511 16531 16534 109 77 16533 AND2_X1
* cell instance $33512 r0 *1 152,200.2
X$33512 77 16440 16853 16351 16629 109 AOI21_X4
* cell instance $33513 r0 *1 154.47,200.2
X$33513 16442 16632 16348 77 16671 109 AOI21_X1
* cell instance $33514 m0 *1 155.04,200.2
X$33514 16351 77 109 16442 INV_X1
* cell instance $33515 m0 *1 154.47,200.2
X$33515 16630 16442 77 109 16631 NAND2_X1
* cell instance $33517 m0 *1 155.61,200.2
X$33517 77 16634 16486 16444 16633 14561 109 NOR4_X4
* cell instance $33519 r0 *1 155.23,200.2
X$33519 16348 16351 16349 77 109 16672 NAND3_X1
* cell instance $33520 r0 *1 155.99,200.2
X$33520 15386 16631 16672 77 16633 109 AOI21_X1
* cell instance $33523 r0 *1 157.32,200.2
X$33523 16636 16536 16535 77 16444 109 AOI21_X2
* cell instance $33524 r0 *1 158.65,200.2
X$33524 16536 109 16403 77 BUF_X4
* cell instance $33525 m0 *1 159.6,200.2
X$33525 16535 16538 16446 109 77 16443 OAI21_X4
* cell instance $33528 m0 *1 162.26,200.2
X$33528 16538 77 109 16635 INV_X1
* cell instance $33529 m0 *1 162.64,200.2
X$33529 16676 16446 16675 109 77 16445 OAI21_X2
* cell instance $33530 m0 *1 163.97,200.2
X$33530 16677 16448 16541 109 77 16446 OAI21_X4
* cell instance $33531 m0 *1 166.44,200.2
X$33531 16537 16545 109 77 15883 XNOR2_X1
* cell instance $33532 m0 *1 167.58,200.2
X$33532 16449 16544 77 109 16011 XNOR2_X2
* cell instance $33533 m0 *1 169.48,200.2
X$33533 16546 16542 109 77 16012 XNOR2_X1
* cell instance $33534 m0 *1 170.62,200.2
X$33534 16450 77 109 16547 INV_X1
* cell instance $33536 m0 *1 171.19,200.2
X$33536 15754 109 16549 77 BUF_X4
* cell instance $33537 m0 *1 172.52,200.2
X$33537 16550 16483 109 77 15579 XNOR2_X1
* cell instance $33538 m0 *1 173.66,200.2
X$33538 77 16485 16551 16550 16615 109 AOI21_X4
* cell instance $33539 m0 *1 176.13,200.2
X$33539 16553 16390 16452 109 77 16448 OAI21_X4
* cell instance $33540 m0 *1 178.6,200.2
X$33540 77 16390 16299 16556 16558 109 AOI21_X4
* cell instance $33541 m0 *1 181.07,200.2
X$33541 16558 16556 16299 77 109 16481 NAND3_X1
* cell instance $33542 m0 *1 181.83,200.2
X$33542 16470 16387 16293 77 109 16558 OR3_X4
* cell instance $33543 m0 *1 183.92,200.2
X$33543 16356 16357 16560 16557 109 16559 77 NOR4_X2
* cell instance $33544 m0 *1 185.63,200.2
X$33544 16454 16607 16456 77 16288 109 AOI21_X2
* cell instance $33545 m0 *1 186.96,200.2
X$33545 16357 16560 77 109 16456 NOR2_X1
* cell instance $33546 m0 *1 187.53,200.2
X$33546 16456 16286 77 109 16574 NAND2_X1
* cell instance $33549 r0 *1 160.17,200.2
X$33549 16537 77 109 16539 INV_X1
* cell instance $33550 r0 *1 160.55,200.2
X$33550 16678 16539 16542 16541 16635 16536 77 109 OAI221_X2
* cell instance $33551 r0 *1 162.64,200.2
X$33551 16675 16446 16676 77 109 16400 OR3_X4
* cell instance $33552 r0 *1 164.73,200.2
X$33552 16537 16544 16680 77 109 16541 NAND3_X2
* cell instance $33553 r0 *1 166.06,200.2
X$33553 16679 16544 16627 77 16545 109 AOI21_X1
* cell instance $33555 r0 *1 167.01,200.2
X$33555 16547 16546 16448 109 77 16449 OAI21_X4
* cell instance $33556 r0 *1 169.48,200.2
X$33556 15762 77 109 16681 INV_X4
* cell instance $33557 r0 *1 170.43,200.2
X$33557 16546 16542 16547 109 16627 77 OAI21_X1
* cell instance $33561 r0 *1 171.19,200.2
X$33561 16680 77 109 16546 INV_X1
* cell instance $33562 r0 *1 171.57,200.2
X$33562 15239 16681 77 109 16220 NOR2_X1
* cell instance $33564 r0 *1 172.52,200.2
X$33564 16619 16721 77 109 16553 NAND2_X1
* cell instance $33565 r0 *1 173.09,200.2
X$33565 8383 15072 13429 77 109 16359 MUX2_X1
* cell instance $33566 r0 *1 174.42,200.2
X$33566 16550 16551 16552 109 16619 77 OAI21_X1
* cell instance $33567 r0 *1 175.18,200.2
X$33567 16553 16452 16554 109 77 16542 OAI21_X4
* cell instance $33568 r0 *1 177.65,200.2
X$33568 16554 16392 77 109 16483 NOR2_X1
* cell instance $33570 r0 *1 178.41,200.2
X$33570 16555 16682 16300 109 77 16392 HA_X1
* cell instance $33571 r0 *1 180.31,200.2
X$33571 16557 77 109 16556 INV_X1
* cell instance $33572 r0 *1 180.69,200.2
X$33572 16776 16557 16300 109 16719 77 OAI21_X1
* cell instance $33573 r0 *1 181.45,200.2
X$33573 77 16554 16719 16559 16683 109 AOI21_X4
* cell instance $33576 r0 *1 184.49,200.2
X$33576 16560 77 109 16684 INV_X1
* cell instance $33577 r0 *1 184.87,200.2
X$33577 16685 16717 16355 109 77 16356 HA_X1
* cell instance $33579 r0 *1 187.15,200.2
X$33579 16604 16715 16358 109 77 16357 HA_X1
* cell instance $33581 m0 *1 188.48,200.2
X$33581 16458 16457 77 109 16607 NAND2_X1
* cell instance $33582 m0 *1 189.24,200.2
X$33582 16457 16458 109 77 15682 XNOR2_X1
* cell instance $33584 m0 *1 190.57,200.2
X$33584 77 16381 16713 16600 15934 16459 109 FA_X1
* cell instance $33587 r0 *1 189.43,200.2
X$33587 16687 77 109 16715 INV_X1
* cell instance $33591 r0 *1 191.9,200.2
X$33591 16543 16380 77 109 16459 NAND2_X1
* cell instance $33592 r0 *1 192.47,200.2
X$33592 15260 77 109 16561 CLKBUF_X3
* cell instance $33595 r0 *1 193.99,200.2
X$33595 77 16229 109 15639 BUF_X8
* cell instance $33596 m0 *1 194.18,200.2
X$33596 77 16600 16463 16462 16602 16460 109 FA_X1
* cell instance $33598 m0 *1 197.22,200.2
X$33598 77 16461 16477 16474 16599 16476 109 FA_X1
* cell instance $33599 m0 *1 200.26,200.2
X$33599 16482 16125 77 109 16476 NOR2_X1
* cell instance $33602 r0 *1 196.46,200.2
X$33602 15578 109 16125 77 BUF_X4
* cell instance $33603 r0 *1 197.79,200.2
X$33603 16549 16360 77 109 16690 NAND2_X1
* cell instance $33604 r0 *1 198.36,200.2
X$33604 16123 16561 77 109 16599 NOR2_X1
* cell instance $33607 r0 *1 200.07,200.2
X$33607 16562 77 109 16712 INV_X1
* cell instance $33610 r0 *1 201.59,200.2
X$33610 15823 16125 77 109 16814 NOR2_X1
* cell instance $33612 m0 *1 201.97,200.2
X$33612 15260 16224 77 109 16475 NOR2_X1
* cell instance $33614 r0 *1 202.16,200.2
X$33614 16482 16229 77 109 16691 NOR2_X1
* cell instance $33617 r0 *1 203.3,200.2
X$33617 16592 16225 77 109 16709 NAND2_X1
* cell instance $33618 r0 *1 203.87,200.2
X$33618 77 16590 16711 16361 16563 16709 109 FA_X1
* cell instance $33619 m0 *1 205.01,200.2
X$33619 16889 16479 77 109 16590 NAND2_X1
* cell instance $33620 m0 *1 204.44,200.2
X$33620 15445 16260 77 109 16563 NAND2_X1
* cell instance $33621 m0 *1 205.58,200.2
X$33621 77 16586 16473 16231 16474 16362 109 FA_X1
* cell instance $33622 m0 *1 208.62,200.2
X$33622 16565 16473 16577 109 77 16566 HA_X1
* cell instance $33623 m0 *1 210.52,200.2
X$33623 16579 77 109 16472 INV_X1
* cell instance $33624 m0 *1 210.9,200.2
X$33624 16566 77 109 16464 INV_X1
* cell instance $33626 m0 *1 212.8,200.2
X$33626 77 16578 16575 16471 16576 16706 109 FA_X1
* cell instance $33628 m0 *1 216.03,200.2
X$33628 16575 77 109 16465 INV_X1
* cell instance $33630 m0 *1 216.6,200.2
X$33630 16572 16574 16029 16571 16470 109 77 AOI211_X2
* cell instance $33631 m0 *1 218.31,200.2
X$33631 16568 16457 16466 77 109 16571 AND3_X4
* cell instance $33632 m0 *1 220.4,200.2
X$33632 16466 16236 109 77 16701 AND2_X1
* cell instance $33634 m0 *1 221.35,200.2
X$33634 16466 16363 16236 109 77 16467 OAI21_X2
* cell instance $33635 m0 *1 222.68,200.2
X$33635 16569 16237 77 109 16364 NOR2_X1
* cell instance $33642 r0 *1 207.1,200.2
X$33642 16463 77 109 16708 INV_X1
* cell instance $33645 r0 *1 208.05,200.2
X$33645 16564 77 109 16565 INV_X1
* cell instance $33648 r0 *1 209,200.2
X$33648 16707 77 109 16583 INV_X2
* cell instance $33649 r0 *1 209.57,200.2
X$33649 16583 16708 16579 109 77 16584 HA_X1
* cell instance $33651 r0 *1 211.85,200.2
X$33651 16584 77 109 16692 INV_X1
* cell instance $33653 r0 *1 212.42,200.2
X$33653 16577 16705 16243 109 77 16576 HA_X1
* cell instance $33657 r0 *1 215.65,200.2
X$33657 16785 16567 109 16683 77 AND2_X4
* cell instance $33658 r0 *1 217.36,200.2
X$33658 16694 16568 16457 77 109 16702 NAND3_X2
* cell instance $33659 r0 *1 218.69,200.2
X$33659 16567 16702 77 109 16572 NAND2_X2
* cell instance $33661 r0 *1 219.83,200.2
X$33661 16701 16695 77 16694 109 OR2_X4
* cell instance $33662 r0 *1 221.54,200.2
X$33662 16466 16029 16236 109 77 16696 OAI21_X2
* cell instance $33663 r0 *1 222.87,200.2
X$33663 16237 16467 77 109 16697 NOR2_X2
* cell instance $33664 r0 *1 223.82,200.2
X$33664 16467 16237 16698 109 16897 77 OAI21_X1
.ENDS ibex_core

* cell DLL_X1
* pin D
* pin GN
* pin PWELL,VSS
* pin NWELL,VDD
* pin Q
.SUBCKT DLL_X1 1 5 6 7 9
* net 1 D
* net 5 GN
* net 6 PWELL,VSS
* net 7 NWELL,VDD
* net 9 Q
* device instance $1 r0 *1 1.52,0.995 PMOS_VTL
M$1 7 4 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.033075P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.71,1.1525 PMOS_VTL
M$2 3 5 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $3 r0 *1 0.79,1.01 PMOS_VTL
M$3 11 3 4 7 PMOS_VTL L=0.05U W=0.09U AS=0.014275P AD=0.0063P PS=0.455U PD=0.23U
* device instance $4 r0 *1 0.98,1.01 PMOS_VTL
M$4 7 8 11 7 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $5 r0 *1 1.17,1.01 PMOS_VTL
M$5 8 4 7 7 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $6 r0 *1 0.22,0.9375 PMOS_VTL
M$6 7 3 2 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 0.41,0.9375 PMOS_VTL
M$7 10 1 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $8 r0 *1 0.6,0.9375 PMOS_VTL
M$8 4 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014275P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 1.71,0.195 NMOS_VTL
M$9 3 5 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.02205P PS=0.555U PD=0.63U
* device instance $10 r0 *1 1.52,0.2975 NMOS_VTL
M$10 6 4 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.021875P PS=1.04U
+ PD=0.555U
* device instance $11 r0 *1 0.79,0.36 NMOS_VTL
M$11 13 2 4 6 NMOS_VTL L=0.05U W=0.09U AS=0.010725P AD=0.0063P PS=0.35U PD=0.23U
* device instance $12 r0 *1 0.98,0.36 NMOS_VTL
M$12 6 8 13 6 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $13 r0 *1 1.17,0.36 NMOS_VTL
M$13 8 4 6 6 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $14 r0 *1 0.22,0.375 NMOS_VTL
M$14 6 3 2 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $15 r0 *1 0.41,0.375 NMOS_VTL
M$15 12 1 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $16 r0 *1 0.6,0.375 NMOS_VTL
M$16 4 3 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.010725P PS=0.35U PD=0.35U
.ENDS DLL_X1

* cell NAND4_X4
* pin PWELL,VSS
* pin A3
* pin A4
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X4 1 2 3 7 8 9 10
* net 1 PWELL,VSS
* net 2 A3
* net 3 A4
* net 7 A1
* net 8 A2
* net 9 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 10 7 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 10 8 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.22365P PS=3.08U PD=3.23U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 10 2 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.22365P AD=0.1764P PS=3.23U PD=3.08U
* device instance $13 r0 *1 2.645,0.995 PMOS_VTL
M$13 10 3 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.885,0.2975 NMOS_VTL
M$17 5 2 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.645,0.2975 NMOS_VTL
M$21 1 3 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.215,0.2975 NMOS_VTL
M$25 9 7 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.975,0.2975 NMOS_VTL
M$29 5 8 4 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND4_X4

* cell AOI222_X4
* pin PWELL,VSS
* pin ZN
* pin A1
* pin A2
* pin B2
* pin B1
* pin C1
* pin C2
* pin NWELL,VDD
.SUBCKT AOI222_X4 1 4 8 9 10 11 12 13 16
* net 1 PWELL,VSS
* net 4 ZN
* net 8 A1
* net 9 A2
* net 10 B2
* net 11 B1
* net 12 C1
* net 13 C2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 2 8 14 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.405,0.995 PMOS_VTL
M$2 14 9 2 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.595,0.995 PMOS_VTL
M$3 15 10 14 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.785,0.995 PMOS_VTL
M$4 14 11 15 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $5 r0 *1 1.125,0.995 PMOS_VTL
M$5 15 12 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U
+ PD=0.77U
* device instance $6 r0 *1 1.315,0.995 PMOS_VTL
M$6 16 13 15 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.505,0.995 PMOS_VTL
M$7 3 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.885,0.995 PMOS_VTL
M$9 4 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.215,0.2975 NMOS_VTL
M$13 5 8 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.405,0.2975 NMOS_VTL
M$14 1 9 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.595,0.2975 NMOS_VTL
M$15 6 10 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.785,0.2975 NMOS_VTL
M$16 2 11 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.060175P PS=0.555U
+ PD=0.705U
* device instance $17 r0 *1 1.125,0.2975 NMOS_VTL
M$17 7 12 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.060175P AD=0.02905P PS=0.705U
+ PD=0.555U
* device instance $18 r0 *1 1.315,0.2975 NMOS_VTL
M$18 1 13 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.505,0.2975 NMOS_VTL
M$19 3 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.885,0.2975 NMOS_VTL
M$21 4 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AOI222_X4

* cell INV_X16
* pin PWELL,VSS
* pin A
* pin ZN
* pin NWELL,VDD
.SUBCKT INV_X16 1 2 3 4
* net 1 PWELL,VSS
* net 2 A
* net 3 ZN
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 4 4 PMOS_VTL L=0.05U W=10.08U AS=0.72765P AD=0.72765P PS=13.02U
+ PD=13.02U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.479325P AD=0.479325P PS=9.365U
+ PD=9.365U
.ENDS INV_X16

* cell OAI211_X2
* pin A
* pin B
* pin C2
* pin C1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI211_X2 1 2 3 4 6 7 8
* net 1 A
* net 2 B
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 6 1 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.111825P AD=0.0882P PS=2.245U PD=1.54U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 8 2 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.089775P PS=1.54U PD=1.545U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 9 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 8 3 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.205,0.2975 NMOS_VTL
M$9 12 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.395,0.2975 NMOS_VTL
M$10 7 2 12 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.585,0.2975 NMOS_VTL
M$11 11 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 5 1 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.02905P PS=0.56U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 6 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 5 4 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI211_X2

* cell AOI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin ZN
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT AOI22_X4 1 2 3 4 5 6 16
* net 1 PWELL,VSS
* net 2 B2
* net 3 B1
* net 4 ZN
* net 5 A2
* net 6 A1
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.695,0.995 PMOS_VTL
M$9 4 5 15 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $10 r0 *1 1.885,0.995 PMOS_VTL
M$10 15 6 4 16 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $17 r0 *1 0.175,0.2975 NMOS_VTL
M$17 7 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.365,0.2975 NMOS_VTL
M$18 4 3 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.555,0.2975 NMOS_VTL
M$19 10 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.745,0.2975 NMOS_VTL
M$20 1 2 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.935,0.2975 NMOS_VTL
M$21 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.125,0.2975 NMOS_VTL
M$22 4 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.315,0.2975 NMOS_VTL
M$23 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.505,0.2975 NMOS_VTL
M$24 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.695,0.2975 NMOS_VTL
M$25 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $26 r0 *1 1.885,0.2975 NMOS_VTL
M$26 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $27 r0 *1 2.075,0.2975 NMOS_VTL
M$27 11 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $28 r0 *1 2.265,0.2975 NMOS_VTL
M$28 1 5 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 2.455,0.2975 NMOS_VTL
M$29 14 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $30 r0 *1 2.645,0.2975 NMOS_VTL
M$30 4 6 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $31 r0 *1 2.835,0.2975 NMOS_VTL
M$31 9 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $32 r0 *1 3.025,0.2975 NMOS_VTL
M$32 1 5 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X4

* cell OR4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OR4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 ZN
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 11 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 7 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 5 1 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 8 2 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 5 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 8 4 5 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 7 5 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR4_X2

* cell AND4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X1 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 5 4 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 10 1 5 7 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 11 2 10 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 9 3 11 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 7 4 9 7 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 5 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND4_X1

* cell OAI211_X4
* pin PWELL,VSS
* pin A
* pin B
* pin C2
* pin ZN
* pin C1
* pin NWELL,VDD
.SUBCKT OAI211_X4 1 3 4 5 6 7 12
* net 1 PWELL,VSS
* net 3 A
* net 4 B
* net 5 C2
* net 6 ZN
* net 7 C1
* net 12 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 3 12 12 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 12 4 6 12 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 15 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 12 5 15 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 14 5 12 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 14 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 12 5 16 12 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 8 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 1 4 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 0.55,0.2975 NMOS_VTL
M$19 10 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 0.74,0.2975 NMOS_VTL
M$20 2 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 0.93,0.2975 NMOS_VTL
M$21 9 3 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.12,0.2975 NMOS_VTL
M$22 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 1.31,0.2975 NMOS_VTL
M$23 11 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 1.5,0.2975 NMOS_VTL
M$24 2 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI211_X4

* cell NAND4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 4 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 7 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 13 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 12 1 13 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 11 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 6 3 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 8 3 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 9 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X2

* cell AOI211_X4
* pin C1
* pin C2
* pin B
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI211_X4 1 2 3 4 8 9 10
* net 1 C1
* net 2 C2
* net 3 B
* net 4 A
* net 8 PWELL,VSS
* net 9 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 6 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 3 7 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 11 9 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 6 9 9 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 5 9 9 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 12 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 8 2 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 6 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 5 6 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 10 5 8 8 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U
+ PD=2.705U
.ENDS AOI211_X4

* cell OAI22_X4
* pin PWELL,VSS
* pin B2
* pin B1
* pin A2
* pin ZN
* pin A1
* pin NWELL,VDD
.SUBCKT OAI22_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 B2
* net 4 B1
* net 5 A2
* net 6 ZN
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 4 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 8 3 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 3 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 6 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 4 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 3 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 13 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 6 7 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 14 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 8 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $13 r0 *1 2.45,0.995 PMOS_VTL
M$13 15 5 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $14 r0 *1 2.64,0.995 PMOS_VTL
M$14 6 7 15 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $15 r0 *1 2.83,0.995 PMOS_VTL
M$15 16 7 6 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $16 r0 *1 3.02,0.995 PMOS_VTL
M$16 8 5 16 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 0.17,0.2975 NMOS_VTL
M$17 1 3 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $18 r0 *1 0.36,0.2975 NMOS_VTL
M$18 2 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
* device instance $25 r0 *1 1.69,0.2975 NMOS_VTL
M$25 6 5 2 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $26 r0 *1 1.88,0.2975 NMOS_VTL
M$26 2 7 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI22_X4

* cell INV_X8
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X8 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.37485P PS=6.86U PD=6.86U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 2 2 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.246925P PS=4.925U
+ PD=4.925U
.ENDS INV_X8

* cell OR4_X1
* pin A1
* pin A2
* pin A3
* pin A4
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR4_X1 1 2 3 4 5 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 10 1 6 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 2 10 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 11 3 9 7 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 6 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 6 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 5 2 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $8 r0 *1 0.55,0.195 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.74,0.195 NMOS_VTL
M$9 5 4 6 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 8 6 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR4_X1

* cell OAI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X2 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 9 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 12 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 4 12 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 11 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 6 3 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 7 1 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 5 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 8 3 5 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $14 r0 *1 1.12,0.2975 NMOS_VTL
M$14 5 4 8 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI22_X2

* cell DFFS_X2
* pin PWELL,VSS
* pin D
* pin SN
* pin Q
* pin CK
* pin NWELL,VDD
.SUBCKT DFFS_X2 1 4 7 8 17 19
* net 1 PWELL,VSS
* net 4 D
* net 7 SN
* net 8 Q
* net 9 QN
* net 17 CK
* net 19 NWELL,VDD
* device instance $1 r0 *1 3.035,0.995 PMOS_VTL
M$1 8 18 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.415,0.995 PMOS_VTL
M$3 9 6 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 3.795,0.995 PMOS_VTL
M$5 18 6 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.785,1.015 PMOS_VTL
M$6 22 3 5 19 PMOS_VTL L=0.05U W=0.09U AS=0.019425P AD=0.008325P PS=0.595U
+ PD=0.275U
* device instance $7 r0 *1 1.02,1.015 PMOS_VTL
M$7 22 16 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0144P AD=0.008325P PS=0.46U
+ PD=0.275U
* device instance $8 r0 *1 1.215,0.9025 PMOS_VTL
M$8 16 7 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.0144P AD=0.02205P PS=0.46U
+ PD=0.455U
* device instance $9 r0 *1 1.405,0.9025 PMOS_VTL
M$9 19 5 16 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $10 r0 *1 1.595,0.9025 PMOS_VTL
M$10 3 17 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $11 r0 *1 0.18,1.0475 PMOS_VTL
M$11 19 3 2 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.025725P PS=0.84U
+ PD=0.56U
* device instance $12 r0 *1 0.37,1.1 PMOS_VTL
M$12 21 4 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.025725P AD=0.0294P PS=0.56U
+ PD=0.56U
* device instance $13 r0 *1 0.56,1.1 PMOS_VTL
M$13 5 2 21 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.019425P PS=0.56U
+ PD=0.595U
* device instance $14 r0 *1 1.935,0.9775 PMOS_VTL
M$14 23 5 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $15 r0 *1 2.125,0.9775 PMOS_VTL
M$15 6 3 23 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.315,1.09 PMOS_VTL
M$16 20 2 6 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $17 r0 *1 2.505,1.09 PMOS_VTL
M$17 19 18 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U
+ PD=0.23U
* device instance $18 r0 *1 2.695,1.09 PMOS_VTL
M$18 20 7 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U
+ PD=0.39U
* device instance $19 r0 *1 2.315,0.315 NMOS_VTL
M$19 15 3 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $20 r0 *1 2.505,0.315 NMOS_VTL
M$20 13 18 15 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $21 r0 *1 2.695,0.315 NMOS_VTL
M$21 13 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.024425P AD=0.0063P PS=0.705U
+ PD=0.23U
* device instance $22 r0 *1 1.745,0.32 NMOS_VTL
M$22 1 17 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $23 r0 *1 1.935,0.32 NMOS_VTL
M$23 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $24 r0 *1 2.125,0.32 NMOS_VTL
M$24 6 2 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $25 r0 *1 3.035,0.2975 NMOS_VTL
M$25 8 18 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.053475P AD=0.0581P PS=1.26U PD=1.11U
* device instance $27 r0 *1 3.415,0.2975 NMOS_VTL
M$27 9 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $29 r0 *1 3.795,0.2975 NMOS_VTL
M$29 18 6 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $30 r0 *1 0.18,0.195 NMOS_VTL
M$30 1 3 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.016975P PS=0.63U
+ PD=0.415U
* device instance $31 r0 *1 0.785,0.31 NMOS_VTL
M$31 11 2 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.01435P AD=0.008325P PS=0.45U
+ PD=0.275U
* device instance $32 r0 *1 1.02,0.31 NMOS_VTL
M$32 1 16 11 1 NMOS_VTL L=0.05U W=0.09U AS=0.008325P AD=0.010725P PS=0.275U
+ PD=0.355U
* device instance $33 r0 *1 0.37,0.2275 NMOS_VTL
M$33 10 4 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.016975P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $34 r0 *1 0.56,0.2275 NMOS_VTL
M$34 5 3 10 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.01435P PS=0.415U
+ PD=0.45U
* device instance $35 r0 *1 1.215,0.37 NMOS_VTL
M$35 12 7 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.010725P AD=0.0147P PS=0.355U
+ PD=0.35U
* device instance $36 r0 *1 1.405,0.37 NMOS_VTL
M$36 16 5 12 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
.ENDS DFFS_X2

* cell BUF_X16
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X16 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=5.04U AS=0.37485P AD=0.3528P PS=6.86U PD=6.16U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 4 3 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.7056P AD=0.72765P PS=12.32U PD=13.02U
* device instance $25 r0 *1 0.185,0.2975 NMOS_VTL
M$25 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.246925P AD=0.2324P PS=4.925U PD=4.44U
* device instance $33 r0 *1 1.705,0.2975 NMOS_VTL
M$33 4 3 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4648P AD=0.479325P PS=8.88U PD=9.365U
.ENDS BUF_X16

* cell OR2_X2
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X2 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 3 2 4 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 4 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR2_X2

* cell NOR3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 6 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 4 2 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR3_X1

* cell XOR2_X1
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT XOR2_X1 1 3 4 5 6
* net 1 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 8 1 2 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 7 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 6 1 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 7 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.195 NMOS_VTL
M$6 2 1 4 4 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.36,0.195 NMOS_VTL
M$7 4 3 2 4 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.555,0.2975 NMOS_VTL
M$8 6 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.745,0.2975 NMOS_VTL
M$9 9 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.935,0.2975 NMOS_VTL
M$10 4 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XOR2_X1

* cell INV_X4
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X4 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 4 1 2 2 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS INV_X4

* cell OR2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT OR2_X4 1 2 3 5 6
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 1 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 4 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 4 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 4 3 3 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR2_X4

* cell AND3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AND3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 4 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 3 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 11 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 10 2 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 4 3 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 8 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 9 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.12,0.2975 NMOS_VTL
M$16 5 1 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.31,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND3_X4

* cell AOI211_X2
* pin B
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI211_X2 1 2 3 4 6 7 8
* net 1 B
* net 2 A
* net 3 C2
* net 4 C1
* net 6 ZN
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 10 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 7 2 10 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.555,0.995 PMOS_VTL
M$3 9 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.745,0.995 PMOS_VTL
M$4 5 1 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.055125P PS=0.77U PD=0.805U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 6 3 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.099225P AD=0.11025P PS=1.575U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 5 4 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 6 1 8 8 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0653625P PS=1.595U
+ PD=1.145U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 6 8 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 11 3 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.0363125P AD=0.02905P PS=0.59U
+ PD=0.555U
* device instance $14 r0 *1 1.16,0.2975 NMOS_VTL
M$14 6 4 11 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.35,0.2975 NMOS_VTL
M$15 12 4 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.54,0.2975 NMOS_VTL
M$16 8 3 12 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI211_X2

* cell DFFS_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin SN
* pin NWELL,VDD
.SUBCKT DFFS_X1 1 7 8 13 15 16 19
* net 1 PWELL,VSS
* net 7 QN
* net 8 Q
* net 13 D
* net 15 CK
* net 16 SN
* net 19 NWELL,VDD
* device instance $1 r0 *1 3.325,0.995 PMOS_VTL
M$1 19 5 7 19 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.515,0.995 PMOS_VTL
M$2 8 6 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.75,1.015 PMOS_VTL
M$3 22 2 4 19 PMOS_VTL L=0.05U W=0.09U AS=0.0183P AD=0.0072P PS=0.57U PD=0.25U
* device instance $4 r0 *1 0.96,1.015 PMOS_VTL
M$4 22 14 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.01485P AD=0.0072P PS=0.47U
+ PD=0.25U
* device instance $5 r0 *1 1.165,0.9025 PMOS_VTL
M$5 14 16 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.01485P AD=0.02205P PS=0.47U
+ PD=0.455U
* device instance $6 r0 *1 1.355,0.9025 PMOS_VTL
M$6 19 4 14 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $7 r0 *1 1.545,0.9025 PMOS_VTL
M$7 2 15 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $8 r0 *1 0.17,1.0725 PMOS_VTL
M$8 3 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.033075P PS=0.56U
+ PD=0.84U
* device instance $9 r0 *1 0.36,1.1 PMOS_VTL
M$9 21 13 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.025725P AD=0.0294P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 0.55,1.1 PMOS_VTL
M$10 4 3 21 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.0183P PS=0.56U PD=0.57U
* device instance $11 r0 *1 1.885,0.9775 PMOS_VTL
M$11 23 4 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $12 r0 *1 2.075,0.9775 PMOS_VTL
M$12 5 2 23 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $13 r0 *1 2.265,1.09 PMOS_VTL
M$13 20 3 5 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $14 r0 *1 2.455,1.09 PMOS_VTL
M$14 19 6 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $15 r0 *1 2.645,1.09 PMOS_VTL
M$15 20 16 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U
+ PD=0.39U
* device instance $16 r0 *1 2.985,0.9775 PMOS_VTL
M$16 6 5 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.84U
+ PD=0.84U
* device instance $17 r0 *1 3.325,0.2975 NMOS_VTL
M$17 1 5 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $18 r0 *1 3.515,0.2975 NMOS_VTL
M$18 8 6 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $19 r0 *1 2.265,0.315 NMOS_VTL
M$19 11 2 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $20 r0 *1 2.455,0.315 NMOS_VTL
M$20 10 6 11 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $21 r0 *1 2.645,0.315 NMOS_VTL
M$21 10 16 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.01095P AD=0.0063P PS=0.36U PD=0.23U
* device instance $22 r0 *1 2.845,0.255 NMOS_VTL
M$22 6 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.01095P AD=0.02205P PS=0.36U PD=0.63U
* device instance $23 r0 *1 1.695,0.375 NMOS_VTL
M$23 1 15 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $24 r0 *1 1.885,0.375 NMOS_VTL
M$24 18 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $25 r0 *1 2.075,0.375 NMOS_VTL
M$25 5 3 18 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $26 r0 *1 0.17,0.26 NMOS_VTL
M$26 3 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.36,0.2275 NMOS_VTL
M$27 9 13 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.016975P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $28 r0 *1 0.55,0.2275 NMOS_VTL
M$28 4 2 9 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.013225P PS=0.415U
+ PD=0.425U
* device instance $29 r0 *1 0.75,0.32 NMOS_VTL
M$29 12 3 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013225P AD=0.0072P PS=0.425U
+ PD=0.25U
* device instance $30 r0 *1 0.96,0.32 NMOS_VTL
M$30 12 14 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.012225P AD=0.0072P PS=0.365U
+ PD=0.25U
* device instance $31 r0 *1 1.165,0.32 NMOS_VTL
M$31 17 16 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.012225P AD=0.0147P PS=0.365U
+ PD=0.35U
* device instance $32 r0 *1 1.355,0.32 NMOS_VTL
M$32 14 4 17 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
.ENDS DFFS_X1

* cell AND2_X4
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT AND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 5 3 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.2975 NMOS_VTL
M$9 8 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.36,0.2975 NMOS_VTL
M$10 3 2 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.55,0.2975 NMOS_VTL
M$11 7 2 3 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.74,0.2975 NMOS_VTL
M$12 6 1 7 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.93,0.2975 NMOS_VTL
M$13 5 3 6 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND2_X4

* cell XNOR2_X2
* pin A
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT XNOR2_X2 2 3 4 5 7
* net 2 A
* net 3 B
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 1.135,0.995 PMOS_VTL
M$1 7 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 1.325,0.995 PMOS_VTL
M$2 9 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 1.515,0.995 PMOS_VTL
M$3 5 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 1.705,0.995 PMOS_VTL
M$4 8 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.18,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $7 r0 *1 0.56,0.995 PMOS_VTL
M$7 1 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 0.75,0.995 PMOS_VTL
M$8 5 2 1 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.135,0.2975 NMOS_VTL
M$9 6 2 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $11 r0 *1 1.515,0.2975 NMOS_VTL
M$11 6 3 7 4 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $13 r0 *1 0.18,0.2975 NMOS_VTL
M$13 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $15 r0 *1 0.56,0.2975 NMOS_VTL
M$15 10 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.75,0.2975 NMOS_VTL
M$16 1 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X2

* cell XOR2_X2
* pin B
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT XOR2_X2 1 2 4 5 7
* net 1 B
* net 2 A
* net 4 NWELL,VDD
* net 5 Z
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.2,0.995 PMOS_VTL
M$1 8 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.39,0.995 PMOS_VTL
M$2 4 1 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.58,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.77,0.995 PMOS_VTL
M$4 5 2 6 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.96,0.995 PMOS_VTL
M$5 6 1 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.2,0.2975 NMOS_VTL
M$9 3 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.39,0.2975 NMOS_VTL
M$10 7 1 3 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.58,0.2975 NMOS_VTL
M$11 5 3 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $12 r0 *1 0.77,0.2975 NMOS_VTL
M$12 10 2 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.96,0.2975 NMOS_VTL
M$13 7 1 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.15,0.2975 NMOS_VTL
M$14 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.34,0.2975 NMOS_VTL
M$15 5 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
.ENDS XOR2_X2

* cell OR3_X4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X4 1 2 3 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.205,0.995 PMOS_VTL
M$1 11 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.395,0.995 PMOS_VTL
M$2 10 2 11 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.585,0.995 PMOS_VTL
M$3 4 3 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.775,0.995 PMOS_VTL
M$4 9 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.965,0.995 PMOS_VTL
M$5 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.155,0.995 PMOS_VTL
M$6 6 1 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.345,0.995 PMOS_VTL
M$7 7 4 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.177975P AD=0.200025P PS=3.085U
+ PD=3.785U
* device instance $11 r0 *1 0.205,0.2975 NMOS_VTL
M$11 4 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.395,0.2975 NMOS_VTL
M$12 5 2 4 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $13 r0 *1 0.585,0.2975 NMOS_VTL
M$13 4 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.345,0.2975 NMOS_VTL
M$17 7 4 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1172375P AD=0.1317625P PS=2.225U
+ PD=2.71U
.ENDS OR3_X4

* cell NOR4_X2
* pin A3
* pin A2
* pin A1
* pin A4
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR4_X2 1 2 3 4 5 6 7
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 A4
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 11 1 12 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 10 2 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 6 3 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 9 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 13 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 8 1 13 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 4 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 6 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 7 1 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $11 r0 *1 0.59,0.2975 NMOS_VTL
M$11 6 2 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $12 r0 *1 0.78,0.2975 NMOS_VTL
M$12 7 3 6 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR4_X2

* cell LOGIC0_X1
* pin Z
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT LOGIC0_X1 1 3 4
* net 1 Z
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* device instance $1 r0 *1 0.185,1.19 PMOS_VTL
M$1 4 2 2 4 PMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
* device instance $2 r0 *1 0.185,0.21 NMOS_VTL
M$2 3 2 1 3 NMOS_VTL L=0.05U W=0.09U AS=0.00945P AD=0.00945P PS=0.39U PD=0.39U
.ENDS LOGIC0_X1

* cell FA_X1
* pin PWELL,VSS
* pin B
* pin CO
* pin S
* pin CI
* pin A
* pin NWELL,VDD
.SUBCKT FA_X1 1 2 3 8 11 12 14
* net 1 PWELL,VSS
* net 2 B
* net 3 CO
* net 8 S
* net 11 CI
* net 12 A
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.385,1.0275 PMOS_VTL
M$1 17 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $2 r0 *1 0.575,1.0275 PMOS_VTL
M$2 4 12 17 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.765,1.0275 PMOS_VTL
M$3 15 11 4 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02265P PS=0.455U
+ PD=0.535U
* device instance $4 r0 *1 0.96,1.1025 PMOS_VTL
M$4 14 12 15 14 PMOS_VTL L=0.05U W=0.315U AS=0.02265P AD=0.02205P PS=0.535U
+ PD=0.455U
* device instance $5 r0 *1 1.15,1.1025 PMOS_VTL
M$5 15 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $6 r0 *1 0.195,0.995 PMOS_VTL
M$6 14 4 3 14 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.033075P PS=1.47U
+ PD=0.77U
* device instance $7 r0 *1 1.49,1.1525 PMOS_VTL
M$7 16 2 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $8 r0 *1 1.68,1.1525 PMOS_VTL
M$8 14 11 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 1.87,1.1525 PMOS_VTL
M$9 16 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $10 r0 *1 2.06,1.1525 PMOS_VTL
M$10 7 4 16 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.023625P PS=0.455U
+ PD=0.465U
* device instance $11 r0 *1 2.26,1.1525 PMOS_VTL
M$11 18 11 7 14 PMOS_VTL L=0.05U W=0.315U AS=0.023625P AD=0.02205P PS=0.465U
+ PD=0.455U
* device instance $12 r0 *1 2.45,1.1525 PMOS_VTL
M$12 19 2 18 14 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $13 r0 *1 2.64,1.1525 PMOS_VTL
M$13 19 12 14 14 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $14 r0 *1 2.83,0.995 PMOS_VTL
M$14 8 7 14 14 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U
+ PD=1.47U
* device instance $15 r0 *1 0.385,0.32 NMOS_VTL
M$15 13 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.0147P PS=0.555U
+ PD=0.35U
* device instance $16 r0 *1 0.575,0.32 NMOS_VTL
M$16 4 12 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $17 r0 *1 0.765,0.32 NMOS_VTL
M$17 5 11 4 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.015225P PS=0.35U
+ PD=0.355U
* device instance $18 r0 *1 0.96,0.32 NMOS_VTL
M$18 1 12 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.015225P AD=0.0147P PS=0.355U
+ PD=0.35U
* device instance $19 r0 *1 1.15,0.32 NMOS_VTL
M$19 5 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $20 r0 *1 0.195,0.2975 NMOS_VTL
M$20 1 4 3 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.021875P PS=1.04U
+ PD=0.555U
* device instance $21 r0 *1 1.49,0.195 NMOS_VTL
M$21 6 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $22 r0 *1 1.68,0.195 NMOS_VTL
M$22 1 11 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $23 r0 *1 1.87,0.195 NMOS_VTL
M$23 6 12 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $24 r0 *1 2.06,0.195 NMOS_VTL
M$24 7 4 6 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.01575P PS=0.35U PD=0.36U
* device instance $25 r0 *1 2.26,0.195 NMOS_VTL
M$25 9 11 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.01575P AD=0.0147P PS=0.36U PD=0.35U
* device instance $26 r0 *1 2.45,0.195 NMOS_VTL
M$26 10 2 9 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 2.64,0.195 NMOS_VTL
M$27 1 12 10 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $28 r0 *1 2.83,0.2975 NMOS_VTL
M$28 8 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS FA_X1

* cell OAI222_X2
* pin PWELL,VSS
* pin C1
* pin C2
* pin B1
* pin B2
* pin A1
* pin A2
* pin ZN
* pin NWELL,VDD
.SUBCKT OAI222_X2 1 4 5 6 7 8 9 10 11
* net 1 PWELL,VSS
* net 4 C1
* net 5 C2
* net 6 B1
* net 7 B2
* net 8 A1
* net 9 A2
* net 10 ZN
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.215,0.995 PMOS_VTL
M$1 12 4 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.405,0.995 PMOS_VTL
M$2 11 5 12 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.595,0.995 PMOS_VTL
M$3 13 5 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.785,0.995 PMOS_VTL
M$4 10 4 13 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.975,0.995 PMOS_VTL
M$5 14 6 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.165,0.995 PMOS_VTL
M$6 11 7 14 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.355,0.995 PMOS_VTL
M$7 15 7 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.545,0.995 PMOS_VTL
M$8 10 6 15 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0945P PS=0.77U PD=0.93U
* device instance $9 r0 *1 1.895,0.995 PMOS_VTL
M$9 16 8 10 11 PMOS_VTL L=0.05U W=0.63U AS=0.0945P AD=0.0441P PS=0.93U PD=0.77U
* device instance $10 r0 *1 2.085,0.995 PMOS_VTL
M$10 11 9 16 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.275,0.995 PMOS_VTL
M$11 17 9 11 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.465,0.995 PMOS_VTL
M$12 10 8 17 11 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0693P PS=0.77U PD=1.48U
* device instance $13 r0 *1 1.895,0.2975 NMOS_VTL
M$13 10 8 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $14 r0 *1 2.085,0.2975 NMOS_VTL
M$14 3 9 10 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 0.215,0.2975 NMOS_VTL
M$17 1 4 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $18 r0 *1 0.405,0.2975 NMOS_VTL
M$18 2 5 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 0.975,0.2975 NMOS_VTL
M$21 3 6 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $22 r0 *1 1.165,0.2975 NMOS_VTL
M$22 2 7 3 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI222_X2

* cell AOI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI221_X1 1 2 3 4 5 6 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 6 PWELL,VSS
* net 8 NWELL,VDD
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 8 1 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 7 2 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 10 3 7 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 9 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 10 5 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 12 1 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 9 2 12 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 11 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 9 5 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X1

* cell OAI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI22_X1 1 2 3 4 6 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 8 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 9 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 7 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 5 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 8 3 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 8 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI22_X1

* cell NAND3_X1
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X1 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.2975 NMOS_VTL
M$4 8 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.36,0.2975 NMOS_VTL
M$5 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X1

* cell DFF_X2
* pin PWELL,VSS
* pin D
* pin CK
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFF_X2 1 6 8 10 11 16
* net 1 PWELL,VSS
* net 6 D
* net 8 CK
* net 10 QN
* net 11 Q
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.855,0.995 PMOS_VTL
M$1 10 9 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 3.235,0.995 PMOS_VTL
M$3 11 2 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.2,0.9275 PMOS_VTL
M$5 16 7 3 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $6 r0 *1 0.39,1.04 PMOS_VTL
M$6 17 4 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $7 r0 *1 0.58,1.04 PMOS_VTL
M$7 17 7 5 16 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $8 r0 *1 0.77,0.975 PMOS_VTL
M$8 18 3 5 16 PMOS_VTL L=0.05U W=0.42U AS=0.01785P AD=0.0294P PS=0.56U PD=0.56U
* device instance $9 r0 *1 0.96,0.975 PMOS_VTL
M$9 16 6 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $10 r0 *1 1.15,1.0275 PMOS_VTL
M$10 4 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $11 r0 *1 2.135,0.915 PMOS_VTL
M$11 20 3 9 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $12 r0 *1 2.325,0.915 PMOS_VTL
M$12 20 2 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $13 r0 *1 1.565,1.0275 PMOS_VTL
M$13 16 8 7 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $14 r0 *1 1.755,1.0275 PMOS_VTL
M$14 19 5 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $15 r0 *1 1.945,1.0275 PMOS_VTL
M$15 9 7 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $16 r0 *1 2.515,0.995 PMOS_VTL
M$16 2 9 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.06615P PS=0.77U PD=1.47U
* device instance $17 r0 *1 2.855,0.2975 NMOS_VTL
M$17 10 9 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $19 r0 *1 3.235,0.2975 NMOS_VTL
M$19 11 2 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $21 r0 *1 0.39,0.31 NMOS_VTL
M$21 12 4 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $22 r0 *1 0.58,0.31 NMOS_VTL
M$22 12 3 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $23 r0 *1 1.15,0.25 NMOS_VTL
M$23 4 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $24 r0 *1 0.77,0.2825 NMOS_VTL
M$24 13 7 5 1 NMOS_VTL L=0.05U W=0.275U AS=0.012775P AD=0.01925P PS=0.415U
+ PD=0.415U
* device instance $25 r0 *1 0.96,0.2825 NMOS_VTL
M$25 1 6 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
* device instance $26 r0 *1 0.2,0.37 NMOS_VTL
M$26 1 7 3 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $27 r0 *1 1.565,0.35 NMOS_VTL
M$27 1 8 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $28 r0 *1 1.755,0.35 NMOS_VTL
M$28 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $29 r0 *1 1.945,0.35 NMOS_VTL
M$29 9 3 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $30 r0 *1 2.135,0.41 NMOS_VTL
M$30 15 7 9 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $31 r0 *1 2.325,0.41 NMOS_VTL
M$31 15 2 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $32 r0 *1 2.515,0.2975 NMOS_VTL
M$32 2 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFF_X2

* cell DFF_X1
* pin PWELL,VSS
* pin QN
* pin Q
* pin D
* pin CK
* pin NWELL,VDD
.SUBCKT DFF_X1 1 8 9 14 15 16
* net 1 PWELL,VSS
* net 8 QN
* net 9 Q
* net 14 D
* net 15 CK
* net 16 NWELL,VDD
* device instance $1 r0 *1 2.85,0.995 PMOS_VTL
M$1 16 6 8 16 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.04,0.995 PMOS_VTL
M$2 9 7 16 16 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.9425 PMOS_VTL
M$3 16 5 2 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.014175P PS=0.84U
+ PD=0.455U
* device instance $4 r0 *1 0.375,1.055 PMOS_VTL
M$4 17 3 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $5 r0 *1 0.565,1.055 PMOS_VTL
M$5 17 5 4 16 PMOS_VTL L=0.05U W=0.09U AS=0.018075P AD=0.0063P PS=0.565U
+ PD=0.23U
* device instance $6 r0 *1 0.76,0.975 PMOS_VTL
M$6 18 2 4 16 PMOS_VTL L=0.05U W=0.42U AS=0.018075P AD=0.0294P PS=0.565U
+ PD=0.56U
* device instance $7 r0 *1 0.95,0.975 PMOS_VTL
M$7 16 14 18 16 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.025725P PS=0.56U
+ PD=0.56U
* device instance $8 r0 *1 1.14,1.0275 PMOS_VTL
M$8 3 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.025725P AD=0.0567P PS=0.56U
+ PD=0.99U
* device instance $9 r0 *1 1.555,1.0275 PMOS_VTL
M$9 16 15 5 16 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $10 r0 *1 1.745,1.0275 PMOS_VTL
M$10 19 4 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $11 r0 *1 1.935,1.0275 PMOS_VTL
M$11 6 5 19 16 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $12 r0 *1 2.125,1.14 PMOS_VTL
M$12 20 2 6 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $13 r0 *1 2.32,1.14 PMOS_VTL
M$13 20 7 16 16 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.006525P PS=0.455U
+ PD=0.235U
* device instance $14 r0 *1 2.51,1.0275 PMOS_VTL
M$14 7 6 16 16 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $15 r0 *1 2.85,0.2975 NMOS_VTL
M$15 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $16 r0 *1 3.04,0.2975 NMOS_VTL
M$16 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $17 r0 *1 2.125,0.345 NMOS_VTL
M$17 12 5 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $18 r0 *1 2.32,0.345 NMOS_VTL
M$18 12 7 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.006525P PS=0.35U
+ PD=0.235U
* device instance $19 r0 *1 1.555,0.36 NMOS_VTL
M$19 1 15 5 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $20 r0 *1 1.745,0.36 NMOS_VTL
M$20 13 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $21 r0 *1 1.935,0.36 NMOS_VTL
M$21 6 2 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $22 r0 *1 2.51,0.36 NMOS_VTL
M$22 7 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.02205P PS=0.35U PD=0.63U
* device instance $23 r0 *1 0.185,0.285 NMOS_VTL
M$23 1 5 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0105P PS=0.63U PD=0.35U
* device instance $24 r0 *1 0.375,0.345 NMOS_VTL
M$24 10 3 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 0.565,0.345 NMOS_VTL
M$25 10 2 4 1 NMOS_VTL L=0.05U W=0.09U AS=0.013P AD=0.0063P PS=0.42U PD=0.23U
* device instance $26 r0 *1 1.14,0.285 NMOS_VTL
M$26 3 4 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.016975P AD=0.02205P PS=0.415U
+ PD=0.63U
* device instance $27 r0 *1 0.76,0.3175 NMOS_VTL
M$27 11 5 4 1 NMOS_VTL L=0.05U W=0.275U AS=0.013P AD=0.01925P PS=0.42U PD=0.415U
* device instance $28 r0 *1 0.95,0.3175 NMOS_VTL
M$28 1 14 11 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.016975P PS=0.415U
+ PD=0.415U
.ENDS DFF_X1

* cell CLKBUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.19,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.38,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.19,0.2075 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.095U AS=0.009975P AD=0.01015P PS=0.4U PD=0.335U
* device instance $4 r0 *1 0.38,0.2575 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.195U AS=0.01015P AD=0.020475P PS=0.335U PD=0.6U
.ENDS CLKBUF_X1

* cell DFFR_X2
* pin PWELL,VSS
* pin CK
* pin D
* pin RN
* pin QN
* pin Q
* pin NWELL,VDD
.SUBCKT DFFR_X2 1 3 5 9 11 12 19
* net 1 PWELL,VSS
* net 3 CK
* net 5 D
* net 9 RN
* net 11 QN
* net 12 Q
* net 19 NWELL,VDD
* device instance $1 r0 *1 2.51,1.025 PMOS_VTL
M$1 23 4 8 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $2 r0 *1 2.7,1.025 PMOS_VTL
M$2 23 10 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0252P AD=0.0063P PS=0.77U PD=0.23U
* device instance $3 r0 *1 1.875,1.0125 PMOS_VTL
M$3 19 6 7 19 PMOS_VTL L=0.05U W=0.315U AS=0.04725P AD=0.0322875P PS=0.93U
+ PD=0.52U
* device instance $4 r0 *1 2.13,1.0125 PMOS_VTL
M$4 22 6 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.0322875P AD=0.02205P PS=0.52U
+ PD=0.455U
* device instance $5 r0 *1 2.32,1.0125 PMOS_VTL
M$5 8 2 22 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $6 r0 *1 2.89,0.995 PMOS_VTL
M$6 10 9 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0252P AD=0.048825P PS=0.77U
+ PD=0.785U
* device instance $7 r0 *1 3.095,0.995 PMOS_VTL
M$7 19 8 10 19 PMOS_VTL L=0.05U W=0.63U AS=0.048825P AD=0.06615P PS=0.785U
+ PD=0.84U
* device instance $8 r0 *1 3.355,0.995 PMOS_VTL
M$8 11 8 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.1323P AD=0.11025P PS=1.68U PD=1.61U
* device instance $10 r0 *1 3.805,0.995 PMOS_VTL
M$10 12 10 19 19 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U
+ PD=2.24U
* device instance $12 r0 *1 1.1,1.065 PMOS_VTL
M$12 20 2 6 19 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $13 r0 *1 1.29,1.065 PMOS_VTL
M$13 19 7 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $14 r0 *1 1.48,1.065 PMOS_VTL
M$14 20 9 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.01035P PS=0.23U
+ PD=0.41U
* device instance $15 r0 *1 0.72,1.05 PMOS_VTL
M$15 21 5 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.0441P AD=0.0294P PS=1.05U PD=0.56U
* device instance $16 r0 *1 0.91,1.05 PMOS_VTL
M$16 6 4 21 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.01785P PS=0.56U PD=0.56U
* device instance $17 r0 *1 0.19,1.0325 PMOS_VTL
M$17 19 3 2 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $18 r0 *1 0.38,1.0325 PMOS_VTL
M$18 4 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $19 r0 *1 3.425,0.2975 NMOS_VTL
M$19 11 8 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U
+ PD=1.11U
* device instance $21 r0 *1 3.805,0.2975 NMOS_VTL
M$21 12 10 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U
+ PD=1.595U
* device instance $23 r0 *1 2.445,0.26 NMOS_VTL
M$23 18 2 8 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $24 r0 *1 2.635,0.26 NMOS_VTL
M$24 18 10 1 1 NMOS_VTL L=0.05U W=0.09U AS=0.017675P AD=0.0063P PS=0.555U
+ PD=0.23U
* device instance $25 r0 *1 1.875,0.32 NMOS_VTL
M$25 1 6 7 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $26 r0 *1 2.065,0.32 NMOS_VTL
M$26 16 6 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $27 r0 *1 2.255,0.32 NMOS_VTL
M$27 8 4 16 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $28 r0 *1 2.825,0.2975 NMOS_VTL
M$28 17 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.017675P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $29 r0 *1 3.015,0.2975 NMOS_VTL
M$29 10 8 17 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $30 r0 *1 0.19,0.245 NMOS_VTL
M$30 1 3 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $31 r0 *1 0.38,0.245 NMOS_VTL
M$31 4 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $32 r0 *1 1.1,0.35 NMOS_VTL
M$32 15 4 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $33 r0 *1 1.29,0.35 NMOS_VTL
M$33 14 7 15 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $34 r0 *1 1.48,0.35 NMOS_VTL
M$34 1 9 14 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $35 r0 *1 0.72,0.3525 NMOS_VTL
M$35 13 5 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.028875P AD=0.01925P PS=0.76U
+ PD=0.415U
* device instance $36 r0 *1 0.91,0.3525 NMOS_VTL
M$36 6 2 13 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.012775P PS=0.415U
+ PD=0.415U
.ENDS DFFR_X2

* cell DFFR_X1
* pin PWELL,VSS
* pin CK
* pin QN
* pin Q
* pin D
* pin RN
* pin NWELL,VDD
.SUBCKT DFFR_X1 1 3 8 9 16 18 19
* net 1 PWELL,VSS
* net 3 CK
* net 8 QN
* net 9 Q
* net 16 D
* net 18 RN
* net 19 NWELL,VDD
* device instance $1 r0 *1 3.41,0.995 PMOS_VTL
M$1 19 6 8 19 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 3.6,0.995 PMOS_VTL
M$2 9 7 19 19 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 2.455,1.04 PMOS_VTL
M$3 21 4 6 19 PMOS_VTL L=0.05U W=0.09U AS=0.014175P AD=0.0063P PS=0.455U
+ PD=0.23U
* device instance $4 r0 *1 2.645,1.04 PMOS_VTL
M$4 19 7 21 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.014175P PS=0.23U
+ PD=0.455U
* device instance $5 r0 *1 1.815,1.0125 PMOS_VTL
M$5 19 5 17 19 PMOS_VTL L=0.05U W=0.315U AS=0.03465P AD=0.033075P PS=0.85U
+ PD=0.525U
* device instance $6 r0 *1 2.075,1.0125 PMOS_VTL
M$6 23 5 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.525U
+ PD=0.455U
* device instance $7 r0 *1 2.265,1.0125 PMOS_VTL
M$7 6 2 23 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.014175P PS=0.455U
+ PD=0.455U
* device instance $8 r0 *1 2.835,1.1525 PMOS_VTL
M$8 7 18 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.014175P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $9 r0 *1 3.025,1.1525 PMOS_VTL
M$9 19 6 7 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $10 r0 *1 1.08,1.065 PMOS_VTL
M$10 20 2 5 19 PMOS_VTL L=0.05U W=0.09U AS=0.01785P AD=0.0063P PS=0.56U PD=0.23U
* device instance $11 r0 *1 1.27,1.065 PMOS_VTL
M$11 19 17 20 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U
+ PD=0.23U
* device instance $12 r0 *1 1.46,1.065 PMOS_VTL
M$12 20 18 19 19 PMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.01035P PS=0.23U
+ PD=0.41U
* device instance $13 r0 *1 0.7,1.05 PMOS_VTL
M$13 22 16 19 19 PMOS_VTL L=0.05U W=0.42U AS=0.0441P AD=0.0294P PS=1.05U
+ PD=0.56U
* device instance $14 r0 *1 0.89,1.05 PMOS_VTL
M$14 5 4 22 19 PMOS_VTL L=0.05U W=0.42U AS=0.0294P AD=0.01785P PS=0.56U PD=0.56U
* device instance $15 r0 *1 0.17,1.1525 PMOS_VTL
M$15 19 3 2 19 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $16 r0 *1 0.36,1.1525 PMOS_VTL
M$16 4 2 19 19 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $17 r0 *1 1.08,0.35 NMOS_VTL
M$17 12 4 5 1 NMOS_VTL L=0.05U W=0.09U AS=0.012775P AD=0.0063P PS=0.415U
+ PD=0.23U
* device instance $18 r0 *1 1.27,0.35 NMOS_VTL
M$18 11 17 12 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0063P PS=0.23U PD=0.23U
* device instance $19 r0 *1 1.46,0.35 NMOS_VTL
M$19 1 18 11 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.00945P PS=0.23U PD=0.39U
* device instance $20 r0 *1 0.7,0.3525 NMOS_VTL
M$20 10 16 1 1 NMOS_VTL L=0.05U W=0.275U AS=0.028875P AD=0.01925P PS=0.76U
+ PD=0.415U
* device instance $21 r0 *1 0.89,0.3525 NMOS_VTL
M$21 5 2 10 1 NMOS_VTL L=0.05U W=0.275U AS=0.01925P AD=0.012775P PS=0.415U
+ PD=0.415U
* device instance $22 r0 *1 0.17,0.245 NMOS_VTL
M$22 1 3 2 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $23 r0 *1 0.36,0.245 NMOS_VTL
M$23 4 2 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $24 r0 *1 2.455,0.26 NMOS_VTL
M$24 15 2 6 1 NMOS_VTL L=0.05U W=0.09U AS=0.0105P AD=0.0063P PS=0.35U PD=0.23U
* device instance $25 r0 *1 2.645,0.26 NMOS_VTL
M$25 1 7 15 1 NMOS_VTL L=0.05U W=0.09U AS=0.0063P AD=0.0105P PS=0.23U PD=0.35U
* device instance $26 r0 *1 1.815,0.32 NMOS_VTL
M$26 1 5 17 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.02205P PS=0.63U PD=0.42U
* device instance $27 r0 *1 2.075,0.32 NMOS_VTL
M$27 14 5 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.42U PD=0.35U
* device instance $28 r0 *1 2.265,0.32 NMOS_VTL
M$28 6 4 14 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0105P PS=0.35U PD=0.35U
* device instance $29 r0 *1 2.835,0.32 NMOS_VTL
M$29 13 18 1 1 NMOS_VTL L=0.05U W=0.21U AS=0.0105P AD=0.0147P PS=0.35U PD=0.35U
* device instance $30 r0 *1 3.025,0.32 NMOS_VTL
M$30 7 6 13 1 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $31 r0 *1 3.41,0.2975 NMOS_VTL
M$31 1 6 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $32 r0 *1 3.6,0.2975 NMOS_VTL
M$32 9 7 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS DFFR_X1

* cell HA_X1
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin CO
.SUBCKT HA_X1 1 2 4 5 6 9
* net 1 A
* net 2 B
* net 4 S
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 9 CO
* device instance $1 r0 *1 0.785,1.0275 PMOS_VTL
M$1 10 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $2 r0 *1 0.975,1.0275 PMOS_VTL
M$2 7 1 10 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.033075P PS=0.455U
+ PD=0.84U
* device instance $3 r0 *1 0.21,0.995 PMOS_VTL
M$3 4 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $4 r0 *1 0.4,0.995 PMOS_VTL
M$4 3 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.59,0.995 PMOS_VTL
M$5 5 7 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0338625P PS=0.77U PD=0.775U
* device instance $6 r0 *1 1.345,1.0275 PMOS_VTL
M$6 8 1 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $7 r0 *1 1.535,1.0275 PMOS_VTL
M$7 8 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $8 r0 *1 1.725,0.995 PMOS_VTL
M$8 9 8 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 1.345,0.195 NMOS_VTL
M$9 12 1 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $10 r0 *1 1.535,0.195 NMOS_VTL
M$10 6 2 12 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $11 r0 *1 1.725,0.2975 NMOS_VTL
M$11 9 8 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $12 r0 *1 0.785,0.195 NMOS_VTL
M$12 7 2 6 6 NMOS_VTL L=0.05U W=0.21U AS=0.0224P AD=0.0147P PS=0.56U PD=0.35U
* device instance $13 r0 *1 0.975,0.195 NMOS_VTL
M$13 6 1 7 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.02205P PS=0.35U PD=0.63U
* device instance $14 r0 *1 0.21,0.2975 NMOS_VTL
M$14 11 2 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $15 r0 *1 0.4,0.2975 NMOS_VTL
M$15 4 1 11 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.59,0.2975 NMOS_VTL
M$16 6 7 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0224P PS=0.555U PD=0.56U
.ENDS HA_X1

* cell AND4_X4
* pin PWELL,VSS
* pin A4
* pin A3
* pin A2
* pin A1
* pin ZN
* pin NWELL,VDD
.SUBCKT AND4_X4 1 2 3 4 6 7 14
* net 1 PWELL,VSS
* net 2 A4
* net 3 A3
* net 4 A2
* net 6 A1
* net 7 ZN
* net 14 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 2 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 14 3 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 5 4 14 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 14 6 5 14 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.705,0.995 PMOS_VTL
M$9 7 5 14 14 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 8 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.375,0.2975 NMOS_VTL
M$14 9 3 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.565,0.2975 NMOS_VTL
M$15 10 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.755,0.2975 NMOS_VTL
M$16 5 6 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 12 6 5 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 11 4 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 13 3 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 2 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 7 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS AND4_X4

* cell XNOR2_X1
* pin A
* pin B
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT XNOR2_X1 1 2 4 5 7
* net 1 A
* net 2 B
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.18,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.37,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.0338625P AD=0.02205P PS=0.775U
+ PD=0.455U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 7 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.0338625P AD=0.0441P PS=0.775U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 8 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 4 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.18,0.195 NMOS_VTL
M$6 9 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $7 r0 *1 0.37,0.195 NMOS_VTL
M$7 5 2 9 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0224P PS=0.35U PD=0.56U
* device instance $8 r0 *1 0.565,0.2975 NMOS_VTL
M$8 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.0224P AD=0.02905P PS=0.56U PD=0.555U
* device instance $9 r0 *1 0.755,0.2975 NMOS_VTL
M$9 7 1 6 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.945,0.2975 NMOS_VTL
M$10 6 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS XNOR2_X1

* cell OR4_X4
* pin PWELL,VSS
* pin ZN
* pin A4
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
.SUBCKT OR4_X4 1 3 4 5 6 7 8
* net 1 PWELL,VSS
* net 3 ZN
* net 4 A4
* net 5 A3
* net 6 A2
* net 7 A1
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 4 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 5 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 11 6 9 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 2 7 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 13 7 2 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 14 6 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 12 5 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 8 4 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 3 2 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 4 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 1 5 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 2 6 1 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 7 2 1 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $21 r0 *1 1.69,0.2975 NMOS_VTL
M$21 3 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS OR4_X4

* cell OR3_X2
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 5 1 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 4 2 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 5 3 4 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS OR3_X2

* cell AOI222_X2
* pin PWELL,VSS
* pin C2
* pin C1
* pin ZN
* pin B2
* pin B1
* pin A1
* pin A2
* pin NWELL,VDD
.SUBCKT AOI222_X2 1 2 3 4 5 6 8 9 16
* net 1 PWELL,VSS
* net 2 C2
* net 3 C1
* net 4 ZN
* net 5 B2
* net 6 B1
* net 8 A1
* net 9 A2
* net 16 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 16 2 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 15 3 16 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 17 5 15 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 15 6 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 4 8 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $11 r0 *1 2.255,0.995 PMOS_VTL
M$11 4 9 17 16 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 10 2 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.36,0.2975 NMOS_VTL
M$14 4 3 10 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.55,0.2975 NMOS_VTL
M$15 12 3 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.74,0.2975 NMOS_VTL
M$16 1 2 12 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 13 5 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 6 13 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.31,0.2975 NMOS_VTL
M$19 14 6 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.5,0.2975 NMOS_VTL
M$20 1 5 14 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 4 8 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $22 r0 *1 2.065,0.2975 NMOS_VTL
M$22 11 8 4 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.255,0.2975 NMOS_VTL
M$23 1 9 11 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.445,0.2975 NMOS_VTL
M$24 7 9 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI222_X2

* cell OAI21_X4
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X4 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 11 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 7 3 11 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.31,0.995 PMOS_VTL
M$7 10 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.5,0.995 PMOS_VTL
M$8 5 2 10 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.69,0.995 PMOS_VTL
M$9 9 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $10 r0 *1 1.88,0.995 PMOS_VTL
M$10 7 3 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 2.07,0.995 PMOS_VTL
M$11 8 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $12 r0 *1 2.26,0.995 PMOS_VTL
M$12 5 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 6 1 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 7 2 4 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $18 r0 *1 1.12,0.2975 NMOS_VTL
M$18 4 3 7 6 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS OAI21_X4

* cell OAI221_X1
* pin B2
* pin B1
* pin A
* pin C2
* pin C1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI221_X1 1 2 3 4 5 7 8 9
* net 1 B2
* net 2 B1
* net 3 A
* net 4 C2
* net 5 C1
* net 7 NWELL,VDD
* net 8 PWELL,VSS
* net 9 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 12 1 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 12 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 9 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 11 4 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 5 11 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 8 1 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 6 2 8 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 10 3 6 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 9 4 10 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.93,0.2975 NMOS_VTL
M$10 10 5 9 8 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI221_X1

* cell NAND4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 7 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 9 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 8 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND4_X1

* cell NOR4_X1
* pin A4
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR4_X1 1 2 3 4 5 6 7
* net 1 A4
* net 2 A3
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 10 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 9 2 10 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 3 9 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 8 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 7 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 5 4 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR4_X1

* cell CLKBUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.17,0.1875 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $5 r0 *1 0.36,0.1875 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.39U AS=0.0273P AD=0.034125P PS=0.67U PD=0.935U
.ENDS CLKBUF_X2

* cell AND4_X2
* pin A1
* pin A2
* pin A3
* pin A4
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND4_X2 1 2 3 4 6 7 8
* net 1 A1
* net 2 A2
* net 3 A3
* net 4 A4
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 6 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 6 4 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 8 5 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 11 1 5 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.36,0.2975 NMOS_VTL
M$8 10 2 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 9 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 7 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.93,0.2975 NMOS_VTL
M$11 8 5 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND4_X2

* cell OAI21_X1
* pin B2
* pin B1
* pin A
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT OAI21_X1 1 2 3 5 6 7
* net 1 B2
* net 2 B1
* net 3 A
* net 5 NWELL,VDD
* net 6 ZN
* net 7 PWELL,VSS
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 8 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 6 2 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.575,0.995 PMOS_VTL
M$3 5 3 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.195,0.2975 NMOS_VTL
M$4 6 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.385,0.2975 NMOS_VTL
M$5 4 2 6 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.575,0.2975 NMOS_VTL
M$6 7 3 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI21_X1

* cell MUX2_X2
* pin A
* pin B
* pin S
* pin NWELL,VDD
* pin PWELL,VSS
* pin Z
.SUBCKT MUX2_X2 1 2 3 6 7 8
* net 1 A
* net 2 B
* net 3 S
* net 6 NWELL,VDD
* net 7 PWELL,VSS
* net 8 Z
* device instance $1 r0 *1 1.16,0.995 PMOS_VTL
M$1 8 4 6 6 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.077175P PS=2.24U PD=1.54U
* device instance $3 r0 *1 1.54,1.1525 PMOS_VTL
M$3 9 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $4 r0 *1 0.215,0.995 PMOS_VTL
M$4 6 1 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $5 r0 *1 0.405,0.995 PMOS_VTL
M$5 5 9 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 0.595,0.995 PMOS_VTL
M$6 4 2 5 6 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.045675P PS=0.77U PD=0.775U
* device instance $7 r0 *1 0.79,0.995 PMOS_VTL
M$7 5 3 4 6 PMOS_VTL L=0.05U W=0.63U AS=0.045675P AD=0.0693P PS=0.775U PD=1.48U
* device instance $8 r0 *1 1.54,0.195 NMOS_VTL
M$8 9 3 7 7 NMOS_VTL L=0.05U W=0.21U AS=0.021875P AD=0.02205P PS=0.555U PD=0.63U
* device instance $9 r0 *1 1.16,0.2975 NMOS_VTL
M$9 8 4 7 7 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.050925P PS=1.595U
+ PD=1.11U
* device instance $11 r0 *1 0.215,0.2975 NMOS_VTL
M$11 11 1 4 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $12 r0 *1 0.405,0.2975 NMOS_VTL
M$12 7 9 11 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.595,0.2975 NMOS_VTL
M$13 10 2 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.0300875P PS=0.555U
+ PD=0.56U
* device instance $14 r0 *1 0.79,0.2975 NMOS_VTL
M$14 4 3 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.0300875P AD=0.043575P PS=0.56U
+ PD=1.04U
.ENDS MUX2_X2

* cell AOI21_X2
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X2 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 6 1 4 4 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 9 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X2

* cell AOI221_X2
* pin B1
* pin B2
* pin A
* pin C2
* pin C1
* pin ZN
* pin NWELL,VDD
* pin PWELL,VSS
.SUBCKT AOI221_X2 1 2 3 4 5 6 8 9
* net 1 B1
* net 2 B2
* net 3 A
* net 4 C2
* net 5 C1
* net 6 ZN
* net 8 NWELL,VDD
* net 9 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 3 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.09135P PS=2.24U PD=1.55U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 8 1 7 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 7 2 8 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 1.32,0.995 PMOS_VTL
M$7 6 4 10 8 PMOS_VTL L=0.05U W=1.26U AS=0.09135P AD=0.11025P PS=1.55U PD=2.24U
* device instance $8 r0 *1 1.51,0.995 PMOS_VTL
M$8 10 5 6 8 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $11 r0 *1 0.17,0.2975 NMOS_VTL
M$11 6 3 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.060175P PS=1.595U
+ PD=1.12U
* device instance $12 r0 *1 0.36,0.2975 NMOS_VTL
M$12 14 1 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.55,0.2975 NMOS_VTL
M$13 9 2 14 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 0.74,0.2975 NMOS_VTL
M$14 13 2 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.93,0.2975 NMOS_VTL
M$15 6 1 13 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 1.32,0.2975 NMOS_VTL
M$17 12 4 9 9 NMOS_VTL L=0.05U W=0.415U AS=0.031125P AD=0.02905P PS=0.565U
+ PD=0.555U
* device instance $18 r0 *1 1.51,0.2975 NMOS_VTL
M$18 6 5 12 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.7,0.2975 NMOS_VTL
M$19 11 5 6 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.89,0.2975 NMOS_VTL
M$20 9 4 11 9 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI221_X2

* cell BUF_X32
* pin PWELL,VSS
* pin A
* pin Z
* pin NWELL,VDD
.SUBCKT BUF_X32 1 2 4 5
* net 1 PWELL,VSS
* net 2 A
* net 4 Z
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 2 5 5 PMOS_VTL L=0.05U W=10.08U AS=0.729225P AD=0.707175P PS=13.025U
+ PD=12.325U
* device instance $17 r0 *1 3.215,0.995 PMOS_VTL
M$17 4 3 5 5 PMOS_VTL L=0.05U W=20.16U AS=1.4175P AD=1.43955P PS=24.66U
+ PD=25.36U
* device instance $49 r0 *1 0.17,0.2975 NMOS_VTL
M$49 3 2 1 1 NMOS_VTL L=0.05U W=6.64U AS=0.4803625P AD=0.4658375P PS=9.37U
+ PD=8.885U
* device instance $65 r0 *1 3.215,0.2975 NMOS_VTL
M$65 4 3 1 1 NMOS_VTL L=0.05U W=13.28U AS=0.93375P AD=0.948275P PS=17.78U
+ PD=18.265U
.ENDS BUF_X32

* cell AND2_X2
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X2 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 3 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $5 r0 *1 0.17,0.2975 NMOS_VTL
M$5 7 1 3 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.36,0.2975 NMOS_VTL
M$6 5 2 7 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.55,0.2975 NMOS_VTL
M$7 6 3 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND2_X2

* cell OAI33_X1
* pin B3
* pin B2
* pin B1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OAI33_X1 1 2 3 4 5 6 7 8 10
* net 1 B3
* net 2 B2
* net 3 B1
* net 4 A1
* net 5 A2
* net 6 A3
* net 7 PWELL,VSS
* net 8 NWELL,VDD
* net 10 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 14 1 8 8 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 13 2 14 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 10 3 13 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 12 4 10 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 11 5 12 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 8 6 11 8 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.185,0.2975 NMOS_VTL
M$7 9 1 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.375,0.2975 NMOS_VTL
M$8 7 2 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.565,0.2975 NMOS_VTL
M$9 9 3 7 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.755,0.2975 NMOS_VTL
M$10 10 4 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.945,0.2975 NMOS_VTL
M$11 9 5 10 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.135,0.2975 NMOS_VTL
M$12 10 6 9 7 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OAI33_X1

* cell OAI21_X2
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT OAI21_X2 1 2 3 5 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 7 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 8 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 3 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 9 3 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 5 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 6 1 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 7 2 4 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $10 r0 *1 0.74,0.2975 NMOS_VTL
M$10 4 3 7 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI21_X2

* cell AOI21_X4
* pin PWELL,VSS
* pin ZN
* pin A
* pin B2
* pin B1
* pin NWELL,VDD
.SUBCKT AOI21_X4 1 2 3 4 5 11
* net 1 PWELL,VSS
* net 2 ZN
* net 3 A
* net 4 B2
* net 5 B1
* net 11 NWELL,VDD
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 11 3 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.945,0.995 PMOS_VTL
M$5 2 4 10 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $6 r0 *1 1.135,0.995 PMOS_VTL
M$6 10 5 2 11 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.185,0.2975 NMOS_VTL
M$13 2 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.945,0.2975 NMOS_VTL
M$17 8 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.135,0.2975 NMOS_VTL
M$18 2 5 8 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.325,0.2975 NMOS_VTL
M$19 9 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.515,0.2975 NMOS_VTL
M$20 1 4 9 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.705,0.2975 NMOS_VTL
M$21 6 4 1 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.895,0.2975 NMOS_VTL
M$22 2 5 6 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.085,0.2975 NMOS_VTL
M$23 7 5 2 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.275,0.2975 NMOS_VTL
M$24 1 4 7 1 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X4

* cell NAND2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.195,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.385,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.195,0.2975 NMOS_VTL
M$5 7 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.385,0.2975 NMOS_VTL
M$6 5 2 7 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.575,0.2975 NMOS_VTL
M$7 6 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.765,0.2975 NMOS_VTL
M$8 3 1 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X2

* cell AOI21_X1
* pin A
* pin B2
* pin B1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT AOI21_X1 1 2 3 4 6 7
* net 1 A
* net 2 B2
* net 3 B1
* net 4 PWELL,VSS
* net 6 ZN
* net 7 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 2 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 7 1 5 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 8 2 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 6 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $6 r0 *1 0.59,0.2975 NMOS_VTL
M$6 4 1 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI21_X1

* cell NOR3_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR3_X4 1 2 3 4 5 8
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 ZN
* net 8 NWELL,VDD
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 2 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 6 3 7 8 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 1.875,0.995 PMOS_VTL
M$9 6 4 8 8 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 5 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 5 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $21 r0 *1 1.875,0.2975 NMOS_VTL
M$21 5 4 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
.ENDS NOR3_X4

* cell NOR4_X4
* pin PWELL,VSS
* pin A1
* pin A2
* pin A3
* pin A4
* pin ZN
* pin NWELL,VDD
.SUBCKT NOR4_X4 1 2 3 4 5 6 10
* net 1 PWELL,VSS
* net 2 A1
* net 3 A2
* net 4 A3
* net 5 A4
* net 6 ZN
* net 10 NWELL,VDD
* device instance $1 r0 *1 1.92,0.995 PMOS_VTL
M$1 8 4 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 2.68,0.995 PMOS_VTL
M$5 10 5 9 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.17,0.995 PMOS_VTL
M$9 6 2 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $13 r0 *1 0.93,0.995 PMOS_VTL
M$13 8 3 7 10 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $17 r0 *1 1.92,0.2975 NMOS_VTL
M$17 1 4 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $21 r0 *1 2.68,0.2975 NMOS_VTL
M$21 1 5 6 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
* device instance $25 r0 *1 0.17,0.2975 NMOS_VTL
M$25 6 2 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $29 r0 *1 0.93,0.2975 NMOS_VTL
M$29 6 3 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NOR4_X4

* cell OR3_X1
* pin A1
* pin A2
* pin A3
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 9 1 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 8 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 8 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 5 1 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 4 2 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 5 3 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR3_X1

* cell AOI22_X1
* pin B2
* pin B1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X1 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A1
* net 4 A2
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.565,0.995 PMOS_VTL
M$3 8 3 6 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.755,0.995 PMOS_VTL
M$4 6 4 8 7 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.185,0.2975 NMOS_VTL
M$5 10 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $6 r0 *1 0.375,0.2975 NMOS_VTL
M$6 8 2 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $7 r0 *1 0.565,0.2975 NMOS_VTL
M$7 9 3 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.755,0.2975 NMOS_VTL
M$8 5 4 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X1

* cell OR2_X1
* pin A1
* pin A2
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT OR2_X1 1 2 3 5 6
* net 1 A1
* net 2 A2
* net 3 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 7 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 7 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 4 1 3 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 3 2 4 3 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 4 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS OR2_X1

* cell NAND2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 5 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 4 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 6 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 5 2 6 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND2_X1

* cell AOI22_X2
* pin B2
* pin B1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT AOI22_X2 1 2 3 4 5 7 8
* net 1 B2
* net 2 B1
* net 3 A2
* net 4 A1
* net 5 PWELL,VSS
* net 7 NWELL,VDD
* net 8 ZN
* device instance $1 r0 *1 0.175,0.995 PMOS_VTL
M$1 7 1 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $2 r0 *1 0.365,0.995 PMOS_VTL
M$2 6 2 7 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $5 r0 *1 0.935,0.995 PMOS_VTL
M$5 8 3 6 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.125,0.995 PMOS_VTL
M$6 6 4 8 7 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $9 r0 *1 0.175,0.2975 NMOS_VTL
M$9 12 1 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $10 r0 *1 0.365,0.2975 NMOS_VTL
M$10 8 2 12 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.555,0.2975 NMOS_VTL
M$11 10 2 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 0.745,0.2975 NMOS_VTL
M$12 5 1 10 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $13 r0 *1 0.935,0.2975 NMOS_VTL
M$13 11 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $14 r0 *1 1.125,0.2975 NMOS_VTL
M$14 8 4 11 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 1.315,0.2975 NMOS_VTL
M$15 9 4 8 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 1.505,0.2975 NMOS_VTL
M$16 5 3 9 5 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AOI22_X2

* cell NOR2_X2
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X2 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 7 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 2 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 4 1 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.21,0.2975 NMOS_VTL
M$5 5 1 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $6 r0 *1 0.4,0.2975 NMOS_VTL
M$6 3 2 5 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR2_X2

* cell AND3_X2
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X2 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 5 3 4 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 0.17,0.2975 NMOS_VTL
M$6 9 1 4 6 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $7 r0 *1 0.36,0.2975 NMOS_VTL
M$7 8 2 9 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $8 r0 *1 0.55,0.2975 NMOS_VTL
M$8 6 3 8 6 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.74,0.2975 NMOS_VTL
M$9 7 4 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS AND3_X2

* cell NAND3_X2
* pin A3
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NAND3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* net 6 ZN
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 6 1 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 6 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 6 3 5 5 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.0882P PS=1.54U PD=1.54U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 10 1 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 9 2 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 6 3 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $10 r0 *1 0.78,0.2975 NMOS_VTL
M$10 8 3 6 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $11 r0 *1 0.97,0.2975 NMOS_VTL
M$11 7 2 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $12 r0 *1 1.16,0.2975 NMOS_VTL
M$12 4 1 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X2

* cell AND3_X1
* pin A1
* pin A2
* pin A3
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND3_X1 1 2 3 5 6 7
* net 1 A1
* net 2 A2
* net 3 A3
* net 5 NWELL,VDD
* net 6 PWELL,VSS
* net 7 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 5 1 4 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 4 2 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 4 3 5 5 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $4 r0 *1 0.74,0.995 PMOS_VTL
M$4 7 4 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $5 r0 *1 0.17,0.195 NMOS_VTL
M$5 8 1 4 6 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $6 r0 *1 0.36,0.195 NMOS_VTL
M$6 9 2 8 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $7 r0 *1 0.55,0.195 NMOS_VTL
M$7 6 3 9 6 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $8 r0 *1 0.74,0.2975 NMOS_VTL
M$8 7 4 6 6 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND3_X1

* cell CLKBUF_X3
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT CLKBUF_X3 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.89U AS=0.1323P AD=0.15435P PS=2.31U PD=3.01U
* device instance $5 r0 *1 0.17,0.1875 NMOS_VTL
M$5 3 1 2 3 NMOS_VTL L=0.05U W=0.195U AS=0.020475P AD=0.01365P PS=0.6U PD=0.335U
* device instance $6 r0 *1 0.36,0.1875 NMOS_VTL
M$6 5 2 3 3 NMOS_VTL L=0.05U W=0.585U AS=0.04095P AD=0.047775P PS=1.005U
+ PD=1.27U
.ENDS CLKBUF_X3

* cell MUX2_X1
* pin A
* pin S
* pin B
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT MUX2_X1 1 2 3 5 6 8
* net 1 A
* net 2 S
* net 3 B
* net 5 PWELL,VSS
* net 6 NWELL,VDD
* net 8 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 6 2 4 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 9 1 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $3 r0 *1 0.55,1.1525 PMOS_VTL
M$3 7 2 9 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $4 r0 *1 0.74,1.1525 PMOS_VTL
M$4 10 4 7 6 PMOS_VTL L=0.05U W=0.315U AS=0.02205P AD=0.02205P PS=0.455U
+ PD=0.455U
* device instance $5 r0 *1 0.93,1.1525 PMOS_VTL
M$5 10 3 6 6 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $6 r0 *1 1.12,0.995 PMOS_VTL
M$6 8 7 6 6 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.17,0.195 NMOS_VTL
M$7 5 2 4 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $8 r0 *1 0.36,0.195 NMOS_VTL
M$8 12 1 5 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $9 r0 *1 0.55,0.195 NMOS_VTL
M$9 7 4 12 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $10 r0 *1 0.74,0.195 NMOS_VTL
M$10 11 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.0147P PS=0.35U PD=0.35U
* device instance $11 r0 *1 0.93,0.195 NMOS_VTL
M$11 5 3 11 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U
+ PD=0.555U
* device instance $12 r0 *1 1.12,0.2975 NMOS_VTL
M$12 8 7 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS MUX2_X1

* cell BUF_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X1 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 2 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.033075P PS=0.77U
+ PD=0.84U
* device instance $2 r0 *1 0.36,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.17,0.195 NMOS_VTL
M$3 3 1 2 3 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.021875P PS=0.63U PD=0.555U
* device instance $4 r0 *1 0.36,0.2975 NMOS_VTL
M$4 5 2 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS BUF_X1

* cell INV_X1
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X1 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.06615P PS=1.47U PD=1.47U
* device instance $2 r0 *1 0.17,0.2975 NMOS_VTL
M$2 4 1 2 2 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.043575P PS=1.04U
+ PD=1.04U
.ENDS INV_X1

* cell OAI221_X2
* pin C2
* pin C1
* pin B1
* pin B2
* pin A
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT OAI221_X2 1 2 3 4 5 7 9 10
* net 1 C2
* net 2 C1
* net 3 B1
* net 4 B2
* net 5 A
* net 7 ZN
* net 9 PWELL,VSS
* net 10 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 12 1 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 7 2 12 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 11 2 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 10 1 11 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 5 10 10 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 14 3 7 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 10 4 14 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 13 4 10 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $9 r0 *1 1.73,0.995 PMOS_VTL
M$9 7 3 13 10 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $11 r0 *1 0.21,0.2975 NMOS_VTL
M$11 7 1 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $12 r0 *1 0.4,0.2975 NMOS_VTL
M$12 6 2 7 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $15 r0 *1 0.97,0.2975 NMOS_VTL
M$15 8 5 6 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
* device instance $16 r0 *1 1.16,0.2975 NMOS_VTL
M$16 9 3 8 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $17 r0 *1 1.35,0.2975 NMOS_VTL
M$17 8 4 9 9 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS OAI221_X2

* cell NAND3_X4
* pin A2
* pin A1
* pin A3
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND3_X4 1 2 3 4 5 6
* net 1 A2
* net 2 A1
* net 3 A3
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 3 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.19845P PS=3.78U PD=3.78U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 6 1 5 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.1764P PS=3.08U PD=3.08U
* device instance $13 r0 *1 0.21,0.2975 NMOS_VTL
M$13 13 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $14 r0 *1 0.4,0.2975 NMOS_VTL
M$14 12 1 13 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $15 r0 *1 0.59,0.2975 NMOS_VTL
M$15 5 2 12 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $16 r0 *1 0.78,0.2975 NMOS_VTL
M$16 10 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $17 r0 *1 0.97,0.2975 NMOS_VTL
M$17 8 1 10 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $18 r0 *1 1.16,0.2975 NMOS_VTL
M$18 4 3 8 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $19 r0 *1 1.35,0.2975 NMOS_VTL
M$19 9 3 4 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $20 r0 *1 1.54,0.2975 NMOS_VTL
M$20 7 1 9 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $21 r0 *1 1.73,0.2975 NMOS_VTL
M$21 5 2 7 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $22 r0 *1 1.92,0.2975 NMOS_VTL
M$22 14 2 5 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $23 r0 *1 2.11,0.2975 NMOS_VTL
M$23 11 1 14 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.02905P PS=0.555U
+ PD=0.555U
* device instance $24 r0 *1 2.3,0.2975 NMOS_VTL
M$24 4 3 11 4 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NAND3_X4

* cell AND2_X1
* pin A1
* pin A2
* pin NWELL,VDD
* pin PWELL,VSS
* pin ZN
.SUBCKT AND2_X1 1 2 4 5 6
* net 1 A1
* net 2 A2
* net 4 NWELL,VDD
* net 5 PWELL,VSS
* net 6 ZN
* device instance $1 r0 *1 0.17,1.1525 PMOS_VTL
M$1 3 1 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.84U
+ PD=0.455U
* device instance $2 r0 *1 0.36,1.1525 PMOS_VTL
M$2 3 2 4 4 PMOS_VTL L=0.05U W=0.315U AS=0.033075P AD=0.02205P PS=0.77U
+ PD=0.455U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 6 3 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.033075P AD=0.06615P PS=0.77U PD=1.47U
* device instance $4 r0 *1 0.17,0.195 NMOS_VTL
M$4 7 1 3 5 NMOS_VTL L=0.05U W=0.21U AS=0.02205P AD=0.0147P PS=0.63U PD=0.35U
* device instance $5 r0 *1 0.36,0.195 NMOS_VTL
M$5 5 2 7 5 NMOS_VTL L=0.05U W=0.21U AS=0.0147P AD=0.021875P PS=0.35U PD=0.555U
* device instance $6 r0 *1 0.55,0.2975 NMOS_VTL
M$6 6 3 5 5 NMOS_VTL L=0.05U W=0.415U AS=0.021875P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS AND2_X1

* cell NOR2_X1
* pin A2
* pin A1
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT NOR2_X1 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 6 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.375,0.995 PMOS_VTL
M$2 5 2 6 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 5 1 3 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $4 r0 *1 0.375,0.2975 NMOS_VTL
M$4 3 2 5 3 NMOS_VTL L=0.05U W=0.415U AS=0.02905P AD=0.043575P PS=0.555U
+ PD=1.04U
.ENDS NOR2_X1

* cell NOR2_X4
* pin A2
* pin A1
* pin ZN
* pin PWELL,VSS
* pin NWELL,VDD
.SUBCKT NOR2_X4 1 2 3 4 5
* net 1 A2
* net 2 A1
* net 3 ZN
* net 4 PWELL,VSS
* net 5 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 9 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 3 2 9 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 8 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 5 1 8 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 1 5 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 3 2 7 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $7 r0 *1 1.35,0.995 PMOS_VTL
M$7 6 2 3 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $8 r0 *1 1.54,0.995 PMOS_VTL
M$8 5 1 6 5 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 3 1 4 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.130725P PS=2.705U
+ PD=2.705U
* device instance $10 r0 *1 0.4,0.2975 NMOS_VTL
M$10 4 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.1162P PS=2.22U PD=2.22U
.ENDS NOR2_X4

* cell NOR3_X2
* pin A3
* pin A2
* pin A1
* pin NWELL,VDD
* pin ZN
* pin PWELL,VSS
.SUBCKT NOR3_X2 1 2 3 4 5 6
* net 1 A3
* net 2 A2
* net 3 A1
* net 4 NWELL,VDD
* net 5 ZN
* net 6 PWELL,VSS
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 10 1 4 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 9 2 10 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $3 r0 *1 0.59,0.995 PMOS_VTL
M$3 5 3 9 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $4 r0 *1 0.78,0.995 PMOS_VTL
M$4 8 3 5 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 7 2 8 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.0441P PS=0.77U PD=0.77U
* device instance $6 r0 *1 1.16,0.995 PMOS_VTL
M$6 4 1 7 4 PMOS_VTL L=0.05U W=0.63U AS=0.0441P AD=0.06615P PS=0.77U PD=1.47U
* device instance $7 r0 *1 0.21,0.2975 NMOS_VTL
M$7 5 1 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
* device instance $8 r0 *1 0.4,0.2975 NMOS_VTL
M$8 6 2 5 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
* device instance $9 r0 *1 0.59,0.2975 NMOS_VTL
M$9 5 3 6 6 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.0581P PS=1.11U PD=1.11U
.ENDS NOR3_X2

* cell NAND2_X4
* pin A2
* pin A1
* pin PWELL,VSS
* pin ZN
* pin NWELL,VDD
.SUBCKT NAND2_X4 1 2 4 5 6
* net 1 A2
* net 2 A1
* net 4 PWELL,VSS
* net 5 ZN
* net 6 NWELL,VDD
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 5 1 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.97,0.995 PMOS_VTL
M$5 5 2 6 6 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $9 r0 *1 0.21,0.2975 NMOS_VTL
M$9 4 1 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $13 r0 *1 0.97,0.2975 NMOS_VTL
M$13 5 2 3 4 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS NAND2_X4

* cell BUF_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin Z
.SUBCKT BUF_X2 1 3 4 5
* net 1 A
* net 3 PWELL,VSS
* net 4 NWELL,VDD
* net 5 Z
* device instance $1 r0 *1 0.21,0.995 PMOS_VTL
M$1 4 1 2 4 PMOS_VTL L=0.05U W=0.63U AS=0.06615P AD=0.0441P PS=1.47U PD=0.77U
* device instance $2 r0 *1 0.4,0.995 PMOS_VTL
M$2 5 2 4 4 PMOS_VTL L=0.05U W=1.26U AS=0.0882P AD=0.11025P PS=1.54U PD=2.24U
* device instance $4 r0 *1 0.21,0.2975 NMOS_VTL
M$4 3 1 2 3 NMOS_VTL L=0.05U W=0.415U AS=0.043575P AD=0.02905P PS=1.04U
+ PD=0.555U
* device instance $5 r0 *1 0.4,0.2975 NMOS_VTL
M$5 5 2 3 3 NMOS_VTL L=0.05U W=0.83U AS=0.0581P AD=0.072625P PS=1.11U PD=1.595U
.ENDS BUF_X2

* cell BUF_X8
* pin PWELL,VSS
* pin Z
* pin NWELL,VDD
* pin A
.SUBCKT BUF_X8 1 3 4 5
* net 1 PWELL,VSS
* net 3 Z
* net 4 NWELL,VDD
* net 5 A
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 5 4 4 PMOS_VTL L=0.05U W=2.52U AS=0.19845P AD=0.1764P PS=3.78U PD=3.08U
* device instance $5 r0 *1 0.93,0.995 PMOS_VTL
M$5 3 2 4 4 PMOS_VTL L=0.05U W=5.04U AS=0.3528P AD=0.37485P PS=6.16U PD=6.86U
* device instance $13 r0 *1 0.17,0.2975 NMOS_VTL
M$13 2 5 1 1 NMOS_VTL L=0.05U W=1.66U AS=0.130725P AD=0.1162P PS=2.705U PD=2.22U
* device instance $17 r0 *1 0.93,0.2975 NMOS_VTL
M$17 3 2 1 1 NMOS_VTL L=0.05U W=3.32U AS=0.2324P AD=0.246925P PS=4.44U PD=4.925U
.ENDS BUF_X8

* cell INV_X2
* pin A
* pin PWELL,VSS
* pin NWELL,VDD
* pin ZN
.SUBCKT INV_X2 1 2 3 4
* net 1 A
* net 2 PWELL,VSS
* net 3 NWELL,VDD
* net 4 ZN
* device instance $1 r0 *1 0.185,0.995 PMOS_VTL
M$1 4 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.11025P PS=2.24U PD=2.24U
* device instance $3 r0 *1 0.185,0.2975 NMOS_VTL
M$3 4 1 2 2 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.072625P PS=1.595U
+ PD=1.595U
.ENDS INV_X2

* cell BUF_X4
* pin A
* pin NWELL,VDD
* pin Z
* pin PWELL,VSS
.SUBCKT BUF_X4 1 3 4 5
* net 1 A
* net 3 NWELL,VDD
* net 4 Z
* net 5 PWELL,VSS
* device instance $1 r0 *1 0.17,0.995 PMOS_VTL
M$1 2 1 3 3 PMOS_VTL L=0.05U W=1.26U AS=0.11025P AD=0.0882P PS=2.24U PD=1.54U
* device instance $3 r0 *1 0.55,0.995 PMOS_VTL
M$3 4 2 3 3 PMOS_VTL L=0.05U W=2.52U AS=0.1764P AD=0.19845P PS=3.08U PD=3.78U
* device instance $7 r0 *1 0.17,0.2975 NMOS_VTL
M$7 2 1 5 5 NMOS_VTL L=0.05U W=0.83U AS=0.072625P AD=0.0581P PS=1.595U PD=1.11U
* device instance $9 r0 *1 0.55,0.2975 NMOS_VTL
M$9 4 2 5 5 NMOS_VTL L=0.05U W=1.66U AS=0.1162P AD=0.130725P PS=2.22U PD=2.705U
.ENDS BUF_X4
