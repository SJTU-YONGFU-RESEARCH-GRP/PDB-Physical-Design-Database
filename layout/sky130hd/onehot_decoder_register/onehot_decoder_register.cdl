* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT onehot_decoder_register binary_in[0] binary_in[1]
+ binary_in[2] binary_in[3] clk enable onehot_out[0] onehot_out[10]
+ onehot_out[11] onehot_out[12] onehot_out[13] onehot_out[14]
+ onehot_out[15] onehot_out[1] onehot_out[2] onehot_out[3] onehot_out[4]
+ onehot_out[5] onehot_out[6] onehot_out[7] onehot_out[8] onehot_out[9]
+ rst_n
X_42_ net6 VSS VSS VDD VDD _16_ sky130_fd_sc_hd__buf_4
X_43_ _16_ VSS VSS VDD VDD _17_ sky130_fd_sc_hd__buf_4
X_44_ net5 net2 VSS VSS VDD VDD _18_ sky130_fd_sc_hd__nor2_1
X_45_ net3 net4 VSS VSS VDD VDD _19_ sky130_fd_sc_hd__nor2_1
X_46_ _16_ net7 VSS VSS VDD VDD _20_ sky130_fd_sc_hd__nor2b_1
X_47_ _17_ _18_ _19_ _20_ VSS VSS VDD VDD _00_ sky130_fd_sc_hd__a31o_1
X_48_ net2 net5 VSS VSS VDD VDD _21_ sky130_fd_sc_hd__nor2b_1
X_49_ net4 net3 VSS VSS VDD VDD _22_ sky130_fd_sc_hd__and2b_1
X_50_ _16_ net8 VSS VSS VDD VDD _23_ sky130_fd_sc_hd__nor2b_1
X_51_ _17_ _21_ _22_ _23_ VSS VSS VDD VDD _01_ sky130_fd_sc_hd__a31o_1
X_52_ net6 VSS VSS VDD VDD _24_ sky130_fd_sc_hd__buf_2
X_53_ _24_ net9 VSS VSS VDD VDD _25_ sky130_fd_sc_hd__nor2b_1
X_54_ net5 net2 _16_ _22_ _25_ VSS VSS VDD VDD _02_ sky130_fd_sc_hd__a41o_1
X_55_ net3 net4 VSS VSS VDD VDD _26_ sky130_fd_sc_hd__nor2b_1
X_56_ _16_ net10 VSS VSS VDD VDD _27_ sky130_fd_sc_hd__nor2b_1
X_57_ _17_ _21_ _26_ _27_ VSS VSS VDD VDD _03_ sky130_fd_sc_hd__a31o_1
X_58_ _24_ net11 VSS VSS VDD VDD _28_ sky130_fd_sc_hd__nor2b_1
X_59_ net5 net2 _16_ _26_ _28_ VSS VSS VDD VDD _04_ sky130_fd_sc_hd__a41o_1
X_60_ _24_ net12 VSS VSS VDD VDD _29_ sky130_fd_sc_hd__nor2b_1
X_61_ net3 net4 _16_ _21_ _29_ VSS VSS VDD VDD _05_ sky130_fd_sc_hd__a41o_1
X_62_ net13 VSS VSS VDD VDD _30_ sky130_fd_sc_hd__inv_1
X_63_ net5 net2 net3 net4 VSS VSS VDD VDD _31_ sky130_fd_sc_hd__nand4_1
X_64_ _30_ _31_ _17_ VSS VSS VDD VDD _06_ sky130_fd_sc_hd__mux2i_1
X_65_ net5 net2 VSS VSS VDD VDD _32_ sky130_fd_sc_hd__and2b_1
X_66_ _24_ net14 VSS VSS VDD VDD _33_ sky130_fd_sc_hd__nor2b_1
X_67_ _17_ _19_ _32_ _33_ VSS VSS VDD VDD _07_ sky130_fd_sc_hd__a31o_1
X_68_ _24_ net15 VSS VSS VDD VDD _34_ sky130_fd_sc_hd__nor2b_1
X_69_ _17_ _18_ _22_ _34_ VSS VSS VDD VDD _08_ sky130_fd_sc_hd__a31o_1
X_70_ _24_ net16 VSS VSS VDD VDD _35_ sky130_fd_sc_hd__nor2b_1
X_71_ _17_ _22_ _32_ _35_ VSS VSS VDD VDD _09_ sky130_fd_sc_hd__a31o_1
X_72_ _24_ net17 VSS VSS VDD VDD _36_ sky130_fd_sc_hd__nor2b_1
X_73_ _17_ _18_ _26_ _36_ VSS VSS VDD VDD _10_ sky130_fd_sc_hd__a31o_1
X_74_ _24_ net18 VSS VSS VDD VDD _37_ sky130_fd_sc_hd__nor2b_1
X_75_ _17_ _26_ _32_ _37_ VSS VSS VDD VDD _11_ sky130_fd_sc_hd__a31o_1
X_76_ _24_ net19 VSS VSS VDD VDD _38_ sky130_fd_sc_hd__nor2b_1
X_77_ net3 net4 _16_ _18_ _38_ VSS VSS VDD VDD _12_ sky130_fd_sc_hd__a41o_1
X_78_ net6 net20 VSS VSS VDD VDD _39_ sky130_fd_sc_hd__nor2b_1
X_79_ net3 net4 _16_ _32_ _39_ VSS VSS VDD VDD _13_ sky130_fd_sc_hd__a41o_1
X_80_ _24_ net21 VSS VSS VDD VDD _40_ sky130_fd_sc_hd__nor2b_1
X_81_ _17_ _19_ _21_ _40_ VSS VSS VDD VDD _14_ sky130_fd_sc_hd__a31o_1
X_82_ net6 net22 VSS VSS VDD VDD _41_ sky130_fd_sc_hd__nor2b_1
X_83_ net5 net2 _16_ _19_ _41_ VSS VSS VDD VDD _15_ sky130_fd_sc_hd__a41o_1
Xonehot_out\[0\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _00_ net1
+ VSS VSS VDD VDD net7 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[10\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _01_ net1
+ VSS VSS VDD VDD net8 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[11\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _02_ net1
+ VSS VSS VDD VDD net9 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[12\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _03_ net1
+ VSS VSS VDD VDD net10 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[13\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _04_ net1
+ VSS VSS VDD VDD net11 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[14\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _05_ net1
+ VSS VSS VDD VDD net12 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[15\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _06_ net1
+ VSS VSS VDD VDD net13 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[1\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _07_ net1
+ VSS VSS VDD VDD net14 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[2\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _08_ net1
+ VSS VSS VDD VDD net15 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[3\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _09_ net1
+ VSS VSS VDD VDD net16 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[4\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _10_ net1
+ VSS VSS VDD VDD net17 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[5\]$_DFFE_PN0P_ clknet_1_0__leaf_clk _11_ net1
+ VSS VSS VDD VDD net18 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[6\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _12_ net1
+ VSS VSS VDD VDD net19 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[7\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _13_ net1
+ VSS VSS VDD VDD net20 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[8\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _14_ net1
+ VSS VSS VDD VDD net21 sky130_fd_sc_hd__dfrtp_1
Xonehot_out\[9\]$_DFFE_PN0P_ clknet_1_1__leaf_clk _15_ net1
+ VSS VSS VDD VDD net22 sky130_fd_sc_hd__dfrtp_1
Xhold1 net23 VSS VSS VDD VDD net1 sky130_fd_sc_hd__buf_6
XTAP_TAPCELL_ROW_0_0 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_1 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_2 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_3 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_4 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_5 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_6 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_7 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_8 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_9 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_10 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_11 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_12 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_13 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_14 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_15 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_16 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_17 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_18 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_19 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_20 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_21 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_22 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_23 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_24 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_25 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_26 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_27 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_28 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_29 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_30 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_31 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_32 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_33 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_34 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_35 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_36 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_37 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_38 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_39 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_40 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_41 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_42 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_43 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_13_44 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_45 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_46 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_47 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_48 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_49 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_50 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_51 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_52 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_53 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_54 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_55 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_56 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_57 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_58 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_59 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_60 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_61 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_62 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_63 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_64 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_65 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_66 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_67 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_68 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_69 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_70 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_71 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_72 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_73 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_74 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_75 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_76 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_77 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_78 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_79 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_80 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_81 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_82 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_83 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_84 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_85 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_86 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_87 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_88 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_89 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_90 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_91 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_92 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_93 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_94 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_95 VSS VDD sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 binary_in[0] VSS VSS VDD VDD net2 sky130_fd_sc_hd__clkbuf_2
Xinput2 binary_in[1] VSS VSS VDD VDD net3 sky130_fd_sc_hd__clkbuf_2
Xinput3 binary_in[2] VSS VSS VDD VDD net4 sky130_fd_sc_hd__clkbuf_2
Xinput4 binary_in[3] VSS VSS VDD VDD net5 sky130_fd_sc_hd__clkbuf_2
Xinput5 enable VSS VSS VDD VDD net6 sky130_fd_sc_hd__dlymetal6s2s_1
Xoutput6 net7 VSS VSS VDD VDD onehot_out[0] sky130_fd_sc_hd__clkbuf_1
Xoutput7 net8 VSS VSS VDD VDD onehot_out[10] sky130_fd_sc_hd__clkbuf_1
Xoutput8 net9 VSS VSS VDD VDD onehot_out[11] sky130_fd_sc_hd__clkbuf_1
Xoutput9 net10 VSS VSS VDD VDD onehot_out[12] sky130_fd_sc_hd__clkbuf_1
Xoutput10 net11 VSS VSS VDD VDD onehot_out[13] sky130_fd_sc_hd__clkbuf_1
Xoutput11 net12 VSS VSS VDD VDD onehot_out[14] sky130_fd_sc_hd__clkbuf_1
Xoutput12 net13 VSS VSS VDD VDD onehot_out[15] sky130_fd_sc_hd__clkbuf_1
Xoutput13 net14 VSS VSS VDD VDD onehot_out[1] sky130_fd_sc_hd__clkbuf_1
Xoutput14 net15 VSS VSS VDD VDD onehot_out[2] sky130_fd_sc_hd__clkbuf_1
Xoutput15 net16 VSS VSS VDD VDD onehot_out[3] sky130_fd_sc_hd__clkbuf_1
Xoutput16 net17 VSS VSS VDD VDD onehot_out[4] sky130_fd_sc_hd__clkbuf_1
Xoutput17 net18 VSS VSS VDD VDD onehot_out[5] sky130_fd_sc_hd__clkbuf_1
Xoutput18 net19 VSS VSS VDD VDD onehot_out[6] sky130_fd_sc_hd__clkbuf_1
Xoutput19 net20 VSS VSS VDD VDD onehot_out[7] sky130_fd_sc_hd__clkbuf_1
Xoutput20 net21 VSS VSS VDD VDD onehot_out[8] sky130_fd_sc_hd__clkbuf_1
Xoutput21 net22 VSS VSS VDD VDD onehot_out[9] sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VSS VSS VDD VDD clknet_0_clk sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_0__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_0__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkbuf_1_1__f_clk clknet_0_clk VSS VSS VDD VDD clknet_1_1__leaf_clk
+ sky130_fd_sc_hd__clkbuf_8
Xclkload0 clknet_1_1__leaf_clk VSS VSS VDD VDD _unconnected_0
+ sky130_fd_sc_hd__clkbuf_8
Xhold2 rst_n VSS VSS VDD VDD net23 sky130_fd_sc_hd__dlygate4sd3_1
.ENDS onehot_decoder_register
