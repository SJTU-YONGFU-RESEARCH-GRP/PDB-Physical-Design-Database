* CDL Netlist generated by OpenROAD

*.BUSDELIMITER [

.SUBCKT parameterized_loadable_counter clk count[0] count[1]
+ count[2] count[3] count[4] count[5] count[6] count[7] data_in[0]
+ data_in[1] data_in[2] data_in[3] data_in[4] data_in[5] data_in[6]
+ data_in[7] enable load rst_n
X_34_ net10 net12 _08_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_35_ net11 _09_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__inv_4
X_36_ net2 _08_ _09_ _00_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_37_ net13 _33_ net10 _10_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_38_ net3 _10_ _09_ _01_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_39_ net10 _32_ _11_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_40_ net14 _11_ _12_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xnor2_2
X_41_ net4 _12_ _09_ _02_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_42_ net10 net12 net14 net13 _13_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_43_ net15 _13_ _14_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_44_ net5 _14_ _09_ _03_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_45_ net10 _32_ net14 net15 _15_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_46_ net16 _15_ _16_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__xor2_2
X_47_ net6 _16_ _09_ _04_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__mux2_2
X_48_ net11 net7 _17_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_49_ net15 net16 _18_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_50_ net17 _19_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_51_ _13_ _18_ net11 _19_ _20_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_52_ _09_ _19_ _13_ _18_ _21_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_53_ _17_ _20_ _21_ _05_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_54_ net11 net8 _22_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand2_2
X_55_ net10 _32_ net14 _23_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_56_ net15 net16 net17 _24_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_57_ _23_ _24_ _09_ net18 _25_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__oai211_2
X_58_ net11 net18 _23_ _24_ _26_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or4_2
X_59_ _22_ _25_ _26_ _06_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__nand3_2
X_60_ net15 net16 net17 net18 _27_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_61_ net19 _28_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkinv_2
X_62_ _13_ _27_ net11 _28_ _29_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__aoi211_2
X_63_ _09_ _28_ _13_ _27_ _30_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and4_2
X_64_ net11 net9 _31_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__and2_2
X_65_ _29_ _30_ _31_ _07_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__or3_2
X_66_ net12 net13 _32_ _33_ VDD VSS gf180mcu_fd_sc_mcu9t5v0__addh_2
Xcounter_reg\[0\]$_DFFE_PN0P_ _00_ net1 clknet_1_0__leaf_clk
+ net12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[1\]$_DFFE_PN0P_ _01_ net1 clknet_1_0__leaf_clk
+ net13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[2\]$_DFFE_PN0P_ _02_ net1 clknet_1_0__leaf_clk
+ net14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[3\]$_DFFE_PN0P_ _03_ net1 clknet_1_1__leaf_clk
+ net15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[4\]$_DFFE_PN0P_ _04_ net1 clknet_1_0__leaf_clk
+ net16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[5\]$_DFFE_PN0P_ _05_ net1 clknet_1_1__leaf_clk
+ net17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[6\]$_DFFE_PN0P_ _06_ net1 clknet_1_1__leaf_clk
+ net18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xcounter_reg\[7\]$_DFFE_PN0P_ _07_ net1 clknet_1_1__leaf_clk
+ net19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dffrnq_2
Xhold1 net20 net1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_4
XPHY_EDGE_ROW_0_Right_0 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Right_1 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Right_2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Right_3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Right_4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Right_5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Right_6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Right_7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Right_8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Right_9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Right_10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Right_11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Right_12 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Right_13 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Right_14 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Right_15 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Right_16 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Right_17 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Right_18 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Right_19 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Right_20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Right_21 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Right_22 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Right_23 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Right_24 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Right_25 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Right_26 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_0_Left_27 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_1_Left_28 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_2_Left_29 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_3_Left_30 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_4_Left_31 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_5_Left_32 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_6_Left_33 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_7_Left_34 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_8_Left_35 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_9_Left_36 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_10_Left_37 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_11_Left_38 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_12_Left_39 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_13_Left_40 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_14_Left_41 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_15_Left_42 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_16_Left_43 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_17_Left_44 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_18_Left_45 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_19_Left_46 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_20_Left_47 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_21_Left_48 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_22_Left_49 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_23_Left_50 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_24_Left_51 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_25_Left_52 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XPHY_EDGE_ROW_26_Left_53 VDD VSS gf180mcu_fd_sc_mcu9t5v0__endcap
XTAP_TAPCELL_ROW_0_54 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_2_55 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_4_56 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_6_57 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_8_58 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_10_59 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_12_60 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_14_61 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_16_62 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_18_63 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_20_64 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_22_65 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_24_66 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
XTAP_TAPCELL_ROW_26_67 VDD VSS gf180mcu_fd_sc_mcu9t5v0__filltie
Xinput1 data_in[0] net2 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput2 data_in[1] net3 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput3 data_in[2] net4 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput4 data_in[3] net5 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput5 data_in[4] net6 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput6 data_in[5] net7 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput7 data_in[6] net8 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput8 data_in[7] net9 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xinput9 enable net10 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_2
Xinput10 load net11 VDD VSS gf180mcu_fd_sc_mcu9t5v0__buf_3
Xoutput11 net12 count[0] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput12 net13 count[1] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput13 net14 count[2] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput14 net15 count[3] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput15 net16 count[4] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput16 net17 count[5] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput17 net18 count[6] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xoutput18 net19 count[7] VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyb_2
Xclkbuf_0_clk clk clknet_0_clk VDD VSS gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_0__f_clk clknet_0_clk clknet_1_0__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xclkbuf_1_1__f_clk clknet_0_clk clknet_1_1__leaf_clk VDD VSS
+ gf180mcu_fd_sc_mcu9t5v0__clkbuf_3
Xhold2 rst_n net20 VDD VSS gf180mcu_fd_sc_mcu9t5v0__dlyc_2
.ENDS parameterized_loadable_counter
